#ifndef _JETBRAINSMONO_EXTRALIGHT6PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xD0, 0x5D, 0x3A, 0x80, 0xF5, 0xD0, 0xEA, 0xF0,
  0x80, 0x6A, 0x90, 0xFC, 0x55, 0x80, 0x5C, 0xC0, 0xC0, 0x80, 0x5A, 0xA0,
  0xFF, 0xAB, 0xE5, 0x70, 0x6C, 0xF0, 0xFD, 0xF7, 0x4E, 0xF0, 0xE5, 0x20,
  0xFF, 0xF5, 0xA0, 0xA0, 0xB0, 0x69, 0xF0, 0x96, 0xDA, 0xFF, 0xDC, 0x4D,
  0xD0, 0xFF, 0xEB, 0xFF, 0xFB, 0xFA, 0xEF, 0xFF, 0xEB, 0x64, 0xF0, 0xEF,
  0xAB, 0xFF, 0xFF, 0xFF, 0xFA, 0xFF, 0x40, 0xFB, 0xE8, 0xF0, 0xE9, 0x20,
  0xFF, 0xAD, 0x20, 0xFE, 0xD0, 0xE9, 0x50, 0xA9, 0x20, 0xEB, 0xEA, 0xB0,
  0xA9, 0x50, 0xFC, 0xB0, 0xE0, 0x80, 0xFF, 0x80, 0xBF, 0xEC, 0x7F, 0xEC,
  0x7D, 0x20, 0xFF, 0xBF, 0x8A, 0xC0, 0x65, 0x70, 0xBB, 0xC9, 0x30, 0xFF,
  0x80, 0xFC, 0xFC, 0xFE, 0xFD, 0xE8, 0xDC, 0xE9, 0x30, 0xFC, 0xAD, 0x00,
  0xEE, 0x80, 0xEA, 0x80, 0xAD, 0x20, 0xEC, 0x69, 0x90, 0xFC, 0xAE, 0xA0,
  0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 3, 3, 4, 0, -4 },
  { 18, 3, 2, 4, 0, -3 },
  { 19, 1, 2, 4, 1, -1 },
  { 20, 2, 1, 4, 1, -2 },
  { 21, 1, 1, 4, 1, -1 },
  { 22, 2, 6, 4, 1, -5 },
  { 24, 2, 4, 4, 1, -4 },
  { 25, 2, 4, 4, 1, -4 },
  { 26, 3, 4, 4, 0, -4 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 2, 4, 4, 1, -4 },
  { 31, 2, 4, 4, 1, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 2, 4, 4, 1, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 1, 3, 4, 1, -3 },
  { 40, 1, 4, 4, 1, -3 },
  { 41, 2, 4, 4, 1, -4 },
  { 42, 2, 2, 4, 1, -3 },
  { 43, 2, 4, 4, 1, -4 },
  { 44, 2, 4, 4, 1, -4 },
  { 45, 3, 5, 4, 0, -4 },
  { 47, 3, 4, 4, 0, -4 },
  { 49, 2, 4, 4, 1, -4 },
  { 50, 2, 4, 4, 1, -4 },
  { 51, 2, 4, 4, 1, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 2, 4, 4, 1, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 2, 4, 4, 1, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 2, 4, 4, 1, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 2, 5, 4, 1, -4 },
  { 67, 2, 4, 4, 1, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 2, 4, 4, 1, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 2, 4, 4, 1, -4 },
  { 82, 2, 6, 4, 1, -5 },
  { 84, 2, 6, 4, 1, -5 },
  { 86, 1, 6, 4, 1, -5 },
  { 87, 2, 2, 4, 1, -4 },
  { 88, 3, 1, 4, 0, 0 },
  { 89, 1, 1, 4, 1, -5 },
  { 90, 3, 3, 4, 0, -3 },
  { 92, 2, 4, 4, 1, -4 },
  { 93, 2, 3, 4, 1, -3 },
  { 94, 2, 4, 4, 1, -4 },
  { 95, 2, 3, 4, 1, -3 },
  { 96, 3, 4, 4, 0, -4 },
  { 98, 2, 4, 4, 1, -3 },
  { 99, 2, 4, 4, 1, -4 },
  { 100, 2, 5, 4, 1, -5 },
  { 102, 2, 6, 4, 1, -5 },
  { 104, 2, 4, 4, 1, -4 },
  { 105, 3, 4, 4, 0, -4 },
  { 107, 3, 3, 4, 0, -3 },
  { 109, 2, 3, 4, 1, -3 },
  { 110, 2, 3, 4, 1, -3 },
  { 111, 2, 4, 4, 1, -3 },
  { 112, 2, 4, 4, 1, -3 },
  { 113, 2, 3, 4, 1, -3 },
  { 114, 2, 3, 4, 1, -3 },
  { 115, 3, 4, 4, 0, -4 },
  { 117, 2, 3, 4, 1, -3 },
  { 118, 3, 3, 4, 0, -3 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 3, 3, 4, 0, -3 },
  { 124, 3, 4, 4, 0, -3 },
  { 126, 2, 3, 4, 1, -3 },
  { 127, 2, 6, 4, 1, -5 },
  { 129, 1, 6, 4, 1, -5 },
  { 130, 2, 6, 4, 1, -5 },
  { 132, 3, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_ExtraLight6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_EXTRALIGHT6PT7B_H_
