#ifndef _JETBRAINSMONO_EXTRALIGHT23PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight23pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0x20, 0x17, 0x60, 0xCF, 0x38, 0xE3, 0x8E,
  0x38, 0x40, 0x08, 0x60, 0x86, 0x08, 0x40, 0x84, 0x18, 0x47, 0xFF, 0x10,
  0xC1, 0x08, 0x10, 0x83, 0x08, 0x30, 0x8F, 0xFE, 0x21, 0x02, 0x10, 0x21,
  0x06, 0x10, 0x43, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x78, 0x7F, 0x93, 0x2C,
  0xCF, 0x30, 0xCC, 0x1B, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0x20, 0xCC, 0x33,
  0x8C, 0xF3, 0x36, 0xD8, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0B, 0x20,
  0x91, 0x8C, 0x8C, 0x44, 0x64, 0x23, 0x61, 0xB2, 0x07, 0x20, 0x03, 0x00,
  0x13, 0x01, 0x3E, 0x1B, 0x10, 0x90, 0x88, 0x84, 0x84, 0x2C, 0x33, 0xC0,
  0xF0, 0x1F, 0x03, 0x38, 0x20, 0x82, 0x0C, 0x20, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x6C, 0x14, 0x42, 0xC6, 0x6C, 0x34, 0xC1, 0xCC, 0x08, 0x41, 0xC6,
  0x36, 0x3E, 0x30, 0xFF, 0xFC, 0x0C, 0xE6, 0x18, 0xC3, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x06, 0x0C, 0x1C, 0x10, 0xC1, 0x83,
  0x06, 0x0C, 0x30, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x0C, 0x61,
  0x9C, 0xE2, 0x00, 0x06, 0x00, 0x60, 0x06, 0x08, 0x61, 0xF4, 0xF3, 0xDC,
  0x06, 0x00, 0xF0, 0x19, 0x01, 0x18, 0x30, 0xC2, 0x08, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37,
  0x66, 0x4C, 0x80, 0xFF, 0xEF, 0xE0, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x3E, 0x1C,
  0xE4, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x33, 0xCC, 0xF3, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x09, 0x8E, 0x3F, 0x00, 0x0C, 0x07, 0x07, 0x43,
  0x10, 0x84, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0xFF, 0xC0, 0x3E, 0x1C, 0xEC, 0x0B, 0x03, 0x80,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x70,
  0x3E, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0E, 0x07, 0x06, 0xC7, 0x3E, 0x00,
  0x01, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x61, 0x60, 0xB0, 0x70,
  0x38, 0x1F, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0x9F, 0xE4, 0x01,
  0x00, 0x40, 0x10, 0x05, 0xF1, 0xCE, 0x40, 0xB0, 0x30, 0x0C, 0x03, 0x00,
  0xF0, 0x3C, 0x09, 0x86, 0x3F, 0x00, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0xFC, 0x61, 0xB0, 0x3C, 0x0E, 0x03, 0x80, 0xF0, 0x3C,
  0x09, 0x86, 0x3F, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x00, 0x1E, 0x1C, 0xE4, 0x0B, 0x03, 0xC0, 0xD0, 0x26, 0x18, 0xFC,
  0x1E, 0x0C, 0xC4, 0x1B, 0x03, 0x80, 0xF0, 0x3C, 0x0D, 0x86, 0x3F, 0x00,
  0x3E, 0x1C, 0xEC, 0x0B, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0x61, 0x9F,
  0xE0, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x00, 0x6F, 0xF0,
  0x00, 0x00, 0x00, 0xEF, 0xE0, 0x33, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0xE6, 0x31, 0x18, 0xC0, 0x00, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x20, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x30, 0x38,
  0x38, 0x38, 0x18, 0x0C, 0x00, 0xF1, 0xF8, 0x18, 0x10, 0x20, 0x40, 0x83,
  0x7C, 0xE1, 0x83, 0x00, 0x00, 0x10, 0x30, 0x60, 0x0F, 0x83, 0x8C, 0x60,
  0x64, 0x02, 0x40, 0x3C, 0x03, 0xC3, 0xFC, 0x63, 0xC4, 0x3C, 0x43, 0xC4,
  0x3C, 0x43, 0xC4, 0x3C, 0x43, 0xC7, 0x7C, 0x3B, 0x40, 0x04, 0x00, 0x60,
  0x03, 0x80, 0x0F, 0x00, 0x06, 0x00, 0xC0, 0x3C, 0x05, 0x80, 0x90, 0x32,
  0x06, 0x60, 0x8C, 0x10, 0x86, 0x10, 0xC3, 0x1F, 0xE2, 0x04, 0xC0, 0x98,
  0x1A, 0x03, 0xC0, 0x20, 0xFE, 0x3F, 0xCC, 0x1B, 0x02, 0xC0, 0xF0, 0x3C,
  0x0B, 0x0C, 0xFF, 0x30, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x0E,
  0xFF, 0x00, 0x1E, 0x1C, 0xE4, 0x0B, 0x03, 0xC0, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x34, 0x09, 0x86, 0x3F, 0x00,
  0xFC, 0x3F, 0xCC, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x2C, 0x1B, 0x1C, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x00, 0x1E, 0x1C, 0xE4, 0x0B, 0x03, 0xC0, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x31, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x34, 0x09, 0x86,
  0x3F, 0x00, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x80, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0x0F, 0xC3, 0xF0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xC0, 0x70, 0x14, 0x0D, 0xC6, 0x3F,
  0x00, 0xC0, 0x58, 0x1B, 0x02, 0x60, 0xCC, 0x11, 0x86, 0x30, 0x86, 0x30,
  0xFC, 0x18, 0xC3, 0x08, 0x61, 0x8C, 0x11, 0x83, 0x30, 0x26, 0x06, 0xC0,
  0x60, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xC0, 0xF8, 0x7A,
  0x16, 0x85, 0xB2, 0xE4, 0xB9, 0x2E, 0x73, 0x8C, 0xE3, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0xE0, 0xF0, 0x78, 0x3E, 0x1D,
  0x0E, 0x87, 0x63, 0x91, 0xCC, 0xE2, 0x71, 0x38, 0xDC, 0x2E, 0x17, 0x0F,
  0x83, 0xC1, 0x80, 0x1E, 0x1C, 0xE4, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x24, 0x09, 0x86, 0x3F,
  0x00, 0xFE, 0x3F, 0xEC, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xFF,
  0xBF, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1E,
  0x1C, 0xE4, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x34, 0x09, 0x86, 0x3F, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0xFE, 0x3F, 0xEC, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x0F, 0x06,
  0xFF, 0xBF, 0x8C, 0x63, 0x0C, 0xC3, 0x30, 0x6C, 0x1B, 0x03, 0xC0, 0xC0,
  0x1E, 0x1C, 0xE4, 0x0B, 0x03, 0xC0, 0x30, 0x06, 0x00, 0xE0, 0x1E, 0x00,
  0xE0, 0x08, 0x03, 0x00, 0xE0, 0x3C, 0x0D, 0x86, 0x3F, 0x00, 0xFF, 0xFF,
  0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x05, 0x02, 0xC3, 0x3F, 0x00, 0xC0, 0x28, 0x05, 0x81, 0xB0, 0x32,
  0x04, 0x41, 0x8C, 0x31, 0x84, 0x10, 0x82, 0x30, 0x66, 0x0C, 0x80, 0x90,
  0x16, 0x03, 0xC0, 0x70, 0x06, 0x00, 0x86, 0x18, 0x63, 0x86, 0x3C, 0x63,
  0xC6, 0x2C, 0xB2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x66, 0x96,
  0x71, 0x67, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0xC0, 0x26, 0x06, 0x20,
  0xC3, 0x0C, 0x11, 0x81, 0x90, 0x0F, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0B,
  0x01, 0x98, 0x10, 0x83, 0x0C, 0x20, 0x46, 0x06, 0xC0, 0x30, 0xC0, 0x34,
  0x02, 0x60, 0x62, 0x04, 0x30, 0xC1, 0x08, 0x19, 0x80, 0x90, 0x0F, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xFF, 0xBF, 0xE0, 0x18, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0xFF, 0xC0, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0xFC,
  0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18,
  0x06, 0x00, 0x80, 0x30, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFC, 0x0C, 0x03, 0x01, 0xE0, 0x48, 0x33,
  0x08, 0x46, 0x11, 0x06, 0xC0, 0xC0, 0xFF, 0xE0, 0xE1, 0x06, 0x1E, 0x3F,
  0x90, 0x78, 0x10, 0x08, 0x05, 0xFF, 0x81, 0x80, 0xC0, 0x70, 0x38, 0x77,
  0xE8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCE, 0x3C, 0xEE, 0x1B, 0x02, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0B, 0x86, 0xDF, 0x00, 0x1E,
  0x1F, 0xE4, 0x1B, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x34,
  0x09, 0x86, 0x3F, 0x00, 0x00, 0x80, 0x40, 0x20, 0x11, 0xCB, 0x95, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x05, 0x06, 0xC3, 0x3E, 0x80,
  0x1E, 0x1C, 0xC4, 0x1B, 0x02, 0xC0, 0xF0, 0x3F, 0xFF, 0x00, 0xC0, 0x30,
  0x14, 0x09, 0x86, 0x3F, 0x00, 0x07, 0xC3, 0xF1, 0x80, 0x60, 0x18, 0x06,
  0x0F, 0xFC, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x00, 0x1C, 0xB9, 0x50, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xA0, 0xD8, 0xE7, 0xD0, 0x08, 0x04, 0x02, 0x03, 0x3F, 0x00, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0xE7, 0x9F, 0x87, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x80, 0x0C, 0x03, 0x80, 0xC0, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x03, 0x03, 0x03, 0x00, 0x00, 0x7F,
  0x7F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x06, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x3C,
  0x1B, 0x0C, 0xC2, 0x31, 0x8F, 0xC3, 0x18, 0xC3, 0x30, 0xCC, 0x1B, 0x02,
  0xC0, 0xC0, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0xF0, 0xBB, 0xB6, 0xB8, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x40, 0xCE, 0x79, 0xF8,
  0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x08,
  0x1E, 0x1F, 0xC4, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x24, 0x09, 0x86, 0x3F, 0x00, 0xCE, 0x3C, 0xEE, 0x1B, 0x02, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0B, 0x86, 0xDF, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x00, 0x1C, 0xB9, 0x50, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x50, 0x6C, 0x33, 0xE8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x9E,
  0x5B, 0xB0, 0x70, 0x38, 0x1C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x3F, 0x1F, 0xE4, 0x0F, 0x00, 0x40, 0x18, 0x03, 0xF0, 0x06,
  0x00, 0xC0, 0x3C, 0x0D, 0x86, 0x3F, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x7F,
  0xFF, 0xFE, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x3F, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x50, 0x6C, 0x73, 0xF0, 0x80, 0x70, 0x3C, 0x09,
  0x02, 0x61, 0x98, 0x42, 0x10, 0xCC, 0x32, 0x04, 0x81, 0xE0, 0x70, 0x0C,
  0x00, 0x86, 0x3C, 0x63, 0xC6, 0x24, 0x62, 0x4A, 0x24, 0x92, 0x49, 0x66,
  0x96, 0x69, 0x42, 0x94, 0x31, 0x43, 0x0C, 0x30, 0xC0, 0x60, 0x64, 0x08,
  0xC3, 0x0C, 0xC0, 0x90, 0x1E, 0x01, 0x80, 0x70, 0x09, 0x03, 0x30, 0xC3,
  0x10, 0x2E, 0x06, 0x80, 0x70, 0x3C, 0x09, 0x06, 0x61, 0x88, 0x43, 0x30,
  0xCC, 0x12, 0x07, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30,
  0x00, 0xFF, 0xBF, 0xE0, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x08, 0x06, 0x03, 0x00, 0xFF, 0xC0, 0x03, 0xC1, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0x0F, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x03, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0E, 0x01, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x00, 0x7C, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x02, 0x00, 0x80, 0x60, 0xF0, 0x30, 0x00, 0xF8, 0x62, 0x18, 0x4E,
  0x0E,
};

const GFXglyph JetBrainsMono_ExtraLight23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 17, 14, 5, -17 },
  { 8, 6, 7, 14, 4, -17 },
  { 14, 12, 17, 14, 1, -17 },
  { 40, 10, 23, 14, 2, -20 },
  { 69, 13, 17, 14, 0, -17 },
  { 97, 12, 17, 14, 1, -17 },
  { 123, 2, 7, 14, 6, -17 },
  { 125, 6, 22, 14, 5, -19 },
  { 142, 6, 22, 14, 3, -19 },
  { 159, 12, 12, 14, 1, -14 },
  { 177, 10, 11, 14, 2, -13 },
  { 191, 4, 7, 14, 4, -3 },
  { 195, 8, 1, 14, 3, -8 },
  { 196, 4, 3, 14, 5, -3 },
  { 198, 10, 22, 14, 2, -19 },
  { 226, 10, 17, 14, 2, -17 },
  { 248, 10, 17, 14, 2, -17 },
  { 270, 10, 17, 14, 2, -17 },
  { 292, 9, 17, 14, 2, -17 },
  { 312, 9, 17, 14, 2, -17 },
  { 332, 10, 17, 14, 2, -17 },
  { 354, 10, 17, 14, 2, -17 },
  { 376, 10, 17, 14, 2, -17 },
  { 398, 10, 17, 14, 2, -17 },
  { 420, 10, 17, 14, 2, -17 },
  { 442, 4, 13, 14, 5, -13 },
  { 449, 5, 17, 14, 4, -13 },
  { 460, 10, 11, 14, 2, -13 },
  { 474, 10, 7, 14, 2, -11 },
  { 483, 10, 11, 14, 2, -13 },
  { 497, 7, 17, 14, 4, -17 },
  { 512, 12, 21, 14, 1, -17 },
  { 544, 11, 17, 14, 1, -17 },
  { 568, 10, 17, 14, 2, -17 },
  { 590, 10, 17, 14, 2, -17 },
  { 612, 10, 17, 14, 2, -17 },
  { 634, 9, 17, 14, 3, -17 },
  { 654, 10, 17, 14, 2, -17 },
  { 676, 10, 17, 14, 2, -17 },
  { 698, 9, 17, 14, 2, -17 },
  { 718, 8, 17, 14, 3, -17 },
  { 735, 10, 17, 14, 1, -17 },
  { 757, 11, 17, 14, 2, -17 },
  { 781, 9, 17, 14, 3, -17 },
  { 801, 10, 17, 14, 2, -17 },
  { 823, 9, 17, 14, 2, -17 },
  { 843, 10, 17, 14, 2, -17 },
  { 865, 10, 17, 14, 2, -17 },
  { 887, 10, 21, 14, 2, -17 },
  { 914, 10, 17, 14, 2, -17 },
  { 936, 10, 17, 14, 2, -17 },
  { 958, 11, 17, 14, 1, -17 },
  { 982, 9, 17, 14, 2, -17 },
  { 1002, 11, 17, 14, 1, -17 },
  { 1026, 12, 17, 14, 1, -17 },
  { 1052, 12, 17, 14, 1, -17 },
  { 1078, 12, 17, 14, 1, -17 },
  { 1104, 10, 17, 14, 2, -17 },
  { 1126, 5, 22, 14, 5, -19 },
  { 1140, 10, 22, 14, 2, -19 },
  { 1168, 5, 22, 14, 4, -19 },
  { 1182, 10, 9, 14, 2, -17 },
  { 1194, 11, 1, 14, 1, 1 },
  { 1196, 5, 3, 14, 4, -18 },
  { 1198, 9, 13, 14, 2, -13 },
  { 1213, 10, 17, 14, 2, -17 },
  { 1235, 10, 13, 14, 2, -13 },
  { 1252, 9, 17, 14, 2, -17 },
  { 1272, 10, 13, 14, 2, -13 },
  { 1289, 10, 17, 14, 2, -17 },
  { 1311, 9, 17, 14, 2, -13 },
  { 1331, 9, 17, 14, 2, -17 },
  { 1351, 10, 18, 14, 2, -18 },
  { 1374, 8, 22, 14, 2, -18 },
  { 1396, 10, 17, 14, 2, -17 },
  { 1418, 12, 17, 14, 1, -17 },
  { 1444, 10, 13, 14, 2, -13 },
  { 1461, 9, 13, 14, 2, -13 },
  { 1476, 10, 13, 14, 2, -13 },
  { 1493, 10, 17, 14, 2, -13 },
  { 1515, 9, 17, 14, 2, -13 },
  { 1535, 9, 13, 14, 3, -13 },
  { 1550, 10, 13, 14, 2, -13 },
  { 1567, 11, 16, 14, 1, -16 },
  { 1589, 9, 13, 14, 2, -13 },
  { 1604, 10, 13, 14, 2, -13 },
  { 1621, 12, 13, 14, 1, -13 },
  { 1641, 11, 13, 14, 1, -13 },
  { 1659, 10, 17, 14, 2, -13 },
  { 1681, 10, 13, 14, 2, -13 },
  { 1698, 10, 22, 14, 2, -19 },
  { 1726, 2, 22, 14, 6, -19 },
  { 1732, 10, 22, 14, 2, -19 },
  { 1760, 10, 4, 14, 2, -10 },
};

const GFXfont JetBrainsMono_ExtraLight23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_EXTRALIGHT23PT7B_H_
