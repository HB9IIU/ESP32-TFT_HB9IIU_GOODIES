#ifndef _JETBRAINSMONO_EXTRALIGHT38PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight38pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCC, 0x63,
  0x18, 0x40, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1B, 0x83, 0x70, 0x60,
  0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x18, 0x03, 0x81, 0x80, 0x30, 0x18, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x03, 0x03, 0x80, 0x70, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x03, 0x00, 0x60, 0x70, 0x0E, 0x06, 0x00, 0xC0, 0x60, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0,
  0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x1C, 0x03, 0x81, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0x7F,
  0xF0, 0x79, 0xBC, 0x38, 0xCF, 0x38, 0x63, 0x98, 0x30, 0xCC, 0x18, 0x66,
  0x0C, 0x03, 0x86, 0x01, 0xC3, 0x00, 0x71, 0x80, 0x3C, 0xC0, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x06, 0x70, 0x03, 0x1C, 0x01,
  0x86, 0x00, 0xC3, 0x80, 0x61, 0xF8, 0x30, 0xFC, 0x18, 0x7E, 0x0C, 0x33,
  0x86, 0x38, 0xE3, 0x38, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x1B, 0xFC, 0x01,
  0x98, 0x60, 0x1D, 0x81, 0x80, 0xCC, 0x0C, 0x0C, 0x60, 0x60, 0xC3, 0x03,
  0x06, 0x18, 0x18, 0x60, 0xC0, 0xC6, 0x07, 0x06, 0x30, 0x1C, 0x63, 0x00,
  0xFF, 0x30, 0x01, 0xE3, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x30, 0x00, 0xC7, 0xE0, 0x0C, 0x77, 0x80, 0xC6, 0x0C, 0x06, 0x30, 0x30,
  0x61, 0x81, 0x86, 0x0C, 0x0C, 0x70, 0x60, 0x63, 0x03, 0x03, 0x30, 0x18,
  0x3B, 0x80, 0xE1, 0x98, 0x03, 0xFD, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFF, 0x00, 0x78, 0xF0, 0x0E, 0x07, 0x03, 0x80, 0x60, 0x70, 0x0C, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1C, 0x60, 0x3B, 0x0E, 0x06, 0xE0,
  0xE1, 0xDC, 0x0E, 0x33, 0x80, 0xCE, 0x70, 0x1D, 0x8E, 0x01, 0xF1, 0xC0,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0xF8, 0x60, 0x3B, 0x8E, 0x0E, 0x38, 0xFF,
  0x83, 0x0F, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x1C,
  0x0F, 0x83, 0xC0, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x70, 0x02,
  0xC0, 0x1E, 0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x07, 0xC3, 0xE0,
  0x78, 0x08, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x04, 0x07, 0x01, 0x70, 0x70, 0xFF, 0xE6, 0x3F, 0x3F,
  0xAF, 0xE0, 0x7F, 0xF0, 0x00, 0x70, 0x00, 0x0D, 0x00, 0x01, 0xD8, 0x00,
  0x39, 0xC0, 0x03, 0x8E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x01, 0xE0, 0x38,
  0x04, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x1E, 0x78, 0xF1, 0xC3, 0x8F, 0x1C, 0x38, 0x61,
  0xC3, 0x86, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x11, 0xF7, 0xFF, 0x7D,
  0xF0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E,
  0x78, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0xC3, 0xE3, 0xC3, 0xE3, 0xC3,
  0xE1, 0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0x60, 0x03, 0x70, 0x07, 0x70, 0x0F, 0x3C, 0x1E, 0x1F, 0xFC,
  0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x3D, 0xC0, 0x79, 0xC0,
  0xE1, 0xC0, 0xC1, 0xC0, 0x81, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x01, 0xC6, 0x00, 0x77, 0x00, 0x1B, 0x80,
  0x0D, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xFC,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E,
  0x38, 0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x07, 0x1C, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x9F, 0xC7, 0x7F,
  0xCF, 0x83, 0xDE, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x1C, 0xE0, 0x78, 0xFF, 0xE0, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x3E, 0x03, 0xFF, 0xC3, 0xF1,
  0xF1, 0xE0, 0x3C, 0xE0, 0x0E, 0xE0, 0x03, 0x70, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0C, 0xC0, 0x0E, 0x70, 0x07,
  0x1E, 0x0F, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x37, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0x07, 0x87, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x0C, 0xE0, 0x06,
  0x70, 0x07, 0x18, 0x03, 0x0E, 0x03, 0x83, 0x83, 0x80, 0xF7, 0x80, 0x1F,
  0x00, 0x1F, 0xC0, 0x3C, 0x78, 0x38, 0x0E, 0x38, 0x03, 0x98, 0x01, 0xDC,
  0x00, 0x6E, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x0C, 0xC0, 0x06, 0x70, 0x07,
  0x1C, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0x0F, 0x8F, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x76, 0x00, 0x73, 0x80,
  0x78, 0xF0, 0x7C, 0x3F, 0xFC, 0x0F, 0xEC, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x7D, 0xFF, 0xDF, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xDF, 0x7C, 0x3E,
  0xFD, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x1C, 0x78, 0xF1, 0xC3, 0x8E, 0x1C, 0x38, 0x61, 0xC3, 0x00, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x03, 0xF0,
  0x7F, 0x03, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0xC0, 0x78, 0x1E, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xE0,
  0x01, 0x98, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x81,
  0xF9, 0xF0, 0x7F, 0xBE, 0x0C, 0x0F, 0xC3, 0x81, 0xF8, 0x70, 0x1F, 0x0E,
  0x03, 0xE1, 0xC0, 0x7C, 0x38, 0x0F, 0x87, 0x01, 0xF0, 0xE0, 0x3E, 0x1C,
  0x07, 0xC3, 0x81, 0xF8, 0x30, 0x3F, 0x07, 0x0B, 0xE0, 0x7F, 0x7C, 0x07,
  0xCF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC,
  0x00, 0x33, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0xC7, 0x00, 0x61, 0xC0,
  0x18, 0x30, 0x0E, 0x0C, 0x03, 0x83, 0x80, 0xC0, 0xE0, 0x30, 0x18, 0x1C,
  0x06, 0x07, 0x01, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x38, 0x03, 0x0E, 0x00,
  0xE3, 0x00, 0x18, 0xC0, 0x06, 0x70, 0x01, 0xDC, 0x00, 0x76, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xC0, 0x1C, 0xC0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0E,
  0xC0, 0x1C, 0xC0, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x1C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0E, 0xC0, 0x1E, 0xC0, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0xE0,
  0x3F, 0xF8, 0x78, 0x3C, 0x70, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x06,
  0xC0, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x0E, 0x70, 0x0E,
  0x78, 0x3C, 0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE6,
  0x01, 0xEC, 0x01, 0xD8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0E, 0xC0, 0x3D, 0x81, 0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x78, 0x3C, 0x70, 0x1C, 0xE0,
  0x0E, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x06, 0xE0, 0x0E, 0x70, 0x0E, 0x78, 0x3C, 0x3F, 0xF8, 0x0F, 0xF0, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x07, 0x3C, 0x1E, 0x1F, 0xFC, 0x0F,
  0xF0, 0xC0, 0x03, 0x60, 0x03, 0xB0, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x30, 0x60, 0x38, 0x30, 0x18,
  0x18, 0x1C, 0x0C, 0x0C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0x81, 0xC0, 0xC0,
  0xE0, 0x60, 0x38, 0x30, 0x1C, 0x18, 0x07, 0x0C, 0x03, 0x86, 0x00, 0xE3,
  0x00, 0x71, 0x80, 0x1C, 0xC0, 0x0E, 0x60, 0x03, 0xB0, 0x01, 0xD8, 0x00,
  0x70, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x03, 0x7B, 0x01, 0xBD, 0x80, 0xFE, 0x60, 0xDF, 0x30, 0x6F,
  0xD8, 0x37, 0xE6, 0x33, 0xF3, 0x19, 0xF9, 0x8C, 0xFC, 0x6C, 0x7E, 0x36,
  0x3F, 0x1B, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x70, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7D, 0x80, 0xFB, 0x01, 0xF7, 0x03, 0xE6, 0x07,
  0xCC, 0x0F, 0x8C, 0x1F, 0x18, 0x3E, 0x38, 0x7C, 0x30, 0xF8, 0x61, 0xF0,
  0xE3, 0xE0, 0xC7, 0xC1, 0x8F, 0x81, 0x9F, 0x03, 0x3E, 0x07, 0x7C, 0x06,
  0xF8, 0x0C, 0xF0, 0x1D, 0xE0, 0x1B, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0xE1, 0xE0, 0xE3, 0x80, 0xEE, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0x60,
  0x1C, 0xF0, 0x78, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x18, 0x01, 0xCC, 0x00, 0x76, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0xE6, 0x01,
  0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x78,
  0x38, 0x70, 0x1C, 0xE0, 0x0E, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x78, 0x3C, 0x3F,
  0xF8, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xC0,
  0x1E, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1E, 0xC0, 0xFC, 0xFF, 0xF8, 0xFF,
  0xC0, 0xC0, 0xE0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0x38, 0xC0,
  0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x07, 0xC0,
  0x07, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x87, 0x01, 0xE7, 0x00, 0x73,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x06, 0x70, 0x07, 0x1C, 0x07, 0x0F, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0x70, 0x1C, 0xF0, 0x78, 0xFF, 0xE0, 0xFF,
  0x00, 0xE0, 0x00, 0xD8, 0x00, 0x37, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0x8C, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x18, 0x03, 0x06, 0x00, 0xC1,
  0xC0, 0x70, 0x70, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0xE0, 0x38,
  0x30, 0x06, 0x0C, 0x01, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x03, 0x18,
  0x00, 0xCE, 0x00, 0x3B, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0x98, 0x14, 0x0C,
  0xC0, 0xA0, 0x66, 0x0D, 0x03, 0x30, 0x6C, 0x19, 0x83, 0x61, 0xCC, 0x1B,
  0x0E, 0x70, 0xD8, 0x73, 0x86, 0xC3, 0x0C, 0x22, 0x18, 0x61, 0x10, 0xC3,
  0x18, 0xC6, 0x18, 0xC6, 0x30, 0xC6, 0x31, 0x86, 0x31, 0x9C, 0x39, 0x8C,
  0xE1, 0xC8, 0x66, 0x0E, 0x41, 0x30, 0x36, 0x09, 0x81, 0xB0, 0x6C, 0x0D,
  0x83, 0x60, 0x6C, 0x1B, 0x03, 0x60, 0xD8, 0x1A, 0x07, 0xC0, 0xF0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x00, 0xCE, 0x00, 0x38, 0xC0,
  0x0E, 0x1C, 0x01, 0xC1, 0x80, 0x70, 0x38, 0x0C, 0x03, 0x83, 0x80, 0x70,
  0x60, 0x07, 0x1C, 0x00, 0x63, 0x00, 0x0E, 0xE0, 0x00, 0xD8, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xB8, 0x00, 0x67,
  0x00, 0x1C, 0x70, 0x03, 0x06, 0x00, 0xE0, 0xE0, 0x18, 0x0C, 0x07, 0x01,
  0xC1, 0xC0, 0x18, 0x38, 0x03, 0x8E, 0x00, 0x39, 0x80, 0x07, 0x70, 0x00,
  0x70, 0xC0, 0x00, 0xFC, 0x00, 0x1D, 0x80, 0x07, 0x38, 0x00, 0xE3, 0x00,
  0x38, 0x70, 0x07, 0x06, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x06, 0x01, 0xC1,
  0xC0, 0x18, 0x30, 0x03, 0x8E, 0x00, 0x31, 0x80, 0x07, 0x70, 0x00, 0x6C,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xE0, 0x03, 0x60, 0x07, 0x70, 0x06, 0x30, 0x0E, 0x38, 0x0C, 0x18, 0x1C,
  0x18, 0x1C, 0x1C, 0x18, 0x0C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x07, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07,
  0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x30, 0x0E, 0x70, 0x07, 0x60, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x0F, 0xFF, 0x3F, 0xFF, 0x78, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x70,
  0x1F, 0x3F, 0xF7, 0x1F, 0xE7, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x63, 0xF8, 0xCF, 0xF9, 0xB0, 0x7B,
  0xC0, 0x77, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x1D, 0xB0, 0x7B, 0x7F, 0xE6, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0x6E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x1D, 0xE0, 0xF1, 0xFF, 0xC1,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x8F, 0xE7, 0x3F, 0xEE, 0xF0, 0x7F, 0x80, 0x7F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x1E, 0xE0, 0x7C, 0xFF, 0xB8, 0xFE, 0x70, 0x0F, 0xE0, 0x7F, 0xF1, 0xE0,
  0xF3, 0x00, 0xEE, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x0F, 0xC0, 0x1D, 0xE0, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1F,
  0xCE, 0x7F, 0xDD, 0xE0, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x70, 0x3E, 0x7F, 0xDC, 0x7F, 0x38, 0x30,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xF8,
  0xFF, 0xE1, 0xFF, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x63, 0xF8, 0xCF, 0xF9, 0xB0, 0x7B, 0xC0,
  0x77, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x0F, 0x8F, 0xFC, 0x3F, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0x83,
  0x83, 0x81, 0xC1, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x70, 0x1C, 0x1C,
  0x0E, 0x07, 0x07, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x07, 0x38, 0x01, 0xDC, 0x00, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0xDF, 0x1E, 0x6F, 0xDF, 0xB8, 0x70, 0xF8, 0x38, 0x7C, 0x1C, 0x1E,
  0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83, 0xC1,
  0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x18, 0xC7, 0xF1,
  0x9F, 0xF3, 0x60, 0xF7, 0x80, 0xEE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xE0, 0x0F, 0xE0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xEE, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x0E, 0xC0, 0x39,
  0xE0, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0xC7, 0xF1, 0x9F, 0xF3, 0x60, 0xF7,
  0x80, 0xEE, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x3B, 0x60, 0xF6, 0xFF, 0xCC, 0x7F, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0xCE, 0x7F, 0xDD, 0xE0, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3D, 0xE0, 0xF9, 0xFF,
  0x71, 0xFC, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0xCF, 0xE1, 0xBF, 0xF3, 0x60, 0xF7, 0x00, 0xEE,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFC,
  0x38, 0x0E, 0x70, 0x07, 0x70, 0x03, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x60, 0x03, 0x70, 0x07, 0x78, 0x0F, 0x3F, 0xFE,
  0x0F, 0xFC, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xE0, 0x39, 0xE0, 0xF1,
  0xFF, 0xC1, 0xFE, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xCC, 0x00,
  0x67, 0x00, 0x73, 0x80, 0x30, 0xC0, 0x18, 0x70, 0x1C, 0x38, 0x0C, 0x0C,
  0x06, 0x07, 0x07, 0x03, 0x83, 0x00, 0xC1, 0x80, 0x71, 0xC0, 0x18, 0xC0,
  0x0C, 0x60, 0x07, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xF0, 0x50, 0x7E, 0x1A,
  0x0C, 0xC3, 0x61, 0x98, 0x6C, 0x33, 0x0D, 0x86, 0x61, 0x10, 0xCC, 0x62,
  0x39, 0xCC, 0x66, 0x19, 0x8C, 0xC3, 0x31, 0x98, 0x64, 0x33, 0x0C, 0x82,
  0x61, 0xB0, 0x5C, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x70, 0x01, 0xCE, 0x00, 0xE1, 0x80, 0x70, 0x70, 0x1C,
  0x0E, 0x0E, 0x01, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0xE0, 0x01, 0xB0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xB0, 0x00, 0xCE, 0x00, 0x71,
  0xC0, 0x38, 0x38, 0x0C, 0x0E, 0x07, 0x01, 0xC3, 0x80, 0x39, 0xC0, 0x0E,
  0xF0, 0x01, 0xC0, 0xE0, 0x03, 0xF0, 0x01, 0xD8, 0x00, 0xCE, 0x00, 0xE7,
  0x00, 0x71, 0x80, 0x30, 0xE0, 0x38, 0x30, 0x18, 0x1C, 0x1C, 0x0E, 0x0E,
  0x03, 0x06, 0x01, 0xC7, 0x00, 0x63, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x06,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x81, 0xFF, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xBF, 0x80, 0xF8, 0xE0, 0x78, 0x38, 0x7C, 0x0E, 0x3E,
  0x03, 0xFB, 0x00, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraLight38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 28, 23, 9, -28 },
  { 19, 11, 12, 23, 6, -28 },
  { 36, 20, 28, 23, 1, -28 },
  { 106, 17, 38, 23, 3, -33 },
  { 187, 21, 28, 23, 1, -28 },
  { 261, 19, 28, 23, 2, -28 },
  { 328, 3, 12, 23, 10, -28 },
  { 333, 11, 37, 23, 7, -32 },
  { 384, 11, 37, 23, 4, -32 },
  { 435, 20, 19, 23, 1, -23 },
  { 483, 17, 17, 23, 3, -21 },
  { 520, 7, 12, 23, 7, -6 },
  { 531, 12, 3, 23, 5, -14 },
  { 536, 6, 6, 23, 8, -6 },
  { 541, 17, 36, 23, 3, -32 },
  { 618, 16, 28, 23, 3, -28 },
  { 674, 16, 28, 23, 4, -28 },
  { 730, 17, 28, 23, 3, -28 },
  { 790, 16, 28, 23, 3, -28 },
  { 846, 16, 28, 23, 3, -28 },
  { 902, 15, 28, 23, 4, -28 },
  { 955, 17, 28, 23, 3, -28 },
  { 1015, 17, 28, 23, 3, -28 },
  { 1075, 17, 28, 23, 3, -28 },
  { 1135, 17, 28, 23, 3, -28 },
  { 1195, 6, 21, 23, 8, -21 },
  { 1211, 7, 27, 23, 7, -21 },
  { 1235, 16, 19, 23, 3, -22 },
  { 1273, 16, 11, 23, 3, -18 },
  { 1295, 16, 19, 23, 3, -22 },
  { 1333, 13, 28, 23, 6, -28 },
  { 1379, 19, 35, 23, 2, -28 },
  { 1463, 18, 28, 23, 2, -28 },
  { 1526, 16, 28, 23, 4, -28 },
  { 1582, 16, 28, 23, 4, -28 },
  { 1638, 15, 28, 23, 4, -28 },
  { 1691, 16, 28, 23, 4, -28 },
  { 1747, 16, 28, 23, 4, -28 },
  { 1803, 16, 28, 23, 4, -28 },
  { 1859, 15, 28, 23, 4, -28 },
  { 1912, 14, 28, 23, 4, -28 },
  { 1961, 16, 28, 23, 2, -28 },
  { 2017, 17, 28, 23, 4, -28 },
  { 2077, 16, 28, 23, 4, -28 },
  { 2133, 17, 28, 23, 3, -28 },
  { 2193, 15, 28, 23, 4, -28 },
  { 2246, 15, 28, 23, 4, -28 },
  { 2299, 17, 28, 23, 4, -28 },
  { 2359, 16, 35, 23, 4, -28 },
  { 2429, 16, 28, 23, 4, -28 },
  { 2485, 17, 28, 23, 3, -28 },
  { 2545, 19, 28, 23, 2, -28 },
  { 2612, 15, 28, 23, 4, -28 },
  { 2665, 18, 28, 23, 2, -28 },
  { 2728, 21, 28, 23, 1, -28 },
  { 2802, 19, 28, 23, 2, -28 },
  { 2869, 19, 28, 23, 2, -28 },
  { 2936, 16, 28, 23, 3, -28 },
  { 2992, 9, 36, 23, 8, -32 },
  { 3033, 17, 36, 23, 3, -32 },
  { 3110, 9, 36, 23, 6, -32 },
  { 3151, 16, 15, 23, 3, -28 },
  { 3181, 19, 2, 23, 2, 1 },
  { 3186, 7, 5, 23, 7, -30 },
  { 3191, 16, 21, 23, 3, -21 },
  { 3233, 15, 28, 23, 4, -28 },
  { 3286, 15, 21, 23, 4, -21 },
  { 3326, 15, 28, 23, 4, -28 },
  { 3379, 15, 21, 23, 4, -21 },
  { 3419, 17, 28, 23, 3, -28 },
  { 3479, 15, 28, 23, 4, -21 },
  { 3532, 15, 28, 23, 4, -28 },
  { 3585, 18, 29, 23, 3, -29 },
  { 3651, 14, 36, 23, 3, -29 },
  { 3714, 17, 28, 23, 4, -28 },
  { 3774, 19, 28, 23, 2, -28 },
  { 3841, 17, 21, 23, 3, -21 },
  { 3886, 15, 21, 23, 4, -21 },
  { 3926, 15, 21, 23, 4, -21 },
  { 3966, 15, 28, 23, 4, -21 },
  { 4019, 15, 28, 23, 4, -21 },
  { 4072, 15, 21, 23, 5, -21 },
  { 4112, 16, 21, 23, 3, -21 },
  { 4154, 17, 27, 23, 2, -27 },
  { 4212, 15, 21, 23, 4, -21 },
  { 4252, 17, 21, 23, 3, -21 },
  { 4297, 19, 21, 23, 2, -21 },
  { 4347, 18, 21, 23, 2, -21 },
  { 4395, 17, 28, 23, 3, -21 },
  { 4455, 15, 21, 23, 4, -21 },
  { 4495, 15, 36, 23, 4, -32 },
  { 4563, 3, 36, 23, 10, -32 },
  { 4577, 15, 36, 23, 4, -32 },
  { 4645, 17, 7, 23, 3, -17 },
};

const GFXfont JetBrainsMono_ExtraLight38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_EXTRALIGHT38PT7B_H_
