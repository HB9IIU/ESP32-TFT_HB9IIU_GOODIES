#ifndef _JETBRAINSMONO_EXTRALIGHT20PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF8, 0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x18, 0x84,
  0x21, 0x08, 0x42, 0x11, 0x3F, 0xF2, 0x10, 0x84, 0x21, 0x08, 0xCF, 0xFD,
  0x88, 0x42, 0x10, 0x84, 0x60, 0x08, 0x08, 0x3C, 0x6E, 0xCB, 0x89, 0x88,
  0xC8, 0x68, 0x3C, 0x0E, 0x0B, 0x09, 0x89, 0x89, 0xCB, 0x7E, 0x08, 0x08,
  0x08, 0x30, 0x34, 0x82, 0x44, 0x44, 0x48, 0x44, 0x84, 0xD0, 0x7A, 0x00,
  0x20, 0x04, 0xC0, 0x96, 0x1A, 0x21, 0x22, 0x22, 0x26, 0x32, 0xC1, 0xE0,
  0x1C, 0x0D, 0xC6, 0x11, 0x84, 0x60, 0x08, 0x03, 0x01, 0xE0, 0xC8, 0xF1,
  0x2C, 0x7B, 0x0C, 0xC3, 0x11, 0xA7, 0xCC, 0xFF, 0xF0, 0x04, 0x73, 0x18,
  0x43, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x60, 0xC1, 0xC0,
  0x83, 0x83, 0x06, 0x08, 0x30, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC2,
  0x18, 0xCE, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0x33, 0x7B, 0x83, 0x01, 0xE0,
  0x48, 0x23, 0x18, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC3, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x6D, 0x69, 0x00, 0xFC, 0x6F, 0x60, 0x01, 0x03,
  0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x60, 0x40, 0xC0, 0x80, 0x3C, 0x66, 0xC3, 0x81, 0x81, 0x81, 0x81,
  0x99, 0x99, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x7E, 0x18, 0x1C, 0x1A, 0x11,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43,
  0xFE, 0x3C, 0x33, 0x20, 0xD0, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x04, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x03, 0xFE, 0xFF, 0xFF, 0x06, 0x04, 0x08, 0x10,
  0x1C, 0x02, 0x03, 0x01, 0x01, 0x81, 0x83, 0xC2, 0x7C, 0x02, 0x04, 0x0C,
  0x08, 0x10, 0x30, 0x20, 0x63, 0xC3, 0x83, 0xFF, 0xFF, 0x03, 0x03, 0x03,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xD8, 0xFE, 0xC3, 0x01, 0x01, 0x01, 0x01,
  0x81, 0xC2, 0x7E, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x60, 0x5C, 0xE7, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC3, 0x7E, 0xFF, 0xFF, 0xE0, 0x50, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x04, 0x06, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x3C,
  0x66, 0xC3, 0x81, 0x81, 0x43, 0x66, 0x18, 0x66, 0xC3, 0x81, 0x81, 0x81,
  0xC3, 0x7E, 0x3C, 0x66, 0xC3, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x7E, 0x06,
  0x04, 0x0C, 0x08, 0x10, 0x30, 0x6F, 0x60, 0x00, 0x00, 0x6F, 0x60, 0x6F,
  0x60, 0x00, 0x00, 0x66, 0x4C, 0x88, 0x01, 0x03, 0x0E, 0x38, 0xE0, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x06, 0x1C, 0x70, 0xC0, 0x80, 0xF1, 0xF8,
  0x10, 0x30, 0x20, 0xC1, 0x1E, 0x30, 0x40, 0x80, 0x00, 0x0E, 0x18, 0x00,
  0x1E, 0x0C, 0x64, 0x09, 0x01, 0xC0, 0x61, 0xD8, 0xCE, 0x21, 0x88, 0x62,
  0x18, 0x86, 0x21, 0x8C, 0xE1, 0xDC, 0x01, 0x00, 0x60, 0x0F, 0x80, 0xE0,
  0x0C, 0x03, 0x00, 0xC0, 0x78, 0x12, 0x04, 0x81, 0x20, 0xCC, 0x21, 0x08,
  0x47, 0xF9, 0x02, 0x40, 0x90, 0x2C, 0x0C, 0xF8, 0xFE, 0x83, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0x83, 0x81, 0x81, 0x81, 0x81, 0x83, 0xFC, 0x3C, 0x66,
  0xC3, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0xC1, 0x43,
  0x3E, 0xF8, 0xFE, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x83, 0x86, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x3C, 0x66, 0xC3, 0x81, 0x80, 0x80, 0x80, 0x80, 0x8F, 0x81, 0x81, 0x81,
  0xC1, 0x43, 0x3E, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x0F, 0x87, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x78, 0x3C, 0x1B,
  0x18, 0xF8, 0x81, 0xC0, 0xA0, 0xD0, 0x48, 0x64, 0x22, 0x31, 0xF0, 0x8C,
  0x42, 0x21, 0x90, 0x48, 0x34, 0x0A, 0x06, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFE,
  0xC3, 0xC3, 0xC3, 0xA5, 0xA5, 0xA5, 0x99, 0x99, 0x99, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC1, 0xC1, 0xE1, 0xA1, 0xA1, 0x91, 0x91, 0x99, 0x89,
  0x89, 0x8D, 0x85, 0x85, 0x83, 0x83, 0x3C, 0x66, 0xC3, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x42, 0x3C, 0xFC, 0x7F, 0xA0,
  0x50, 0x38, 0x1C, 0x0E, 0x05, 0x0E, 0xFC, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x3C, 0x66, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x42, 0x3E, 0x04, 0x06, 0x03, 0x01, 0xF8, 0x7F, 0x20,
  0x50, 0x28, 0x1C, 0x0A, 0x05, 0xFC, 0xF8, 0x42, 0x21, 0x10, 0xC8, 0x24,
  0x1A, 0x06, 0x3C, 0x66, 0xC3, 0x81, 0x80, 0xC0, 0x60, 0x3C, 0x06, 0x03,
  0x01, 0x81, 0x81, 0xC3, 0x7E, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC3, 0x42, 0x3C, 0xC0, 0xD0, 0x24, 0x09, 0x02, 0x61, 0x88, 0x42, 0x10,
  0x84, 0x33, 0x04, 0x81, 0x20, 0x68, 0x1E, 0x03, 0x00, 0xC0, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x72, 0x9D, 0x2D, 0x4A, 0x52, 0x94, 0xA5, 0x29,
  0x4A, 0x52, 0x98, 0x66, 0x18, 0xC0, 0xD0, 0x26, 0x18, 0x84, 0x12, 0x04,
  0x80, 0xC0, 0x30, 0x0C, 0x04, 0x81, 0x30, 0x84, 0x61, 0x90, 0x2C, 0x0C,
  0x80, 0x70, 0x34, 0x09, 0x86, 0x21, 0x0C, 0xC1, 0x20, 0x78, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xFF, 0xFF, 0x03, 0x02, 0x04,
  0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x80, 0xFF, 0xFF, 0xF1,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0x80, 0xC0,
  0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04,
  0x04, 0x06, 0x02, 0x03, 0x01, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xFE, 0x18, 0x18, 0x3C, 0x24, 0x26, 0x42, 0x42,
  0x81, 0xFF, 0xFF, 0xF0, 0xC4, 0x30, 0x1F, 0x10, 0x90, 0x20, 0x10, 0x09,
  0xFD, 0x03, 0x81, 0x41, 0xB0, 0xCF, 0xA0, 0x80, 0x80, 0x80, 0x80, 0xBE,
  0xC3, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0xC3, 0xBE, 0x3E, 0x43,
  0xC1, 0x81, 0x80, 0x80, 0x80, 0x81, 0xC1, 0x43, 0x3E, 0x01, 0x01, 0x01,
  0x01, 0x7D, 0xC3, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0xC3, 0x7D,
  0x3C, 0x42, 0x81, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x81, 0x43, 0x3E, 0x03,
  0xC3, 0xF0, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x7D, 0x43, 0xC3, 0x81, 0x81, 0x81,
  0x81, 0x83, 0xC3, 0x7D, 0x01, 0x01, 0x03, 0x7E, 0x7C, 0x80, 0x80, 0x80,
  0x80, 0xBE, 0xC2, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x1C, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x43, 0xFE, 0x06, 0x0C, 0x00, 0x0F, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x05, 0xFB, 0xC0, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x1C, 0x1A, 0x19, 0x08, 0x8C, 0x7C, 0x23, 0x10, 0xC8,
  0x24, 0x1A, 0x06, 0xF8, 0x3E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x7C, 0xFB, 0xB3,
  0x2C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCC,
  0xBE, 0xC2, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3C,
  0x42, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x42, 0x3C, 0xBE, 0xC3,
  0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0xC2, 0xBE, 0x80, 0x80, 0x80,
  0x80, 0x7D, 0x43, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x43, 0x7D,
  0x01, 0x01, 0x01, 0x01, 0xDE, 0xE3, 0xC1, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x7E, 0xC3, 0x81, 0xC0, 0x60, 0x3E, 0x03, 0x01, 0x81,
  0xC3, 0x7E, 0x18, 0x0C, 0x06, 0x1F, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x80, 0x7C, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC3, 0x42, 0x3C, 0xC0, 0xD0, 0x26, 0x18, 0x84, 0x21, 0x0C,
  0xC1, 0x20, 0x48, 0x1E, 0x03, 0x00, 0xC0, 0x8C, 0x63, 0x18, 0xC7, 0x33,
  0x52, 0x94, 0xA5, 0x29, 0x4A, 0x52, 0x9C, 0xE2, 0x10, 0x40, 0x88, 0x43,
  0x30, 0x48, 0x0C, 0x03, 0x01, 0xE0, 0x48, 0x33, 0x18, 0x6C, 0x0C, 0xC0,
  0xD0, 0x26, 0x18, 0x84, 0x31, 0x04, 0xC1, 0x20, 0x68, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0xFF, 0x03, 0x06, 0x04, 0x08, 0x18,
  0x30, 0x20, 0x40, 0xC0, 0xFF, 0x03, 0x0F, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0xF0, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x0F, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0xE0,
  0xE1, 0x91, 0x89, 0x87,
};

const GFXglyph JetBrainsMono_ExtraLight20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 15, 12, 5, -15 },
  { 5, 6, 6, 12, 3, -15 },
  { 10, 10, 15, 12, 1, -15 },
  { 29, 8, 20, 12, 2, -17 },
  { 49, 12, 15, 12, 0, -15 },
  { 72, 10, 15, 12, 1, -15 },
  { 91, 2, 6, 12, 5, -15 },
  { 93, 6, 19, 12, 4, -17 },
  { 108, 6, 19, 12, 2, -17 },
  { 123, 10, 10, 12, 1, -12 },
  { 136, 10, 9, 12, 1, -11 },
  { 148, 3, 6, 12, 4, -3 },
  { 151, 6, 1, 12, 3, -7 },
  { 152, 4, 3, 12, 4, -3 },
  { 154, 8, 19, 12, 2, -17 },
  { 173, 8, 15, 12, 2, -15 },
  { 188, 9, 15, 12, 2, -15 },
  { 205, 9, 15, 12, 2, -15 },
  { 222, 8, 15, 12, 2, -15 },
  { 237, 8, 15, 12, 2, -15 },
  { 252, 8, 15, 12, 2, -15 },
  { 267, 8, 15, 12, 2, -15 },
  { 282, 9, 15, 12, 2, -15 },
  { 299, 8, 15, 12, 2, -15 },
  { 314, 8, 15, 12, 2, -15 },
  { 329, 4, 11, 12, 4, -11 },
  { 335, 4, 14, 12, 4, -11 },
  { 342, 8, 11, 12, 2, -12 },
  { 353, 8, 6, 12, 2, -10 },
  { 359, 8, 11, 12, 2, -12 },
  { 370, 7, 15, 12, 3, -15 },
  { 384, 10, 19, 12, 1, -15 },
  { 408, 10, 15, 12, 1, -15 },
  { 427, 8, 15, 12, 2, -15 },
  { 442, 8, 15, 12, 2, -15 },
  { 457, 8, 15, 12, 2, -15 },
  { 472, 8, 15, 12, 2, -15 },
  { 487, 9, 15, 12, 2, -15 },
  { 504, 8, 15, 12, 2, -15 },
  { 519, 8, 15, 12, 2, -15 },
  { 534, 8, 15, 12, 2, -15 },
  { 549, 9, 15, 12, 1, -15 },
  { 566, 9, 15, 12, 2, -15 },
  { 583, 9, 15, 12, 2, -15 },
  { 600, 8, 15, 12, 2, -15 },
  { 615, 8, 15, 12, 2, -15 },
  { 630, 8, 15, 12, 2, -15 },
  { 645, 9, 15, 12, 2, -15 },
  { 662, 8, 19, 12, 2, -15 },
  { 681, 9, 15, 12, 2, -15 },
  { 698, 8, 15, 12, 2, -15 },
  { 713, 10, 15, 12, 1, -15 },
  { 732, 8, 15, 12, 2, -15 },
  { 747, 10, 15, 12, 1, -15 },
  { 766, 10, 15, 12, 1, -15 },
  { 785, 10, 15, 12, 1, -15 },
  { 804, 10, 15, 12, 1, -15 },
  { 823, 8, 15, 12, 2, -15 },
  { 838, 5, 19, 12, 4, -17 },
  { 850, 8, 19, 12, 2, -17 },
  { 869, 5, 19, 12, 3, -17 },
  { 881, 8, 8, 12, 2, -15 },
  { 889, 10, 2, 12, 1, 0 },
  { 892, 4, 3, 12, 4, -16 },
  { 894, 9, 11, 12, 1, -11 },
  { 907, 8, 15, 12, 2, -15 },
  { 922, 8, 11, 12, 2, -11 },
  { 933, 8, 15, 12, 2, -15 },
  { 948, 8, 11, 12, 2, -11 },
  { 959, 10, 15, 12, 1, -15 },
  { 978, 8, 15, 12, 2, -11 },
  { 993, 8, 15, 12, 2, -15 },
  { 1008, 9, 15, 12, 2, -15 },
  { 1025, 7, 19, 12, 2, -15 },
  { 1042, 9, 15, 12, 2, -15 },
  { 1059, 10, 15, 12, 1, -15 },
  { 1078, 10, 11, 12, 1, -11 },
  { 1092, 8, 11, 12, 2, -11 },
  { 1103, 8, 11, 12, 2, -11 },
  { 1114, 8, 15, 12, 2, -11 },
  { 1129, 8, 15, 12, 2, -11 },
  { 1144, 8, 11, 12, 2, -11 },
  { 1155, 8, 11, 12, 2, -11 },
  { 1166, 9, 14, 12, 1, -14 },
  { 1182, 8, 11, 12, 2, -11 },
  { 1193, 10, 11, 12, 1, -11 },
  { 1207, 10, 11, 12, 1, -11 },
  { 1221, 10, 11, 12, 1, -11 },
  { 1235, 10, 15, 12, 1, -11 },
  { 1254, 8, 11, 12, 2, -11 },
  { 1265, 8, 19, 12, 2, -17 },
  { 1284, 2, 19, 12, 5, -17 },
  { 1289, 8, 19, 12, 2, -17 },
  { 1308, 8, 4, 12, 2, -9 },
};

const GFXfont JetBrainsMono_ExtraLight20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_EXTRALIGHT20PT7B_H_
