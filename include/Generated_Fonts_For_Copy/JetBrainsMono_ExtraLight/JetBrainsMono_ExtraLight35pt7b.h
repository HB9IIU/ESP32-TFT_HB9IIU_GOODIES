#ifndef _JETBRAINSMONO_EXTRALIGHT35PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight35pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x84, 0x21,
  0x08, 0x00, 0x01, 0xDF, 0xFB, 0x80, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x01, 0x81, 0x80, 0x30, 0x30,
  0x04, 0x06, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x7F, 0xFF, 0xE0, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00,
  0x60, 0x60, 0x18, 0x08, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06,
  0x06, 0x00, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x06, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0x6E, 0x38, 0xCE,
  0x61, 0x8E, 0xC3, 0x1F, 0x86, 0x1B, 0x0C, 0x06, 0x18, 0x0E, 0x30, 0x0E,
  0x60, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0C, 0xE0, 0x18,
  0xE0, 0x31, 0xC0, 0x61, 0xE0, 0xC3, 0xC1, 0x87, 0xC3, 0x0F, 0x86, 0x3B,
  0x8C, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x6F, 0xE0, 0x0F, 0x8E, 0x03, 0x60, 0xC0,
  0xCC, 0x18, 0x19, 0x83, 0x06, 0x30, 0x61, 0x86, 0x0C, 0x60, 0xC1, 0x8C,
  0x1C, 0x73, 0x01, 0xFC, 0xC0, 0x1F, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x80, 0x0C, 0xFE, 0x03, 0x38, 0xC0, 0x66, 0x0C, 0x18, 0xC1,
  0x86, 0x18, 0x31, 0x83, 0x06, 0x30, 0x60, 0xCC, 0x0C, 0x1B, 0x01, 0x83,
  0x60, 0x1F, 0xD8, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xFC, 0x01, 0xC7, 0x80,
  0xE0, 0x70, 0x30, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1C, 0xC0,
  0x6E, 0x18, 0x3B, 0x87, 0x0C, 0xC0, 0xE7, 0x30, 0x19, 0x8C, 0x03, 0xE3,
  0x00, 0xF0, 0xC0, 0x1C, 0x38, 0x0F, 0x0E, 0x03, 0x61, 0xC3, 0xDC, 0x7F,
  0xE3, 0x87, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0xF0,
  0xF0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xC0, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x1C, 0x0F, 0x07, 0x87, 0xC3, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC1, 0xC1, 0xBF,
  0x11, 0xF9, 0xFA, 0xFC, 0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x06, 0x80, 0x01,
  0xD8, 0x00, 0x31, 0x80, 0x0E, 0x38, 0x03, 0x83, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x00, 0x80, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x1E, 0x38, 0xF1, 0xC3, 0x86, 0x1C, 0x38,
  0x60, 0xC3, 0x00, 0xFF, 0xFF, 0xFC, 0x77, 0xFF, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x3F, 0xE0, 0xF1, 0xE3, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x18, 0x3C, 0x38,
  0x78, 0x70, 0xF0, 0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xDC, 0x07, 0x3C, 0x1E, 0x3F, 0xF8, 0x1F,
  0xC0, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1D, 0xC0, 0x79, 0xC0, 0x61,
  0xC0, 0x41, 0xC0, 0x81, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0xE1, 0xE0, 0xE3, 0x80,
  0xEE, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x36, 0x01, 0xDC, 0x0E,
  0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x03, 0x18, 0x0C, 0xE0, 0x37, 0x00, 0xD8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC7, 0x81, 0xBF, 0xC3, 0xE3,
  0xC7, 0x01, 0xCE, 0x01, 0x98, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0x98, 0x07, 0x38, 0x1C, 0x3F,
  0xF8, 0x1F, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE2, 0x01,
  0xBF, 0x87, 0xEF, 0x8E, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xD8, 0x03, 0x3C, 0x1E,
  0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0xF0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xD8, 0x03, 0xB0, 0x06, 0x60,
  0x0C, 0xE0, 0x38, 0xE0, 0xE0, 0xF7, 0x80, 0x7C, 0x01, 0xFC, 0x07, 0x1C,
  0x18, 0x0C, 0x60, 0x0D, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x01, 0xD8, 0x03, 0x38, 0x0E, 0x3F, 0xF8, 0x3F, 0xE0, 0x07, 0xC0, 0x3F,
  0xE0, 0xF1, 0xE3, 0x80, 0xEE, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x77, 0x01, 0xCF, 0x07, 0x8F,
  0xFF, 0x07, 0xCC, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x27, 0xFF,
  0xFF, 0x90, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xF0, 0x08,
  0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x1C, 0x78, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0x61, 0x80, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0C,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0,
  0x01, 0x80, 0x00, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x0E, 0x03, 0xE1, 0xF8,
  0x1E, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03,
  0x87, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0xF0, 0x3F, 0xF8, 0x38, 0x7C, 0x18, 0x1E, 0x0C, 0x0F,
  0x0E, 0x07, 0x87, 0x03, 0xC3, 0x81, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0x30,
  0x3C, 0x18, 0x1E, 0x0E, 0x1F, 0x03, 0xFF, 0x80, 0xFB, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x1D, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03,
  0x8E, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xE0, 0xE0, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x1F, 0xFF, 0x0F, 0xFF, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x80,
  0x39, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xC0, 0xFE, 0x03,
  0xFF, 0x8F, 0xFF, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x3C, 0xFF, 0xC3, 0xFF, 0xCC, 0x03,
  0xB0, 0x06, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xB0, 0x1E, 0xFF, 0xF3, 0xFF, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0xF0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x36, 0x00, 0xEC,
  0x01, 0xDC, 0x03, 0x1C, 0x0E, 0x3F, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFF,
  0x0F, 0xFE, 0x30, 0x1C, 0xC0, 0x3B, 0x00, 0x6C, 0x01, 0xB0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0xEC,
  0x03, 0x30, 0x3C, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0xFF, 0xEC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xFF, 0xFB, 0xFF, 0xEC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xF0, 0xE3, 0x80, 0xE6, 0x00,
  0xCC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x36, 0x00, 0xEC, 0x01, 0xDC, 0x03, 0x1C, 0x0E,
  0x3F, 0xF8, 0x1F, 0xC0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xD8,
  0x03, 0x3C, 0x0E, 0x3F, 0xF8, 0x1F, 0xC0, 0xC0, 0x0F, 0x80, 0x1B, 0x00,
  0x76, 0x00, 0xCC, 0x03, 0x98, 0x06, 0x30, 0x1C, 0x60, 0x30, 0xC0, 0xE1,
  0x81, 0x83, 0x07, 0x06, 0x0C, 0x0F, 0xF8, 0x1F, 0xF0, 0x30, 0x70, 0x60,
  0xE0, 0xC0, 0xE1, 0x81, 0xC3, 0x01, 0xC6, 0x03, 0x8C, 0x03, 0x98, 0x07,
  0x30, 0x06, 0x60, 0x0E, 0xC0, 0x0D, 0x80, 0x1C, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFD, 0x83, 0x7B, 0x06, 0xF6, 0x0D, 0xE6, 0x33,
  0xCC, 0x67, 0x98, 0xCF, 0x1B, 0x1E, 0x36, 0x3C, 0x2C, 0x78, 0x70, 0xF0,
  0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0C, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xEC, 0x0F, 0x60, 0x7B, 0x03, 0xCC,
  0x1E, 0x60, 0xF3, 0x87, 0x8C, 0x3C, 0x61, 0xE1, 0x8F, 0x0C, 0x78, 0x63,
  0xC1, 0x9E, 0x0C, 0xF0, 0x77, 0x81, 0xBC, 0x0D, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0xF1, 0xE3, 0x80,
  0xE6, 0x00, 0xCC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xCC, 0x01, 0x9C, 0x07,
  0x1C, 0x1C, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE6,
  0x00, 0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x36, 0x00, 0xEC, 0x03, 0x9F, 0xFE, 0x3F, 0xF0, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xF1,
  0xE3, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEC, 0x01,
  0x9C, 0x07, 0x1C, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0xE6, 0x01, 0xCC, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x76, 0x01, 0xEC, 0x0F, 0x9F, 0xFE, 0x3F, 0xE0, 0x60,
  0xC0, 0xC1, 0xC1, 0x81, 0x83, 0x03, 0x86, 0x03, 0x8C, 0x07, 0x18, 0x07,
  0x30, 0x0E, 0x60, 0x0E, 0xC0, 0x1D, 0x80, 0x1C, 0x07, 0xC0, 0x3F, 0xE0,
  0xF0, 0xE3, 0x80, 0xE6, 0x00, 0xEC, 0x01, 0xF8, 0x01, 0xB0, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xB8, 0x0E, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xEE, 0x0E, 0x7F, 0xF0, 0xFE, 0x00,
  0xE0, 0x01, 0xF0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x73, 0x80,
  0x38, 0xC0, 0x18, 0x60, 0x0C, 0x38, 0x0E, 0x0C, 0x06, 0x06, 0x03, 0x03,
  0x01, 0x81, 0xC1, 0xC0, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0E, 0x38,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xE6, 0x00, 0x77, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0xE0, 0x78, 0x1C,
  0x0F, 0x83, 0x83, 0xB0, 0x50, 0x66, 0x0A, 0x0C, 0xC1, 0x61, 0x98, 0x6C,
  0x33, 0x0D, 0x86, 0x61, 0xB0, 0xCC, 0x36, 0x19, 0xC4, 0x43, 0x18, 0x88,
  0xC3, 0x11, 0x18, 0x66, 0x33, 0x0C, 0xC6, 0x61, 0x98, 0xCC, 0x33, 0x19,
  0x86, 0x61, 0x30, 0xC8, 0x26, 0x1D, 0x04, 0xC1, 0xA0, 0xF0, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x80, 0xE0, 0xE0, 0x03,
  0xB0, 0x01, 0x9C, 0x01, 0xC6, 0x00, 0xC3, 0x80, 0xE0, 0xC0, 0x60, 0x30,
  0x60, 0x1C, 0x70, 0x06, 0x30, 0x03, 0xB8, 0x00, 0xD8, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x06, 0x30, 0x03, 0x1C,
  0x03, 0x06, 0x03, 0x83, 0x81, 0x80, 0xC1, 0xC0, 0x70, 0xC0, 0x18, 0xE0,
  0x0E, 0x60, 0x03, 0x70, 0x01, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00,
  0xCC, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0x60, 0x38, 0x30, 0x18, 0x1C,
  0x1C, 0x06, 0x0C, 0x03, 0x8E, 0x00, 0xC6, 0x00, 0x77, 0x00, 0x1B, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0xFF, 0xFF, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x1F, 0x00, 0x36, 0x00, 0x6E, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x18,
  0x18, 0x30, 0x70, 0x70, 0xC0, 0x63, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x87, 0x01, 0x00, 0x7F, 0xC3,
  0xEF, 0x9C, 0x07, 0x60, 0x0D, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x7F, 0xF7, 0xFF, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x1F, 0x80, 0xF7, 0xFE, 0xCF, 0xF3, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x10, 0x33, 0xF8, 0xDD, 0xF3, 0x80,
  0xEE, 0x01, 0xB0, 0x06, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x6E, 0x03, 0xBC,
  0x1E, 0xDF, 0xF3, 0x3F, 0x80, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0x80,
  0xE6, 0x00, 0xCC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xB0, 0x07, 0x70,
  0x0C, 0x70, 0x38, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x20, 0xC7, 0xF3, 0x3E, 0xED, 0xC0,
  0x76, 0x01, 0xD8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0D, 0x80, 0x37, 0x01, 0xDC,
  0x0F, 0x3F, 0xEC, 0x7F, 0x30, 0x01, 0x00, 0x3F, 0xE0, 0xFB, 0xE3, 0x80,
  0xE6, 0x00, 0xCC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x07, 0x70,
  0x0C, 0x70, 0x38, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x7F, 0x33, 0xEE, 0xDC, 0x07, 0x60, 0x1D, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0D, 0x80, 0x36,
  0x01, 0xDC, 0x07, 0x3C, 0xEC, 0x7F, 0xB0, 0x38, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x1F, 0xF8, 0x7F, 0xC0, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x04, 0x19, 0xFC, 0xDD, 0xF7,
  0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x03, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x9F, 0xF8, 0xFF, 0x80, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x06, 0xC0, 0x1D, 0x80, 0x73, 0x01,
  0xC6, 0x03, 0x0C, 0x0E, 0x18, 0x38, 0x30, 0x60, 0x7F, 0xC0, 0xFF, 0x81,
  0x83, 0x03, 0x07, 0x06, 0x07, 0x0C, 0x06, 0x18, 0x0E, 0x30, 0x0E, 0x60,
  0x0C, 0xC0, 0x1D, 0x80, 0x1C, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x0C, 0x11, 0xFC, 0xFB, 0x9D, 0x3E, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x0E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87,
  0x87, 0x0F, 0x0E, 0x1E, 0x1C, 0x30, 0x01, 0x06, 0x7F, 0x37, 0x7D, 0xC0,
  0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x30, 0x03, 0x00, 0x3F, 0xE0, 0xFB, 0xE3, 0x80, 0xE6, 0x00,
  0xCC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB0, 0x06, 0x70, 0x1C, 0x70,
  0x70, 0xFF, 0xE0, 0x7F, 0x00, 0x01, 0x03, 0x3F, 0x8D, 0xDF, 0x38, 0x0E,
  0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x06, 0xE0, 0x3B, 0xC1,
  0xED, 0xFF, 0x33, 0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x7F, 0x33, 0xEE, 0xDC, 0x07, 0x60, 0x1D,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xD8, 0x03, 0x70, 0x1D, 0xE0, 0xF3, 0xFE,
  0xC7, 0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x03, 0xBF, 0xCF, 0xCF, 0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x3F, 0xE0, 0xFF, 0xF3, 0x80, 0xE6, 0x00, 0xEC, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x0E, 0xE0, 0x38, 0xFF, 0xF0,
  0xFF, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0x70, 0x73, 0xFF, 0x07, 0xF0, 0xE0,
  0x03, 0xB0, 0x01, 0x9C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0xC0, 0x70,
  0x60, 0x30, 0x30, 0x18, 0x1C, 0x1C, 0x06, 0x0C, 0x03, 0x06, 0x01, 0xC7,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x1D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x50, 0x78, 0x28,
  0x3C, 0x16, 0x1F, 0x1B, 0x19, 0x8D, 0x8C, 0xC6, 0x46, 0x62, 0x23, 0x31,
  0x11, 0x99, 0x8C, 0xCE, 0xC6, 0x43, 0x63, 0x61, 0xA0, 0xB0, 0xD0, 0x58,
  0x68, 0x2C, 0x3C, 0x1E, 0x1E, 0x0E, 0x07, 0x07, 0x00, 0x70, 0x07, 0x1C,
  0x07, 0x06, 0x03, 0x03, 0x83, 0x80, 0xE1, 0x80, 0x31, 0x80, 0x1D, 0xC0,
  0x06, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0x63,
  0x00, 0x71, 0xC0, 0x70, 0x70, 0x30, 0x18, 0x38, 0x0E, 0x38, 0x03, 0xB8,
  0x00, 0xE0, 0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC6, 0x00, 0xC3, 0x80,
  0xE0, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x38, 0x0C, 0x18, 0x07, 0x0C, 0x01,
  0x8E, 0x00, 0xC6, 0x00, 0x73, 0x00, 0x1B, 0x80, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF8,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x01, 0xFC,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x01, 0xFC, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0xFE, 0x07, 0x80, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x7E, 0x00, 0xF8,
  0x00, 0x38, 0x06, 0xFC, 0x0F, 0x9C, 0x1E, 0x1C, 0x3C, 0x1C, 0x78, 0x1F,
  0xF0, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 26, 21, 8, -26 },
  { 18, 9, 11, 21, 6, -26 },
  { 31, 19, 26, 21, 1, -26 },
  { 93, 15, 35, 21, 3, -30 },
  { 159, 19, 26, 21, 1, -26 },
  { 221, 18, 26, 21, 2, -26 },
  { 280, 3, 11, 21, 9, -26 },
  { 285, 10, 33, 21, 7, -29 },
  { 327, 10, 33, 21, 4, -29 },
  { 369, 19, 18, 21, 1, -21 },
  { 412, 17, 17, 21, 2, -20 },
  { 449, 7, 11, 21, 6, -5 },
  { 459, 11, 2, 21, 5, -13 },
  { 462, 5, 5, 21, 8, -5 },
  { 466, 15, 33, 21, 3, -29 },
  { 528, 15, 26, 21, 3, -26 },
  { 577, 16, 26, 21, 3, -26 },
  { 629, 15, 26, 21, 3, -26 },
  { 678, 14, 26, 21, 3, -26 },
  { 724, 14, 26, 21, 3, -26 },
  { 770, 15, 26, 21, 3, -26 },
  { 819, 15, 26, 21, 3, -26 },
  { 868, 16, 26, 21, 3, -26 },
  { 920, 15, 26, 21, 3, -26 },
  { 969, 15, 26, 21, 3, -26 },
  { 1018, 5, 20, 21, 8, -20 },
  { 1031, 7, 26, 21, 6, -20 },
  { 1054, 15, 18, 21, 3, -21 },
  { 1088, 15, 11, 21, 3, -17 },
  { 1109, 15, 18, 21, 3, -21 },
  { 1143, 12, 26, 21, 5, -26 },
  { 1182, 17, 32, 21, 2, -26 },
  { 1250, 17, 26, 21, 2, -26 },
  { 1306, 14, 26, 21, 4, -26 },
  { 1352, 15, 26, 21, 3, -26 },
  { 1401, 14, 26, 21, 4, -26 },
  { 1447, 14, 26, 21, 4, -26 },
  { 1493, 14, 26, 21, 4, -26 },
  { 1539, 15, 26, 21, 3, -26 },
  { 1588, 13, 26, 21, 4, -26 },
  { 1631, 13, 26, 21, 4, -26 },
  { 1674, 15, 26, 21, 2, -26 },
  { 1723, 15, 26, 21, 4, -26 },
  { 1772, 15, 26, 21, 4, -26 },
  { 1821, 15, 26, 21, 3, -26 },
  { 1870, 13, 26, 21, 4, -26 },
  { 1913, 15, 26, 21, 3, -26 },
  { 1962, 15, 26, 21, 4, -26 },
  { 2011, 15, 32, 21, 3, -26 },
  { 2071, 15, 26, 21, 4, -26 },
  { 2120, 15, 26, 21, 3, -26 },
  { 2169, 17, 26, 21, 2, -26 },
  { 2225, 13, 26, 21, 4, -26 },
  { 2268, 17, 26, 21, 2, -26 },
  { 2324, 19, 26, 21, 1, -26 },
  { 2386, 17, 26, 21, 2, -26 },
  { 2442, 17, 26, 21, 2, -26 },
  { 2498, 15, 26, 21, 3, -26 },
  { 2547, 9, 33, 21, 7, -29 },
  { 2585, 15, 33, 21, 3, -29 },
  { 2647, 9, 33, 21, 5, -29 },
  { 2685, 15, 14, 21, 3, -26 },
  { 2712, 17, 2, 21, 2, 1 },
  { 2717, 6, 4, 21, 7, -27 },
  { 2720, 14, 20, 21, 3, -20 },
  { 2755, 14, 26, 21, 4, -26 },
  { 2801, 15, 20, 21, 3, -20 },
  { 2839, 14, 26, 21, 3, -26 },
  { 2885, 15, 20, 21, 3, -20 },
  { 2923, 16, 26, 21, 2, -26 },
  { 2975, 14, 26, 21, 3, -20 },
  { 3021, 13, 26, 21, 4, -26 },
  { 3064, 16, 27, 21, 3, -27 },
  { 3118, 13, 33, 21, 3, -27 },
  { 3172, 15, 26, 21, 4, -26 },
  { 3221, 18, 26, 21, 1, -26 },
  { 3280, 15, 20, 21, 3, -20 },
  { 3318, 13, 20, 21, 4, -20 },
  { 3351, 15, 20, 21, 3, -20 },
  { 3389, 14, 26, 21, 4, -20 },
  { 3435, 14, 26, 21, 3, -20 },
  { 3481, 14, 20, 21, 4, -20 },
  { 3516, 15, 20, 21, 3, -20 },
  { 3554, 16, 25, 21, 2, -25 },
  { 3604, 13, 19, 21, 4, -19 },
  { 3635, 17, 19, 21, 2, -19 },
  { 3676, 17, 19, 21, 2, -19 },
  { 3717, 17, 19, 21, 2, -19 },
  { 3758, 17, 25, 21, 2, -19 },
  { 3812, 15, 19, 21, 3, -19 },
  { 3848, 15, 33, 21, 3, -29 },
  { 3910, 3, 33, 21, 9, -29 },
  { 3923, 15, 33, 21, 3, -29 },
  { 3985, 15, 7, 21, 3, -16 },
};

const GFXfont JetBrainsMono_ExtraLight35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_EXTRALIGHT35PT7B_H_
