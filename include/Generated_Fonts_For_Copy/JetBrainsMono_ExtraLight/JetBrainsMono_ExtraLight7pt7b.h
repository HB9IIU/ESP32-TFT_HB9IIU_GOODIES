#ifndef _JETBRAINSMONO_EXTRALIGHT7PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x5F, 0x6F, 0xA0, 0x56, 0x27, 0x50, 0xDE, 0x27, 0xB0,
  0x64, 0xDA, 0xF0, 0xC0, 0x6A, 0xA4, 0x95, 0x58, 0x2F, 0x60, 0x2F, 0x20,
  0xE0, 0xC0, 0x80, 0x29, 0x29, 0x20, 0xF6, 0xDC, 0xC9, 0x2E, 0xE5, 0x4E,
  0xD5, 0xC0, 0x6F, 0x40, 0xDA, 0x9C, 0x53, 0xDC, 0xE5, 0x28, 0xF7, 0x5E,
  0xF6, 0xA8, 0x90, 0x43, 0x80, 0x71, 0x80, 0xFC, 0x8F, 0x00, 0xD6, 0x80,
  0x7B, 0xDD, 0xB6, 0x26, 0x66, 0x90, 0xF7, 0x5C, 0xF2, 0x4E, 0xD6, 0xDC,
  0xF3, 0x4E, 0xF3, 0x48, 0xF3, 0xDE, 0xFF, 0xC0, 0xD5, 0xC0, 0x24, 0x9E,
  0xBB, 0x6A, 0x92, 0x4E, 0xBE, 0xDA, 0xFF, 0xC0, 0xF6, 0xDC, 0xF7, 0x48,
  0xF6, 0xDC, 0xC0, 0xF7, 0x6A, 0xF1, 0x1E, 0xF2, 0x22, 0x20, 0xB6, 0xDC,
  0x95, 0x66, 0x20, 0xDB, 0xB5, 0x60, 0xD6, 0x26, 0x90, 0x96, 0x22, 0x20,
  0xE9, 0x4E, 0xEA, 0xAC, 0x92, 0x24, 0x88, 0xD5, 0x5C, 0x5A, 0x80, 0xF0,
  0xC0, 0xCE, 0xF0, 0x9A, 0xDC, 0xD6, 0x70, 0x7F, 0xC0, 0xD7, 0x70, 0x7F,
  0x44, 0x40, 0xFF, 0xC0, 0x9A, 0xDA, 0x51, 0x2E, 0x75, 0x70, 0x97, 0x6A,
  0xC4, 0x44, 0x70, 0xF6, 0xD0, 0xD6, 0xD0, 0xD6, 0xE0, 0xD6, 0xE8, 0xFF,
  0x40, 0xD6, 0x40, 0xF1, 0xF0, 0x4F, 0x44, 0x70, 0xB6, 0xE0, 0x95, 0x62,
  0xBB, 0x66, 0x56, 0x2D, 0x96, 0x62, 0x40, 0xCA, 0x70, 0x69, 0x44, 0x98,
  0xFE, 0x92, 0x39, 0x20, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 7, 4, 1, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 4, 2, -5 },
  { 16, 2, 7, 4, 1, -6 },
  { 18, 2, 7, 4, 1, -6 },
  { 20, 4, 3, 4, 0, -4 },
  { 22, 4, 3, 4, 0, -4 },
  { 24, 2, 2, 4, 1, -1 },
  { 25, 2, 1, 4, 1, -3 },
  { 26, 1, 1, 4, 2, -1 },
  { 27, 3, 7, 4, 1, -6 },
  { 30, 3, 5, 4, 1, -5 },
  { 32, 3, 5, 4, 1, -5 },
  { 34, 3, 5, 4, 1, -5 },
  { 36, 2, 5, 4, 1, -5 },
  { 38, 2, 5, 4, 1, -5 },
  { 40, 3, 5, 4, 1, -5 },
  { 42, 3, 5, 4, 1, -5 },
  { 44, 3, 5, 4, 1, -5 },
  { 46, 3, 5, 4, 1, -5 },
  { 48, 3, 5, 4, 1, -5 },
  { 50, 1, 4, 4, 2, -4 },
  { 51, 2, 5, 4, 1, -4 },
  { 53, 3, 3, 4, 1, -4 },
  { 55, 3, 2, 4, 1, -3 },
  { 56, 3, 3, 4, 1, -4 },
  { 58, 2, 5, 4, 1, -5 },
  { 60, 4, 6, 4, 0, -5 },
  { 63, 4, 5, 4, 0, -5 },
  { 66, 3, 5, 4, 1, -5 },
  { 68, 3, 5, 4, 1, -5 },
  { 70, 3, 5, 4, 1, -5 },
  { 72, 3, 5, 4, 1, -5 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 3, 5, 4, 1, -5 },
  { 78, 2, 5, 4, 1, -5 },
  { 80, 2, 5, 4, 1, -5 },
  { 82, 3, 5, 4, 0, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 3, 5, 4, 1, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 2, 5, 4, 1, -5 },
  { 92, 3, 5, 4, 1, -5 },
  { 94, 3, 5, 4, 1, -5 },
  { 96, 3, 6, 4, 1, -5 },
  { 99, 3, 5, 4, 1, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 3, 5, 4, 1, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 3, 5, 4, 1, -5 },
  { 122, 2, 7, 4, 1, -6 },
  { 124, 3, 7, 4, 1, -6 },
  { 127, 2, 7, 4, 1, -6 },
  { 129, 3, 3, 4, 1, -5 },
  { 131, 4, 1, 4, 0, 0 },
  { 132, 2, 1, 4, 1, -6 },
  { 133, 3, 4, 4, 1, -4 },
  { 135, 3, 5, 4, 1, -5 },
  { 137, 3, 4, 4, 1, -4 },
  { 139, 2, 5, 4, 1, -5 },
  { 141, 3, 4, 4, 1, -4 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 2, 5, 4, 1, -4 },
  { 148, 3, 5, 4, 1, -5 },
  { 150, 3, 5, 4, 1, -5 },
  { 152, 2, 6, 4, 1, -5 },
  { 154, 3, 5, 4, 1, -5 },
  { 156, 4, 5, 4, 0, -5 },
  { 159, 3, 4, 4, 1, -4 },
  { 161, 3, 4, 4, 1, -4 },
  { 163, 3, 4, 4, 1, -4 },
  { 165, 3, 5, 4, 1, -4 },
  { 167, 2, 5, 4, 1, -4 },
  { 169, 3, 4, 4, 1, -4 },
  { 171, 3, 4, 4, 1, -4 },
  { 173, 4, 5, 4, 0, -5 },
  { 176, 3, 4, 4, 1, -4 },
  { 178, 4, 4, 4, 0, -4 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 4, 4, 4, 0, -4 },
  { 184, 4, 5, 4, 0, -4 },
  { 187, 3, 4, 4, 1, -4 },
  { 189, 3, 7, 4, 1, -6 },
  { 192, 1, 7, 4, 2, -6 },
  { 193, 3, 7, 4, 1, -6 },
  { 196, 3, 1, 4, 1, -3 },
};

const GFXfont JetBrainsMono_ExtraLight7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_EXTRALIGHT7PT7B_H_
