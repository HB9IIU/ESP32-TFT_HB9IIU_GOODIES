#ifndef _JETBRAINSMONO_EXTRALIGHT16PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight16pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x8F, 0x99, 0x99, 0x90, 0x12, 0x22, 0x22, 0x22, 0xFD,
  0x24, 0x44, 0x44, 0xFE, 0x44, 0x48, 0x88, 0x10, 0x20, 0xF2, 0xB5, 0x2A,
  0x14, 0x18, 0x1C, 0x24, 0x4C, 0x95, 0x27, 0x84, 0x08, 0x70, 0xA8, 0x62,
  0x51, 0x45, 0x41, 0x20, 0x20, 0x2F, 0x14, 0x92, 0x51, 0x38, 0x70, 0x38,
  0x44, 0x44, 0x40, 0x40, 0x60, 0x91, 0x9A, 0x8A, 0x84, 0x8A, 0x7B, 0xF8,
  0x19, 0x11, 0x88, 0x42, 0x10, 0x84, 0x20, 0x84, 0x18, 0x20, 0xC2, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x26, 0x80, 0x10, 0x10, 0x10, 0xD7, 0x38, 0x18,
  0x24, 0x46, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x6B, 0x48, 0xF8,
  0xF0, 0x02, 0x0C, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x60, 0x81, 0x04,
  0x08, 0x30, 0x00, 0x38, 0x8D, 0x0E, 0x1C, 0x3A, 0x76, 0xE1, 0xC3, 0x85,
  0x09, 0xE0, 0x30, 0xA2, 0x44, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47,
  0xF0, 0x38, 0x8E, 0x0C, 0x10, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x07, 0xF0,
  0x7E, 0x0C, 0x10, 0x41, 0x03, 0x80, 0x81, 0x03, 0x05, 0x1B, 0xE0, 0x04,
  0x18, 0x20, 0x83, 0x04, 0x50, 0xE1, 0xFE, 0x04, 0x08, 0x10, 0x7E, 0x81,
  0x02, 0x05, 0x8C, 0xD0, 0x81, 0x03, 0x85, 0x09, 0xE0, 0x08, 0x30, 0x41,
  0x02, 0x0F, 0x90, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0xFF, 0x06, 0x08, 0x10,
  0x40, 0x83, 0x04, 0x08, 0x20, 0x41, 0x80, 0x38, 0x8D, 0x0A, 0x14, 0x67,
  0x0F, 0x21, 0xC3, 0x05, 0x0B, 0xE0, 0x38, 0x8F, 0x0C, 0x18, 0x28, 0x5F,
  0x82, 0x0C, 0x10, 0x41, 0x80, 0xF0, 0x03, 0xC0, 0x6C, 0x00, 0x03, 0x5A,
  0x40, 0x02, 0x18, 0xC6, 0x06, 0x03, 0x01, 0x81, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0xC0, 0x60, 0x30, 0x10, 0x63, 0x18, 0x40, 0xF0, 0x20, 0x41, 0x04,
  0x23, 0x08, 0x20, 0x06, 0x18, 0x3C, 0x42, 0x81, 0x81, 0x8D, 0x93, 0x91,
  0x91, 0x91, 0x91, 0x9F, 0x80, 0x80, 0x40, 0x38, 0x18, 0x18, 0x18, 0x28,
  0x24, 0x24, 0x44, 0x44, 0x7E, 0x42, 0x82, 0x83, 0xF2, 0x38, 0x61, 0x87,
  0xE9, 0xA1, 0x86, 0x18, 0x7E, 0x7B, 0x38, 0x61, 0x82, 0x08, 0x20, 0x82,
  0x18, 0x5E, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0xBC, 0xFE,
  0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82,
  0x0F, 0xE0, 0x82, 0x08, 0x20, 0x7B, 0x38, 0x61, 0x82, 0x09, 0xE1, 0x86,
  0x18, 0x5E, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x61, 0xFC,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x3F, 0x1E, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x03, 0x07, 0x13, 0xE0, 0x87, 0x0A, 0x34, 0x49, 0x9E,
  0x24, 0x4C, 0x89, 0x1A, 0x14, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x3F, 0xC3, 0x8E, 0x9D, 0x3A, 0xB3, 0x64, 0xC1, 0x83, 0x06,
  0x0C, 0x10, 0x87, 0x1C, 0x71, 0xA6, 0x9A, 0x65, 0x96, 0x38, 0xE3, 0x72,
  0x38, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0xDE, 0xF1, 0x1A, 0x14, 0x18,
  0x70, 0xBE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x72, 0x38, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x5E, 0x08, 0x20, 0x40, 0xF1, 0x1A, 0x14, 0x28, 0x51,
  0xBE, 0x48, 0x89, 0x12, 0x14, 0x30, 0x3C, 0x8D, 0x0A, 0x04, 0x06, 0x03,
  0x01, 0x03, 0x05, 0x0B, 0xE0, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0xDE, 0x81, 0x82, 0x42, 0x42, 0x46, 0x44, 0x24, 0x24, 0x28, 0x28,
  0x18, 0x18, 0x91, 0x99, 0x99, 0x99, 0x99, 0xAA, 0xAA, 0xA6, 0x66, 0x66,
  0x66, 0x46, 0x83, 0x42, 0x44, 0x24, 0x28, 0x18, 0x18, 0x28, 0x24, 0x44,
  0x42, 0x83, 0x81, 0x82, 0x42, 0x44, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFE, 0x04, 0x10, 0x20, 0x81, 0x04, 0x18, 0x20, 0x81, 0x07,
  0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0, 0x81, 0x81,
  0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40, 0x40, 0x80, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x10, 0x30, 0xA1, 0x24, 0x48,
  0x70, 0x80, 0xFF, 0x88, 0x80, 0x3C, 0x8D, 0x08, 0x17, 0xF8, 0x60, 0xE3,
  0x7A, 0x82, 0x08, 0x3E, 0x8E, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x7A, 0x38,
  0x60, 0x82, 0x08, 0x61, 0x78, 0x04, 0x10, 0x5D, 0x8E, 0x18, 0x61, 0x86,
  0x18, 0xDD, 0x7A, 0x38, 0x61, 0xFE, 0x08, 0x21, 0x78, 0x0E, 0x20, 0x40,
  0x8F, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x76, 0x38, 0x61, 0x86,
  0x18, 0x7F, 0x04, 0x10, 0xDE, 0x82, 0x08, 0x3E, 0x8E, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x18, 0x08, 0x00, 0x78, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x0C, 0x10, 0x1F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x2F, 0x00, 0x81, 0x02, 0x04, 0x38, 0xD1, 0x24, 0x78, 0x91, 0x12, 0x34,
  0x30, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x1F, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0x92, 0xFA, 0x38, 0x61,
  0x86, 0x18, 0x61, 0x84, 0x7A, 0x38, 0x61, 0x86, 0x18, 0x61, 0x78, 0xFA,
  0x38, 0x61, 0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x76, 0x38, 0x61, 0x86,
  0x18, 0x63, 0x74, 0x10, 0x41, 0xBB, 0x18, 0x61, 0x82, 0x08, 0x20, 0x80,
  0x3C, 0x85, 0x02, 0x03, 0xC0, 0x60, 0xA1, 0x7C, 0x10, 0x23, 0xF8, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x78, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63,
  0x78, 0x83, 0x42, 0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x18, 0x91, 0x99,
  0x99, 0x9A, 0xAA, 0x6A, 0x66, 0x66, 0x64, 0xC2, 0x44, 0x24, 0x38, 0x10,
  0x38, 0x24, 0x46, 0xC3, 0x83, 0x42, 0x42, 0x64, 0x24, 0x2C, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x20, 0xFC, 0x30, 0x84, 0x21, 0x84, 0x20, 0xFC, 0x0E,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x78, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01,
  0x80, 0xFF, 0xFE, 0xE0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0x10, 0x20,
  0x40, 0x81, 0x06, 0x38, 0x00, 0x73, 0x36, 0x38,
};

const GFXglyph JetBrainsMono_ExtraLight16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 5, 10, 3, -12 },
  { 7, 8, 12, 10, 1, -12 },
  { 19, 7, 16, 10, 1, -14 },
  { 33, 9, 12, 10, 0, -12 },
  { 47, 8, 12, 10, 1, -12 },
  { 59, 1, 5, 10, 4, -12 },
  { 60, 5, 15, 10, 3, -13 },
  { 70, 4, 15, 10, 2, -13 },
  { 78, 8, 8, 10, 1, -10 },
  { 86, 7, 7, 10, 1, -9 },
  { 93, 3, 5, 10, 3, -2 },
  { 95, 5, 1, 10, 2, -6 },
  { 96, 2, 2, 10, 4, -2 },
  { 97, 7, 15, 10, 1, -13 },
  { 111, 7, 12, 10, 1, -12 },
  { 122, 7, 12, 10, 2, -12 },
  { 133, 7, 12, 10, 1, -12 },
  { 144, 7, 12, 10, 1, -12 },
  { 155, 7, 12, 10, 1, -12 },
  { 166, 7, 12, 10, 1, -12 },
  { 177, 7, 12, 10, 1, -12 },
  { 188, 7, 12, 10, 1, -12 },
  { 199, 7, 12, 10, 1, -12 },
  { 210, 7, 12, 10, 1, -12 },
  { 221, 2, 9, 10, 4, -9 },
  { 224, 3, 12, 10, 3, -9 },
  { 229, 7, 8, 10, 1, -9 },
  { 236, 7, 5, 10, 1, -8 },
  { 241, 7, 8, 10, 1, -9 },
  { 248, 6, 12, 10, 2, -12 },
  { 257, 8, 15, 10, 1, -12 },
  { 272, 8, 12, 10, 1, -12 },
  { 284, 6, 12, 10, 2, -12 },
  { 293, 6, 12, 10, 2, -12 },
  { 302, 6, 12, 10, 2, -12 },
  { 311, 6, 12, 10, 2, -12 },
  { 320, 6, 12, 10, 2, -12 },
  { 329, 6, 12, 10, 2, -12 },
  { 338, 6, 12, 10, 2, -12 },
  { 347, 6, 12, 10, 2, -12 },
  { 356, 7, 12, 10, 1, -12 },
  { 367, 7, 12, 10, 2, -12 },
  { 378, 6, 12, 10, 2, -12 },
  { 387, 7, 12, 10, 1, -12 },
  { 398, 6, 12, 10, 2, -12 },
  { 407, 6, 12, 10, 2, -12 },
  { 416, 7, 12, 10, 2, -12 },
  { 427, 6, 15, 10, 2, -12 },
  { 439, 7, 12, 10, 2, -12 },
  { 450, 7, 12, 10, 1, -12 },
  { 461, 8, 12, 10, 1, -12 },
  { 473, 6, 12, 10, 2, -12 },
  { 482, 8, 12, 10, 1, -12 },
  { 494, 8, 12, 10, 1, -12 },
  { 506, 8, 12, 10, 1, -12 },
  { 518, 8, 12, 10, 1, -12 },
  { 530, 7, 12, 10, 1, -12 },
  { 541, 4, 15, 10, 3, -13 },
  { 549, 7, 15, 10, 1, -13 },
  { 563, 4, 15, 10, 2, -13 },
  { 571, 7, 7, 10, 1, -12 },
  { 578, 8, 1, 10, 1, 0 },
  { 579, 3, 3, 10, 3, -13 },
  { 581, 7, 9, 10, 1, -9 },
  { 589, 6, 12, 10, 2, -12 },
  { 598, 6, 9, 10, 2, -9 },
  { 605, 6, 12, 10, 2, -12 },
  { 614, 6, 9, 10, 2, -9 },
  { 621, 7, 12, 10, 1, -12 },
  { 632, 6, 12, 10, 2, -9 },
  { 641, 6, 12, 10, 2, -12 },
  { 650, 8, 12, 10, 1, -12 },
  { 662, 6, 15, 10, 1, -12 },
  { 674, 7, 12, 10, 2, -12 },
  { 685, 8, 12, 10, 1, -12 },
  { 697, 7, 9, 10, 1, -9 },
  { 705, 6, 9, 10, 2, -9 },
  { 712, 6, 9, 10, 2, -9 },
  { 719, 6, 12, 10, 2, -9 },
  { 728, 6, 12, 10, 2, -9 },
  { 737, 6, 9, 10, 2, -9 },
  { 744, 7, 9, 10, 1, -9 },
  { 752, 7, 11, 10, 1, -11 },
  { 762, 6, 9, 10, 2, -9 },
  { 769, 8, 9, 10, 1, -9 },
  { 778, 8, 9, 10, 1, -9 },
  { 787, 8, 9, 10, 1, -9 },
  { 796, 8, 12, 10, 1, -9 },
  { 808, 6, 9, 10, 2, -9 },
  { 815, 7, 15, 10, 1, -13 },
  { 829, 1, 15, 10, 4, -13 },
  { 831, 7, 15, 10, 1, -13 },
  { 845, 7, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_ExtraLight16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_EXTRALIGHT16PT7B_H_
