#ifndef _JETBRAINSMONO_EXTRALIGHT24PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight24pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xC9, 0x24, 0x02, 0xFC, 0xC7, 0x8F, 0x1E, 0x3C,
  0x58, 0xB1, 0x62, 0x0C, 0x20, 0x61, 0x02, 0x08, 0x10, 0xC0, 0x86, 0x3F,
  0xFD, 0xFF, 0xE2, 0x08, 0x10, 0xC0, 0x86, 0x04, 0x20, 0x61, 0x0F, 0xFF,
  0x10, 0xC0, 0x86, 0x04, 0x20, 0x61, 0x03, 0x08, 0x00, 0x04, 0x01, 0x00,
  0x40, 0x38, 0x3F, 0x99, 0x34, 0x4F, 0x11, 0xC4, 0x19, 0x07, 0x40, 0xF0,
  0x0F, 0x01, 0x60, 0x4C, 0x11, 0x04, 0x71, 0x1C, 0x4D, 0xD7, 0x3F, 0x01,
  0x00, 0x40, 0x10, 0x18, 0x05, 0xF0, 0x24, 0x61, 0x90, 0x84, 0x42, 0x21,
  0x09, 0x04, 0x6C, 0x1F, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x27, 0x01, 0x36,
  0x0C, 0x8C, 0x26, 0x31, 0x18, 0xCC, 0x63, 0x60, 0xCB, 0x01, 0xE0, 0x0E,
  0x00, 0xFC, 0x0C, 0x30, 0x41, 0x82, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x3C, 0x03, 0x60, 0x91, 0x8D, 0x86, 0xCC, 0x16, 0x60, 0xE3, 0x03, 0x08,
  0x3C, 0x63, 0x21, 0xF1, 0xC0, 0xFF, 0xFF, 0x06, 0x38, 0xC3, 0x04, 0x18,
  0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x81, 0x83,
  0x03, 0x83, 0xC1, 0x80, 0xC1, 0xC0, 0xC0, 0xC0, 0xC1, 0x81, 0x03, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0xC3, 0x1C, 0x20,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC6, 0x3F, 0xAF, 0x1F, 0xC0,
  0x60, 0x0D, 0x01, 0x98, 0x18, 0xC3, 0x0E, 0x10, 0x40, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x39, 0x8C, 0xC6, 0x31, 0x18, 0xFF, 0xFF, 0x7F, 0x70, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x00, 0x1E, 0x0F, 0xE6, 0x1F, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xCC, 0x73, 0x9C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0D, 0x03,
  0x71, 0x8F, 0xC0, 0x06, 0x03, 0xC0, 0xD8, 0x33, 0x0C, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x1F, 0xFC, 0x1E, 0x0F, 0xF1, 0x83, 0x60, 0x6C, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x1F, 0xFC, 0x7F, 0xDF, 0xF0, 0x18, 0x04, 0x02, 0x01,
  0x00, 0xC0, 0x7C, 0x03, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xF0, 0x3C, 0x0F,
  0x03, 0x61, 0x8F, 0xC0, 0x01, 0x80, 0x40, 0x30, 0x18, 0x04, 0x03, 0x01,
  0x80, 0x40, 0x30, 0xD8, 0x36, 0x0F, 0x03, 0xC0, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x7F, 0xDF, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x41,
  0x7E, 0x61, 0x90, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x1C, 0x0D, 0x03, 0x71,
  0x8F, 0xC0, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x30, 0x7F, 0x9C, 0x1B, 0x03, 0x60, 0x28, 0x07, 0x00, 0xB0, 0x16, 0x06,
  0x71, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x2C, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x0E, 0x0F, 0xE6, 0x0D, 0x03, 0xC0, 0x50, 0x36,
  0x0C, 0xC6, 0x1E, 0x07, 0xC6, 0x19, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0x61, 0x8F, 0xC0, 0x1E, 0x07, 0xF1, 0x83, 0x60, 0x6C, 0x05, 0x80, 0xE0,
  0x1E, 0x02, 0xC0, 0xCE, 0x38, 0xFE, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x7F, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x70, 0x7B,
  0xCE, 0x00, 0x00, 0x00, 0x01, 0xCC, 0x67, 0x31, 0x88, 0xC0, 0x00, 0x40,
  0x70, 0x70, 0x70, 0x38, 0x38, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x03,
  0x00, 0xE0, 0xFC, 0x06, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x7C, 0x60,
  0x60, 0x60, 0x00, 0x00, 0x20, 0x70, 0x70, 0x07, 0x01, 0xFC, 0x30, 0x66,
  0x03, 0x40, 0x1C, 0x01, 0xC1, 0x9C, 0x7D, 0xC6, 0x3C, 0x41, 0xC4, 0x1C,
  0x41, 0xC4, 0x1C, 0x41, 0xC6, 0x3C, 0x7D, 0xC1, 0x84, 0x00, 0x60, 0x06,
  0x00, 0x38, 0x01, 0xF8, 0x06, 0x00, 0x70, 0x07, 0x00, 0xD0, 0x0D, 0x00,
  0x98, 0x09, 0x81, 0x88, 0x18, 0x81, 0x0C, 0x30, 0xC3, 0x04, 0x3F, 0xC2,
  0x06, 0x60, 0x66, 0x02, 0x40, 0x3C, 0x03, 0xFC, 0x1F, 0xF3, 0x06, 0x60,
  0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xFF, 0x1F, 0xF3, 0x03, 0x60, 0x2C,
  0x05, 0x80, 0xF0, 0x16, 0x06, 0xC3, 0x9F, 0xE0, 0x0E, 0x0F, 0xE6, 0x0D,
  0x03, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x05, 0x83, 0x71, 0x8F, 0xC0, 0xF8, 0x3F, 0xCC, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x06, 0xC7, 0xBF, 0x80, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xBF, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x0E, 0x0F, 0xE6, 0x0D, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x31, 0xFC, 0x7F, 0x01, 0xC0, 0x70, 0x1C, 0x05, 0x83, 0x71, 0x8F,
  0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30,
  0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x7F, 0xC0, 0x07, 0xE0, 0xFC,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x07, 0x80, 0xD0, 0x1B, 0x06, 0x71, 0xC3, 0xF0, 0xC0, 0x78,
  0x0B, 0x03, 0x60, 0x4C, 0x19, 0x82, 0x30, 0xC6, 0x10, 0xFE, 0x1F, 0xC3,
  0x08, 0x61, 0x8C, 0x11, 0x83, 0x30, 0x26, 0x06, 0xC0, 0x58, 0x0C, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xC0, 0xF8,
  0x3A, 0x1E, 0x85, 0xB1, 0x74, 0xDD, 0x27, 0x69, 0xCE, 0x73, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x10, 0xE0, 0xF8, 0x3E,
  0x0F, 0xC3, 0xD0, 0xF4, 0x3D, 0x8F, 0x23, 0xCC, 0xF1, 0x3C, 0x4F, 0x1B,
  0xC2, 0xF0, 0xFC, 0x3F, 0x05, 0xC1, 0xF0, 0x30, 0x0E, 0x0F, 0xE6, 0x19,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0D, 0x03, 0x71, 0x8F, 0xC0, 0xFC, 0x1F, 0xF3, 0x03, 0x60,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xDF, 0xF3, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x0F, 0xE6, 0x0B,
  0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0D, 0x03, 0x71, 0x8F, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0xFC, 0x1F, 0xF3, 0x03, 0x60, 0x2C, 0x07, 0x80, 0xF0, 0x1E, 0x06, 0xC1,
  0xDF, 0xF3, 0x18, 0x61, 0x8C, 0x31, 0x83, 0x30, 0x66, 0x06, 0xC0, 0xD8,
  0x0C, 0x1E, 0x0F, 0xE6, 0x0D, 0x03, 0xC0, 0x70, 0x06, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x1C, 0x07, 0x03, 0x71, 0xCF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x34, 0x0D, 0x83, 0x71,
  0x8F, 0xC0, 0xC0, 0x34, 0x03, 0x60, 0x26, 0x02, 0x20, 0x62, 0x06, 0x30,
  0x43, 0x04, 0x10, 0xC1, 0x0C, 0x18, 0x81, 0x98, 0x09, 0x80, 0xD0, 0x0D,
  0x00, 0xF0, 0x07, 0x00, 0x60, 0x86, 0x1C, 0x30, 0xB1, 0x85, 0x8E, 0x2C,
  0x51, 0x62, 0x89, 0x14, 0xC9, 0x26, 0x49, 0x32, 0x49, 0x92, 0x48, 0xD1,
  0x46, 0x8A, 0x34, 0x51, 0xE2, 0x86, 0x1C, 0x30, 0xE1, 0x87, 0x00, 0xC0,
  0x36, 0x02, 0x20, 0x63, 0x04, 0x10, 0xC1, 0x98, 0x0D, 0x00, 0xF0, 0x06,
  0x00, 0x60, 0x0F, 0x00, 0x98, 0x19, 0x81, 0x0C, 0x30, 0x42, 0x06, 0x60,
  0x2C, 0x03, 0xC0, 0x14, 0x03, 0x60, 0x22, 0x06, 0x30, 0x41, 0x0C, 0x18,
  0x80, 0x98, 0x0D, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x0C, 0x02, 0x01, 0x80,
  0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01,
  0x00, 0xC0, 0x3F, 0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xC0, 0x10,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00,
  0x80, 0x30, 0x04, 0xFF, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xFF, 0xE0, 0x0C, 0x03, 0x00, 0xE0, 0x68, 0x13,
  0x0C, 0x42, 0x19, 0x82, 0x40, 0xF0, 0x30, 0xFF, 0xF0, 0xC6, 0x23, 0x3F,
  0x18, 0x64, 0x0E, 0x03, 0x00, 0xC3, 0xF7, 0xFF, 0x03, 0x80, 0xE0, 0x3C,
  0x0F, 0x87, 0x7E, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCE,
  0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0xF1, 0xB7, 0xC0, 0x3F, 0x18, 0x64, 0x0F, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x36, 0x0D, 0xC6, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xCF, 0xB6, 0x1D, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0D, 0x03, 0x61, 0xCF, 0xB0, 0x3F, 0x18, 0x64, 0x0F, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x04, 0x0D, 0xC6, 0x3F, 0x00,
  0x01, 0xE1, 0xFC, 0x30, 0x04, 0x00, 0x80, 0x10, 0x3F, 0xFF, 0xFF, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x3E, 0xD8, 0x74, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xD8, 0x37, 0x3C, 0xFB, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x3F, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCE, 0x1B, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFC, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x67, 0xE0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x38, 0x1A, 0x0C, 0x86, 0x21,
  0x8F, 0xC3, 0xF0, 0x8C, 0x21, 0x88, 0x32, 0x0C, 0x81, 0xA0, 0x30, 0xFC,
  0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x3F, 0xBB, 0xD9, 0x8A, 0x31, 0xC6, 0x38, 0xC7, 0x18, 0xE3, 0x1C,
  0x63, 0x8C, 0x71, 0x8E, 0x31, 0xC6, 0x38, 0xC6, 0xDF, 0x38, 0x6E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xC0, 0x3F, 0x18, 0x64, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x34, 0x0D, 0xC6, 0x3F, 0x00, 0xDF, 0x38, 0x6E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0xC6, 0xDF, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x00, 0x3E, 0xD8, 0x74, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x34, 0x0D, 0xC7, 0x3E, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0xBF, 0x28, 0x6C, 0x0B, 0x03, 0x80, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x3F, 0x98, 0x34, 0x0D, 0x00,
  0x60, 0x1F, 0x01, 0xF8, 0x03, 0x00, 0xC0, 0x1C, 0x05, 0x87, 0x3F, 0x80,
  0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x07, 0xC0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD0, 0x36, 0x0D,
  0xC6, 0x3F, 0x00, 0xC0, 0x78, 0x09, 0x03, 0x30, 0x66, 0x08, 0x43, 0x0C,
  0x41, 0x88, 0x13, 0x03, 0x40, 0x68, 0x07, 0x00, 0xC0, 0xC6, 0x1C, 0x61,
  0x46, 0x34, 0x53, 0x45, 0x34, 0x92, 0x69, 0x26, 0x92, 0x69, 0xA2, 0x8E,
  0x28, 0xE3, 0x0C, 0x30, 0xC0, 0xC0, 0xEC, 0x10, 0xC6, 0x19, 0x81, 0xA0,
  0x1C, 0x03, 0x00, 0xF0, 0x13, 0x06, 0x21, 0x86, 0x20, 0x6C, 0x06, 0xC0,
  0x78, 0x19, 0x03, 0x30, 0x46, 0x18, 0x63, 0x0C, 0x40, 0x98, 0x1B, 0x03,
  0x40, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x00, 0x7F,
  0xC0, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06,
  0x03, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xC3, 0xE0, 0x04, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x3E, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x02, 0x00, 0xC0, 0x1F, 0x0C, 0x02, 0x01, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x3E, 0x0C, 0x00, 0x70, 0x7F, 0x0E, 0x31,
  0xC3, 0xE8, 0x38,
};

const GFXglyph JetBrainsMono_ExtraLight24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 18, 14, 6, -18 },
  { 8, 7, 8, 14, 4, -18 },
  { 15, 13, 18, 14, 1, -18 },
  { 45, 10, 24, 14, 2, -21 },
  { 75, 14, 18, 14, 0, -18 },
  { 107, 13, 18, 14, 1, -18 },
  { 137, 2, 8, 14, 6, -18 },
  { 139, 7, 23, 14, 5, -20 },
  { 160, 7, 23, 14, 3, -20 },
  { 181, 12, 13, 14, 1, -15 },
  { 201, 11, 12, 14, 2, -14 },
  { 218, 5, 8, 14, 4, -4 },
  { 223, 8, 2, 14, 3, -9 },
  { 225, 4, 3, 14, 5, -3 },
  { 227, 10, 23, 14, 2, -20 },
  { 256, 10, 18, 14, 2, -18 },
  { 279, 11, 18, 14, 2, -18 },
  { 304, 11, 18, 14, 2, -18 },
  { 329, 10, 18, 14, 2, -18 },
  { 352, 10, 18, 14, 2, -18 },
  { 375, 10, 18, 14, 2, -18 },
  { 398, 11, 18, 14, 2, -18 },
  { 423, 11, 18, 14, 2, -18 },
  { 448, 10, 18, 14, 2, -18 },
  { 471, 11, 18, 14, 2, -18 },
  { 496, 4, 13, 14, 5, -13 },
  { 503, 5, 17, 14, 4, -13 },
  { 514, 10, 12, 14, 2, -14 },
  { 529, 10, 7, 14, 2, -11 },
  { 538, 10, 12, 14, 2, -14 },
  { 553, 8, 18, 14, 4, -18 },
  { 571, 12, 22, 14, 1, -18 },
  { 604, 12, 18, 14, 1, -18 },
  { 631, 11, 18, 14, 2, -18 },
  { 656, 10, 18, 14, 2, -18 },
  { 679, 10, 18, 14, 2, -18 },
  { 702, 9, 18, 14, 3, -18 },
  { 723, 10, 18, 14, 3, -18 },
  { 746, 10, 18, 14, 2, -18 },
  { 769, 10, 18, 14, 2, -18 },
  { 792, 9, 18, 14, 3, -18 },
  { 813, 11, 18, 14, 1, -18 },
  { 838, 11, 18, 14, 2, -18 },
  { 863, 10, 18, 14, 3, -18 },
  { 886, 10, 18, 14, 2, -18 },
  { 909, 10, 18, 14, 2, -18 },
  { 932, 10, 18, 14, 2, -18 },
  { 955, 11, 18, 14, 2, -18 },
  { 980, 10, 22, 14, 2, -18 },
  { 1008, 11, 18, 14, 2, -18 },
  { 1033, 10, 18, 14, 2, -18 },
  { 1056, 12, 18, 14, 1, -18 },
  { 1083, 10, 18, 14, 2, -18 },
  { 1106, 12, 18, 14, 1, -18 },
  { 1133, 13, 18, 14, 1, -18 },
  { 1163, 12, 18, 14, 1, -18 },
  { 1190, 12, 18, 14, 1, -18 },
  { 1217, 10, 18, 14, 2, -18 },
  { 1240, 6, 23, 14, 5, -20 },
  { 1258, 10, 23, 14, 2, -20 },
  { 1287, 5, 23, 14, 4, -20 },
  { 1302, 10, 10, 14, 2, -18 },
  { 1315, 12, 1, 14, 1, 1 },
  { 1317, 4, 4, 14, 5, -19 },
  { 1319, 10, 13, 14, 2, -13 },
  { 1336, 10, 18, 14, 2, -18 },
  { 1359, 10, 13, 14, 2, -13 },
  { 1376, 10, 18, 14, 2, -18 },
  { 1399, 10, 13, 14, 2, -13 },
  { 1416, 11, 18, 14, 2, -18 },
  { 1441, 10, 17, 14, 2, -13 },
  { 1463, 10, 18, 14, 2, -18 },
  { 1486, 11, 18, 14, 2, -18 },
  { 1511, 9, 22, 14, 2, -18 },
  { 1536, 10, 18, 14, 3, -18 },
  { 1559, 12, 18, 14, 1, -18 },
  { 1586, 11, 13, 14, 2, -13 },
  { 1604, 10, 13, 14, 2, -13 },
  { 1621, 10, 13, 14, 2, -13 },
  { 1638, 10, 17, 14, 2, -13 },
  { 1660, 10, 17, 14, 2, -13 },
  { 1682, 10, 13, 14, 3, -13 },
  { 1699, 10, 13, 14, 2, -13 },
  { 1716, 10, 17, 14, 2, -17 },
  { 1738, 10, 13, 14, 2, -13 },
  { 1755, 11, 13, 14, 2, -13 },
  { 1773, 12, 13, 14, 1, -13 },
  { 1793, 11, 13, 14, 2, -13 },
  { 1811, 11, 17, 14, 2, -13 },
  { 1835, 10, 13, 14, 2, -13 },
  { 1852, 10, 23, 14, 2, -20 },
  { 1881, 2, 23, 14, 6, -20 },
  { 1887, 10, 23, 14, 2, -20 },
  { 1916, 11, 5, 14, 2, -11 },
};

const GFXfont JetBrainsMono_ExtraLight24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_EXTRALIGHT24PT7B_H_
