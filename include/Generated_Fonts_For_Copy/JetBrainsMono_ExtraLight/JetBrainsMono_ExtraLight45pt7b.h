#ifndef _JETBRAINSMONO_EXTRALIGHT45PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight45pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x08, 0x00, 0x00, 0x00, 0x73, 0xEF,
  0xFE, 0xF8, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xD8, 0x0E, 0xC0, 0x66, 0x03, 0x30,
  0x18, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x70, 0x03, 0x00, 0xE0, 0x06, 0x01,
  0x80, 0x1C, 0x03, 0x00, 0x38, 0x06, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x38,
  0x01, 0x80, 0x60, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0,
  0x30, 0x0E, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x07,
  0x01, 0xC0, 0x0C, 0x03, 0x80, 0x18, 0x07, 0x00, 0x30, 0x0C, 0x00, 0xE0,
  0x18, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0C, 0x03,
  0x00, 0x38, 0x06, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x70,
  0x03, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0x7F, 0x87, 0x8C, 0x79,
  0xE1, 0x87, 0x38, 0x30, 0xF7, 0x06, 0x0F, 0xC0, 0xC1, 0xD8, 0x18, 0x03,
  0x83, 0x00, 0x70, 0x60, 0x0F, 0x0C, 0x00, 0xE1, 0x80, 0x1F, 0x30, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x6F, 0x80,
  0x0C, 0x78, 0x01, 0x87, 0x00, 0x30, 0x70, 0x06, 0x0E, 0x00, 0xC1, 0xC0,
  0x18, 0x3F, 0x03, 0x07, 0xE0, 0x60, 0xFC, 0x0C, 0x1F, 0xC1, 0x87, 0xBC,
  0x31, 0xE3, 0xE6, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x1F,
  0x80, 0x03, 0x9F, 0xE0, 0x01, 0x9E, 0x38, 0x01, 0xCC, 0x0E, 0x01, 0xCE,
  0x07, 0x00, 0xC7, 0x03, 0x80, 0xC3, 0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0x60,
  0xE0, 0x70, 0x60, 0x70, 0x38, 0x70, 0x38, 0x1C, 0x70, 0x0C, 0x0E, 0x30,
  0x07, 0x9E, 0x38, 0x01, 0xFE, 0x38, 0x00, 0x7E, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x1E, 0x00, 0x0E,
  0x3F, 0xC0, 0x0E, 0x3F, 0xF0, 0x06, 0x38, 0x38, 0x07, 0x1C, 0x0E, 0x07,
  0x0E, 0x07, 0x03, 0x07, 0x03, 0x83, 0x83, 0x81, 0xC3, 0x81, 0xC0, 0xE1,
  0x80, 0xE0, 0x71, 0x80, 0x70, 0x39, 0xC0, 0x38, 0x18, 0xC0, 0x0E, 0x1C,
  0xC0, 0x07, 0xFC, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x79, 0xC0, 0x03, 0xC3, 0x80, 0xFE, 0x0F, 0x03, 0xB8,
  0x1C, 0x1C, 0xE0, 0x38, 0x73, 0x80, 0x73, 0x8E, 0x01, 0xEE, 0x38, 0x03,
  0xF0, 0xE0, 0x07, 0xC3, 0x80, 0x1E, 0x0E, 0x00, 0x7C, 0x38, 0x01, 0xF0,
  0xE0, 0x0E, 0xE3, 0xC0, 0x79, 0xC7, 0xC7, 0xC7, 0x0F, 0xFE, 0x0E, 0x1F,
  0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x03, 0xC0,
  0x7E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x0E, 0x80, 0x07, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0xFE,
  0x07, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x10, 0x0E, 0x01,
  0x78, 0x1C, 0x0F, 0xFE, 0x38, 0xFE, 0xFF, 0x27, 0xF8, 0x3F, 0x5F, 0x80,
  0x0F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0xE3, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x78,
  0x0F, 0x01, 0xE0, 0x0F, 0x01, 0x80, 0x1C, 0x01, 0x00, 0x10, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E,
  0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFE, 0xFE, 0x3E, 0x03, 0xC7, 0x80, 0x3C,
  0xE0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x38, 0x3F,
  0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x83, 0x83, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xE7, 0x80, 0x1C, 0xF8, 0x07, 0x8F,
  0xC7, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x00, 0xF7, 0x00, 0x1E, 0x70, 0x07, 0xC7, 0x00, 0x70, 0x70,
  0x06, 0x07, 0x00, 0x40, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F,
  0x1F, 0x87, 0x80, 0x3C, 0x70, 0x01, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x03, 0xDE, 0x01,
  0xE3, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x01, 0xCE, 0x00,
  0x77, 0x80, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x18, 0x07, 0x3F, 0xE0, 0xEF, 0xFE, 0x1F, 0x83, 0xE3, 0xE0,
  0x1E, 0x78, 0x01, 0xCE, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x07, 0xB8, 0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x07, 0x0F, 0x87,
  0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x39, 0xF8, 0x0E, 0xFF, 0xC3, 0xFD, 0xFC, 0x7C, 0x07, 0xDE, 0x00,
  0x3B, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0xF7, 0x00, 0x1C, 0xF0, 0x07, 0x8F, 0x83, 0xE0, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFE, 0xFE, 0x1E, 0x01, 0xC7, 0x80, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x39,
  0xC0, 0x07, 0x1C, 0x01, 0xE3, 0xC0, 0x78, 0x3C, 0x1E, 0x03, 0xEF, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xF7, 0xC0, 0x78, 0x3C, 0x1C, 0x03, 0xC7,
  0x00, 0x3C, 0xE0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x77, 0x00, 0x1C, 0xF0, 0x07, 0x8F,
  0x83, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0,
  0xFC, 0x7E, 0x3E, 0x03, 0xC7, 0x00, 0x1D, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x78, 0x03, 0xC7,
  0xE3, 0xF8, 0x7F, 0xEE, 0x03, 0xFB, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xE1, 0xE0,
  0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x7C, 0x1F, 0xF0, 0x3F, 0xC0, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x00, 0x3C, 0x38, 0x00,
  0x71, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xC7, 0xC0, 0x3F, 0xDF, 0x01,
  0xFF, 0xFC, 0x0F, 0x03, 0xF0, 0x38, 0x07, 0xC0, 0xE0, 0x1F, 0x03, 0x80,
  0x7C, 0x0E, 0x01, 0xF0, 0x38, 0x07, 0xC0, 0xE0, 0x1F, 0x03, 0x80, 0x7C,
  0x0E, 0x01, 0xF0, 0x38, 0x07, 0xC0, 0xE0, 0x1F, 0x03, 0x80, 0x7C, 0x0E,
  0x03, 0xF0, 0x1C, 0x1F, 0xC0, 0x7F, 0xDF, 0x00, 0xFE, 0x7E, 0x00, 0x40,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xB0, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x31,
  0x80, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x06, 0x0C, 0x00,
  0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x1C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x3B, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x38, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x03,
  0xB8, 0x01, 0xCE, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x0F, 0xCE,
  0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xB8, 0x03, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xE0, 0x7E, 0x7E, 0x1E, 0x01, 0xE7, 0x80, 0x1C, 0xE0, 0x03,
  0xDC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x80, 0x1C, 0x78, 0x07, 0x8F, 0xC7, 0xE0,
  0x7F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0x80, 0x78, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x0F, 0x38, 0x07,
  0x8F, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xB8, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7E,
  0x7E, 0x1E, 0x01, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xDC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0xF7, 0x80, 0x1C, 0x78, 0x07, 0x8F, 0xC7, 0xE0, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x07, 0x0F, 0xC7,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0,
  0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E,
  0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0E, 0x07, 0x00, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0E, 0x01,
  0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x1E, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xEC, 0x01, 0xBD, 0xC0, 0x37,
  0xB8, 0x0E, 0xF3, 0x01, 0x9E, 0x70, 0x73, 0xEE, 0x0E, 0xFC, 0xC1, 0x9F,
  0x9C, 0x73, 0xF1, 0x8E, 0x7E, 0x31, 0x8F, 0xC7, 0x71, 0xF8, 0x6E, 0x3F,
  0x0D, 0x87, 0xE1, 0xF0, 0xFC, 0x1C, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3D, 0x80, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0x98, 0x03,
  0xCE, 0x01, 0xE3, 0x00, 0xF1, 0xC0, 0x78, 0xE0, 0x3C, 0x30, 0x1E, 0x1C,
  0x0F, 0x0E, 0x07, 0x83, 0x03, 0xC1, 0xC1, 0xE0, 0x60, 0xF0, 0x38, 0x78,
  0x1C, 0x3C, 0x06, 0x1E, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0x63, 0xC0, 0x39,
  0xE0, 0x0C, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x00, 0xDE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7E,
  0xFC, 0x1E, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x3C, 0x70, 0x07, 0x0F, 0xC7, 0xE0, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x70, 0x03, 0xCE, 0x00,
  0x3D, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xF7, 0x00, 0x3C, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xC0, 0x7E, 0xFC, 0x1E, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00,
  0x77, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07,
  0x38, 0x00, 0xE7, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0xC7, 0xE0, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x07, 0xCE, 0x00, 0x3D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x01, 0xE7, 0x00, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x3C, 0x70, 0x03, 0x8E, 0x00, 0x79, 0xC0, 0x07, 0x38, 0x00, 0xF7,
  0x00, 0x0E, 0xE0, 0x01, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFE, 0x7E,
  0x1E, 0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xDC, 0x00, 0x3F, 0x00, 0x07,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x1E, 0xF0, 0x07, 0x8F, 0xC3, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7B, 0xC0, 0x78, 0xF8, 0xFC, 0x7F, 0xFC, 0x0F,
  0xF8, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0x81, 0xC0, 0x1C,
  0x0E, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0x77,
  0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x3F, 0x03, 0x60, 0x7E, 0x06, 0xC0, 0xFC, 0x0D, 0x81, 0xF8, 0x1B,
  0x03, 0xF0, 0x36, 0x07, 0x60, 0x6C, 0x0C, 0xC0, 0xDC, 0x19, 0xC1, 0x98,
  0x33, 0x86, 0x30, 0xE7, 0x0C, 0x61, 0xCE, 0x18, 0xC3, 0x9C, 0x31, 0x87,
  0x38, 0x63, 0x0E, 0x70, 0xC6, 0x18, 0x61, 0x86, 0x30, 0xC6, 0x0C, 0x61,
  0xCC, 0x18, 0xC3, 0x98, 0x33, 0x87, 0x30, 0x67, 0x0E, 0x60, 0xCE, 0x1C,
  0xC1, 0x9C, 0x39, 0x83, 0x38, 0x36, 0x03, 0x60, 0x6C, 0x06, 0xC0, 0xD8,
  0x0D, 0x81, 0xF0, 0x1B, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x1E, 0x01, 0xF0, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x78,
  0x03, 0x80, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC1,
  0xC0, 0x07, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x03,
  0x81, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x71,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0x30, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80,
  0x0E, 0x70, 0x01, 0xDC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0x7E, 0x0F, 0x01, 0xE3, 0xC0, 0x1E, 0x70, 0x01, 0xCE, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x83, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7C, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x77, 0x00, 0x1E, 0xF0, 0x06,
  0xCF, 0x81, 0xD8, 0xFF, 0xF3, 0x0F, 0xF8, 0x60, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE3, 0xF8, 0x3B, 0xFF, 0x8F, 0xF7, 0xF3, 0xE0, 0x3C, 0xF0,
  0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E, 0xF0,
  0x03, 0xBE, 0x01, 0xCF, 0xC1, 0xF3, 0xBF, 0xF8, 0xE7, 0xF8, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1E, 0x03, 0xC7, 0x80, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE7, 0x80,
  0x1C, 0x78, 0x07, 0x8F, 0xC7, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x07, 0xF1, 0xC7, 0xFF, 0x73, 0xFB, 0xFC,
  0xF0, 0x1F, 0x78, 0x03, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x1D,
  0xC0, 0x07, 0x70, 0x03, 0xCE, 0x01, 0xF3, 0xE0, 0xFC, 0x7F, 0xF7, 0x0F,
  0xF9, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1E, 0x03, 0xC7,
  0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xB8,
  0x00, 0xE7, 0x00, 0x1C, 0x70, 0x07, 0x8F, 0x83, 0xE0, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF1, 0xC7, 0xFF, 0x73, 0xFB, 0xFC,
  0xF0, 0x1F, 0x78, 0x03, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x80, 0x3C,
  0xE0, 0x1F, 0x3F, 0x1F, 0xC7, 0xFF, 0x70, 0x7F, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE3, 0xF8, 0x77, 0xFF, 0x3F, 0xCF, 0xDF, 0x01, 0xEF, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x3B, 0x80, 0x0F, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x07,
  0x87, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x83, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xC1, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x3C,
  0x1C, 0x03, 0x83, 0x80, 0x38, 0x70, 0x07, 0x8E, 0x00, 0x71, 0xC0, 0x07,
  0x38, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x0F, 0xFC, 0xE7, 0xC7, 0xC7, 0x7F, 0x7F, 0x3E, 0x3B, 0x3D, 0xE0,
  0xE0, 0xEE, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07,
  0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07,
  0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F,
  0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38,
  0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x38, 0xE3, 0xF8, 0x77,
  0xFF, 0x3F, 0xDF, 0xDF, 0x01, 0xEF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7E, 0xFC, 0x1E, 0x03,
  0xC7, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x07,
  0x38, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x07, 0x0F, 0xC7, 0xE0, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0xE3, 0xF8, 0x3B, 0xFF, 0x8F, 0xF7, 0xF3, 0xE0, 0x3C,
  0xF0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E,
  0xF0, 0x03, 0xBE, 0x01, 0xCF, 0xC1, 0xF3, 0xBF, 0xF8, 0xE7, 0xF8, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF1, 0xC7, 0xFF, 0x73, 0xFB,
  0xFC, 0xF0, 0x1F, 0x78, 0x03, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x07, 0x70, 0x03, 0xCE, 0x01, 0xF3, 0xE0, 0xFC, 0x7F, 0xF7,
  0x0F, 0xF9, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xE1, 0xFC, 0x1C,
  0xFF, 0xC3, 0xBC, 0xFE, 0x76, 0x03, 0xCF, 0x80, 0x3D, 0xE0, 0x03, 0xBC,
  0x00, 0x77, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3C, 0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x01, 0xDC,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0E, 0xF0,
  0x03, 0x8F, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7B, 0xC0, 0x78, 0xF8, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x0F,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x60, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80,
  0xE0, 0x3B, 0x03, 0x60, 0x66, 0x06, 0xC0, 0xCE, 0x0D, 0x81, 0x9C, 0x1B,
  0x07, 0x38, 0x36, 0x0E, 0x70, 0x64, 0x1C, 0x61, 0x8C, 0x30, 0xC3, 0x18,
  0x61, 0x86, 0x30, 0xC3, 0x8C, 0x63, 0x87, 0x18, 0xC7, 0x0E, 0x60, 0xCE,
  0x0C, 0xC1, 0x98, 0x19, 0x83, 0x30, 0x33, 0x06, 0x60, 0x76, 0x0D, 0xC0,
  0xEC, 0x1B, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x8E, 0x00,
  0x38, 0x38, 0x03, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00,
  0xF1, 0xE0, 0x03, 0x8E, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x03,
  0x8E, 0x00, 0x38, 0x38, 0x03, 0xC1, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x1C,
  0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x8E, 0x00, 0x0E, 0xF0, 0x00, 0x78, 0xE0,
  0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x38, 0x1E, 0x01, 0xC0, 0x70,
  0x1E, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x39, 0xFE, 0x01, 0xDE, 0x78, 0x0E, 0xE1, 0xE0,
  0x7E, 0x07, 0x83, 0x70, 0x1E, 0x3B, 0x80, 0x7F, 0xDC, 0x01, 0xFC,
};

const GFXglyph JetBrainsMono_ExtraLight45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 6, 33, 27, 11, -33 },
  { 26, 13, 14, 27, 7, -33 },
  { 49, 23, 33, 27, 2, -33 },
  { 144, 19, 45, 27, 4, -39 },
  { 251, 25, 33, 27, 1, -33 },
  { 355, 22, 33, 27, 3, -33 },
  { 446, 3, 14, 27, 12, -33 },
  { 452, 13, 43, 27, 9, -38 },
  { 522, 13, 43, 27, 5, -38 },
  { 592, 23, 23, 27, 2, -27 },
  { 659, 21, 21, 27, 3, -25 },
  { 715, 8, 14, 27, 8, -7 },
  { 729, 15, 2, 27, 6, -16 },
  { 733, 7, 7, 27, 10, -7 },
  { 740, 19, 42, 27, 4, -37 },
  { 840, 19, 33, 27, 4, -33 },
  { 919, 20, 33, 27, 4, -33 },
  { 1002, 20, 33, 27, 4, -33 },
  { 1085, 18, 33, 27, 4, -33 },
  { 1160, 18, 33, 27, 4, -33 },
  { 1235, 19, 33, 27, 4, -33 },
  { 1314, 19, 33, 27, 4, -33 },
  { 1393, 20, 33, 27, 4, -33 },
  { 1476, 19, 33, 27, 4, -33 },
  { 1555, 19, 33, 27, 4, -33 },
  { 1634, 7, 25, 27, 10, -25 },
  { 1656, 9, 32, 27, 8, -25 },
  { 1692, 19, 23, 27, 4, -26 },
  { 1747, 19, 13, 27, 4, -21 },
  { 1778, 19, 23, 27, 4, -26 },
  { 1833, 15, 33, 27, 7, -33 },
  { 1895, 22, 41, 27, 3, -33 },
  { 2008, 21, 33, 27, 3, -33 },
  { 2095, 18, 33, 27, 5, -33 },
  { 2170, 19, 33, 27, 4, -33 },
  { 2249, 18, 33, 27, 5, -33 },
  { 2324, 18, 33, 27, 5, -33 },
  { 2399, 19, 33, 27, 5, -33 },
  { 2478, 19, 33, 27, 4, -33 },
  { 2557, 17, 33, 27, 5, -33 },
  { 2628, 17, 33, 27, 5, -33 },
  { 2699, 19, 33, 27, 3, -33 },
  { 2778, 20, 33, 27, 5, -33 },
  { 2861, 19, 33, 27, 5, -33 },
  { 2940, 19, 33, 27, 4, -33 },
  { 3019, 17, 33, 27, 5, -33 },
  { 3090, 19, 33, 27, 4, -33 },
  { 3169, 19, 33, 27, 5, -33 },
  { 3248, 19, 41, 27, 4, -33 },
  { 3346, 19, 33, 27, 5, -33 },
  { 3425, 19, 33, 27, 4, -33 },
  { 3504, 21, 33, 27, 3, -33 },
  { 3591, 17, 33, 27, 5, -33 },
  { 3662, 21, 33, 27, 3, -33 },
  { 3749, 23, 33, 27, 2, -33 },
  { 3844, 23, 33, 27, 2, -33 },
  { 3939, 23, 33, 27, 2, -33 },
  { 4034, 19, 33, 27, 4, -33 },
  { 4113, 10, 42, 27, 10, -37 },
  { 4166, 19, 42, 27, 4, -37 },
  { 4266, 10, 42, 27, 7, -37 },
  { 4319, 19, 18, 27, 4, -33 },
  { 4362, 21, 3, 27, 3, 1 },
  { 4370, 8, 6, 27, 9, -35 },
  { 4376, 19, 25, 27, 3, -25 },
  { 4436, 18, 33, 27, 5, -33 },
  { 4511, 19, 25, 27, 4, -25 },
  { 4571, 18, 33, 27, 4, -33 },
  { 4646, 19, 25, 27, 4, -25 },
  { 4706, 21, 33, 27, 3, -33 },
  { 4793, 18, 33, 27, 4, -25 },
  { 4868, 17, 33, 27, 5, -33 },
  { 4939, 20, 35, 27, 4, -35 },
  { 5027, 16, 43, 27, 4, -35 },
  { 5113, 19, 33, 27, 5, -33 },
  { 5192, 22, 33, 27, 2, -33 },
  { 5283, 21, 25, 27, 3, -25 },
  { 5349, 17, 25, 27, 5, -25 },
  { 5403, 19, 25, 27, 4, -25 },
  { 5463, 18, 33, 27, 5, -25 },
  { 5538, 18, 33, 27, 4, -25 },
  { 5613, 19, 25, 27, 5, -25 },
  { 5673, 19, 25, 27, 4, -25 },
  { 5733, 20, 32, 27, 3, -32 },
  { 5813, 17, 25, 27, 5, -25 },
  { 5867, 21, 25, 27, 3, -25 },
  { 5933, 23, 25, 27, 2, -25 },
  { 6005, 21, 25, 27, 3, -25 },
  { 6071, 21, 33, 27, 3, -25 },
  { 6158, 19, 25, 27, 4, -25 },
  { 6218, 19, 42, 27, 4, -37 },
  { 6318, 3, 42, 27, 12, -37 },
  { 6334, 19, 42, 27, 4, -37 },
  { 6434, 21, 8, 27, 3, -20 },
};

const GFXfont JetBrainsMono_ExtraLight45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_EXTRALIGHT45PT7B_H_
