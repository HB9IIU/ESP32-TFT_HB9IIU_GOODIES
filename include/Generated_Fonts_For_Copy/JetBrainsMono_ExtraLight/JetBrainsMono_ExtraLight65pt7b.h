#ifndef _JETBRAINSMONO_EXTRALIGHT65PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight65pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F,
  0x9F, 0xFF, 0xF7, 0xFB, 0xF8, 0xFC, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFB, 0xC0,
  0x1F, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xE3, 0x8F, 0xE0, 0x7E, 0x1C, 0x1F,
  0x03, 0xE0, 0xE0, 0x7C, 0x3E, 0x07, 0x01, 0xE1, 0xE0, 0x38, 0x0F, 0x8F,
  0x01, 0xC0, 0x3C, 0x78, 0x0E, 0x01, 0xE7, 0xC0, 0x70, 0x0F, 0x3E, 0x03,
  0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3E, 0x07, 0x00,
  0x01, 0xF0, 0x38, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3F, 0x0E, 0x00, 0x00,
  0xFC, 0x70, 0x00, 0x07, 0xFB, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0E, 0xFF, 0x00, 0x00, 0x71, 0xFC, 0x00, 0x03, 0x83, 0xF0,
  0x00, 0x1C, 0x0F, 0x80, 0x00, 0xE0, 0x3E, 0x00, 0x07, 0x01, 0xF0, 0x00,
  0x38, 0x07, 0x80, 0x01, 0xC0, 0x3E, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x70,
  0x0F, 0xF8, 0x03, 0x80, 0x7F, 0xE0, 0x1C, 0x03, 0xFF, 0x00, 0xE0, 0x1F,
  0x78, 0x07, 0x00, 0xF3, 0xE0, 0x38, 0x07, 0x9F, 0x01, 0xC0, 0x7C, 0x7C,
  0x0E, 0x07, 0xC1, 0xF8, 0x70, 0x7E, 0x0F, 0xFB, 0x9F, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x08, 0x7F,
  0xE0, 0x00, 0x03, 0x87, 0xFF, 0x80, 0x00, 0x38, 0x7F, 0xFE, 0x00, 0x03,
  0xC3, 0xC0, 0xF8, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0x01, 0xC1, 0xE0, 0x0F,
  0x00, 0x1E, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x0E, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xC0,
  0x0F, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x38, 0x00, 0x78, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0x3C, 0x3C, 0x00, 0x0F, 0xEF, 0xC1, 0xC0, 0x00, 0x3F, 0xFE,
  0x1E, 0x00, 0x00, 0xFF, 0xE1, 0xE0, 0x00, 0x01, 0xFC, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x83, 0xFE, 0x00, 0x00, 0x38, 0x3F, 0xFC, 0x00, 0x03, 0xC3, 0xFF,
  0xF0, 0x00, 0x3C, 0x3E, 0x0F, 0x80, 0x01, 0xC1, 0xE0, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0x38, 0x07, 0x00, 0x78, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x0E, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x03, 0x80,
  0x3C, 0x3C, 0x00, 0x1E, 0x03, 0xE1, 0xC0, 0x00, 0xF8, 0x3E, 0x1E, 0x00,
  0x03, 0xFF, 0xE1, 0xE0, 0x00, 0x0F, 0xFE, 0x1E, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0x3E, 0x0F, 0x80, 0x0F, 0x3E,
  0x03, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0x07, 0x8F, 0x00, 0x7C, 0x07, 0xC7,
  0x80, 0x1F, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xE1, 0xE0, 0x01, 0xE1, 0xE0,
  0xF0, 0x00, 0xF9, 0xF0, 0x78, 0x00, 0x3E, 0xF0, 0x3C, 0x00, 0x0F, 0xF8,
  0x1E, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x1F,
  0xE0, 0x7C, 0x00, 0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0x3E, 0x0F, 0xC0, 0x3F,
  0x0F, 0x03, 0xF8, 0x7F, 0x07, 0xC1, 0xFF, 0xFF, 0x01, 0xF0, 0x3F, 0xFF,
  0x00, 0x7C, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBC, 0x00,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0xDF, 0x00, 0x38, 0x01,
  0xFF, 0xF0, 0x1C, 0x07, 0xFF, 0xFE, 0x0E, 0x1F, 0xFD, 0xFF, 0xC7, 0x1F,
  0xFC, 0x3F, 0xFB, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0x8F, 0xF9, 0xFF, 0x3F, 0xEF, 0xFE, 0xFF, 0x9F,
  0xF3, 0xFE, 0x3F, 0x80, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0x7C, 0x07, 0xF8, 0x02, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0xC0, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x7C, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x80, 0x0F, 0x80,
  0x08, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x7C,
  0x00, 0x0F, 0x1F, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x3D,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x3F, 0xF0, 0x0F, 0x1F, 0xFF, 0x81, 0xE7, 0xFF, 0xF8, 0x3D, 0xFF, 0xFF,
  0x87, 0xBC, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x1F, 0x7F, 0xF8, 0x01,
  0xF7, 0xFF, 0xF0, 0x0F, 0x7F, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x7C,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xEF, 0x00,
  0x0F, 0xFC, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x8F, 0xF9, 0xFF, 0x3F, 0xEF, 0xFE, 0xFF, 0x9F, 0xF1, 0xFC, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF7, 0xFF, 0x7F, 0xCF, 0xF9, 0xFF,
  0x1F, 0xC0, 0xC0, 0x0F, 0xE0, 0xFF, 0x87, 0xFC, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0x7F, 0xC3, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x08,
  0x0F, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0xCF, 0xF0, 0x03, 0xFF,
  0xEF, 0xF0, 0x07, 0xE0, 0x7F, 0xF0, 0x0F, 0x80, 0x3F, 0xF0, 0x0F, 0x80,
  0x1F, 0xF0, 0x0F, 0x00, 0x1F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00,
  0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00,
  0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00,
  0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00,
  0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00,
  0x1F, 0xF0, 0x0F, 0x80, 0x1F, 0xF0, 0x07, 0x80, 0x3F, 0xF0, 0x07, 0xE0,
  0x6F, 0xF0, 0x03, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0xCF, 0xF0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x78, 0x03, 0xFF, 0x0F, 0x00, 0x07,
  0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C,
  0x78, 0x00, 0x3F, 0x0F, 0x00, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0xF0, 0x03, 0xFE, 0x1E, 0x00, 0x07, 0xE3,
  0xC0, 0x00, 0x7E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF0,
  0x00, 0x0F, 0x9E, 0x00, 0x03, 0xF3, 0xC0, 0x01, 0xFC, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x81, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x7F, 0xF0, 0xF0, 0x00,
  0xFE, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x3F, 0x3C, 0x00,
  0x1F, 0x8F, 0x00, 0x1F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xFE,
  0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x1E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x81, 0xFE, 0x07, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x3C,
  0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8,
  0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0xE0, 0x00, 0xEF, 0xDE, 0x00, 0x3D,
  0xFB, 0xC0, 0x07, 0xBF, 0x38, 0x00, 0xE7, 0xE7, 0x80, 0x3C, 0xFC, 0x70,
  0x07, 0x9F, 0x8E, 0x00, 0xE3, 0xF1, 0xE0, 0x3C, 0x7E, 0x1C, 0x07, 0x8F,
  0xE3, 0x80, 0xE3, 0xFC, 0x78, 0x3C, 0x7F, 0x87, 0x07, 0x0F, 0xF0, 0xE0,
  0xE1, 0xFE, 0x1E, 0x3C, 0x3F, 0xC1, 0xC7, 0x07, 0xF8, 0x3C, 0xE0, 0xFF,
  0x07, 0xBC, 0x1F, 0xE0, 0x77, 0x03, 0xFC, 0x0E, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xEE, 0x00, 0x0F, 0xF7, 0x80, 0x07, 0xFB,
  0xC0, 0x03, 0xFC, 0xF0, 0x01, 0xFE, 0x78, 0x00, 0xFF, 0x1C, 0x00, 0x7F,
  0x8F, 0x00, 0x3F, 0xC7, 0x80, 0x1F, 0xE1, 0xE0, 0x0F, 0xF0, 0xF0, 0x07,
  0xF8, 0x78, 0x03, 0xFC, 0x1E, 0x01, 0xFE, 0x0F, 0x00, 0xFF, 0x03, 0x80,
  0x7F, 0x81, 0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1E,
  0x07, 0xF8, 0x0F, 0x03, 0xFC, 0x03, 0xC1, 0xFE, 0x01, 0xE0, 0xFF, 0x00,
  0x70, 0x7F, 0x80, 0x3C, 0x3F, 0xC0, 0x1E, 0x1F, 0xE0, 0x07, 0x8F, 0xF0,
  0x03, 0xC7, 0xF8, 0x01, 0xE3, 0xFC, 0x00, 0x79, 0xFE, 0x00, 0x3C, 0xFF,
  0x00, 0x0F, 0x7F, 0x80, 0x07, 0xBF, 0xC0, 0x03, 0xDF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7B, 0xF8, 0x00, 0x3D, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xF8, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x7C,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x1F, 0xF8, 0xF0, 0x00,
  0x1F, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x01,
  0xFC, 0xF0, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x3C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83,
  0xF0, 0x01, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x3F,
  0xF0, 0xF0, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x1F,
  0x8F, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x0F,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1,
  0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x87,
  0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x00,
  0x3E, 0x00, 0x3D, 0xE0, 0x07, 0xE0, 0x0F, 0x3C, 0x00, 0xFC, 0x01, 0xE7,
  0x80, 0x1B, 0x80, 0x3C, 0xF0, 0x07, 0x70, 0x07, 0x9E, 0x00, 0xEE, 0x00,
  0xF3, 0xC0, 0x1D, 0xC0, 0x1E, 0x78, 0x03, 0xB8, 0x03, 0xCF, 0x00, 0x77,
  0x00, 0x78, 0xF0, 0x0E, 0x70, 0x0E, 0x1E, 0x01, 0xCE, 0x03, 0xC3, 0xC0,
  0x71, 0xC0, 0x78, 0x78, 0x0E, 0x38, 0x0F, 0x0F, 0x01, 0xC7, 0x01, 0xE1,
  0xE0, 0x38, 0xE0, 0x3C, 0x3C, 0x07, 0x1C, 0x07, 0x87, 0x80, 0xE3, 0x80,
  0xF0, 0xF0, 0x1C, 0x38, 0x1E, 0x0F, 0x03, 0x07, 0x03, 0x81, 0xE0, 0xE0,
  0xE0, 0xF0, 0x3C, 0x1C, 0x1C, 0x1E, 0x07, 0x83, 0x83, 0x83, 0xC0, 0xF0,
  0x70, 0x70, 0x78, 0x1E, 0x0E, 0x0E, 0x0F, 0x03, 0xC1, 0xC0, 0xC1, 0xE0,
  0x78, 0x30, 0x1C, 0x3C, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x70,
  0xE0, 0x1E, 0x38, 0x0E, 0x3C, 0x03, 0xC7, 0x01, 0xC7, 0x80, 0x78, 0xE0,
  0x38, 0xF0, 0x0F, 0x1C, 0x07, 0x1E, 0x01, 0xE3, 0x00, 0x73, 0xC0, 0x3C,
  0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0x7B, 0x80, 0x39, 0xC0,
  0x0F, 0x70, 0x07, 0x38, 0x01, 0xEE, 0x00, 0xEF, 0x00, 0x3D, 0xC0, 0x1D,
  0xE0, 0x07, 0xB8, 0x03, 0xBC, 0x00, 0xF6, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0,
  0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x1F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x9F, 0x80, 0x00, 0xF7, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0x3F, 0x80,
  0x7D, 0xE3, 0xFF, 0xFF, 0x3C, 0x3F, 0xFF, 0xC7, 0x81, 0xFF, 0xE0, 0xF0,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC1, 0xFF, 0x80, 0xF1, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF,
  0x0F, 0x7E, 0x1F, 0xE3, 0xDC, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x3F, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xCF, 0xF0, 0x03, 0xF3, 0xDF,
  0x03, 0xF8, 0xF3, 0xFF, 0xFC, 0x3C, 0x7F, 0xFE, 0x0F, 0x0F, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x03, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xBC, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0xFE, 0x0F, 0x07,
  0xFF, 0xE3, 0xC3, 0xFF, 0xFC, 0xF1, 0xFE, 0x1F, 0xBC, 0x7E, 0x00, 0xEF,
  0x3E, 0x00, 0x1F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7D, 0xE0, 0x00,
  0x1F, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x03,
  0xF3, 0xF0, 0x03, 0xFC, 0x7F, 0x03, 0xEF, 0x0F, 0xFF, 0xF3, 0xC1, 0xFF,
  0xF8, 0xF0, 0x1F, 0xFC, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3C, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x83, 0xC0, 0xFF, 0xF8, 0xF0, 0xFF, 0xFF, 0x3C, 0x7F, 0x87, 0xEF, 0x1F,
  0x80, 0x3B, 0xCF, 0x80, 0x07, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x3B, 0xC7, 0xF8, 0x3E, 0xF0,
  0xFF, 0xFF, 0x3C, 0x1F, 0xFF, 0x8F, 0x01, 0xFF, 0x83, 0xC0, 0x02, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0xFC, 0x0F,
  0x1F, 0xFF, 0x87, 0x9F, 0xFF, 0xE3, 0xDF, 0x07, 0xF9, 0xEE, 0x00, 0xFC,
  0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0x00,
  0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xF0,
  0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x3E,
  0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xF8, 0x0F,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x1F, 0x0F, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xF8, 0x1F, 0xC7, 0xBF,
  0xE1, 0xFF, 0x3D, 0xFF, 0x9F, 0xFD, 0xF8, 0x7E, 0xC3, 0xEF, 0x81, 0xFC,
  0x0F, 0xFC, 0x07, 0xC0, 0x3F, 0xC0, 0x3E, 0x01, 0xFE, 0x00, 0xE0, 0x0F,
  0xF0, 0x07, 0x00, 0x7F, 0x80, 0x38, 0x03, 0xFC, 0x01, 0xC0, 0x1F, 0xE0,
  0x0E, 0x00, 0xFF, 0x00, 0x70, 0x07, 0xF8, 0x03, 0x80, 0x3F, 0xC0, 0x1C,
  0x01, 0xFE, 0x00, 0xE0, 0x0F, 0xF0, 0x07, 0x00, 0x7F, 0x80, 0x38, 0x03,
  0xFC, 0x01, 0xC0, 0x1F, 0xE0, 0x0E, 0x00, 0xFF, 0x00, 0x70, 0x07, 0xF8,
  0x03, 0x80, 0x3F, 0xC0, 0x1C, 0x01, 0xFE, 0x00, 0xE0, 0x0F, 0xF0, 0x07,
  0x00, 0x7F, 0x80, 0x38, 0x03, 0xFC, 0x01, 0xC0, 0x1F, 0xE0, 0x0E, 0x00,
  0xFF, 0x00, 0x70, 0x07, 0xF8, 0x03, 0x80, 0x3F, 0xC0, 0x1C, 0x01, 0xFE,
  0x00, 0xE0, 0x0F, 0xF0, 0x07, 0x00, 0x7F, 0x80, 0x38, 0x03, 0xFC, 0x01,
  0xC0, 0x1F, 0xE0, 0x0E, 0x00, 0xF0, 0xF0, 0x7F, 0xE0, 0x78, 0xFF, 0xFC,
  0x3C, 0xFF, 0xFF, 0x1E, 0xFC, 0x3F, 0xCF, 0x70, 0x07, 0xE7, 0xF0, 0x00,
  0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFD, 0xFF,
  0x01, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x3E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0xF0, 0x7F, 0xE0, 0x3C, 0x7F, 0xFE, 0x0F, 0x3F,
  0xFF, 0xC3, 0xDF, 0x87, 0xF8, 0xF7, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xCF,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF3, 0xFC, 0x00, 0xFC,
  0xF7, 0xC0, 0xFE, 0x3C, 0xFF, 0xFF, 0x0F, 0x1F, 0xFF, 0x83, 0xC3, 0xFF,
  0x80, 0xF0, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xC1, 0xFF, 0xF8, 0xF0, 0xFF,
  0xFF, 0x3C, 0x7F, 0x87, 0xEF, 0x1F, 0x00, 0x3B, 0xCF, 0x80, 0x07, 0xF7,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0xEF,
  0x1F, 0xC0, 0xFB, 0xC3, 0xFF, 0xFC, 0xF0, 0x7F, 0xFE, 0x3C, 0x07, 0xFE,
  0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x3C, 0x7F, 0xFE, 0x0F, 0x3F,
  0xFF, 0xC3, 0xDF, 0x87, 0xF8, 0xF7, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xCF,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x3E, 0x3F, 0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x7C,
  0x00, 0xF7, 0x80, 0x36, 0x00, 0x73, 0xC0, 0x3B, 0x80, 0x79, 0xE0, 0x1D,
  0xC0, 0x3C, 0xF0, 0x0E, 0xE0, 0x1E, 0x78, 0x07, 0x70, 0x0F, 0x3C, 0x03,
  0xB8, 0x07, 0x8E, 0x01, 0x8C, 0x03, 0x87, 0x81, 0xC7, 0x01, 0xC3, 0xC0,
  0xE3, 0x81, 0xE1, 0xE0, 0x71, 0xC0, 0xF0, 0xF0, 0x38, 0xE0, 0x78, 0x78,
  0x1C, 0x30, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F, 0x0E, 0x0E, 0x0E, 0x07,
  0x87, 0x07, 0x0F, 0x03, 0xC3, 0x83, 0x87, 0x81, 0xE1, 0xC1, 0xC3, 0xC0,
  0xF0, 0xC0, 0x61, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x70,
  0x0F, 0x38, 0x0E, 0x78, 0x07, 0x9C, 0x07, 0x3C, 0x03, 0xCE, 0x03, 0x9E,
  0x01, 0xE6, 0x00, 0xEF, 0x00, 0x77, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3B,
  0x80, 0x1D, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x78, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x0F,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x79, 0xFF, 0xC0, 0x03, 0xDF, 0xFF, 0x00, 0x1E,
  0xFD, 0xFC, 0x00, 0xFF, 0x83, 0xF0, 0x07, 0xF8, 0x07, 0xC0, 0x3F, 0xC0,
  0x3E, 0x01, 0xFE, 0x00, 0xF8, 0x1F, 0xF0, 0x03, 0xF1, 0xF7, 0x80, 0x0F,
  0xFF, 0xBC, 0x00, 0x3F, 0xF9, 0xE0, 0x00, 0x7F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 9, 47, 39, 15, -47 },
  { 54, 19, 19, 39, 10, -47 },
  { 100, 35, 47, 39, 2, -47 },
  { 306, 29, 66, 39, 5, -57 },
  { 546, 37, 48, 39, 1, -48 },
  { 768, 33, 49, 39, 4, -48 },
  { 971, 5, 19, 39, 17, -47 },
  { 983, 19, 63, 39, 13, -55 },
  { 1133, 19, 63, 39, 7, -55 },
  { 1283, 33, 34, 39, 3, -40 },
  { 1424, 29, 31, 39, 5, -37 },
  { 1537, 12, 20, 39, 12, -10 },
  { 1567, 21, 3, 39, 9, -23 },
  { 1575, 11, 10, 39, 14, -9 },
  { 1589, 27, 61, 39, 6, -54 },
  { 1795, 27, 49, 39, 6, -48 },
  { 1961, 29, 47, 39, 6, -47 },
  { 2132, 29, 48, 39, 5, -48 },
  { 2306, 27, 48, 39, 5, -47 },
  { 2468, 26, 47, 39, 6, -47 },
  { 2621, 27, 48, 39, 6, -47 },
  { 2783, 29, 48, 39, 5, -47 },
  { 2957, 29, 47, 39, 5, -47 },
  { 3128, 27, 49, 39, 6, -48 },
  { 3294, 29, 48, 39, 5, -48 },
  { 3468, 11, 37, 39, 14, -36 },
  { 3519, 13, 46, 39, 12, -36 },
  { 3594, 27, 33, 39, 6, -38 },
  { 3706, 27, 19, 39, 6, -31 },
  { 3771, 27, 33, 39, 6, -38 },
  { 3883, 22, 47, 39, 10, -47 },
  { 4013, 32, 60, 39, 4, -48 },
  { 4253, 31, 47, 39, 4, -47 },
  { 4436, 27, 47, 39, 7, -47 },
  { 4595, 27, 49, 39, 6, -48 },
  { 4761, 26, 47, 39, 7, -47 },
  { 4914, 26, 47, 39, 7, -47 },
  { 5067, 27, 47, 39, 7, -47 },
  { 5226, 27, 49, 39, 6, -48 },
  { 5392, 25, 47, 39, 7, -47 },
  { 5539, 25, 48, 39, 7, -48 },
  { 5689, 28, 48, 39, 4, -47 },
  { 5857, 29, 48, 39, 7, -48 },
  { 6031, 26, 47, 39, 8, -47 },
  { 6184, 27, 47, 39, 6, -47 },
  { 6343, 25, 47, 39, 7, -47 },
  { 6490, 27, 49, 39, 6, -48 },
  { 6656, 28, 47, 39, 7, -47 },
  { 6821, 28, 60, 39, 6, -48 },
  { 7031, 28, 47, 39, 7, -47 },
  { 7196, 29, 49, 39, 5, -48 },
  { 7374, 31, 47, 39, 4, -47 },
  { 7557, 25, 48, 39, 7, -47 },
  { 7707, 31, 47, 39, 4, -47 },
  { 7890, 35, 47, 39, 2, -47 },
  { 8096, 33, 47, 39, 3, -47 },
  { 8290, 33, 47, 39, 3, -47 },
  { 8484, 27, 47, 39, 6, -47 },
  { 8643, 15, 61, 39, 14, -54 },
  { 8758, 27, 61, 39, 6, -54 },
  { 8964, 15, 61, 39, 10, -54 },
  { 9079, 27, 25, 39, 6, -47 },
  { 9164, 31, 3, 39, 4, 2 },
  { 9176, 12, 9, 39, 13, -51 },
  { 9190, 27, 37, 39, 5, -36 },
  { 9315, 26, 48, 39, 7, -47 },
  { 9471, 27, 37, 39, 6, -36 },
  { 9596, 26, 48, 39, 6, -47 },
  { 9752, 27, 37, 39, 6, -36 },
  { 9877, 30, 47, 39, 4, -47 },
  { 10054, 26, 48, 39, 6, -36 },
  { 10210, 25, 47, 39, 7, -47 },
  { 10357, 29, 50, 39, 6, -50 },
  { 10539, 23, 62, 39, 6, -50 },
  { 10718, 28, 47, 39, 7, -47 },
  { 10883, 32, 47, 39, 3, -47 },
  { 11071, 29, 36, 39, 5, -36 },
  { 11202, 25, 36, 39, 7, -36 },
  { 11315, 27, 37, 39, 6, -36 },
  { 11440, 26, 48, 39, 7, -36 },
  { 11596, 26, 48, 39, 6, -36 },
  { 11752, 26, 36, 39, 8, -36 },
  { 11869, 27, 37, 39, 6, -36 },
  { 11994, 29, 46, 39, 4, -46 },
  { 12161, 25, 37, 39, 7, -36 },
  { 12277, 31, 36, 39, 4, -36 },
  { 12417, 33, 36, 39, 3, -36 },
  { 12566, 31, 36, 39, 4, -36 },
  { 12706, 31, 48, 39, 4, -36 },
  { 12892, 27, 36, 39, 6, -36 },
  { 13014, 27, 61, 39, 6, -54 },
  { 13220, 5, 61, 39, 17, -54 },
  { 13259, 27, 61, 39, 6, -54 },
  { 13465, 29, 12, 39, 5, -29 },
};

const GFXfont JetBrainsMono_ExtraLight65pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight65pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _JETBRAINSMONO_EXTRALIGHT65PT7B_H_
