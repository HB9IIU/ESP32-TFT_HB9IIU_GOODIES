#ifndef _JETBRAINSMONO_EXTRALIGHT27PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight27pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x06, 0xF7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x43, 0x06, 0x18, 0x10, 0x60, 0x41,
  0x03, 0x04, 0x0C, 0x10, 0x30, 0xC7, 0xFF, 0xC2, 0x08, 0x08, 0x20, 0x60,
  0x81, 0x86, 0x04, 0x18, 0x10, 0x63, 0xFF, 0xE3, 0x04, 0x0C, 0x30, 0x30,
  0xC0, 0x83, 0x02, 0x08, 0x18, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xF8,
  0x3F, 0xC7, 0x26, 0x62, 0x36, 0x23, 0x62, 0x06, 0x20, 0x62, 0x03, 0xA0,
  0x1F, 0x00, 0x7C, 0x02, 0xE0, 0x26, 0x02, 0x30, 0x23, 0xC2, 0x3C, 0x23,
  0x62, 0x67, 0xBE, 0x1F, 0x80, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x1C,
  0x03, 0x7E, 0x06, 0x63, 0x04, 0x43, 0x0C, 0x43, 0x18, 0x43, 0x10, 0x43,
  0x20, 0x66, 0x60, 0x3E, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x3C, 0x02,
  0x7E, 0x06, 0x42, 0x0C, 0xC2, 0x08, 0xC2, 0x10, 0xC2, 0x30, 0xC2, 0x20,
  0x66, 0xC0, 0x3C, 0x1F, 0x01, 0xFC, 0x18, 0x30, 0xC1, 0x86, 0x04, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x03, 0xC0, 0x33, 0x07, 0x8C, 0x68, 0x33,
  0x41, 0xB2, 0x07, 0x90, 0x18, 0x80, 0xE6, 0x0F, 0x39, 0xCC, 0xFC, 0x30,
  0xFF, 0xFF, 0x01, 0x07, 0x0E, 0x18, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x30,
  0x38, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0C, 0x06, 0x06, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06,
  0x06, 0x0E, 0x0C, 0x38, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xE3, 0x1D, 0xF5, 0xE0, 0xFE, 0x00, 0xC0, 0x06, 0x80, 0x33, 0x01,
  0xC6, 0x06, 0x18, 0x30, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39,
  0x9C, 0xC6, 0x33, 0x18, 0xFF, 0xFF, 0x6F, 0xFF, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0x83,
  0xFC, 0x70, 0x66, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x63, 0xC7, 0x3C, 0x23, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x36,
  0x06, 0x39, 0xC1, 0xF8, 0x0E, 0x03, 0xC1, 0xD8, 0x73, 0x08, 0x61, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC3, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x60,
  0x6C, 0x03, 0xC0, 0x3C, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xEF, 0xFC, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0E, 0x01,
  0xC0, 0x6C, 0x0D, 0xE7, 0x0F, 0xC0, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x0C, 0xC1, 0xB0, 0x3C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xDF,
  0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0xF8, 0xFF, 0x9C, 0x1B,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x58, 0x19, 0xCE,
  0x1F, 0x80, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x37, 0x87, 0xFE, 0x60, 0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x40, 0x36, 0x06, 0x39, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3C, 0x03, 0xC0, 0x6C, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x0F, 0x83, 0xFC, 0x60, 0x66, 0x02, 0x60, 0x36, 0x03, 0x60,
  0x63, 0x06, 0x19, 0xC0, 0xF0, 0x1F, 0x83, 0x0C, 0x60, 0x64, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x06, 0x79, 0xE1, 0xF8, 0x0F, 0x83, 0xFC, 0x60,
  0x66, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x07, 0x70,
  0xE3, 0xF6, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x7F, 0xF6, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x7B, 0xDE,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x73, 0x39, 0x8C, 0x66, 0x30, 0x00, 0x10,
  0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x08, 0x00, 0xF8, 0x7F, 0x00, 0xC0, 0x30, 0x18, 0x04, 0x06,
  0x03, 0x01, 0x83, 0x8F, 0x86, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x1E, 0x07, 0x00, 0x0F, 0x81, 0xEF, 0x18, 0x0D, 0x80, 0x6C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x7B, 0x87, 0x3C, 0x30, 0xE1, 0x07, 0x08, 0x38, 0x41,
  0xC2, 0x0E, 0x10, 0x70, 0x83, 0x86, 0x3C, 0x1F, 0xE0, 0x21, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0xF0, 0x0F, 0x80, 0x06, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0x90, 0x04, 0xC0, 0x66, 0x03, 0x30, 0x10, 0x81, 0x86,
  0x0C, 0x30, 0x60, 0x82, 0x06, 0x3F, 0xF1, 0x81, 0x8C, 0x04, 0x40, 0x36,
  0x01, 0xB0, 0x0D, 0x80, 0x30, 0xFC, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x07,
  0x80, 0xF0, 0x1E, 0x06, 0xC1, 0xDF, 0xE3, 0xFE, 0x60, 0x6C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1B, 0xFF, 0x7F, 0x80, 0x1F, 0x0F, 0xF3,
  0x83, 0x60, 0x2C, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x03, 0xC0, 0x78, 0x19, 0xCF, 0x1F,
  0x80, 0xFC, 0x1F, 0xE3, 0x06, 0x60, 0x6C, 0x0D, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x02, 0xC0,
  0xD8, 0x3B, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0xFF, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0xFF,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x00, 0x1F, 0x0F, 0xF3, 0x83, 0x60, 0x2C, 0x07, 0x00, 0xE0, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x19, 0xCF, 0x1F, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x19, 0xCF, 0x1F, 0x80, 0xC0,
  0x7C, 0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18, 0xC3, 0x0C, 0x30, 0xC6,
  0x0F, 0xE0, 0xFE, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0,
  0xCC, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0xE0, 0x7E, 0x05,
  0xF0, 0x7F, 0x0F, 0xD0, 0xBD, 0x8B, 0xC9, 0xBC, 0x93, 0xCD, 0x3C, 0x73,
  0xC6, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x1E, 0x06, 0x81, 0xB0, 0x64, 0x19, 0x86,
  0x61, 0x88, 0x63, 0x18, 0xC6, 0x11, 0x86, 0x60, 0x98, 0x36, 0x0D, 0x81,
  0x60, 0x78, 0x1E, 0x03, 0x1F, 0x0F, 0xF3, 0x83, 0x60, 0x6C, 0x05, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0xD8, 0x19, 0xCE, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xC0,
  0xEC, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x6C, 0x0C, 0xFF,
  0x8F, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x1F, 0x0F, 0xF3, 0x83, 0x60, 0x68, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x58, 0x19, 0xCE, 0x1F, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0xFE, 0x1F, 0xF3, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF8, 0x3B, 0xFE, 0x63, 0x0C, 0x31, 0x86, 0x30, 0x66, 0x0C, 0xC0,
  0xD8, 0x1B, 0x01, 0xE0, 0x30, 0x0F, 0x83, 0xFC, 0x60, 0x66, 0x03, 0x60,
  0x36, 0x00, 0x60, 0x06, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x79, 0xE1, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x37, 0x38, 0xFC, 0xC0, 0x1E, 0x01,
  0xB0, 0x0D, 0x80, 0x66, 0x02, 0x30, 0x31, 0x81, 0x84, 0x0C, 0x30, 0x41,
  0x86, 0x0C, 0x30, 0x21, 0x81, 0x88, 0x0C, 0xC0, 0x66, 0x01, 0x30, 0x0D,
  0x00, 0x78, 0x03, 0xC0, 0x0C, 0x00, 0xC3, 0x07, 0x0C, 0x3C, 0x30, 0xF0,
  0xE3, 0xC2, 0x8D, 0x1A, 0x34, 0x68, 0xD1, 0x22, 0x64, 0x89, 0x92, 0x26,
  0x4D, 0x99, 0x36, 0x6C, 0x58, 0xB1, 0x62, 0x85, 0x8A, 0x14, 0x28, 0x50,
  0xE1, 0x43, 0x87, 0x0E, 0x1C, 0x60, 0x1D, 0x80, 0x63, 0x03, 0x0C, 0x0C,
  0x18, 0x60, 0x21, 0x80, 0xCC, 0x01, 0xA0, 0x07, 0x80, 0x0C, 0x00, 0x38,
  0x01, 0xE0, 0x04, 0xC0, 0x33, 0x01, 0x86, 0x06, 0x18, 0x30, 0x30, 0xC0,
  0x66, 0x01, 0xB8, 0x03, 0xC0, 0x0D, 0x80, 0x26, 0x01, 0x8C, 0x04, 0x30,
  0x30, 0x60, 0x81, 0x86, 0x03, 0x10, 0x0C, 0xC0, 0x1A, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x7F, 0xE7, 0xFE, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x3F, 0xFC, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F,
  0xFC, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xD0, 0x19, 0x81, 0x88, 0x30, 0xC3,
  0x0C, 0x20, 0x66, 0x06, 0xC0, 0x30, 0xFF, 0xF8, 0xE1, 0x8C, 0x30, 0x1F,
  0x87, 0xF9, 0x81, 0xB0, 0x30, 0x02, 0x00, 0x40, 0x09, 0xFF, 0x60, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x06, 0xE3, 0x4F, 0xC8, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xBE, 0x3E, 0xE7, 0x06, 0xC0, 0xD8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x58, 0x1B, 0xC6, 0x6F, 0x80,
  0x3F, 0x0F, 0xF3, 0x03, 0x60, 0x28, 0x07, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x01, 0xE0, 0x3C, 0x0C, 0xE7, 0x8F, 0xC0, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x4F, 0x97, 0xF7, 0x03, 0xC0, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0xF0, 0x37, 0x34, 0xF9, 0x3F, 0x0E,
  0x73, 0x03, 0x60, 0x68, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x3C, 0x0C, 0xE3, 0x0F, 0xC0, 0x01, 0xF0, 0x7F, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x3E, 0x5F, 0xDC, 0x0F, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x0F, 0x03, 0x7F, 0x4F, 0x90, 0x04, 0x01, 0x00, 0xC0, 0x33,
  0xF8, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCF, 0xBB, 0x83,
  0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x02, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC1, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0xFF, 0x3F, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x07, 0xC0, 0xEC, 0x0C, 0xC1,
  0x8C, 0x30, 0xC3, 0x0F, 0xE0, 0xFE, 0x0C, 0x60, 0xC3, 0x0C, 0x18, 0xC1,
  0x8C, 0x0C, 0xC0, 0xEC, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x3F, 0xC0, 0x7F, 0xFC, 0xEE, 0xF3, 0xC6, 0x3C, 0x61, 0xC6, 0x1C,
  0x61, 0xC6, 0x1C, 0x61, 0xC6, 0x1C, 0x61, 0xC6, 0x1C, 0x61, 0xC6, 0x1C,
  0x61, 0xC6, 0x10, 0xDF, 0x3E, 0xEE, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x04, 0x3F, 0x0F,
  0xF3, 0x03, 0x60, 0x68, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x2C, 0x0C, 0xE7, 0x0F, 0xC0, 0xDF, 0x1F, 0x73, 0x83, 0x60,
  0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x2C,
  0x0D, 0xE3, 0x37, 0xC6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x3E,
  0x5F, 0xDC, 0x0F, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x03, 0xC0, 0xDC, 0xD3, 0xE4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0xCF, 0x9B, 0x7B, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x1F, 0xC3, 0xFE,
  0x60, 0x66, 0x03, 0x60, 0x06, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0xE0, 0x03,
  0x00, 0x3C, 0x03, 0x60, 0x37, 0x0E, 0x3F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x07,
  0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xDC, 0xE3, 0xF0, 0xC0, 0x3C, 0x03, 0x40,
  0x36, 0x06, 0x60, 0x62, 0x06, 0x30, 0xC3, 0x0C, 0x10, 0xC1, 0x98, 0x19,
  0x80, 0x90, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0xC3, 0x0F, 0x0C, 0x34, 0x30,
  0xD0, 0xE2, 0x66, 0x89, 0x92, 0x26, 0x49, 0x99, 0x26, 0x24, 0x98, 0x93,
  0x42, 0xC5, 0x0E, 0x14, 0x38, 0x70, 0xE1, 0xC1, 0x87, 0x00, 0xC0, 0x36,
  0x06, 0x30, 0x63, 0x0C, 0x19, 0x80, 0xD0, 0x0F, 0x00, 0x60, 0x0F, 0x00,
  0xD8, 0x19, 0x83, 0x0C, 0x70, 0x66, 0x06, 0xC0, 0x30, 0xC0, 0x3C, 0x03,
  0x60, 0x36, 0x06, 0x20, 0x63, 0x0C, 0x30, 0xC1, 0x8C, 0x19, 0x80, 0x98,
  0x0D, 0x80, 0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0xFF, 0xDF, 0xF8, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x7E, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x1F, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0x00, 0x60, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x07, 0xF0, 0x7E,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x30,
  0x06, 0x07, 0xC0, 0xE0, 0x00, 0x78, 0x3E, 0xC3, 0xC6, 0x3C, 0x3F, 0xC1,
  0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 8, 8, 16, 4, -20 },
  { 19, 14, 20, 16, 1, -20 },
  { 54, 12, 27, 16, 2, -23 },
  { 95, 16, 20, 16, 0, -20 },
  { 135, 13, 20, 16, 2, -20 },
  { 168, 2, 8, 16, 7, -20 },
  { 170, 8, 26, 16, 5, -23 },
  { 196, 8, 26, 16, 3, -23 },
  { 222, 14, 13, 16, 1, -16 },
  { 245, 12, 12, 16, 2, -15 },
  { 263, 5, 8, 16, 5, -4 },
  { 268, 8, 2, 16, 4, -10 },
  { 270, 4, 4, 16, 6, -4 },
  { 272, 12, 25, 16, 2, -22 },
  { 310, 12, 20, 16, 2, -20 },
  { 340, 11, 20, 16, 3, -20 },
  { 368, 12, 20, 16, 2, -20 },
  { 398, 11, 20, 16, 2, -20 },
  { 426, 11, 20, 16, 2, -20 },
  { 454, 11, 20, 16, 3, -20 },
  { 482, 12, 20, 16, 2, -20 },
  { 512, 12, 20, 16, 2, -20 },
  { 542, 12, 20, 16, 2, -20 },
  { 572, 12, 20, 16, 2, -20 },
  { 602, 4, 15, 16, 6, -15 },
  { 610, 5, 19, 16, 5, -15 },
  { 622, 12, 14, 16, 2, -16 },
  { 643, 12, 8, 16, 2, -13 },
  { 655, 12, 14, 16, 2, -16 },
  { 676, 9, 20, 16, 4, -20 },
  { 699, 13, 25, 16, 2, -20 },
  { 740, 13, 20, 16, 2, -20 },
  { 773, 11, 20, 16, 3, -20 },
  { 801, 11, 20, 16, 3, -20 },
  { 829, 11, 20, 16, 3, -20 },
  { 857, 11, 20, 16, 3, -20 },
  { 885, 11, 20, 16, 3, -20 },
  { 913, 11, 20, 16, 3, -20 },
  { 941, 10, 20, 16, 3, -20 },
  { 966, 10, 20, 16, 3, -20 },
  { 991, 11, 20, 16, 2, -20 },
  { 1019, 12, 20, 16, 3, -20 },
  { 1049, 11, 20, 16, 3, -20 },
  { 1077, 12, 20, 16, 2, -20 },
  { 1107, 10, 20, 16, 3, -20 },
  { 1132, 11, 20, 16, 3, -20 },
  { 1160, 12, 20, 16, 3, -20 },
  { 1190, 11, 25, 16, 3, -20 },
  { 1225, 11, 20, 16, 3, -20 },
  { 1253, 12, 20, 16, 2, -20 },
  { 1283, 13, 20, 16, 2, -20 },
  { 1316, 10, 20, 16, 3, -20 },
  { 1341, 13, 20, 16, 2, -20 },
  { 1374, 14, 20, 16, 1, -20 },
  { 1409, 14, 20, 16, 1, -20 },
  { 1444, 14, 20, 16, 1, -20 },
  { 1479, 12, 20, 16, 2, -20 },
  { 1509, 6, 25, 16, 6, -22 },
  { 1528, 12, 25, 16, 2, -22 },
  { 1566, 6, 25, 16, 4, -22 },
  { 1585, 12, 11, 16, 2, -20 },
  { 1602, 13, 1, 16, 2, 1 },
  { 1604, 5, 4, 16, 5, -21 },
  { 1607, 11, 15, 16, 2, -15 },
  { 1628, 11, 20, 16, 3, -20 },
  { 1656, 11, 15, 16, 3, -15 },
  { 1677, 10, 20, 16, 3, -20 },
  { 1702, 11, 15, 16, 3, -15 },
  { 1723, 12, 20, 16, 2, -20 },
  { 1753, 10, 20, 16, 3, -15 },
  { 1778, 10, 20, 16, 3, -20 },
  { 1803, 13, 21, 16, 2, -21 },
  { 1838, 10, 26, 16, 2, -21 },
  { 1871, 12, 20, 16, 3, -20 },
  { 1901, 14, 20, 16, 1, -20 },
  { 1936, 12, 15, 16, 2, -15 },
  { 1959, 10, 15, 16, 3, -15 },
  { 1978, 11, 15, 16, 3, -15 },
  { 1999, 11, 20, 16, 3, -15 },
  { 2027, 10, 20, 16, 3, -15 },
  { 2052, 11, 15, 16, 3, -15 },
  { 2073, 12, 15, 16, 2, -15 },
  { 2096, 12, 19, 16, 2, -19 },
  { 2125, 10, 15, 16, 3, -15 },
  { 2144, 12, 15, 16, 2, -15 },
  { 2167, 14, 15, 16, 1, -15 },
  { 2194, 12, 15, 16, 2, -15 },
  { 2217, 12, 20, 16, 2, -15 },
  { 2247, 11, 15, 16, 3, -15 },
  { 2268, 11, 25, 16, 3, -22 },
  { 2303, 2, 25, 16, 7, -22 },
  { 2310, 11, 25, 16, 3, -22 },
  { 2345, 12, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_ExtraLight27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_EXTRALIGHT27PT7B_H_
