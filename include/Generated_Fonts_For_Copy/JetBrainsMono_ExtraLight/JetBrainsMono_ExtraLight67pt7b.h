#ifndef _JETBRAINSMONO_EXTRALIGHT67PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight67pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x9F, 0xEF, 0xF7, 0xFF, 0xFD, 0xFE, 0x7E, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0xC0,
  0x3F, 0x0E, 0x3F, 0x81, 0xF8, 0x38, 0x3F, 0x07, 0xC0, 0xE0, 0x7C, 0x3E,
  0x03, 0x80, 0xF0, 0xF8, 0x0E, 0x03, 0xE3, 0xC0, 0x38, 0x0F, 0x8F, 0x00,
  0xE0, 0x1E, 0x3C, 0x03, 0x80, 0x78, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xF8, 0x0E, 0x00,
  0x01, 0xF0, 0x38, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00,
  0x1F, 0xCE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0x9F, 0xE0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x38,
  0x3F, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x0E, 0x03,
  0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x1F, 0x00, 0x03, 0x80, 0x7F,
  0xE0, 0x0E, 0x01, 0xFF, 0x80, 0x38, 0x07, 0xFE, 0x00, 0xE0, 0x1F, 0x78,
  0x03, 0x80, 0x7D, 0xF0, 0x0E, 0x01, 0xE7, 0xC0, 0x38, 0x0F, 0x8F, 0x80,
  0xE0, 0x3E, 0x3F, 0x03, 0x81, 0xF0, 0x7F, 0x0E, 0x1F, 0x80, 0xFF, 0xBB,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3C, 0x3F, 0xF8, 0x00, 0x01, 0xE1, 0xFF, 0xF0, 0x00,
  0x07, 0x0F, 0xC7, 0xE0, 0x00, 0x3C, 0x3C, 0x07, 0xC0, 0x01, 0xE1, 0xE0,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x01,
  0xE0, 0x78, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x07, 0x80,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x38,
  0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x1E, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1F, 0x0F, 0x00,
  0x03, 0xF1, 0xF8, 0x78, 0x00, 0x07, 0xFF, 0xC1, 0xE0, 0x00, 0x0F, 0xFE,
  0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xC0,
  0x00, 0x03, 0xC1, 0xFF, 0xC0, 0x00, 0x0F, 0x0F, 0xFF, 0x80, 0x00, 0x78,
  0x7F, 0x7F, 0x00, 0x03, 0xC1, 0xE0, 0x3E, 0x00, 0x0E, 0x0F, 0x00, 0x78,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0x0E, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0xE0,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x07, 0x83,
  0xC0, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x70, 0x00, 0x1F,
  0x8F, 0xC3, 0xC0, 0x00, 0x3F, 0xFE, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF9, 0xF0,
  0x3E, 0x00, 0x3C, 0xF8, 0x07, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0x0F, 0x8F,
  0x80, 0x3E, 0x03, 0xE3, 0xE0, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0xF8, 0x78,
  0x3E, 0x00, 0x1F, 0x3E, 0x0F, 0x80, 0x07, 0xCF, 0x03, 0xE0, 0x00, 0xFF,
  0xC0, 0xF8, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x3E, 0x00,
  0x03, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0x01, 0xE0, 0x00, 0xFB, 0xE0, 0x7C,
  0x00, 0x7C, 0x7C, 0x1F, 0x80, 0x3F, 0x0F, 0x03, 0xFC, 0x7F, 0x83, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7C, 0x0F, 0xFF, 0xC0, 0x0F, 0x81, 0xFF, 0xC0, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0x00, 0x07, 0x80, 0x02, 0x3C, 0x00, 0xF0, 0x03,
  0xEF, 0xF0, 0x1E, 0x03, 0xFD, 0xFF, 0xC3, 0xC1, 0xFF, 0xBF, 0xFE, 0x38,
  0xFF, 0xF8, 0xFF, 0xE6, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0xFF, 0x01, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01,
  0xF8, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0xFE, 0x3C,
  0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7F, 0x03, 0xC0, 0x01, 0xF8, 0x0F, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x40, 0x03, 0xC0, 0x02,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x0F,
  0xC0, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC1, 0xFF, 0x00, 0x7C, 0x7F, 0xFC, 0x07, 0xCF,
  0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0x87, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x0F,
  0xC7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x9F, 0xFE, 0x00, 0x3D, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x81, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x1F, 0xF0,
  0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x3F,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFB, 0xE0, 0x07, 0xFF, 0x9F, 0x00, 0x03, 0xF8, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x04, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xE0,
  0xC0, 0x01, 0x80, 0x7F, 0x83, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xFC,
  0xFF, 0x00, 0x3F, 0xFF, 0x7F, 0x80, 0x1F, 0x83, 0xBF, 0xC0, 0x1F, 0x00,
  0x7F, 0xE0, 0x0F, 0x00, 0x1F, 0xF0, 0x07, 0x80, 0x0F, 0xF8, 0x07, 0xC0,
  0x03, 0xFC, 0x03, 0xC0, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0xF0,
  0x00, 0x7F, 0x80, 0x78, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x1F, 0xE0, 0x1E,
  0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x03, 0xFC, 0x03,
  0xC0, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x7F, 0x80,
  0x7C, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x3F, 0xE0, 0x0F, 0x00, 0x1F, 0xF0,
  0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x1D, 0xFE,
  0x00, 0x7F, 0xFE, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xF0, 0x00, 0xFF, 0x0F, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x3F, 0x0F,
  0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0xFC,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x7F, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x7E, 0x00, 0x7F, 0x1F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xF8, 0x7E, 0x00,
  0x3F, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0x00, 0x1F, 0xE1,
  0xE0, 0x00, 0xFE, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0xF0, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x3F, 0x8F,
  0x00, 0x1F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xF0,
  0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x1F, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x0F,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x0F, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xEE, 0x00, 0x07, 0x7E,
  0xF0, 0x00, 0xF7, 0xE7, 0x00, 0x0F, 0x7E, 0x70, 0x00, 0xE7, 0xF7, 0x80,
  0x1E, 0x7F, 0x38, 0x01, 0xE7, 0xF3, 0xC0, 0x1C, 0x7F, 0x3C, 0x03, 0xC7,
  0xF1, 0xC0, 0x3C, 0xFF, 0x1E, 0x03, 0x8F, 0xF1, 0xE0, 0x78, 0xFF, 0x0E,
  0x07, 0x8F, 0xF0, 0xF0, 0x70, 0xFF, 0x0F, 0x0F, 0x0F, 0xF0, 0x70, 0xF0,
  0xFF, 0x07, 0x8E, 0x0F, 0xF0, 0x79, 0xE0, 0xFF, 0x03, 0x9E, 0x0F, 0xF0,
  0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xF8,
  0x0F, 0xF0, 0x0F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xDE, 0x00, 0x0F,
  0xF7, 0x80, 0x03, 0xFD, 0xE0, 0x00, 0xFF, 0x3C, 0x00, 0x3F, 0xCF, 0x00,
  0x0F, 0xF1, 0xE0, 0x03, 0xFC, 0x78, 0x00, 0xFF, 0x1E, 0x00, 0x3F, 0xC3,
  0xC0, 0x0F, 0xF0, 0xF0, 0x03, 0xFC, 0x3C, 0x00, 0xFF, 0x07, 0x80, 0x3F,
  0xC1, 0xE0, 0x0F, 0xF0, 0x3C, 0x03, 0xFC, 0x0F, 0x00, 0xFF, 0x03, 0xC0,
  0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0xC0, 0xFF, 0x00,
  0xF0, 0x3F, 0xC0, 0x3C, 0x0F, 0xF0, 0x07, 0x83, 0xFC, 0x01, 0xE0, 0xFF,
  0x00, 0x78, 0x3F, 0xC0, 0x0F, 0x0F, 0xF0, 0x03, 0xC3, 0xFC, 0x00, 0x78,
  0xFF, 0x00, 0x1E, 0x3F, 0xC0, 0x07, 0x8F, 0xF0, 0x00, 0xF3, 0xFC, 0x00,
  0x3C, 0xFF, 0x00, 0x0F, 0x3F, 0xC0, 0x01, 0xEF, 0xF0, 0x00, 0x7B, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00,
  0x7E, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x03,
  0xFC, 0x78, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3F, 0x9E, 0x00, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x07, 0xE3,
  0xC0, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xE3, 0xC0, 0x00,
  0x7F, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0xF8, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x1E,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x0F, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF0, 0x7F, 0x00, 0x1F, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F,
  0x78, 0x01, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x80, 0x1F, 0x78, 0x01, 0xF8,
  0x01, 0xE7, 0x80, 0x1D, 0xC0, 0x1E, 0x78, 0x01, 0xDC, 0x01, 0xE7, 0x80,
  0x1D, 0xC0, 0x1E, 0x78, 0x01, 0xDC, 0x01, 0xE7, 0xC0, 0x39, 0xC0, 0x1E,
  0x3C, 0x03, 0x9C, 0x01, 0xE3, 0xC0, 0x39, 0xC0, 0x1E, 0x3C, 0x03, 0x9C,
  0x03, 0xC3, 0xC0, 0x38, 0xE0, 0x3C, 0x3C, 0x03, 0x8E, 0x03, 0xC3, 0xC0,
  0x38, 0xE0, 0x3C, 0x3C, 0x03, 0x8E, 0x03, 0xC3, 0xC0, 0x70, 0xE0, 0x3C,
  0x3E, 0x07, 0x0E, 0x03, 0xC1, 0xE0, 0x70, 0xE0, 0x3C, 0x1E, 0x07, 0x0E,
  0x03, 0x81, 0xE0, 0x70, 0x70, 0x78, 0x1E, 0x07, 0x07, 0x07, 0x81, 0xE0,
  0x70, 0x70, 0x78, 0x1E, 0x0E, 0x07, 0x07, 0x81, 0xE0, 0xE0, 0x70, 0x78,
  0x1F, 0x0E, 0x07, 0x07, 0x80, 0xF0, 0xE0, 0x70, 0x78, 0x0F, 0x0E, 0x07,
  0x07, 0x00, 0xF0, 0xE0, 0x38, 0x70, 0x0F, 0x0E, 0x03, 0x8F, 0x00, 0xF1,
  0xC0, 0x38, 0xF0, 0x0F, 0x1C, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x38, 0xF0,
  0x0F, 0x1C, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x38, 0xF0, 0x07, 0x9C, 0x03,
  0xCE, 0x00, 0x79, 0xC0, 0x1C, 0xE0, 0x07, 0x98, 0x01, 0xCE, 0x00, 0x7B,
  0x80, 0x1D, 0xE0, 0x07, 0xB8, 0x01, 0xDE, 0x00, 0x7B, 0x80, 0x1D, 0xE0,
  0x07, 0xB8, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x3C,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xF0, 0x00, 0x0F, 0x7C, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0xEF, 0x3F, 0xC0, 0x7E, 0xF1, 0xFF, 0xFF, 0xCF, 0x0F,
  0xFF, 0xF8, 0xF0, 0x3F, 0xFE, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x01, 0x00, 0x0F, 0x07, 0xFF, 0x01, 0xE1, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF,
  0x87, 0x9F, 0x0F, 0xF8, 0xF7, 0x00, 0x3F, 0x1E, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1E, 0xF8, 0x00, 0x03, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x7F,
  0x00, 0x07, 0xCF, 0x70, 0x03, 0xF9, 0xEF, 0xC1, 0xFE, 0x3C, 0xFF, 0xFF,
  0x87, 0x8F, 0xFF, 0xE0, 0xF0, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x01, 0xFC, 0x0F, 0xF0,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x17, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x06, 0x00, 0xF0, 0x0F, 0xFC, 0x1E,
  0x07, 0xFF, 0xE3, 0xC3, 0xFF, 0xFE, 0x78, 0x7F, 0x87, 0xEF, 0x1F, 0x80,
  0x1D, 0xE7, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF1, 0xF8, 0x01, 0xDE,
  0x3F, 0xC0, 0xFB, 0xC3, 0xFF, 0xFE, 0x78, 0x3F, 0xFF, 0x8F, 0x01, 0xFF,
  0xC1, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF0, 0x7F, 0x01, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xE0, 0xF0, 0x7F, 0xFE, 0x3C, 0x3F, 0xFF, 0xCF, 0x1F, 0xE1, 0xFB,
  0xCF, 0xC0, 0x0E, 0xF7, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x03,
  0xBC, 0x7F, 0x87, 0xEF, 0x0F, 0xFF, 0xF3, 0xC1, 0xFF, 0xF8, 0xF0, 0x1F,
  0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x08, 0x00, 0xF0, 0x7F, 0xF0, 0x3C, 0x3F, 0xFE,
  0x0F, 0x3F, 0xFF, 0xE3, 0xCF, 0x83, 0xFC, 0xF7, 0x00, 0x3F, 0x3D, 0x80,
  0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x20, 0x01, 0x03, 0xC7,
  0xF0, 0x7F, 0x8F, 0x3F, 0xE3, 0xFF, 0x3D, 0xFF, 0xCF, 0xFE, 0xFE, 0x1F,
  0x70, 0xFB, 0xF0, 0x3F, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xFC, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03,
  0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF,
  0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0,
  0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07,
  0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03,
  0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF,
  0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0,
  0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07,
  0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x3C, 0x1F, 0xFC,
  0x0F, 0x0F, 0xFF, 0x83, 0xCF, 0xFF, 0xF8, 0xF3, 0xE1, 0xFF, 0x3D, 0xE0,
  0x0F, 0xCF, 0x60, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xF0,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E,
  0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x1E, 0x0F, 0xFE, 0x03, 0xC3, 0xFF, 0xF0, 0x79, 0xFF, 0xFF,
  0x0F, 0x3E, 0x1F, 0xF1, 0xEF, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xE7, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F,
  0x7C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3D, 0xF0, 0x00, 0x07, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0x9E, 0xE0, 0x07, 0xE3, 0xDF, 0x83, 0xFC, 0x79, 0xFF, 0xFF,
  0x0F, 0x1F, 0xFF, 0xC1, 0xE0, 0xFF, 0xE0, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xE0, 0xF0, 0x7F, 0xFE, 0x3C, 0x7F, 0xFF,
  0xCF, 0x1F, 0xE1, 0xFB, 0xCF, 0xC0, 0x0E, 0xF7, 0xE0, 0x01, 0xFD, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xCF,
  0xC0, 0x0E, 0xF3, 0xFC, 0x0F, 0xBC, 0x7F, 0xFF, 0xCF, 0x07, 0xFF, 0xE3,
  0xC0, 0xFF, 0xE0, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x1E, 0x0F,
  0xFE, 0x03, 0xC3, 0xFF, 0xF0, 0x78, 0xFF, 0xFF, 0x0F, 0x3E, 0x0F, 0xF1,
  0xEF, 0x00, 0x7F, 0x3D, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x3E, 0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE3,
  0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78,
  0x03, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00,
  0x7C, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x3D, 0xE0, 0x0F, 0xC0, 0x0F, 0x78,
  0x03, 0xF0, 0x03, 0xDE, 0x00, 0xFC, 0x01, 0xE7, 0x80, 0x3B, 0x00, 0x79,
  0xE0, 0x0E, 0xE0, 0x1E, 0x78, 0x07, 0x38, 0x07, 0x8F, 0x01, 0xCE, 0x01,
  0xE3, 0xC0, 0x73, 0x80, 0x78, 0xF0, 0x1C, 0xE0, 0x3C, 0x3C, 0x07, 0x1C,
  0x0F, 0x0F, 0x01, 0x87, 0x03, 0xC3, 0xC0, 0xE1, 0xC0, 0xF0, 0xF0, 0x38,
  0x70, 0x3C, 0x1E, 0x0E, 0x1C, 0x0E, 0x07, 0x83, 0x87, 0x03, 0x81, 0xE0,
  0xE0, 0xE1, 0xE0, 0x78, 0x70, 0x38, 0x78, 0x1E, 0x1C, 0x0E, 0x1E, 0x07,
  0x87, 0x03, 0x87, 0x80, 0xF1, 0xC0, 0xE1, 0xC0, 0x3C, 0x70, 0x3C, 0x70,
  0x0F, 0x1C, 0x07, 0x3C, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0xF3, 0x80, 0x73,
  0xC0, 0x3C, 0xE0, 0x1C, 0xF0, 0x07, 0x38, 0x07, 0x38, 0x01, 0xEE, 0x01,
  0xEE, 0x00, 0x7B, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x7F, 0xE0, 0x00, 0xF3, 0xFF, 0xC0, 0x03, 0xDF, 0xFF, 0x80, 0x0F,
  0x78, 0x1F, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x03, 0xFC,
  0x01, 0xF8, 0x1F, 0xF0, 0x03, 0xF0, 0x7B, 0xC0, 0x07, 0xFF, 0xEF, 0x00,
  0x0F, 0xFF, 0x3C, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraLight67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 9, 49, 40, 16, -49 },
  { 57, 18, 20, 40, 11, -49 },
  { 102, 36, 49, 40, 2, -49 },
  { 323, 30, 67, 40, 5, -58 },
  { 575, 38, 49, 40, 1, -49 },
  { 808, 34, 51, 40, 4, -50 },
  { 1025, 6, 20, 40, 17, -49 },
  { 1040, 20, 64, 40, 13, -56 },
  { 1200, 19, 64, 40, 8, -56 },
  { 1352, 35, 34, 40, 3, -41 },
  { 1501, 30, 31, 40, 5, -38 },
  { 1618, 12, 21, 40, 12, -10 },
  { 1650, 22, 4, 40, 9, -24 },
  { 1661, 10, 11, 40, 15, -10 },
  { 1675, 28, 63, 40, 6, -56 },
  { 1896, 28, 51, 40, 6, -50 },
  { 2075, 30, 49, 40, 6, -49 },
  { 2259, 30, 50, 40, 5, -50 },
  { 2447, 28, 50, 40, 5, -49 },
  { 2622, 27, 49, 40, 6, -49 },
  { 2788, 28, 50, 40, 6, -49 },
  { 2963, 30, 50, 40, 5, -49 },
  { 3151, 29, 49, 40, 6, -49 },
  { 3329, 28, 51, 40, 6, -50 },
  { 3508, 30, 50, 40, 5, -50 },
  { 3696, 10, 39, 40, 15, -38 },
  { 3745, 13, 49, 40, 12, -38 },
  { 3825, 28, 34, 40, 6, -39 },
  { 3944, 28, 20, 40, 6, -32 },
  { 4014, 28, 34, 40, 6, -39 },
  { 4133, 23, 49, 40, 10, -49 },
  { 4274, 33, 62, 40, 4, -50 },
  { 4530, 32, 49, 40, 4, -49 },
  { 4726, 28, 49, 40, 7, -49 },
  { 4898, 27, 51, 40, 7, -50 },
  { 5071, 27, 49, 40, 7, -49 },
  { 5237, 27, 49, 40, 7, -49 },
  { 5403, 28, 49, 40, 7, -49 },
  { 5575, 27, 51, 40, 7, -50 },
  { 5748, 26, 49, 40, 7, -49 },
  { 5908, 25, 49, 40, 8, -49 },
  { 6062, 29, 50, 40, 4, -49 },
  { 6244, 30, 49, 40, 7, -49 },
  { 6428, 27, 49, 40, 8, -49 },
  { 6594, 28, 49, 40, 6, -49 },
  { 6766, 26, 49, 40, 7, -49 },
  { 6926, 27, 51, 40, 7, -50 },
  { 7099, 29, 49, 40, 7, -49 },
  { 7277, 29, 62, 40, 6, -50 },
  { 7502, 29, 49, 40, 7, -49 },
  { 7680, 30, 51, 40, 5, -50 },
  { 7872, 32, 49, 40, 4, -49 },
  { 8068, 26, 50, 40, 7, -49 },
  { 8231, 32, 49, 40, 4, -49 },
  { 8427, 36, 49, 40, 2, -49 },
  { 8648, 34, 49, 40, 3, -49 },
  { 8857, 34, 49, 40, 3, -49 },
  { 9066, 28, 49, 40, 6, -49 },
  { 9238, 16, 63, 40, 14, -56 },
  { 9364, 28, 63, 40, 6, -56 },
  { 9585, 16, 63, 40, 10, -56 },
  { 9711, 28, 26, 40, 6, -49 },
  { 9802, 32, 4, 40, 4, 2 },
  { 9818, 12, 10, 40, 13, -53 },
  { 9833, 28, 39, 40, 5, -38 },
  { 9970, 27, 50, 40, 7, -49 },
  { 10139, 28, 39, 40, 6, -38 },
  { 10276, 27, 50, 40, 6, -49 },
  { 10445, 28, 39, 40, 6, -38 },
  { 10582, 31, 49, 40, 4, -49 },
  { 10772, 26, 50, 40, 7, -38 },
  { 10935, 26, 49, 40, 7, -49 },
  { 11095, 30, 52, 40, 6, -52 },
  { 11290, 24, 64, 40, 6, -52 },
  { 11482, 29, 49, 40, 7, -49 },
  { 11660, 33, 49, 40, 3, -49 },
  { 11863, 30, 38, 40, 5, -38 },
  { 12006, 26, 38, 40, 7, -38 },
  { 12130, 28, 38, 40, 6, -37 },
  { 12263, 27, 50, 40, 7, -38 },
  { 12432, 26, 50, 40, 7, -38 },
  { 12595, 27, 38, 40, 8, -38 },
  { 12724, 28, 38, 40, 6, -37 },
  { 12857, 30, 47, 40, 4, -47 },
  { 13034, 26, 38, 40, 7, -37 },
  { 13158, 31, 37, 40, 5, -37 },
  { 13302, 34, 37, 40, 3, -37 },
  { 13460, 32, 37, 40, 4, -37 },
  { 13608, 31, 49, 40, 5, -37 },
  { 13798, 27, 37, 40, 7, -37 },
  { 13923, 28, 63, 40, 6, -56 },
  { 14144, 4, 63, 40, 18, -56 },
  { 14176, 28, 63, 40, 6, -56 },
  { 14397, 30, 13, 40, 5, -30 },
};

const GFXfont JetBrainsMono_ExtraLight67pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight67pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _JETBRAINSMONO_EXTRALIGHT67PT7B_H_
