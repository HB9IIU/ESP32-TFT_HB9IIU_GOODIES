#ifndef _JETBRAINSMONO_EXTRALIGHT17PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x0F, 0x99, 0x99, 0x90, 0x11, 0x11, 0x08, 0x9F, 0xF2,
  0x21, 0x11, 0x10, 0x88, 0xFF, 0x22, 0x11, 0x19, 0x00, 0x08, 0x08, 0x18,
  0x6E, 0x4A, 0x49, 0x48, 0x68, 0x3C, 0x0E, 0x0B, 0x09, 0xC9, 0x4A, 0x3E,
  0x08, 0x08, 0x20, 0x56, 0x28, 0x8A, 0x24, 0x8A, 0x1D, 0x00, 0x40, 0x24,
  0x12, 0x85, 0x12, 0x45, 0x11, 0xC3, 0x80, 0x18, 0x36, 0x10, 0x88, 0x04,
  0x01, 0x01, 0xC1, 0x32, 0x8B, 0x43, 0x21, 0x91, 0xC7, 0x98, 0xFF, 0x40,
  0x19, 0x98, 0x84, 0x63, 0x18, 0xC6, 0x30, 0x84, 0x30, 0xC1, 0xC1, 0x04,
  0x21, 0x84, 0x21, 0x08, 0x42, 0x31, 0x19, 0x90, 0x08, 0x04, 0x22, 0x5F,
  0xF0, 0x80, 0xE0, 0x90, 0x84, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08,
  0x08, 0x6D, 0x2D, 0x00, 0xFC, 0xF0, 0x03, 0x02, 0x02, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0xC0, 0x18, 0x76,
  0x42, 0x41, 0xC1, 0xC1, 0xD9, 0xC9, 0xC1, 0xC1, 0x43, 0x42, 0x3C, 0x71,
  0xA2, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x18, 0x66,
  0x42, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x7F, 0x7E,
  0x08, 0x30, 0xC1, 0xC0, 0xC0, 0x81, 0x03, 0x85, 0x09, 0xE0, 0x0C, 0x61,
  0x08, 0x61, 0x18, 0x61, 0xFC, 0x10, 0x41, 0xFD, 0x02, 0x04, 0x0F, 0xD0,
  0x81, 0x83, 0x07, 0x0E, 0x13, 0xC0, 0x0C, 0x18, 0x10, 0x20, 0x28, 0x76,
  0x43, 0xC1, 0x81, 0xC1, 0x42, 0x3C, 0xFF, 0xC1, 0xC2, 0x02, 0x06, 0x04,
  0x04, 0x08, 0x08, 0x18, 0x10, 0x30, 0x18, 0x66, 0x42, 0x43, 0x42, 0x26,
  0x18, 0x26, 0x42, 0xC1, 0x41, 0x42, 0x3E, 0x18, 0x66, 0x43, 0xC1, 0x81,
  0xC1, 0x42, 0x3E, 0x04, 0x04, 0x08, 0x18, 0x30, 0x7C, 0x00, 0xF0, 0x2D,
  0x80, 0x03, 0x69, 0x68, 0x01, 0x06, 0x18, 0x60, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x06,
  0x18, 0x60, 0x80, 0xF0, 0x42, 0x10, 0x9D, 0x08, 0x40, 0x11, 0xC0, 0x18,
  0x66, 0x41, 0x81, 0x81, 0x8F, 0x91, 0x91, 0x91, 0x91, 0x91, 0x8F, 0x80,
  0xC0, 0x40, 0x3C, 0x18, 0x18, 0x14, 0x24, 0x24, 0x24, 0x22, 0x42, 0x7E,
  0x42, 0xC1, 0x81, 0xFD, 0x0A, 0x1C, 0x28, 0x5F, 0x21, 0x41, 0x83, 0x06,
  0x17, 0xC0, 0x31, 0x9A, 0x14, 0x18, 0x10, 0x20, 0x40, 0x81, 0x02, 0x1C,
  0x27, 0x80, 0xF9, 0x0A, 0x14, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0A, 0x37,
  0xC0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02, 0x07, 0xF0,
  0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02, 0x04, 0x00, 0x31,
  0x9A, 0x14, 0x18, 0x10, 0x20, 0x4F, 0x83, 0x06, 0x1C, 0x27, 0x80, 0x86,
  0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x61, 0xFC, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x3F, 0x1E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x07, 0x1B, 0xE0, 0x87, 0x0A, 0x34, 0x49, 0x9E, 0x26, 0x44, 0x8D,
  0x0A, 0x1C, 0x10, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x07, 0xF0, 0xC3, 0xA5, 0xA5, 0xA5, 0xD9, 0xD9, 0xC9, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC7, 0x1C, 0x69, 0xA6, 0xD9, 0x65, 0x8E, 0x38, 0xE1, 0x31,
  0x9A, 0x14, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x14, 0x27, 0x80, 0xFD,
  0x06, 0x0C, 0x18, 0x31, 0xBE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x31, 0x9A,
  0x14, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x27, 0x81, 0x03, 0x03,
  0xFD, 0x0E, 0x0C, 0x18, 0x71, 0xBC, 0x44, 0x89, 0x0A, 0x14, 0x10, 0x18,
  0x66, 0x42, 0x41, 0x40, 0x60, 0x3C, 0x06, 0x03, 0x01, 0xC1, 0x42, 0x3E,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x81, 0x41, 0x42,
  0x42, 0x42, 0x26, 0x24, 0x24, 0x34, 0x1C, 0x18, 0x18, 0x99, 0xCC, 0xA6,
  0x53, 0x29, 0x54, 0xAA, 0x94, 0xCA, 0x65, 0x33, 0x19, 0x8C, 0x40, 0xC3,
  0x42, 0x24, 0x24, 0x18, 0x18, 0x18, 0x34, 0x24, 0x42, 0x43, 0x81, 0x81,
  0x43, 0x42, 0x26, 0x24, 0x1C, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFC,
  0x08, 0x30, 0x41, 0x02, 0x08, 0x30, 0x41, 0x82, 0x07, 0xF0, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x10,
  0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x02, 0x03, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x30, 0x71, 0x22, 0x48, 0x50, 0xC0,
  0xFF, 0xC4, 0x08, 0x7D, 0x08, 0x10, 0x2F, 0xF0, 0xC1, 0xC2, 0xFC, 0x81,
  0x02, 0x47, 0x68, 0x50, 0xE1, 0xC3, 0x87, 0x0A, 0x17, 0xC0, 0x10, 0xFA,
  0x14, 0x38, 0x10, 0x20, 0x43, 0x84, 0xF0, 0x04, 0x12, 0x7F, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x5F, 0x10, 0xDA, 0x14, 0x38, 0x7F, 0xE0, 0x41, 0x84,
  0xF0, 0x1F, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x23, 0xF8, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10, 0x41, 0x7C, 0x82,
  0x09, 0x3B, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x30, 0x60, 0x00, 0x0F,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x0C, 0x30, 0x00, 0xF8,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0xBC, 0x81, 0x02, 0x04, 0x38,
  0x51, 0x24, 0x78, 0x89, 0x1A, 0x14, 0x10, 0xF0, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F, 0x22, 0xDF, 0x89, 0x89, 0x89,
  0x89, 0x89, 0x89, 0x89, 0x89, 0x13, 0xB8, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x10, 0x10, 0xFA, 0x14, 0x38, 0x70, 0xE1, 0xC2, 0x84, 0xF0, 0x11, 0xDA,
  0x14, 0x38, 0x70, 0xE1, 0xC2, 0x85, 0xF2, 0x04, 0x08, 0x00, 0x23, 0xF8,
  0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x04, 0x11, 0x5B, 0x1C, 0x18,
  0x10, 0x20, 0x40, 0x81, 0x00, 0x11, 0xFA, 0x1C, 0x0C, 0x07, 0x81, 0x81,
  0x86, 0xF8, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x1F, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xC1, 0x42, 0x42,
  0x62, 0x24, 0x24, 0x14, 0x18, 0x18, 0x99, 0x99, 0x99, 0x99, 0x55, 0x66,
  0x66, 0x66, 0x66, 0xC3, 0x26, 0x24, 0x18, 0x18, 0x1C, 0x24, 0x42, 0xC3,
  0xC1, 0x42, 0x42, 0x26, 0x24, 0x34, 0x18, 0x18, 0x08, 0x10, 0x10, 0x30,
  0xFC, 0x18, 0x20, 0x82, 0x0C, 0x10, 0x40, 0xFE, 0x0E, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x78, 0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x07, 0xFF, 0xFF,
  0xC0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x0F, 0x30, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x60, 0x61, 0xD1, 0x89, 0x86,
};

const GFXglyph JetBrainsMono_ExtraLight17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 5, 10, 3, -12 },
  { 7, 9, 12, 10, 1, -12 },
  { 21, 8, 17, 10, 1, -15 },
  { 38, 10, 13, 10, 0, -13 },
  { 55, 9, 13, 10, 1, -13 },
  { 70, 2, 5, 10, 4, -12 },
  { 72, 5, 16, 10, 3, -14 },
  { 82, 5, 16, 10, 2, -14 },
  { 92, 9, 8, 10, 1, -10 },
  { 101, 8, 8, 10, 1, -10 },
  { 109, 3, 6, 10, 3, -3 },
  { 112, 6, 1, 10, 2, -6 },
  { 113, 2, 2, 10, 4, -2 },
  { 114, 8, 16, 10, 1, -14 },
  { 130, 8, 13, 10, 1, -13 },
  { 143, 7, 12, 10, 2, -12 },
  { 154, 8, 13, 10, 1, -13 },
  { 167, 7, 12, 10, 1, -12 },
  { 178, 6, 12, 10, 2, -12 },
  { 187, 7, 12, 10, 2, -12 },
  { 198, 8, 12, 10, 1, -12 },
  { 210, 8, 12, 10, 1, -12 },
  { 222, 8, 13, 10, 1, -13 },
  { 235, 8, 13, 10, 1, -13 },
  { 248, 2, 10, 10, 4, -10 },
  { 251, 3, 13, 10, 3, -10 },
  { 256, 8, 9, 10, 1, -10 },
  { 265, 7, 5, 10, 2, -8 },
  { 270, 8, 9, 10, 1, -10 },
  { 279, 5, 12, 10, 3, -12 },
  { 287, 8, 16, 10, 1, -13 },
  { 303, 8, 12, 10, 1, -12 },
  { 315, 7, 12, 10, 2, -12 },
  { 326, 7, 13, 10, 2, -13 },
  { 338, 7, 12, 10, 2, -12 },
  { 349, 7, 12, 10, 2, -12 },
  { 360, 7, 12, 10, 2, -12 },
  { 371, 7, 13, 10, 2, -13 },
  { 383, 6, 12, 10, 2, -12 },
  { 392, 6, 12, 10, 2, -12 },
  { 401, 7, 12, 10, 1, -12 },
  { 412, 7, 12, 10, 2, -12 },
  { 423, 7, 12, 10, 2, -12 },
  { 434, 8, 12, 10, 1, -12 },
  { 446, 6, 12, 10, 2, -12 },
  { 455, 7, 13, 10, 2, -13 },
  { 467, 7, 12, 10, 2, -12 },
  { 478, 7, 16, 10, 2, -13 },
  { 492, 7, 12, 10, 2, -12 },
  { 503, 8, 13, 10, 1, -13 },
  { 516, 8, 12, 10, 1, -12 },
  { 528, 6, 12, 10, 2, -12 },
  { 537, 8, 12, 10, 1, -12 },
  { 549, 9, 12, 10, 1, -12 },
  { 563, 8, 12, 10, 1, -12 },
  { 575, 8, 12, 10, 1, -12 },
  { 587, 7, 12, 10, 2, -12 },
  { 598, 4, 16, 10, 4, -14 },
  { 606, 8, 16, 10, 1, -14 },
  { 622, 4, 16, 10, 3, -14 },
  { 630, 7, 6, 10, 2, -12 },
  { 636, 8, 1, 10, 1, 0 },
  { 637, 3, 2, 10, 3, -13 },
  { 638, 7, 10, 10, 1, -10 },
  { 647, 7, 12, 10, 2, -12 },
  { 658, 7, 10, 10, 2, -10 },
  { 667, 6, 12, 10, 2, -12 },
  { 676, 7, 10, 10, 2, -10 },
  { 685, 8, 12, 10, 1, -12 },
  { 697, 6, 13, 10, 2, -10 },
  { 707, 6, 12, 10, 2, -12 },
  { 716, 7, 13, 10, 2, -13 },
  { 728, 6, 16, 10, 2, -13 },
  { 740, 7, 12, 10, 2, -12 },
  { 751, 8, 12, 10, 1, -12 },
  { 763, 8, 10, 10, 1, -10 },
  { 773, 6, 10, 10, 2, -10 },
  { 781, 7, 10, 10, 2, -10 },
  { 790, 7, 13, 10, 2, -10 },
  { 802, 6, 13, 10, 2, -10 },
  { 812, 7, 10, 10, 2, -10 },
  { 821, 7, 10, 10, 2, -10 },
  { 830, 8, 12, 10, 1, -12 },
  { 842, 6, 9, 10, 2, -9 },
  { 849, 8, 9, 10, 1, -9 },
  { 858, 8, 9, 10, 1, -9 },
  { 867, 8, 9, 10, 1, -9 },
  { 876, 8, 12, 10, 1, -9 },
  { 888, 7, 9, 10, 2, -9 },
  { 896, 7, 16, 10, 2, -14 },
  { 910, 1, 16, 10, 5, -14 },
  { 912, 7, 16, 10, 2, -14 },
  { 926, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_ExtraLight17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_EXTRALIGHT17PT7B_H_
