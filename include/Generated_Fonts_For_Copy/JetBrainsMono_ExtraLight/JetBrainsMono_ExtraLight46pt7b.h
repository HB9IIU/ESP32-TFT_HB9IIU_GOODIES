#ifndef _JETBRAINSMONO_EXTRALIGHT46PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight46pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFD, 0xE0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03,
  0xB8, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0xC0, 0x38, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x30, 0x01,
  0xC0, 0x30, 0x01, 0x80, 0x70, 0x01, 0x80, 0x70, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x03, 0x80, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06,
  0x01, 0xC0, 0x06, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C,
  0x03, 0x00, 0x1C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00, 0x18,
  0x07, 0x00, 0x38, 0x06, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xC6, 0x3C, 0x78, 0x61, 0xE7,
  0x06, 0x0E, 0x70, 0x60, 0xE7, 0x06, 0x0E, 0x70, 0x60, 0xF7, 0x06, 0x00,
  0x70, 0x60, 0x07, 0x06, 0x00, 0x78, 0x60, 0x03, 0xC6, 0x00, 0x1F, 0x60,
  0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x06,
  0x7C, 0x00, 0x61, 0xE0, 0x06, 0x0E, 0x00, 0x60, 0xE0, 0x06, 0x07, 0x00,
  0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0xE7,
  0x06, 0x0E, 0x78, 0x61, 0xE3, 0xF6, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0x01, 0xCF, 0xF0, 0x00, 0xE7, 0xFE, 0x00,
  0x31, 0xC1, 0xC0, 0x1C, 0xE0, 0x70, 0x0E, 0x38, 0x0C, 0x03, 0x0E, 0x03,
  0x01, 0xC3, 0x80, 0xC0, 0xE0, 0xE0, 0x30, 0x30, 0x38, 0x0C, 0x18, 0x0E,
  0x03, 0x0E, 0x03, 0x81, 0xC7, 0x00, 0x70, 0x71, 0x80, 0x1F, 0xF8, 0xE0,
  0x03, 0xFC, 0x70, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE3, 0xF0, 0x00, 0x71, 0xFF, 0x00,
  0x18, 0xF1, 0xE0, 0x0C, 0x30, 0x38, 0x07, 0x1C, 0x06, 0x03, 0x87, 0x01,
  0x80, 0xC1, 0xC0, 0x60, 0x70, 0x70, 0x18, 0x38, 0x1C, 0x06, 0x0C, 0x07,
  0x01, 0x87, 0x01, 0xC0, 0x63, 0x80, 0x30, 0x38, 0xC0, 0x0F, 0x1E, 0x60,
  0x01, 0xFF, 0x38, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xF3, 0xC0, 0x3B, 0xC3, 0x80,
  0x77, 0x03, 0x81, 0xCE, 0x07, 0x83, 0x9C, 0x07, 0x8E, 0x38, 0x07, 0x1C,
  0x70, 0x07, 0x70, 0xE0, 0x07, 0xE1, 0xC0, 0x0F, 0x83, 0x80, 0x0E, 0x07,
  0x00, 0x1E, 0x0E, 0x00, 0x7E, 0x1C, 0x01, 0xFE, 0x3C, 0x07, 0x9C, 0x3E,
  0x3E, 0x1C, 0x3F, 0xF8, 0x3C, 0x3F, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEE, 0xEE, 0xEE, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x03, 0xF0, 0x7C, 0x07,
  0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3E, 0x00, 0x70, 0x00, 0x80, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x03, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x60, 0x38, 0x06,
  0xFC, 0x18, 0x3E, 0xFF, 0x18, 0xFF, 0x3F, 0xDB, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE7, 0x00,
  0x01, 0xC7, 0x80, 0x03, 0xC3, 0x80, 0x03, 0x83, 0xC0, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x18, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xC0, 0x7C, 0x78, 0x03, 0xC7, 0x00,
  0x1E, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0x0F, 0xE1, 0xF0, 0xFE, 0x1F, 0x0F, 0xE0, 0xF0, 0xFE, 0x04, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEF, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80,
  0x1E, 0x3C, 0x03, 0xC3, 0xF9, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x01, 0xF3, 0x80,
  0x1E, 0x1C, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0x40, 0x38, 0x04, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xC0, 0x7C, 0x78, 0x01, 0xCF, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x1C, 0xE0, 0x07, 0x9E, 0x01, 0xE1, 0xF8, 0xFC, 0x1F, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x03,
  0xBC, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x1F, 0xC0, 0xE7, 0xFE, 0x1D, 0xFF, 0xE3,
  0xF0, 0x3E, 0x78, 0x01, 0xCF, 0x00, 0x3D, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0x8E,
  0x00, 0xF1, 0xF8, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3D, 0xFE, 0x03, 0xFF,
  0xF8, 0x7E, 0x0F, 0xC7, 0x80, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x80, 0x1E,
  0x3C, 0x03, 0xC3, 0xF0, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xC0, 0x7C, 0x78, 0x01, 0xC7,
  0x00, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x80, 0x1C, 0x38, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x1F,
  0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0x9F, 0x01, 0xE0,
  0x78, 0x38, 0x03, 0xC7, 0x00, 0x1E, 0x70, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xE7,
  0x00, 0x1E, 0x78, 0x03, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xC0, 0x7C, 0x78, 0x01,
  0xC7, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x7E, 0x3F, 0xFF, 0xC0,
  0xFF, 0xB8, 0x03, 0xE3, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0xFF, 0xFF, 0x7E, 0xF8,
  0x0F, 0x0F, 0xCF, 0xE7, 0xF3, 0xF8, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xF0,
  0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFE,
  0xFE, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x1F, 0xCF, 0x00, 0xFF, 0xBC, 0x07, 0x86, 0xF0, 0x1C,
  0x07, 0xC0, 0xE0, 0x1F, 0x03, 0x80, 0x7C, 0x0E, 0x01, 0xF0, 0x38, 0x07,
  0xC0, 0xE0, 0x1F, 0x03, 0x80, 0x7C, 0x0E, 0x01, 0xF0, 0x38, 0x07, 0xC0,
  0xE0, 0x1F, 0x03, 0x80, 0x7C, 0x0E, 0x01, 0xF0, 0x1C, 0x07, 0xC0, 0x78,
  0x2F, 0x00, 0xFF, 0xBE, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x80, 0x01,
  0xCE, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x60, 0x00, 0xE1, 0xC0, 0x03, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0x70,
  0x07, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x70, 0xFF,
  0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x70, 0x0F, 0x8E, 0x00, 0x79, 0xC0,
  0x07, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x03, 0xC7, 0xFF,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x80, 0x3E, 0x70, 0x01, 0xEE, 0x00,
  0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x01,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00,
  0x77, 0x00, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x1D, 0xE0, 0x07, 0x9E, 0x01, 0xE1, 0xF8, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0x80, 0xFC, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xB8, 0x01,
  0xEE, 0x01, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3E,
  0x07, 0xC7, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00,
  0x1D, 0xE0, 0x07, 0x9E, 0x01, 0xE1, 0xF8, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0x80, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x1E, 0xE0, 0x03, 0x9E, 0x00, 0xF1, 0xF8, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE,
  0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70,
  0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0xE0, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0E, 0x01, 0xC0, 0xE0,
  0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x1E,
  0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFD, 0x80, 0x3F,
  0xDC, 0x03, 0xFD, 0xC0, 0x37, 0xEC, 0x07, 0x7E, 0xE0, 0x67, 0xEE, 0x06,
  0x7E, 0x60, 0xE7, 0xE7, 0x0C, 0x7E, 0x30, 0xC7, 0xE3, 0x1C, 0x7E, 0x39,
  0x87, 0xE1, 0x98, 0x7E, 0x1B, 0x87, 0xE1, 0xF0, 0x7E, 0x0F, 0x07, 0xE0,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xD8, 0x01, 0xF7, 0x00, 0x7F, 0xC0, 0x1F, 0xB0, 0x07, 0xEE, 0x01, 0xF9,
  0x80, 0x7E, 0x70, 0x1F, 0x9C, 0x07, 0xE3, 0x01, 0xF8, 0xE0, 0x7E, 0x38,
  0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x30, 0x7E, 0x0E, 0x1F, 0x83, 0x87,
  0xE0, 0x61, 0xF8, 0x1C, 0x7E, 0x07, 0x1F, 0x80, 0xE7, 0xE0, 0x39, 0xF8,
  0x06, 0x7E, 0x01, 0xDF, 0x80, 0x77, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xF1, 0xE0, 0x3C, 0x70, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0xE7, 0x80, 0x78, 0xF8, 0xFC, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8E, 0x00, 0xFC, 0xE0,
  0x03, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0E,
  0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xC0, 0x78,
  0x78, 0x03, 0xC7, 0x00, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x01, 0xE7, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xF1, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x01, 0xF8, 0xE0, 0x03, 0xCE,
  0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01,
  0xCE, 0x00, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0E, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0,
  0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xEE, 0x00, 0x0F,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xC0, 0x3C, 0x78, 0x01,
  0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xF7, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xE7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xF0, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xBC, 0x00, 0xE7, 0x80, 0x78, 0xF8, 0xFC, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0xC0, 0x0E, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00,
  0x03, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0xC0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x7C, 0x06, 0xE0, 0x6C, 0x06, 0xE0,
  0x6E, 0x0E, 0x60, 0x66, 0x0E, 0x60, 0x66, 0x0E, 0x70, 0x66, 0x0E, 0x70,
  0x66, 0x0E, 0x70, 0x66, 0x0E, 0x70, 0xC6, 0x0C, 0x70, 0xC6, 0x0C, 0x70,
  0xC3, 0x0C, 0x70, 0xC3, 0x1C, 0x30, 0xC3, 0x1C, 0x38, 0xC3, 0x1C, 0x38,
  0xC3, 0x1C, 0x39, 0xC3, 0x1C, 0x39, 0x83, 0x18, 0x39, 0x83, 0x98, 0x39,
  0x81, 0x98, 0x39, 0x81, 0x98, 0x19, 0x81, 0xB8, 0x19, 0x81, 0xB8, 0x1F,
  0x81, 0xB8, 0x1F, 0x01, 0xB8, 0x1F, 0x01, 0xB0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0xF0,
  0x00, 0x38, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x01, 0xC0,
  0x0E, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x81, 0xC0, 0x07, 0x07,
  0x80, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x70, 0x07, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0F, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xE7, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1B, 0x80, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0x70,
  0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x38,
  0x70, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0xFE, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x78, 0x38,
  0x1C, 0x0E, 0x0F, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0,
  0x3C, 0x1C, 0x01, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3C, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01,
  0xF3, 0xE0, 0x77, 0x1F, 0xFE, 0x70, 0xFF, 0xC7, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0xF0, 0x39, 0xFF, 0x0E, 0xFF, 0xF3, 0xF0, 0x3C, 0xF8,
  0x07, 0xBC, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0xEF, 0x80, 0x7B, 0xF8, 0x7C, 0xEF, 0xFE, 0x38, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x03, 0xE3, 0xC0,
  0x3C, 0xF0, 0x03, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0xB8, 0x00,
  0x77, 0x00, 0x0E, 0xF0, 0x03, 0xCF, 0x00, 0xF0, 0xFC, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x01, 0xE0,
  0xE1, 0xFF, 0x1C, 0x7F, 0xFB, 0x9F, 0x03, 0x73, 0x80, 0x3E, 0xF0, 0x03,
  0xDC, 0x00, 0x7B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E,
  0xF0, 0x03, 0xCF, 0x00, 0xF9, 0xF8, 0x77, 0x1F, 0xFC, 0xE0, 0xFF, 0x1C,
  0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x03, 0xC3, 0x80, 0x3C,
  0xE0, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x0E, 0xF0, 0x03, 0xCF, 0x00, 0xF0, 0xF8, 0x7C, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFC,
  0x73, 0xFF, 0xDD, 0xF0, 0x37, 0x70, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0x78, 0x0D, 0xCF, 0xDF, 0x71, 0xFF, 0x9C,
  0x3F, 0xC7, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFE, 0x1F, 0xFF, 0x07, 0xFF,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE1, 0xF0, 0x39, 0xFF, 0x0E,
  0xFF, 0xF3, 0xF0, 0x3C, 0xF8, 0x07, 0xBC, 0x00, 0xEE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x03, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x0E, 0xE0,
  0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x0E,
  0x01, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x80, 0xE0, 0x3C,
  0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00,
  0x78, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFC, 0x03, 0x81, 0xC7, 0x7F, 0x3F, 0xBB, 0xFB, 0xFD, 0xE1, 0xF0, 0xFF,
  0x07, 0x83, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70,
  0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0,
  0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81,
  0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81,
  0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xC0, 0x00, 0xF0,
  0x39, 0xFF, 0x0E, 0xFF, 0xF3, 0xF0, 0x3C, 0xF8, 0x07, 0xBC, 0x00, 0xEE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x03, 0xC3, 0x80, 0x3C, 0xF0, 0x03, 0x9C,
  0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E, 0xF0,
  0x03, 0x8F, 0x00, 0xF0, 0xF8, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xF0, 0x39, 0xFF, 0x0E, 0xFF, 0xF3, 0xF0, 0x3C, 0xF8, 0x07, 0xBC, 0x00,
  0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0xEF, 0x80, 0x7B, 0xB8, 0x7C, 0xEF, 0xFE, 0x38, 0xFF, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x73, 0xFF, 0xDD, 0xF0,
  0x37, 0x70, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x7D, 0xF8, 0x77, 0x3F, 0xF9,
  0xC3, 0xFC, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xF0, 0x39,
  0xFF, 0x0E, 0xFF, 0xF3, 0xF0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xEE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0xE7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03,
  0xFE, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0E, 0xF0, 0x03,
  0x9E, 0x01, 0xE3, 0xE3, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1E, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x70, 0xF0, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xF0, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x06, 0xE0, 0x3C,
  0x0E, 0x60, 0x3C, 0x0E, 0x70, 0x6C, 0x0E, 0x70, 0x6C, 0x0E, 0x70, 0x66,
  0x0C, 0x70, 0x66, 0x0C, 0x70, 0x66, 0x1C, 0x30, 0x66, 0x1C, 0x38, 0xC6,
  0x1C, 0x38, 0xC6, 0x1C, 0x38, 0xC3, 0x18, 0x38, 0xC3, 0x18, 0x38, 0xC3,
  0x18, 0x19, 0xC3, 0x38, 0x19, 0x83, 0x38, 0x1D, 0x83, 0x38, 0x1D, 0x81,
  0xB0, 0x1D, 0x81, 0xB0, 0x1D, 0x81, 0xB0, 0x0F, 0x01, 0xF0, 0x0F, 0x01,
  0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0x78, 0x00, 0x78, 0xE0, 0x03,
  0xC3, 0xC0, 0x0E, 0x07, 0x80, 0x78, 0x0E, 0x03, 0xC0, 0x1C, 0x0E, 0x00,
  0x78, 0x70, 0x00, 0xE3, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0,
  0x00, 0x73, 0x80, 0x03, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0xF0, 0x38, 0x03,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3B, 0x80, 0x01, 0xDE, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x3C, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0x70, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x79, 0xE0, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x77, 0xF0, 0x07, 0xFF, 0xC0, 0x7E, 0x1C, 0x07, 0xE0, 0xE0, 0x7C,
  0x07, 0x07, 0xC0, 0x3C, 0xFC, 0x03, 0xFE, 0xC0, 0x0F, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraLight46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 6, 34, 28, 11, -34 },
  { 27, 13, 14, 28, 7, -34 },
  { 50, 24, 34, 28, 2, -34 },
  { 152, 20, 46, 28, 4, -40 },
  { 267, 26, 34, 28, 1, -34 },
  { 378, 23, 34, 28, 3, -34 },
  { 476, 4, 14, 28, 12, -34 },
  { 483, 13, 45, 28, 9, -39 },
  { 557, 14, 45, 28, 5, -39 },
  { 636, 24, 23, 28, 2, -28 },
  { 705, 21, 21, 28, 3, -26 },
  { 761, 9, 14, 28, 8, -7 },
  { 777, 15, 3, 28, 6, -17 },
  { 783, 7, 7, 28, 10, -7 },
  { 790, 20, 43, 28, 4, -38 },
  { 898, 20, 34, 28, 4, -34 },
  { 983, 21, 34, 28, 4, -34 },
  { 1073, 20, 34, 28, 4, -34 },
  { 1158, 19, 34, 28, 4, -34 },
  { 1239, 19, 34, 28, 4, -34 },
  { 1320, 19, 34, 28, 4, -34 },
  { 1401, 20, 34, 28, 4, -34 },
  { 1486, 20, 34, 28, 4, -34 },
  { 1571, 20, 34, 28, 4, -34 },
  { 1656, 20, 34, 28, 4, -34 },
  { 1741, 7, 26, 28, 10, -26 },
  { 1764, 9, 33, 28, 8, -26 },
  { 1802, 20, 24, 28, 4, -27 },
  { 1862, 19, 13, 28, 4, -22 },
  { 1893, 20, 24, 28, 4, -27 },
  { 1953, 16, 34, 28, 7, -34 },
  { 2021, 22, 42, 28, 3, -34 },
  { 2137, 22, 34, 28, 3, -34 },
  { 2231, 19, 34, 28, 5, -34 },
  { 2312, 19, 34, 28, 5, -34 },
  { 2393, 18, 34, 28, 5, -34 },
  { 2470, 19, 34, 28, 5, -34 },
  { 2551, 19, 34, 28, 5, -34 },
  { 2632, 19, 34, 28, 5, -34 },
  { 2713, 18, 34, 28, 5, -34 },
  { 2790, 17, 34, 28, 5, -34 },
  { 2863, 19, 34, 28, 3, -34 },
  { 2944, 20, 34, 28, 5, -34 },
  { 3029, 19, 34, 28, 5, -34 },
  { 3110, 20, 34, 28, 4, -34 },
  { 3195, 18, 34, 28, 5, -34 },
  { 3272, 18, 34, 28, 5, -34 },
  { 3349, 20, 34, 28, 5, -34 },
  { 3434, 20, 42, 28, 4, -34 },
  { 3539, 20, 34, 28, 5, -34 },
  { 3624, 20, 34, 28, 4, -34 },
  { 3709, 22, 34, 28, 3, -34 },
  { 3803, 18, 34, 28, 5, -34 },
  { 3880, 22, 34, 28, 3, -34 },
  { 3974, 24, 34, 28, 2, -34 },
  { 4076, 23, 34, 28, 2, -34 },
  { 4174, 24, 34, 28, 2, -34 },
  { 4276, 20, 34, 28, 4, -34 },
  { 4361, 11, 43, 28, 10, -38 },
  { 4421, 20, 43, 28, 4, -38 },
  { 4529, 11, 43, 28, 7, -38 },
  { 4589, 19, 18, 28, 4, -34 },
  { 4632, 22, 3, 28, 3, 1 },
  { 4641, 8, 6, 28, 9, -36 },
  { 4647, 20, 26, 28, 3, -26 },
  { 4712, 18, 34, 28, 5, -34 },
  { 4789, 19, 26, 28, 4, -26 },
  { 4851, 19, 34, 28, 4, -34 },
  { 4932, 19, 26, 28, 4, -26 },
  { 4994, 21, 34, 28, 3, -34 },
  { 5084, 18, 34, 28, 5, -26 },
  { 5161, 18, 34, 28, 5, -34 },
  { 5238, 21, 35, 28, 4, -35 },
  { 5330, 17, 43, 28, 4, -35 },
  { 5422, 20, 34, 28, 5, -34 },
  { 5507, 23, 34, 28, 2, -34 },
  { 5605, 21, 26, 28, 3, -26 },
  { 5674, 18, 26, 28, 5, -26 },
  { 5733, 19, 26, 28, 4, -26 },
  { 5795, 18, 34, 28, 5, -26 },
  { 5872, 18, 34, 28, 5, -26 },
  { 5949, 18, 26, 28, 6, -26 },
  { 6008, 20, 26, 28, 4, -26 },
  { 6073, 21, 32, 28, 3, -32 },
  { 6157, 18, 25, 28, 5, -25 },
  { 6214, 21, 25, 28, 3, -25 },
  { 6280, 24, 25, 28, 2, -25 },
  { 6355, 22, 25, 28, 3, -25 },
  { 6424, 21, 33, 28, 3, -25 },
  { 6511, 18, 25, 28, 5, -25 },
  { 6568, 19, 43, 28, 4, -38 },
  { 6671, 3, 43, 28, 12, -38 },
  { 6688, 19, 43, 28, 4, -38 },
  { 6791, 20, 9, 28, 4, -21 },
};

const GFXfont JetBrainsMono_ExtraLight46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_EXTRALIGHT46PT7B_H_
