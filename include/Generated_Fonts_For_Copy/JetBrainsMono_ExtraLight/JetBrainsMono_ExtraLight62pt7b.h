#ifndef _JETBRAINSMONO_EXTRALIGHT62PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x70, 0x07, 0xB8, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70,
  0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFC, 0xE3, 0xF0, 0x3E, 0x1C, 0x1F, 0x0F, 0x83, 0x81, 0xE1, 0xE0, 0x70,
  0x3E, 0x3C, 0x0E, 0x03, 0xCF, 0x01, 0xC0, 0x79, 0xE0, 0x38, 0x0F, 0xBC,
  0x07, 0x00, 0xF7, 0x80, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x1F, 0x03, 0x80,
  0x01, 0xE0, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x7E,
  0x38, 0x00, 0x07, 0xE7, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xDF, 0xE0, 0x00, 0x38, 0xFE, 0x00, 0x07, 0x07, 0xC0, 0x00, 0xE0, 0x7C,
  0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xF8, 0x00, 0x70, 0x0F, 0x00, 0x0E,
  0x01, 0xE0, 0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07, 0xF8, 0x07, 0x00, 0xFF,
  0x00, 0xE0, 0x1F, 0xF0, 0x1C, 0x03, 0xDE, 0x03, 0x80, 0xFB, 0xE0, 0x70,
  0x1E, 0x7E, 0x0E, 0x07, 0xC7, 0xE1, 0xC1, 0xF0, 0x7F, 0x39, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3C, 0x7F, 0xF8, 0x00, 0x0F, 0x1F, 0xFF, 0x00, 0x01, 0xC3, 0xC0, 0xF0,
  0x00, 0x70, 0xF0, 0x0E, 0x00, 0x1E, 0x1C, 0x01, 0xE0, 0x03, 0x83, 0x80,
  0x3C, 0x00, 0xE0, 0x70, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x0F, 0x01,
  0xC0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x78, 0x1E,
  0x00, 0xE0, 0x0F, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x3C,
  0x3C, 0x00, 0x78, 0x0F, 0x07, 0x00, 0x07, 0xC3, 0xE1, 0xC0, 0x00, 0xFF,
  0xF8, 0x78, 0x00, 0x0F, 0xFE, 0x0E, 0x00, 0x00, 0x7F, 0x83, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E,
  0x0F, 0xF8, 0x00, 0x03, 0x83, 0xFF, 0x80, 0x00, 0xF0, 0xFF, 0xF8, 0x00,
  0x1C, 0x3C, 0x0F, 0x80, 0x07, 0x07, 0x80, 0xF0, 0x01, 0xE1, 0xE0, 0x0E,
  0x00, 0x78, 0x3C, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0xF0,
  0x07, 0x80, 0xF0, 0x1E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xE0, 0x0E, 0x0E,
  0x00, 0x1C, 0x01, 0xC3, 0xC0, 0x03, 0xC0, 0x78, 0x70, 0x00, 0x7C, 0x1F,
  0x1C, 0x00, 0x07, 0xFF, 0xC7, 0x80, 0x00, 0x7F, 0xF1, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x3D, 0xF0, 0x3E, 0x00, 0xF3, 0xC0, 0x3E, 0x01, 0xE7, 0x80,
  0x3C, 0x07, 0x8F, 0x00, 0x7C, 0x1F, 0x1E, 0x00, 0x7C, 0x3C, 0x3C, 0x00,
  0x78, 0xF8, 0x78, 0x00, 0x79, 0xE0, 0xF0, 0x00, 0xFF, 0x81, 0xE0, 0x00,
  0xFF, 0x03, 0xC0, 0x00, 0xFC, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x3F,
  0xE0, 0xF8, 0x00, 0xFB, 0xE0, 0xF8, 0x03, 0xE3, 0xE1, 0xFC, 0x1F, 0x83,
  0xC1, 0xFF, 0xFE, 0x03, 0xC1, 0xFF, 0xF8, 0x07, 0xC0, 0xFF, 0xC0, 0x07,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x73, 0x80, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x10, 0x00, 0xF0, 0x00,
  0x9E, 0x00, 0x78, 0x03, 0xCF, 0xE0, 0x38, 0x0F, 0xE7, 0xFC, 0x1C, 0x1F,
  0xFF, 0xFF, 0x8E, 0x3F, 0xF8, 0x3F, 0xF7, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x04, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xBC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xF0, 0x1F, 0xF0, 0x3F, 0x03,
  0xFE, 0x0F, 0xE0, 0x7F, 0xC1, 0xFC, 0x0F, 0xF8, 0x3F, 0x81, 0xFF, 0x03,
  0xE0, 0x3F, 0xE0, 0x18, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7F, 0x83, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFB, 0xC0, 0x00, 0x7E, 0x78, 0x00, 0x3F, 0x8F, 0x00, 0x0F, 0xC1, 0xE0,
  0x03, 0xF0, 0x3C, 0x00, 0xFC, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0x80, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x78, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x7C,
  0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F,
  0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x3F,
  0x00, 0x78, 0xFF, 0xF0, 0x3C, 0xFF, 0xFC, 0x1E, 0xFF, 0xFF, 0x0F, 0xF0,
  0x1F, 0xC7, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7D, 0xE0, 0x00,
  0x3C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0xC0, 0x7E, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x60, 0x00,
  0x3C, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x80,
  0xFE, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xE1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xBF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x03, 0xF0, 0x7F,
  0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x3C, 0x00,
  0xFF, 0xCF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xC1, 0x00, 0x03, 0x80, 0x7F,
  0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xFE, 0xFE, 0x00, 0x7F, 0xF9, 0xF8, 0x03, 0xF0, 0x77, 0xE0, 0x0F, 0x80,
  0x7F, 0x80, 0x7C, 0x01, 0xFE, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0x80, 0x0F,
  0xE0, 0x1E, 0x00, 0x3F, 0x80, 0x78, 0x00, 0xFE, 0x01, 0xE0, 0x03, 0xF8,
  0x07, 0x80, 0x0F, 0xE0, 0x1E, 0x00, 0x3F, 0x80, 0x78, 0x00, 0xFE, 0x01,
  0xE0, 0x03, 0xF8, 0x07, 0x80, 0x0F, 0xE0, 0x1E, 0x00, 0x3F, 0x80, 0x78,
  0x00, 0xFE, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0x80, 0x0F, 0xE0, 0x1F, 0x00,
  0x3F, 0x80, 0x3C, 0x01, 0xFE, 0x00, 0xF8, 0x0D, 0xF8, 0x01, 0xFF, 0xF7,
  0xE0, 0x03, 0xFF, 0x9F, 0x80, 0x07, 0xFC, 0x7F, 0x00, 0x03, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x1F,
  0xF0, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x00,
  0x03, 0xE3, 0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x83, 0xC0, 0x0F, 0xF8, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x7E, 0xF0, 0x00,
  0x7F, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x0F, 0xC7, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xF0, 0x00,
  0x3E, 0x3C, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1E, 0x01, 0xFF,
  0x0F, 0x00, 0x0F, 0xC7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x7D, 0xE0, 0x00,
  0x3E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xC0,
  0x00, 0xF9, 0xE0, 0x00, 0xFC, 0xF0, 0x01, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x78,
  0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x0F, 0xC0,
  0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x3F, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xB8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0x7F, 0xF0, 0x00, 0xEF, 0xEE, 0x00, 0x3D, 0xFD, 0xC0, 0x07, 0x7F,
  0xBC, 0x00, 0xEF, 0xF3, 0x80, 0x3D, 0xFE, 0x70, 0x07, 0x3F, 0xCF, 0x00,
  0xE7, 0xF8, 0xE0, 0x38, 0xFF, 0x1C, 0x07, 0x1F, 0xE3, 0xC1, 0xE3, 0xFC,
  0x38, 0x38, 0x7F, 0x87, 0x87, 0x0F, 0xF0, 0x71, 0xE1, 0xFE, 0x0E, 0x38,
  0x3F, 0xC1, 0xE7, 0x07, 0xF8, 0x1C, 0xE0, 0xFF, 0x03, 0xB8, 0x1F, 0xE0,
  0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xDC, 0x00, 0x1F, 0xEF, 0x00, 0x0F, 0xF3, 0x80, 0x07,
  0xF9, 0xE0, 0x03, 0xFC, 0xF0, 0x01, 0xFE, 0x38, 0x00, 0xFF, 0x1E, 0x00,
  0x7F, 0x8F, 0x00, 0x3F, 0xC3, 0x80, 0x1F, 0xE1, 0xE0, 0x0F, 0xF0, 0x70,
  0x07, 0xF8, 0x3C, 0x03, 0xFC, 0x1E, 0x01, 0xFE, 0x07, 0x00, 0xFF, 0x03,
  0xC0, 0x7F, 0x81, 0xE0, 0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0,
  0x0E, 0x07, 0xF8, 0x07, 0x83, 0xFC, 0x03, 0xC1, 0xFE, 0x00, 0xE0, 0xFF,
  0x00, 0x78, 0x7F, 0x80, 0x3C, 0x3F, 0xC0, 0x0F, 0x1F, 0xE0, 0x07, 0x8F,
  0xF0, 0x01, 0xC7, 0xF8, 0x00, 0xF3, 0xFC, 0x00, 0x79, 0xFE, 0x00, 0x1E,
  0xFF, 0x00, 0x0F, 0x7F, 0x80, 0x03, 0xBF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xE1, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1F, 0xF0, 0xF0, 0x00,
  0x1F, 0x8F, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F,
  0x80, 0xFE, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x3C,
  0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xDF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x78, 0x01, 0xFF, 0x8F, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1F,
  0x3C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xCF,
  0x00, 0x03, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x7C,
  0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF0, 0x7F, 0x01,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB,
  0xC0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x0F, 0xE0, 0x7E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x01,
  0xEE, 0x00, 0x7E, 0x00, 0xF7, 0x80, 0x3F, 0x00, 0x7B, 0xC0, 0x1B, 0x80,
  0x39, 0xE0, 0x0D, 0xC0, 0x1C, 0xF0, 0x0E, 0xE0, 0x1E, 0x78, 0x07, 0x70,
  0x0F, 0x3C, 0x03, 0x98, 0x07, 0x9E, 0x01, 0xCE, 0x03, 0xC7, 0x00, 0xE7,
  0x01, 0xE3, 0x80, 0x63, 0x80, 0xF1, 0xE0, 0x31, 0xC0, 0x70, 0xF0, 0x38,
  0xE0, 0x38, 0x78, 0x1C, 0x70, 0x1C, 0x3C, 0x0E, 0x38, 0x1E, 0x1E, 0x07,
  0x0C, 0x0F, 0x0F, 0x03, 0x87, 0x07, 0x87, 0x81, 0xC3, 0x83, 0xC1, 0xC0,
  0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x78, 0x70, 0x70, 0x70, 0x3C,
  0x38, 0x38, 0x38, 0x1E, 0x1C, 0x1C, 0x1C, 0x0F, 0x0E, 0x06, 0x1E, 0x07,
  0x87, 0x03, 0x8F, 0x03, 0xC3, 0x01, 0xC7, 0x80, 0xE1, 0x80, 0xE3, 0xC0,
  0x71, 0xC0, 0x71, 0xC0, 0x3C, 0xE0, 0x38, 0xE0, 0x1E, 0x70, 0x1C, 0x70,
  0x0F, 0x38, 0x06, 0x38, 0x07, 0x9C, 0x03, 0x1C, 0x03, 0xCC, 0x01, 0xDE,
  0x01, 0xE6, 0x00, 0xEF, 0x00, 0x77, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x3B,
  0xC0, 0x1D, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03,
  0x70, 0x03, 0xF0, 0x01, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0xF1, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xC0, 0x7F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF0, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFD, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xF7, 0xC0, 0x01, 0xBC, 0xFC, 0x01, 0xEF, 0x3F, 0xFF, 0xF3, 0xC3, 0xFF,
  0xF8, 0xF0, 0x7F, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x1E, 0x0F, 0xFC, 0x0F, 0x1F, 0xFF,
  0x87, 0x9F, 0xFF, 0xE3, 0xDE, 0x03, 0xF9, 0xEE, 0x00, 0x7C, 0xFC, 0x00,
  0x1F, 0x7E, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3D, 0xFC, 0x00,
  0x3E, 0xF7, 0x00, 0x3E, 0x7B, 0xC0, 0x7F, 0x3C, 0xFF, 0xFF, 0x1E, 0x3F,
  0xFF, 0x0F, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE1,
  0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x81, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x01, 0xE0,
  0x7F, 0xF0, 0xF0, 0xFF, 0xFC, 0x78, 0xFF, 0xFF, 0x3C, 0xFE, 0x03, 0xDE,
  0x7C, 0x00, 0x6F, 0x7C, 0x00, 0x1F, 0xBC, 0x00, 0x0F, 0xDE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x7D,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x37, 0x9F, 0xC0, 0x7B,
  0xC7, 0xFF, 0xF9, 0xE1, 0xFF, 0xF8, 0xF0, 0x3F, 0xF0, 0x78, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x81, 0xF8, 0x07, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC3, 0xC3, 0xFF, 0xF1, 0xE3,
  0xFF, 0xFC, 0xF3, 0xF8, 0x0F, 0x79, 0xF0, 0x01, 0xBD, 0xF0, 0x00, 0x7E,
  0xF0, 0x00, 0x3F, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xE7, 0xC0, 0x06, 0xF1, 0xF8, 0x0F, 0x78, 0xFF, 0xFF, 0x3C,
  0x3F, 0xFF, 0x1E, 0x07, 0xFF, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x07, 0xC0,
  0x1E, 0x0F, 0xFC, 0x0F, 0x1F, 0xFF, 0x87, 0x9F, 0xFF, 0xE3, 0xDE, 0x03,
  0xF9, 0xEC, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0x78, 0x00,
  0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7C,
  0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F,
  0x1E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x7E, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xC0, 0x0E,
  0x0E, 0x7F, 0x87, 0xF8, 0xEF, 0xFC, 0xFF, 0xCE, 0xFF, 0xCF, 0xFC, 0xE8,
  0x3F, 0x83, 0xEF, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x01, 0xEF, 0x00, 0xE0,
  0x0F, 0xE0, 0x0E, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xFE,
  0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x0E,
  0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xFE, 0x00, 0xE0, 0x0F,
  0xE0, 0x0E, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xFE, 0x00,
  0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0x00,
  0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0,
  0x0E, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xFE, 0x00, 0xE0,
  0x0F, 0xE0, 0x0E, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x78, 0x3F, 0xF0, 0x3C, 0x7F, 0xFE, 0x1E, 0x7F, 0xFF,
  0x8F, 0x78, 0x0F, 0xE7, 0xB0, 0x01, 0xF3, 0xD8, 0x00, 0x7D, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x3F,
  0xF0, 0x3C, 0x7F, 0xFE, 0x1E, 0x7F, 0xFF, 0x8F, 0x78, 0x0F, 0xE7, 0xB8,
  0x01, 0xF3, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xF7, 0xF0, 0x00, 0xFB, 0xDC, 0x00, 0xF9, 0xEF, 0x01, 0xFC, 0xF3,
  0xFF, 0xFC, 0x78, 0xFF, 0xFC, 0x3C, 0x1F, 0xF8, 0x1E, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0xC3, 0xC3, 0xFF, 0xF1, 0xE3, 0xFF, 0xFC, 0xF3, 0xF8, 0x0F, 0x79, 0xF0,
  0x01, 0xBD, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0xDE, 0x3F, 0x01, 0xEF, 0x1F,
  0xFF, 0xE7, 0x87, 0xFF, 0xE3, 0xC0, 0xFF, 0xC1, 0xE0, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x7C, 0x3F,
  0xF0, 0x3E, 0x7F, 0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xF8, 0x07, 0xE7, 0xF0,
  0x01, 0xFB, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0x00,
  0x7F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xF8,
  0x01, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3E,
  0x00, 0xFF, 0x00, 0x6C, 0x01, 0xEE, 0x00, 0xDC, 0x03, 0xDE, 0x03, 0xB8,
  0x07, 0x3C, 0x07, 0x70, 0x0E, 0x78, 0x0E, 0x60, 0x3C, 0xF0, 0x1C, 0xC0,
  0x79, 0xE0, 0x31, 0xC0, 0xF1, 0xC0, 0x63, 0x81, 0xE3, 0x81, 0xC7, 0x03,
  0x87, 0x83, 0x8E, 0x07, 0x0F, 0x07, 0x0C, 0x0E, 0x1E, 0x0E, 0x18, 0x3C,
  0x3C, 0x18, 0x38, 0x78, 0x38, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0xE1, 0xC0,
  0xF1, 0xC1, 0xC3, 0x81, 0xE3, 0x81, 0x87, 0x03, 0xC6, 0x03, 0x9E, 0x07,
  0x8C, 0x07, 0x3C, 0x07, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x1C, 0xE0, 0x1E,
  0xE0, 0x39, 0xC0, 0x3D, 0xC0, 0x33, 0x80, 0x7B, 0x00, 0x7F, 0x00, 0xF6,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xC0,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE7, 0xFC, 0x00,
  0x1D, 0xFF, 0xE0, 0x03, 0xBF, 0xFE, 0x00, 0x7F, 0x83, 0xE0, 0x0F, 0xE0,
  0x3C, 0x01, 0xFC, 0x03, 0xC0, 0x7F, 0x80, 0x7C, 0x0F, 0xF0, 0x07, 0xE3,
  0xFE, 0x00, 0x7F, 0xFB, 0xC0, 0x07, 0xFE, 0x78, 0x00, 0x3F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraLight62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 8, 45, 37, 15, -45 },
  { 46, 17, 18, 37, 10, -45 },
  { 85, 33, 45, 37, 2, -45 },
  { 271, 27, 63, 37, 5, -54 },
  { 484, 35, 46, 37, 1, -46 },
  { 686, 31, 47, 37, 4, -46 },
  { 869, 5, 18, 37, 16, -45 },
  { 881, 18, 59, 37, 12, -52 },
  { 1014, 18, 59, 37, 7, -52 },
  { 1147, 33, 32, 37, 2, -38 },
  { 1279, 29, 29, 37, 4, -35 },
  { 1385, 12, 19, 37, 11, -9 },
  { 1414, 20, 3, 37, 9, -22 },
  { 1422, 9, 10, 37, 14, -9 },
  { 1434, 27, 58, 37, 5, -51 },
  { 1630, 27, 47, 37, 5, -46 },
  { 1789, 27, 45, 37, 6, -45 },
  { 1941, 28, 46, 37, 5, -46 },
  { 2102, 26, 46, 37, 5, -45 },
  { 2252, 24, 45, 37, 6, -45 },
  { 2387, 25, 46, 37, 6, -45 },
  { 2531, 27, 46, 37, 5, -45 },
  { 2687, 28, 45, 37, 5, -45 },
  { 2845, 27, 47, 37, 5, -46 },
  { 3004, 27, 46, 37, 5, -46 },
  { 3160, 9, 36, 37, 14, -35 },
  { 3201, 13, 45, 37, 11, -35 },
  { 3275, 27, 31, 37, 5, -36 },
  { 3380, 26, 19, 37, 6, -30 },
  { 3442, 27, 31, 37, 5, -36 },
  { 3547, 21, 45, 37, 10, -45 },
  { 3666, 30, 57, 37, 4, -46 },
  { 3880, 29, 45, 37, 4, -45 },
  { 4044, 26, 45, 37, 6, -45 },
  { 4191, 26, 47, 37, 6, -46 },
  { 4344, 25, 45, 37, 6, -45 },
  { 4485, 25, 45, 37, 7, -45 },
  { 4626, 26, 45, 37, 7, -45 },
  { 4773, 26, 47, 37, 6, -46 },
  { 4926, 25, 45, 37, 6, -45 },
  { 5067, 23, 45, 37, 7, -45 },
  { 5197, 26, 46, 37, 4, -45 },
  { 5347, 28, 45, 37, 6, -45 },
  { 5505, 26, 45, 37, 7, -45 },
  { 5652, 27, 45, 37, 5, -45 },
  { 5804, 25, 45, 37, 6, -45 },
  { 5945, 25, 47, 37, 6, -46 },
  { 6092, 28, 45, 37, 6, -45 },
  { 6250, 26, 57, 37, 6, -46 },
  { 6436, 27, 45, 37, 6, -45 },
  { 6588, 27, 47, 37, 5, -46 },
  { 6747, 30, 45, 37, 4, -45 },
  { 6916, 25, 46, 37, 6, -45 },
  { 7060, 29, 45, 37, 4, -45 },
  { 7224, 33, 45, 37, 2, -45 },
  { 7410, 31, 45, 37, 3, -45 },
  { 7585, 31, 45, 37, 3, -45 },
  { 7760, 26, 45, 37, 6, -45 },
  { 7907, 15, 58, 37, 13, -51 },
  { 8016, 27, 58, 37, 5, -51 },
  { 8212, 15, 58, 37, 9, -51 },
  { 8321, 26, 24, 37, 6, -45 },
  { 8399, 29, 3, 37, 4, 2 },
  { 8410, 11, 9, 37, 12, -49 },
  { 8423, 26, 36, 37, 5, -35 },
  { 8540, 25, 46, 37, 6, -45 },
  { 8684, 25, 36, 37, 6, -35 },
  { 8797, 25, 46, 37, 6, -45 },
  { 8941, 25, 36, 37, 6, -35 },
  { 9054, 29, 45, 37, 4, -45 },
  { 9218, 25, 46, 37, 6, -35 },
  { 9362, 25, 45, 37, 6, -45 },
  { 9503, 28, 48, 37, 6, -48 },
  { 9671, 22, 59, 37, 6, -48 },
  { 9834, 27, 45, 37, 7, -45 },
  { 9986, 31, 45, 37, 3, -45 },
  { 10161, 28, 35, 37, 5, -35 },
  { 10284, 25, 35, 37, 6, -35 },
  { 10394, 25, 36, 37, 6, -35 },
  { 10507, 25, 46, 37, 6, -35 },
  { 10651, 25, 46, 37, 6, -35 },
  { 10795, 25, 35, 37, 7, -35 },
  { 10905, 26, 36, 37, 6, -35 },
  { 11022, 28, 44, 37, 4, -44 },
  { 11176, 25, 35, 37, 6, -34 },
  { 11286, 29, 34, 37, 4, -34 },
  { 11410, 31, 34, 37, 3, -34 },
  { 11542, 29, 34, 37, 4, -34 },
  { 11666, 29, 45, 37, 4, -34 },
  { 11830, 25, 34, 37, 6, -34 },
  { 11937, 25, 58, 37, 6, -51 },
  { 12119, 4, 58, 37, 17, -51 },
  { 12148, 25, 58, 37, 6, -51 },
  { 12330, 27, 12, 37, 5, -28 },
};

const GFXfont JetBrainsMono_ExtraLight62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_EXTRALIGHT62PT7B_H_
