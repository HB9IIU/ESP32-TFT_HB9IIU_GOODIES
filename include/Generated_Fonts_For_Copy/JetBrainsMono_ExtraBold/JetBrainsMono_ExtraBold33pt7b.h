#ifndef _JETBRAINSMONO_EXTRABOLD33PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0xDE, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x07, 0x87,
  0x01, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0x87, 0x80, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xC1, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE3, 0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x78, 0x0E, 0x1E, 0x03,
  0x87, 0x81, 0xE1, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE, 0xFD, 0xBF,
  0xF9, 0x9F, 0xF9, 0x80, 0xF9, 0x80, 0xFD, 0x80, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xBF, 0x01, 0x9F,
  0xF9, 0x9F, 0xF9, 0x9F, 0xFD, 0xBF, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x1F, 0x80, 0x79, 0xFE, 0x03, 0x8F, 0xF8, 0x38, 0xF1, 0xC3, 0xC7, 0x8E,
  0x1C, 0x3C, 0x71, 0xC1, 0xE3, 0x9E, 0x0F, 0x1D, 0xE0, 0x3F, 0xEE, 0x00,
  0xFE, 0xE0, 0x03, 0xCF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x73,
  0xE0, 0x07, 0xBF, 0x80, 0x3B, 0xFE, 0x03, 0x9C, 0x70, 0x3C, 0xE3, 0x83,
  0xC7, 0x1C, 0x1C, 0x38, 0xE1, 0xC1, 0xC7, 0x1E, 0x0F, 0xF8, 0xE0, 0x3F,
  0x9E, 0x00, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0xF9, 0xEF, 0x9F,
  0xFB, 0xE7, 0xFC, 0xF8, 0xFF, 0x3E, 0x1F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xEF, 0x7B, 0xC0, 0x00, 0x20, 0x1C, 0x0F, 0x83, 0xF1, 0xFE, 0x3F,
  0x8F, 0xC3, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x78, 0x03,
  0x80, 0x1C, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC3, 0xF1,
  0xFC, 0x7F, 0x8F, 0xE1, 0xF0, 0x3C, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x61, 0xE1, 0x9E, 0x71, 0xEF, 0xCD, 0xFB,
  0xFF, 0xFF, 0x3F, 0xFF, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x1D, 0xE0, 0x0F,
  0x3C, 0x07, 0xCF, 0x83, 0xE3, 0xF0, 0x78, 0x78, 0x0C, 0x08, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFB, 0xDF, 0xFB, 0xDF, 0xFB, 0xDF, 0xFB, 0xDF, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F,
  0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x1E, 0x7C, 0x38, 0xF8, 0x61, 0xF0, 0x83, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFC, 0x7E,
  0xF8, 0x3F, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0xFB, 0xE1,
  0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0xE0, 0x7B, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xBC, 0x0F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xFF, 0xF3, 0xF0, 0xFD, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC,
  0x07, 0xDF, 0x03, 0xEF, 0xC3, 0xF3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7D, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7E,
  0x7E, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xE1, 0xFB, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0x78, 0x0F,
  0xBE, 0x07, 0xDF, 0x87, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFE, 0xF8, 0x0C,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0xFB, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F,
  0x3F, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF0, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0x80,
  0xFC, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x3E, 0x00,
  0x3C, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x7F, 0x00,
  0xF0, 0x01, 0x80, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3,
  0xFE, 0x1F, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xF8, 0x3E, 0x78, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFB, 0xFC, 0x7F, 0x7F, 0x1F, 0xFF, 0xCF, 0x8F, 0xF3, 0xC3,
  0xFC, 0xF0, 0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0xF0, 0xFF,
  0x3E, 0x3F, 0xC7, 0xFF, 0xF1, 0xFD, 0xFC, 0x3E, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07,
  0xCF, 0x01, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F, 0x87, 0x83, 0xE1,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8, 0x1F, 0xFC,
  0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF1, 0xF8, 0xF8, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1F, 0x9F, 0x07, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xBF, 0xB9, 0xDF, 0xDC, 0xFF,
  0xEE, 0x7F, 0xF7, 0x77, 0xFD, 0xFB, 0xFE, 0xFD, 0xFF, 0x7E, 0xFF, 0xBE,
  0x7F, 0xCF, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xF7, 0x1F, 0xF7, 0x9F, 0xF7, 0x9F, 0xF3, 0x9F, 0xF3, 0xDF,
  0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x87, 0xF7, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF,
  0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0xFC,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0xCF, 0x83, 0xE7,
  0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3F, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x78, 0x78,
  0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0xF0, 0xF1, 0xFF, 0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0x78,
  0xF7, 0x8F, 0x1E, 0xF3, 0xE3, 0xDE, 0x7E, 0x7B, 0xCF, 0xCF, 0x79, 0xB9,
  0xEF, 0x37, 0x3D, 0xE6, 0x67, 0x3C, 0xCC, 0xE3, 0x99, 0xBC, 0x73, 0x37,
  0x8E, 0xE6, 0xF1, 0xFC, 0xDE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7F,
  0x1F, 0x8F, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C,
  0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x3E, 0x07,
  0xCF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xFC, 0x7E, 0x1F, 0x1F,
  0x07, 0xEF, 0xC0, 0xFB, 0xE0, 0x3F, 0xFC, 0x03, 0xEF, 0x80, 0xFC, 0xF8,
  0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9E, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x7C,
  0x3C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3F, 0x80, 0x1F,
  0x00, 0x1F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xDF, 0x3F, 0x9F,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9, 0xF8,
  0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x1F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F,
  0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x7E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x1F, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xFE, 0x7F, 0x7F, 0xFF, 0x7F, 0xDF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7F,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xF0,
  0x3E, 0xF8, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0x1F, 0x1F, 0x8F, 0x8F, 0x87,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F,
  0x1F, 0x0F, 0xCF, 0x83, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xF7, 0xDF, 0x7B, 0xEF, 0xFF, 0xFF, 0xFF,
  0x3C, 0xFF, 0x9E, 0x7F, 0xCF, 0x3F, 0xE7, 0x9F, 0xF3, 0xCF, 0xF9, 0xE7,
  0xFC, 0xF3, 0xFE, 0x79, 0xFF, 0x3C, 0xFF, 0x9E, 0x7F, 0xCF, 0x3F, 0xE7,
  0x9F, 0xF3, 0xCF, 0xF9, 0xE7, 0xFC, 0xF3, 0xC0, 0xF9, 0xF8, 0xFB, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x0F, 0xF0, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E,
  0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xF9, 0xF8, 0xFB, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9, 0xF8, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x9F, 0x3F, 0xDF,
  0x7F, 0xDF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFF, 0xFF, 0x7F, 0xDF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF3, 0xF8, 0xF7, 0xFC,
  0xF7, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFE, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xFF,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3D, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0xF0, 0xF1, 0xEF, 0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0x78, 0xF7,
  0x9F, 0x1E, 0xF3, 0xE3, 0xDE, 0x7E, 0x7B, 0xCD, 0xCE, 0x39, 0x9B, 0xC7,
  0xB3, 0x78, 0xF6, 0x6F, 0x1F, 0xCD, 0xE3, 0xF9, 0xBC, 0x7F, 0x3F, 0x0F,
  0xC7, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x0F, 0xDF,
  0x87, 0xC3, 0xE3, 0xF0, 0x7C, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xCF, 0x83, 0xF3, 0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0xBF,
  0x03, 0xF0, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x3E, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xCF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x1F, 0xC0, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0xC1, 0xDF, 0xF0, 0xFF, 0xFC, 0x7F, 0x1F, 0x7F, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFE, 0x00, 0x08, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 12, 10, 20, 4, -24 },
  { 34, 18, 24, 20, 1, -24 },
  { 88, 16, 34, 20, 2, -29 },
  { 156, 21, 24, 20, -1, -24 },
  { 219, 18, 24, 20, 1, -24 },
  { 273, 5, 10, 20, 7, -24 },
  { 280, 11, 32, 20, 5, -28 },
  { 324, 11, 32, 20, 4, -28 },
  { 368, 18, 17, 20, 1, -20 },
  { 407, 16, 16, 20, 2, -19 },
  { 439, 8, 10, 20, 5, -5 },
  { 449, 10, 4, 20, 5, -13 },
  { 454, 6, 6, 20, 7, -6 },
  { 459, 16, 31, 20, 2, -27 },
  { 521, 16, 24, 20, 2, -24 },
  { 569, 15, 24, 20, 3, -24 },
  { 614, 16, 24, 20, 2, -24 },
  { 662, 16, 24, 20, 2, -24 },
  { 710, 15, 24, 20, 2, -24 },
  { 755, 16, 24, 20, 2, -24 },
  { 803, 17, 24, 20, 1, -24 },
  { 854, 17, 24, 20, 1, -24 },
  { 905, 16, 24, 20, 2, -24 },
  { 953, 17, 24, 20, 1, -24 },
  { 1004, 6, 18, 20, 7, -18 },
  { 1018, 8, 23, 20, 5, -18 },
  { 1041, 15, 18, 20, 2, -20 },
  { 1075, 14, 13, 20, 3, -17 },
  { 1098, 15, 18, 20, 2, -20 },
  { 1132, 13, 24, 20, 4, -24 },
  { 1171, 18, 30, 20, 1, -24 },
  { 1239, 18, 24, 20, 1, -24 },
  { 1293, 16, 24, 20, 2, -24 },
  { 1341, 16, 24, 20, 2, -24 },
  { 1389, 16, 24, 20, 2, -24 },
  { 1437, 14, 24, 20, 3, -24 },
  { 1479, 16, 24, 20, 2, -24 },
  { 1527, 16, 24, 20, 2, -24 },
  { 1575, 16, 24, 20, 2, -24 },
  { 1623, 14, 24, 20, 3, -24 },
  { 1665, 16, 24, 20, 1, -24 },
  { 1713, 17, 24, 20, 2, -24 },
  { 1764, 15, 24, 20, 3, -24 },
  { 1809, 17, 24, 20, 1, -24 },
  { 1860, 16, 24, 20, 2, -24 },
  { 1908, 16, 24, 20, 2, -24 },
  { 1956, 17, 24, 20, 2, -24 },
  { 2007, 16, 30, 20, 2, -24 },
  { 2067, 17, 24, 20, 2, -24 },
  { 2118, 16, 24, 20, 2, -24 },
  { 2166, 17, 24, 20, 1, -24 },
  { 2217, 16, 24, 20, 2, -24 },
  { 2265, 18, 24, 20, 1, -24 },
  { 2319, 19, 24, 20, 0, -24 },
  { 2376, 18, 24, 20, 1, -24 },
  { 2430, 19, 24, 20, 0, -24 },
  { 2487, 15, 24, 20, 2, -24 },
  { 2532, 10, 31, 20, 6, -27 },
  { 2571, 16, 31, 20, 2, -27 },
  { 2633, 10, 31, 20, 4, -27 },
  { 2672, 16, 13, 20, 2, -24 },
  { 2698, 16, 4, 20, 2, 1 },
  { 2706, 9, 5, 20, 5, -26 },
  { 2712, 16, 18, 20, 2, -18 },
  { 2748, 16, 24, 20, 2, -24 },
  { 2796, 16, 18, 20, 2, -18 },
  { 2832, 16, 24, 20, 2, -24 },
  { 2880, 16, 18, 20, 2, -18 },
  { 2916, 16, 24, 20, 2, -24 },
  { 2964, 16, 24, 20, 2, -18 },
  { 3012, 16, 24, 20, 2, -24 },
  { 3060, 16, 26, 20, 2, -26 },
  { 3112, 13, 32, 20, 3, -26 },
  { 3164, 17, 24, 20, 2, -24 },
  { 3215, 18, 24, 20, 1, -24 },
  { 3269, 17, 18, 20, 1, -18 },
  { 3308, 16, 18, 20, 2, -18 },
  { 3344, 16, 18, 20, 2, -18 },
  { 3380, 16, 24, 20, 2, -18 },
  { 3428, 16, 24, 20, 2, -18 },
  { 3476, 16, 18, 20, 3, -18 },
  { 3512, 16, 18, 20, 2, -18 },
  { 3548, 17, 23, 20, 1, -23 },
  { 3597, 16, 18, 20, 2, -18 },
  { 3633, 18, 18, 20, 1, -18 },
  { 3674, 19, 18, 20, 0, -18 },
  { 3717, 18, 18, 20, 1, -18 },
  { 3758, 18, 24, 20, 1, -18 },
  { 3812, 15, 18, 20, 2, -18 },
  { 3846, 15, 31, 20, 2, -27 },
  { 3905, 5, 31, 20, 7, -27 },
  { 3925, 15, 31, 20, 2, -27 },
  { 3984, 17, 9, 20, 1, -16 },
};

const GFXfont JetBrainsMono_ExtraBold33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_EXTRABOLD33PT7B_H_
