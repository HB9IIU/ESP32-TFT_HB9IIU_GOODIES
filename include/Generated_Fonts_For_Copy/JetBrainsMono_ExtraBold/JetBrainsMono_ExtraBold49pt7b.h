#ifndef _JETBRAINSMONO_EXTRABOLD49PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xFC,
  0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xE0, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xEF, 0xE1, 0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0,
  0xFE, 0xFC, 0x1F, 0xDF, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x07,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07,
  0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF3, 0xFE, 0xEF, 0xF9, 0xFE, 0x73, 0xFC, 0xFE, 0x38, 0xFE, 0x7F, 0x1C,
  0x7F, 0xBF, 0x8E, 0x00, 0x1F, 0xC7, 0x00, 0x0F, 0xF3, 0x80, 0x07, 0xFD,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xEF, 0xFC, 0x00, 0x71, 0xFE, 0x00, 0x38, 0xFF,
  0x00, 0x1C, 0x3F, 0xFF, 0x8E, 0x1F, 0xFF, 0xC7, 0x0F, 0xFF, 0xE3, 0x8F,
  0xF7, 0xFD, 0xCF, 0xFB, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x1F, 0xF8, 0x00, 0xF8, 0x7F, 0xF8, 0x03, 0xF1, 0xFF, 0xF0, 0x07,
  0xC3, 0xE3, 0xF0, 0x1F, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x3E, 0x00,
  0xF0, 0x7C, 0x7C, 0x01, 0xF0, 0xF9, 0xF0, 0x03, 0xFF, 0xF7, 0xC0, 0x03,
  0xFF, 0xCF, 0x80, 0x07, 0xFF, 0x3E, 0x00, 0x03, 0xFC, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x03, 0xEF, 0xFE, 0x00, 0x0F,
  0xBF, 0xFE, 0x00, 0x3E, 0x7F, 0xFC, 0x00, 0x7D, 0xF8, 0xFC, 0x01, 0xF3,
  0xE0, 0xF8, 0x07, 0xC7, 0xC1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x3E, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xFC,
  0x7E, 0x1F, 0x00, 0xFF, 0xF8, 0x7C, 0x01, 0xFF, 0xF1, 0xF0, 0x01, 0xFF,
  0xC7, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x00, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xFF,
  0x3F, 0xBF, 0x9F, 0xCF, 0xEF, 0xE3, 0xFF, 0xF3, 0xF8, 0x7F, 0xFC, 0xFE,
  0x1F, 0xFE, 0x3F, 0x83, 0xFF, 0x8F, 0xE0, 0x7F, 0xC3, 0xF8, 0x1F, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xFD, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF3, 0xF8, 0x1F,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xEF, 0xDF, 0x80, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x07, 0xC0, 0x21,
  0xE0, 0xF8, 0x3C, 0x3F, 0x0F, 0x1F, 0xCF, 0xF1, 0xE7, 0xF9, 0xFF, 0xB9,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3E, 0x03, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x10, 0x04, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x3E, 0x3F, 0xFE, 0x7E, 0x7F, 0xFD, 0xFC, 0xFF, 0xFB,
  0xF9, 0xFF, 0xF3, 0xF3, 0xFF, 0xE7, 0xC7, 0xFF, 0xC2, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xBF, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xC1, 0xFC, 0x07, 0x03,
  0xF8, 0x08, 0x07, 0xF0, 0x10, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xDF, 0xFC, 0xFF, 0x01, 0xFE,
  0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x3F, 0xC1,
  0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE7, 0xFC,
  0x1F, 0xDF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD,
  0xFF, 0x9F, 0xFB, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x9F, 0x80, 0x7F, 0xBF, 0xF0, 0x3F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFC, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xFE,
  0x07, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xEF, 0xFC, 0x7F, 0x83, 0xFC, 0xFF, 0x01, 0xFE, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xFC,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x01,
  0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xEF, 0xE0, 0x1F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0xEF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE7, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xE7, 0xF0, 0x0F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xF1,
  0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F,
  0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x7E, 0x3F,
  0xF8, 0x1F, 0xF7, 0xFF, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0x8F, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0x81, 0xFF,
  0xC3, 0xF0, 0x3F, 0xF8, 0x7E, 0x07, 0xFF, 0x0F, 0xC0, 0xFF, 0xE1, 0xF8,
  0x1F, 0xFC, 0x3F, 0x03, 0xFF, 0x87, 0xE0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFE,
  0x1F, 0x83, 0xFF, 0xC3, 0xF8, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFE,
  0xFF, 0xE0, 0x7F, 0xDF, 0xFC, 0x07, 0xE3, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x07, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0xFE, 0x0F, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE,
  0x03, 0xFE, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x00,
  0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xF3, 0xFC, 0x07, 0xF9,
  0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xDE, 0x07, 0xFF, 0xFF, 0x07,
  0xBF, 0xFF, 0x83, 0xDF, 0xFF, 0xE1, 0xEF, 0xFE, 0xF1, 0xFF, 0xFF, 0x78,
  0xF7, 0xFF, 0xBE, 0x7B, 0xFF, 0xDF, 0x3D, 0xFF, 0xE7, 0xBE, 0xFF, 0xF3,
  0xDE, 0x7F, 0xF9, 0xFF, 0x3F, 0xFC, 0xFF, 0x9F, 0xFE, 0x3F, 0xCF, 0xFF,
  0x9F, 0xC7, 0xFF, 0xCF, 0xE3, 0xFF, 0xE3, 0xF1, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0x83, 0xFF, 0xDF, 0x87, 0xFF, 0xBF, 0x0F,
  0xFF, 0x3E, 0x1F, 0xFE, 0x7E, 0x3F, 0xFC, 0xFC, 0x7F, 0xF8, 0xF8, 0xFF,
  0xF1, 0xF9, 0xFF, 0xE3, 0xF3, 0xFF, 0xC3, 0xE7, 0xFF, 0x87, 0xEF, 0xFF,
  0x0F, 0xDF, 0xFE, 0x0F, 0xBF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0x7F, 0xF0,
  0x3E, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFE, 0x03,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xC3, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x83, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC,
  0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xFC, 0xFF,
  0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xDF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xFB, 0xFE, 0x07, 0xF9, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xEF, 0xF0,
  0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x0F, 0xC1,
  0xFB, 0xF0, 0x7E, 0x0F, 0xDF, 0x83, 0xF0, 0x7E, 0xFC, 0x1F, 0x83, 0xF7,
  0xE1, 0xFC, 0x1F, 0x3F, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x0F, 0xCF, 0xC3,
  0xF8, 0x7E, 0x7E, 0x1D, 0xC3, 0xF3, 0xF0, 0xEF, 0x1F, 0x9F, 0x87, 0x78,
  0xFC, 0x7C, 0x3B, 0xC7, 0xE3, 0xE1, 0xDE, 0x3F, 0x1F, 0x9E, 0xF1, 0xF8,
  0xFC, 0xF3, 0x8F, 0x87, 0xE7, 0x9C, 0x7C, 0x3F, 0x3C, 0xE3, 0xE1, 0xF9,
  0xE7, 0x1F, 0x0F, 0xCE, 0x38, 0xF8, 0x7E, 0x71, 0xEF, 0xC3, 0xF3, 0x8F,
  0x7E, 0x1F, 0x9C, 0x7B, 0xF0, 0x7D, 0xE3, 0xDF, 0x83, 0xEF, 0x1E, 0xFC,
  0x1F, 0x78, 0x77, 0xC0, 0xFB, 0xC3, 0xBE, 0x07, 0xDE, 0x1D, 0xF0, 0x3E,
  0xE0, 0xEF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xEF,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xE7, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0xC0, 0xFE, 0x1F, 0x81,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFE, 0x7F,
  0x01, 0xFC, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xF7, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xC0, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFE, 0x7F, 0x0F, 0xFC,
  0x7F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC3, 0xF9, 0xFF, 0xC7, 0xF7, 0xFF, 0xCF,
  0xEF, 0xFF, 0xDF, 0xDF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFE, 0xFF, 0xFD,
  0xFD, 0xFF, 0xF3, 0xF9, 0xFF, 0xC7, 0xF1, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF1, 0xFC, 0x7F,
  0xF3, 0xF9, 0xFF, 0xF7, 0xF3, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x3F, 0xFE, 0xFE, 0x7F, 0xFD, 0xFC, 0x7F, 0xF3, 0xF8, 0x3F,
  0xC7, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0x9F, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x0F, 0xEF, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0xFE, 0x3F, 0xF9, 0xFC, 0xFF, 0xFB, 0xF9, 0xFF, 0xF7,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0x8F, 0xFE, 0x7F, 0x07, 0xF8,
  0xFE, 0x01, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x3F, 0xC3, 0xFD, 0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xEF, 0xFF, 0xDF, 0xDF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x3F,
  0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xE3,
  0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0xFC, 0xF8, 0x7E,
  0x7E, 0xFE, 0x7F, 0xBF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF8, 0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x3E,
  0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0x87, 0xC3, 0xFF, 0xC3,
  0xE1, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC,
  0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0x87, 0xC3, 0xFF,
  0xC3, 0xE1, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x3F,
  0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xE0, 0xFE, 0x1F,
  0xE1, 0xFC, 0xFF, 0xE3, 0xFB, 0xFF, 0xE7, 0xF7, 0xFF, 0xEF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFE, 0x1F,
  0xE1, 0xFC, 0xFF, 0xE3, 0xFB, 0xFF, 0xE7, 0xF7, 0xFF, 0xEF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0x7F, 0xFE, 0xFE, 0xFF, 0xF9, 0xFC, 0xFF,
  0xE3, 0xFC, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x3F, 0xF9, 0xFC,
  0xFF, 0xFB, 0xF9, 0xFF, 0xF7, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x9F, 0xFF, 0x7F, 0x3F, 0xFE, 0xFE, 0x3F, 0xF9, 0xFC, 0x1F, 0xE3, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x3F, 0xE0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00,
  0x7F, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFC,
  0x0F, 0x81, 0xFB, 0xF0, 0x7E, 0x0F, 0xDF, 0x83, 0xF0, 0x7E, 0xFC, 0x1F,
  0x83, 0xE7, 0xE1, 0xFC, 0x1F, 0x3F, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x0F,
  0xC7, 0xC3, 0xB8, 0x7E, 0x3F, 0x1D, 0xE3, 0xF1, 0xF8, 0xEF, 0x1F, 0x8F,
  0xC7, 0x78, 0xF8, 0x7E, 0x79, 0xC7, 0xC3, 0xF3, 0xCE, 0x7E, 0x1F, 0x9E,
  0x73, 0xF0, 0x7C, 0xF3, 0x9F, 0x83, 0xE7, 0x1E, 0xFC, 0x1F, 0xB8, 0xF7,
  0xE0, 0xFD, 0xC7, 0xBE, 0x07, 0xFE, 0x3D, 0xF0, 0x3F, 0xF0, 0xEF, 0x81,
  0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x9F, 0xE0,
  0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xEF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF1, 0xFC, 0x7F, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0x80,
  0xFF, 0xC0, 0x00, 0x1F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 36, 29, 10, -36 },
  { 42, 19, 15, 29, 5, -36 },
  { 78, 27, 36, 29, 1, -36 },
  { 200, 25, 50, 29, 2, -43 },
  { 357, 31, 36, 29, -1, -36 },
  { 497, 26, 36, 29, 2, -36 },
  { 614, 7, 15, 29, 11, -36 },
  { 628, 16, 47, 29, 8, -41 },
  { 722, 16, 47, 29, 6, -41 },
  { 816, 27, 26, 29, 1, -30 },
  { 904, 24, 24, 29, 3, -28 },
  { 976, 13, 15, 29, 7, -7 },
  { 1001, 16, 7, 29, 7, -20 },
  { 1015, 10, 9, 29, 10, -9 },
  { 1027, 25, 46, 29, 2, -41 },
  { 1171, 23, 36, 29, 3, -36 },
  { 1275, 23, 36, 29, 4, -36 },
  { 1379, 25, 36, 29, 2, -36 },
  { 1492, 23, 36, 29, 3, -36 },
  { 1596, 23, 36, 29, 3, -36 },
  { 1700, 23, 36, 29, 3, -36 },
  { 1804, 25, 36, 29, 2, -36 },
  { 1917, 25, 36, 29, 2, -36 },
  { 2030, 24, 36, 29, 3, -36 },
  { 2138, 25, 36, 29, 2, -36 },
  { 2251, 10, 27, 29, 10, -27 },
  { 2285, 13, 35, 29, 7, -27 },
  { 2342, 23, 28, 29, 3, -30 },
  { 2423, 21, 19, 29, 4, -26 },
  { 2473, 23, 28, 29, 3, -30 },
  { 2554, 20, 36, 29, 5, -36 },
  { 2644, 27, 45, 29, 1, -36 },
  { 2796, 27, 36, 29, 1, -36 },
  { 2918, 24, 36, 29, 3, -36 },
  { 3026, 24, 36, 29, 3, -36 },
  { 3134, 24, 36, 29, 3, -36 },
  { 3242, 22, 36, 29, 4, -36 },
  { 3341, 23, 36, 29, 3, -36 },
  { 3445, 24, 36, 29, 3, -36 },
  { 3553, 23, 36, 29, 3, -36 },
  { 3657, 21, 36, 29, 4, -36 },
  { 3752, 24, 37, 29, 1, -36 },
  { 3863, 25, 36, 29, 3, -36 },
  { 3976, 21, 36, 29, 5, -36 },
  { 4071, 25, 36, 29, 2, -36 },
  { 4184, 23, 36, 29, 3, -36 },
  { 4288, 23, 36, 29, 3, -36 },
  { 4392, 25, 36, 29, 3, -36 },
  { 4505, 24, 45, 29, 3, -36 },
  { 4640, 25, 36, 29, 3, -36 },
  { 4753, 25, 36, 29, 2, -36 },
  { 4866, 25, 36, 29, 2, -36 },
  { 4979, 23, 36, 29, 3, -36 },
  { 5083, 27, 36, 29, 1, -36 },
  { 5205, 29, 36, 29, 0, -36 },
  { 5336, 27, 36, 29, 1, -36 },
  { 5458, 28, 36, 29, 1, -36 },
  { 5584, 22, 36, 29, 4, -36 },
  { 5683, 15, 46, 29, 8, -41 },
  { 5770, 25, 46, 29, 2, -41 },
  { 5914, 15, 46, 29, 6, -41 },
  { 6001, 23, 19, 29, 3, -36 },
  { 6056, 23, 7, 29, 3, 1 },
  { 6077, 14, 6, 29, 7, -38 },
  { 6088, 24, 27, 29, 2, -27 },
  { 6169, 23, 36, 29, 3, -36 },
  { 6273, 24, 27, 29, 3, -27 },
  { 6354, 23, 36, 29, 3, -36 },
  { 6458, 23, 27, 29, 3, -27 },
  { 6536, 25, 36, 29, 2, -36 },
  { 6649, 23, 36, 29, 3, -27 },
  { 6753, 23, 36, 29, 3, -36 },
  { 6857, 24, 39, 29, 3, -39 },
  { 6974, 20, 48, 29, 4, -39 },
  { 7094, 25, 36, 29, 3, -36 },
  { 7207, 27, 36, 29, 1, -36 },
  { 7329, 25, 27, 29, 2, -27 },
  { 7414, 23, 27, 29, 3, -27 },
  { 7492, 23, 27, 29, 3, -27 },
  { 7570, 23, 36, 29, 3, -27 },
  { 7674, 23, 36, 29, 3, -27 },
  { 7778, 24, 27, 29, 4, -27 },
  { 7859, 25, 27, 29, 2, -27 },
  { 7944, 24, 35, 29, 2, -35 },
  { 8049, 23, 27, 29, 3, -27 },
  { 8127, 27, 27, 29, 1, -27 },
  { 8219, 29, 27, 29, 0, -27 },
  { 8317, 27, 27, 29, 1, -27 },
  { 8409, 27, 36, 29, 1, -27 },
  { 8531, 23, 27, 29, 3, -27 },
  { 8609, 22, 46, 29, 4, -41 },
  { 8736, 7, 46, 29, 11, -41 },
  { 8777, 22, 46, 29, 4, -41 },
  { 8904, 25, 13, 29, 2, -24 },
};

const GFXfont JetBrainsMono_ExtraBold49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_EXTRABOLD49PT7B_H_
