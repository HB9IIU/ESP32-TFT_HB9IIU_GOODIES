#ifndef _JETBRAINSMONO_EXTRABOLD53PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold53pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7,
  0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xE3, 0xF0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80,
  0x07, 0xE0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x9F, 0xF3, 0x9F, 0xF3,
  0xFC, 0x71, 0xFE, 0x7F, 0x8E, 0x1F, 0xEF, 0xF1, 0xC3, 0xFD, 0xFE, 0x38,
  0x00, 0x3F, 0xC7, 0x00, 0x07, 0xFC, 0xE0, 0x00, 0xFF, 0xDC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x73, 0xFF, 0x00, 0x0E, 0x3F,
  0xE0, 0x01, 0xC3, 0xFC, 0x00, 0x38, 0x7F, 0xFF, 0x87, 0x0F, 0xF7, 0xF8,
  0xE1, 0xFE, 0xFF, 0x1C, 0x3F, 0xDF, 0xF3, 0x8F, 0xFB, 0xFF, 0xF7, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC3, 0xFF, 0x80, 0x07, 0xE1, 0xFF, 0xF0, 0x01, 0xF0, 0xFF, 0xFC, 0x00,
  0xF8, 0x3F, 0xBF, 0x80, 0x7E, 0x0F, 0x83, 0xE0, 0x3F, 0x03, 0xE0, 0xF8,
  0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x83, 0xF0, 0x0F, 0x83,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x3F, 0x00, 0x3E,
  0x0F, 0x9F, 0x80, 0x0F, 0xFF, 0xE7, 0xC0, 0x01, 0xFF, 0xF3, 0xE0, 0x00,
  0x7F, 0xFD, 0xF8, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x00, 0x38, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0x80, 0x00, 0x7E,
  0x7F, 0xF0, 0x00, 0x1F, 0x3F, 0xFE, 0x00, 0x0F, 0x9F, 0xFF, 0xC0, 0x07,
  0xE7, 0xC3, 0xF0, 0x01, 0xF3, 0xF0, 0x7C, 0x00, 0xF8, 0xFC, 0x1F, 0x00,
  0x7C, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x7C,
  0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x07, 0xE3,
  0xF0, 0x7C, 0x01, 0xFF, 0xF8, 0x3E, 0x00, 0x3F, 0xFE, 0x1F, 0x80, 0x07,
  0xFF, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0xBF,
  0xC7, 0xFB, 0xFD, 0xFE, 0x3F, 0x9F, 0xC7, 0xFB, 0xFC, 0xFE, 0x1F, 0xFF,
  0xC7, 0xF0, 0x7F, 0xFE, 0x3F, 0x83, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0x0F,
  0xE0, 0x3F, 0xF0, 0x7F, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE7, 0xF8,
  0x1F, 0xFC, 0x1F, 0xE0, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x1C, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x40,
  0x3F, 0x00, 0x87, 0xC1, 0xF8, 0x3E, 0x3F, 0x07, 0x87, 0xF1, 0xFE, 0x3C,
  0x7F, 0x9F, 0xF9, 0xEF, 0xFE, 0xFF, 0xE6, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x00, 0xF0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xC0, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0x03, 0xFE, 0xFF,
  0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x1E, 0x3F, 0xFF, 0xCF, 0xCF, 0xFF, 0xF7, 0xF3, 0xFF, 0xFD,
  0xFE, 0xFF, 0xFF, 0x7F, 0xBF, 0xFF, 0xCF, 0xCF, 0xFF, 0xF3, 0xE3, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xC0,
  0x3F, 0x8F, 0xF0, 0x0F, 0xC3, 0xFC, 0x03, 0xE0, 0xFF, 0x00, 0xE0, 0x3F,
  0xC0, 0x30, 0x0F, 0xF0, 0x08, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFF, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x07, 0xFB, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xEF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x86,
  0x00, 0x1F, 0xE7, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xE3, 0xFF, 0x9F, 0xF0, 0x0F,
  0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x3F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x01,
  0xFE, 0x7F, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x3F,
  0xF1, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xF3, 0xFE, 0x03, 0xFE, 0x7F,
  0x80, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xFC,
  0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xDF, 0xE0, 0x0F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0E, 0x1F, 0xEF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x87, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x80, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x0F, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF, 0xE0, 0x7F,
  0xCF, 0xFF, 0x83, 0xFF, 0xBF, 0xFE, 0x0F, 0xFE, 0xFF, 0xF8, 0x7F, 0x9F,
  0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x87, 0xE0, 0x7F, 0xFE, 0x1F, 0x81, 0xFF,
  0xF8, 0x7E, 0x07, 0xFF, 0xE1, 0xF8, 0x1F, 0xFF, 0x87, 0xE0, 0x7F, 0xFE,
  0x1F, 0x81, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0xE1, 0xF8, 0x1F, 0xFF, 0x87,
  0xE0, 0x7F, 0xFE, 0x1F, 0x81, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0xE1, 0xFC,
  0x1F, 0xFF, 0x87, 0xFD, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFB,
  0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0x80, 0x7C, 0x3F, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x07,
  0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0xE7, 0xF8, 0x03, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF7,
  0xF8, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFD,
  0xFF, 0x01, 0xFF, 0x7F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x0F,
  0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9,
  0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFE,
  0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x9F, 0xE0,
  0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7B, 0xFF, 0xDE, 0x07, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF,
  0xDF, 0x0F, 0xFF, 0xFD, 0xF0, 0xF7, 0xFF, 0xEF, 0x1F, 0x7F, 0xFE, 0xF9,
  0xF7, 0xFF, 0xEF, 0x9F, 0x7F, 0xFE, 0xF9, 0xE7, 0xFF, 0xE7, 0xFE, 0x7F,
  0xFE, 0x7F, 0xE7, 0xFF, 0xE7, 0xFE, 0x7F, 0xFE, 0x7F, 0xC7, 0xFF, 0xE3,
  0xFC, 0x7F, 0xFE, 0x3F, 0xCF, 0xFF, 0xE3, 0xFC, 0xFF, 0xFE, 0x1F, 0x8F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFE, 0xFC, 0x1F, 0xFF, 0xBF, 0x07, 0xFF, 0xEF, 0xC1, 0xFF, 0xF9, 0xF8,
  0x7F, 0xFE, 0x7E, 0x1F, 0xFF, 0x9F, 0x87, 0xFF, 0xE3, 0xF1, 0xFF, 0xF8,
  0xFC, 0x7F, 0xFE, 0x3F, 0x1F, 0xFF, 0x87, 0xE7, 0xFF, 0xE1, 0xF9, 0xFF,
  0xF8, 0x7E, 0x7F, 0xFE, 0x0F, 0xDF, 0xFF, 0x83, 0xF7, 0xFF, 0xE0, 0xFD,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFE,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF7, 0xF8, 0x1F, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x5F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F, 0xFE, 0xFF, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xFD, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0,
  0x7F, 0xFC, 0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xE1, 0xFE, 0x1F,
  0xFF, 0x87, 0xF8, 0x7F, 0xFE, 0x1F, 0xE1, 0xFB, 0xF8, 0x7F, 0x87, 0xEF,
  0xE1, 0xFE, 0x1F, 0x9F, 0x87, 0x78, 0x7E, 0x7E, 0x1D, 0xE1, 0xF9, 0xF8,
  0xF3, 0x87, 0xE7, 0xE3, 0xCE, 0x1F, 0x9F, 0x8F, 0x3C, 0x7E, 0x7E, 0x3C,
  0xF1, 0xF9, 0xF8, 0xF3, 0xCF, 0xE7, 0xE3, 0xCF, 0x3F, 0x1F, 0xCF, 0x3C,
  0xFC, 0x7F, 0x3C, 0xF3, 0xF0, 0xFC, 0xE3, 0xCF, 0xC3, 0xF7, 0x8F, 0x3F,
  0x0F, 0xDE, 0x1C, 0xFC, 0x3F, 0x78, 0x7B, 0xF0, 0xFD, 0xE1, 0xEF, 0xC3,
  0xF7, 0x87, 0xBF, 0x0F, 0xDE, 0x1E, 0xFC, 0x3F, 0x78, 0x7B, 0xE0, 0xFD,
  0xE1, 0xEF, 0x83, 0xF7, 0x07, 0xBE, 0x0F, 0xDC, 0x1E, 0xF8, 0x1F, 0xF0,
  0x7B, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF,
  0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF3, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF9, 0xFC, 0x00, 0xFE,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xDF, 0xFF, 0xEF, 0xE7, 0xFF, 0xF7, 0xF1,
  0xFF, 0xF3, 0xF8, 0x7F, 0xE1, 0xFC, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0xF0, 0x0F, 0xF1, 0xFF, 0x83, 0xFC, 0xFF, 0xF0,
  0xFF, 0x7F, 0xFE, 0x3F, 0xDF, 0xFF, 0xCF, 0xF7, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE1, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xF8, 0x07, 0xFB, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xF7, 0xFF, 0xF3, 0xFD, 0xFF, 0xFC, 0xFF, 0x7F, 0xFE, 0x3F, 0xCF, 0xFF,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0xCF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x78, 0x3F, 0xC1, 0xFF, 0x1F, 0xE1, 0xFF,
  0xEF, 0xF1, 0xFF, 0xF3, 0xF9, 0xFF, 0xFD, 0xFD, 0xFF, 0xFE, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xF3, 0xFF, 0xBF, 0xFF, 0xDF, 0xDF, 0xFF,
  0xEF, 0xE7, 0xFF, 0xF7, 0xF1, 0xFF, 0xF3, 0xF8, 0x7F, 0xF1, 0xFC, 0x1F,
  0xF0, 0xFE, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0x3F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0,
  0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x40, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xC3,
  0xFF, 0xDF, 0xE3, 0xFF, 0xEF, 0xF3, 0xFF, 0xFB, 0xFB, 0xFF, 0xFD, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFE, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0xBF, 0x8F,
  0xFF, 0x9F, 0xC3, 0xFF, 0x8F, 0xE0, 0x7F, 0x87, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x81, 0xE0, 0x3F, 0xC7, 0xFE, 0x1F, 0xE7, 0xFF, 0x8F,
  0xF7, 0xFF, 0xE7, 0xFB, 0xFF, 0xFB, 0xFD, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x0F, 0xF9,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0x03,
  0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x0F,
  0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC,
  0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF,
  0xBF, 0xC0, 0x1F, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x18, 0x06, 0x0F, 0xCF, 0xE3, 0xF8, 0xFC, 0xFE, 0x7F,
  0xCF, 0xDF, 0xF7, 0xFE, 0xFD, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x1F, 0x8F, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8,
  0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF,
  0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F,
  0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F,
  0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1,
  0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87,
  0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0x00,
  0x03, 0xC0, 0x7F, 0x8F, 0xFC, 0x3F, 0xCF, 0xFF, 0x1F, 0xEF, 0xFF, 0xCF,
  0xF7, 0xFF, 0xF7, 0xFB, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x7F,
  0x80, 0x7F, 0xBF, 0xE0, 0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC7, 0xFE, 0x0F, 0xF3, 0xFF, 0xC3,
  0xFD, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x87, 0xFE, 0xFF, 0xC0, 0x7F, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xFF, 0xCF, 0xF7, 0xFF, 0xF3, 0xFD, 0xFF, 0xF8, 0xFF, 0x3F, 0xFC,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x10, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xC3, 0xFF, 0xCF, 0xE3, 0xFF, 0xE7,
  0xF3, 0xFF, 0xFB, 0xFB, 0xFF, 0xFD, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFE,
  0xFF, 0xE7, 0xFF, 0x7F, 0xFF, 0xBF, 0x9F, 0xFF, 0xDF, 0xCF, 0xFF, 0xEF,
  0xE3, 0xFF, 0xEF, 0xF0, 0xFF, 0xE7, 0xF8, 0x3F, 0xE3, 0xFC, 0x01, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x3F, 0xC7, 0xFE, 0x0F,
  0xF3, 0xFF, 0xE3, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0xCF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFE, 0x7F, 0x80,
  0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F,
  0xFE, 0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0x87, 0xEF, 0xE1, 0xFE, 0x1F, 0x9F,
  0x87, 0xF8, 0x7E, 0x7E, 0x1F, 0xE1, 0xF9, 0xF8, 0x77, 0x87, 0xE7, 0xE1,
  0xCE, 0x1F, 0x9F, 0x8F, 0x38, 0xFE, 0x7F, 0x3C, 0xF3, 0xF0, 0xFC, 0xF3,
  0xCF, 0xC3, 0xF3, 0xCF, 0x3F, 0x0F, 0xCF, 0x3C, 0xFC, 0x3F, 0x38, 0xF3,
  0xF0, 0xFD, 0xE1, 0xCF, 0xC3, 0xF7, 0x87, 0x7F, 0x0F, 0xDE, 0x1F, 0xF8,
  0x1F, 0x78, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07,
  0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF9, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xF3, 0xFC, 0x00,
  0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xDF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xEF, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFB,
  0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0x3F, 0xFE, 0x07, 0xF7, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xC7, 0xFF,
  0xE1, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFE, 0xFC, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 10, 39, 32, 11, -39 },
  { 50, 20, 16, 32, 6, -39 },
  { 90, 30, 39, 32, 1, -39 },
  { 237, 27, 53, 32, 2, -46 },
  { 416, 34, 39, 32, -1, -39 },
  { 582, 29, 40, 32, 2, -39 },
  { 727, 8, 16, 32, 12, -39 },
  { 743, 18, 51, 32, 8, -45 },
  { 858, 18, 51, 32, 6, -45 },
  { 973, 29, 28, 32, 1, -32 },
  { 1075, 26, 25, 32, 3, -30 },
  { 1157, 14, 16, 32, 7, -8 },
  { 1185, 17, 7, 32, 7, -21 },
  { 1200, 10, 11, 32, 11, -10 },
  { 1214, 26, 50, 32, 3, -44 },
  { 1377, 26, 40, 32, 3, -39 },
  { 1507, 26, 39, 32, 4, -39 },
  { 1634, 26, 39, 32, 3, -39 },
  { 1761, 26, 40, 32, 3, -39 },
  { 1891, 25, 39, 32, 3, -39 },
  { 2013, 26, 40, 32, 3, -39 },
  { 2143, 27, 40, 32, 2, -39 },
  { 2278, 27, 39, 32, 2, -39 },
  { 2410, 26, 40, 32, 3, -39 },
  { 2540, 27, 39, 32, 2, -39 },
  { 2672, 10, 31, 32, 11, -30 },
  { 2711, 13, 38, 32, 8, -30 },
  { 2773, 24, 29, 32, 4, -32 },
  { 2860, 24, 21, 32, 4, -28 },
  { 2923, 24, 29, 32, 4, -32 },
  { 3010, 21, 39, 32, 6, -39 },
  { 3113, 30, 48, 32, 1, -39 },
  { 3293, 29, 39, 32, 1, -39 },
  { 3435, 27, 39, 32, 3, -39 },
  { 3567, 26, 40, 32, 3, -39 },
  { 3697, 26, 39, 32, 3, -39 },
  { 3824, 24, 39, 32, 4, -39 },
  { 3941, 25, 39, 32, 4, -39 },
  { 4063, 26, 40, 32, 3, -39 },
  { 4193, 25, 39, 32, 3, -39 },
  { 4315, 24, 39, 32, 4, -39 },
  { 4432, 27, 40, 32, 1, -39 },
  { 4567, 27, 39, 32, 3, -39 },
  { 4699, 24, 39, 32, 5, -39 },
  { 4816, 28, 39, 32, 2, -39 },
  { 4953, 26, 39, 32, 3, -39 },
  { 5080, 26, 40, 32, 3, -39 },
  { 5210, 27, 39, 32, 3, -39 },
  { 5342, 26, 49, 32, 3, -39 },
  { 5502, 27, 39, 32, 3, -39 },
  { 5634, 27, 40, 32, 2, -39 },
  { 5769, 28, 39, 32, 2, -39 },
  { 5906, 26, 40, 32, 3, -39 },
  { 6036, 29, 39, 32, 1, -39 },
  { 6178, 30, 39, 32, 1, -39 },
  { 6325, 30, 39, 32, 1, -39 },
  { 6472, 30, 39, 32, 1, -39 },
  { 6619, 24, 39, 32, 4, -39 },
  { 6736, 16, 50, 32, 9, -44 },
  { 6836, 26, 50, 32, 3, -44 },
  { 6999, 16, 50, 32, 7, -44 },
  { 7099, 26, 21, 32, 3, -39 },
  { 7168, 26, 8, 32, 3, 1 },
  { 7194, 14, 8, 32, 8, -42 },
  { 7208, 25, 31, 32, 3, -30 },
  { 7305, 26, 40, 32, 3, -39 },
  { 7435, 26, 31, 32, 3, -30 },
  { 7536, 25, 40, 32, 3, -39 },
  { 7661, 26, 31, 32, 3, -30 },
  { 7762, 26, 39, 32, 3, -39 },
  { 7889, 25, 40, 32, 3, -30 },
  { 8014, 25, 39, 32, 3, -39 },
  { 8136, 26, 42, 32, 4, -42 },
  { 8273, 22, 52, 32, 4, -42 },
  { 8416, 27, 39, 32, 4, -39 },
  { 8548, 29, 39, 32, 1, -39 },
  { 8690, 28, 30, 32, 2, -30 },
  { 8795, 25, 30, 32, 3, -30 },
  { 8889, 26, 31, 32, 3, -30 },
  { 8990, 26, 40, 32, 3, -30 },
  { 9120, 25, 40, 32, 3, -30 },
  { 9245, 26, 30, 32, 4, -30 },
  { 9343, 26, 31, 32, 3, -30 },
  { 9444, 26, 37, 32, 2, -37 },
  { 9565, 25, 30, 32, 3, -29 },
  { 9659, 29, 29, 32, 1, -29 },
  { 9765, 30, 29, 32, 1, -29 },
  { 9874, 29, 29, 32, 1, -29 },
  { 9980, 29, 39, 32, 1, -29 },
  { 10122, 24, 29, 32, 4, -29 },
  { 10209, 24, 50, 32, 4, -44 },
  { 10359, 8, 50, 32, 12, -44 },
  { 10409, 24, 50, 32, 4, -44 },
  { 10559, 28, 13, 32, 2, -25 },
};

const GFXfont JetBrainsMono_ExtraBold53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_EXTRABOLD53PT7B_H_
