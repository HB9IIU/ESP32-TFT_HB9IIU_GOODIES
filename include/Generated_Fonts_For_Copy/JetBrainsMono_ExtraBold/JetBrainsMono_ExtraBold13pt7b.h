#ifndef _JETBRAINSMONO_EXTRABOLD13PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xDE, 0xD2, 0x36, 0x36, 0x7F, 0x24, 0x24, 0xFE,
  0xFE, 0x6C, 0x48, 0x20, 0xCF, 0xFB, 0xE3, 0xC7, 0xCB, 0xEF, 0xF7, 0x88,
  0x20, 0x21, 0xF2, 0x96, 0xD4, 0x68, 0x10, 0x3E, 0x2B, 0x4B, 0x8E, 0x18,
  0x3C, 0x66, 0x60, 0x70, 0x72, 0xDE, 0xCC, 0x6E, 0x7F, 0xFC, 0x13, 0x6C,
  0xCC, 0xCC, 0xCE, 0x73, 0x10, 0xC7, 0x0C, 0x71, 0x8C, 0x63, 0x19, 0x9D,
  0xC8, 0x00, 0x18, 0x31, 0xDF, 0xF3, 0x8D, 0xC9, 0x00, 0x30, 0xCF, 0xFF,
  0x30, 0xC0, 0x7F, 0x60, 0xFF, 0xBC, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x18,
  0x61, 0x8C, 0x30, 0x33, 0xEC, 0xF3, 0xFF, 0xFC, 0xF3, 0xFD, 0xE0, 0x73,
  0xCB, 0x0C, 0x30, 0xC3, 0x3F, 0xFC, 0x33, 0xEC, 0xC3, 0x0C, 0x63, 0x18,
  0xFF, 0xF0, 0xFC, 0x63, 0x0E, 0x3C, 0x3C, 0xFF, 0x78, 0x18, 0xC6, 0x38,
  0xCF, 0x3F, 0xC3, 0x0C, 0xFF, 0x0C, 0x3E, 0xCC, 0x30, 0xFF, 0x78, 0x39,
  0xC6, 0x36, 0xFF, 0x3C, 0xFF, 0x78, 0xFF, 0x3C, 0xC6, 0x18, 0xC3, 0x18,
  0x60, 0x33, 0xEC, 0xF3, 0xF9, 0xEC, 0xF3, 0xFD, 0xE0, 0x33, 0xFC, 0xE3,
  0xCF, 0xF1, 0x86, 0x31, 0x80, 0xF0, 0x3C, 0x6C, 0x00, 0xDE, 0xC0, 0x04,
  0x77, 0x30, 0xE0, 0xF0, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x87, 0x83,
  0x3F, 0xCC, 0x00, 0xF8, 0x70, 0xDE, 0x79, 0x80, 0x18, 0x60, 0x18, 0x7E,
  0x42, 0xC3, 0xDF, 0xD3, 0xD3, 0xD3, 0xDF, 0xC0, 0x60, 0x38, 0x38, 0x78,
  0xF1, 0x66, 0x4F, 0xDF, 0xB3, 0xC6, 0xFF, 0x3C, 0xFE, 0xFB, 0x3C, 0xFF,
  0xF8, 0x33, 0xFC, 0xF0, 0xC3, 0x0C, 0x33, 0xFD, 0xE0, 0xFB, 0x3C, 0xF3,
  0xCF, 0x3C, 0xFF, 0xF8, 0xFF, 0x0C, 0x3E, 0xFB, 0x0C, 0x3F, 0xFC, 0xFF,
  0x0C, 0x3F, 0xFF, 0x0C, 0x30, 0xC0, 0x33, 0xFC, 0xF0, 0xC3, 0x7C, 0xF3,
  0xFD, 0xE0, 0xCF, 0x3C, 0xFF, 0xFF, 0x3C, 0xF3, 0xCC, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x3F, 0xFC, 0x1E, 0x0C, 0x18, 0x30, 0x60, 0xF1, 0xBF, 0x7C,
  0xCF, 0x7D, 0xBE, 0xFB, 0x6D, 0xB3, 0xCC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x3F, 0xFC, 0xCF, 0x7F, 0x6D, 0xB6, 0x38, 0xE3, 0x8C, 0xCF, 0xBA, 0xEB,
  0xBF, 0x7D, 0xF7, 0xCC, 0x33, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xFD, 0xE0,
  0xFF, 0x3C, 0xF3, 0xFF, 0xCC, 0x30, 0xC0, 0x33, 0xEC, 0xF3, 0xCF, 0x3C,
  0xF3, 0xFD, 0xE1, 0x83, 0xFF, 0x3C, 0xF3, 0xFB, 0x6D, 0xB3, 0xCC, 0x33,
  0xFC, 0xF0, 0xF1, 0xF0, 0xF3, 0xFD, 0xE0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0xE6, 0xCD, 0x9B,
  0x22, 0xC7, 0x8F, 0x1E, 0x18, 0xDB, 0xDA, 0xDA, 0xDA, 0x5A, 0x6A, 0x6A,
  0x66, 0x66, 0xE6, 0x7C, 0x3C, 0x18, 0x18, 0x3C, 0x3C, 0x66, 0xE7, 0xE7,
  0x66, 0x2C, 0x3C, 0x38, 0x18, 0x18, 0x18, 0x18, 0xFC, 0x71, 0x8C, 0x31,
  0x8E, 0x3F, 0xFC, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xC3, 0x0C, 0x18,
  0x60, 0xC3, 0x0C, 0x18, 0x61, 0x83, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x3F,
  0x31, 0xE5, 0xB3, 0xCC, 0xFF, 0xF0, 0xEC, 0x7B, 0x30, 0xFF, 0xCF, 0x3F,
  0xC0, 0xC3, 0x0F, 0xB7, 0xCF, 0x3C, 0xFF, 0xF8, 0x7B, 0x7C, 0x30, 0xCF,
  0xF7, 0x80, 0x0C, 0x3F, 0xF7, 0xCF, 0x3C, 0xFF, 0x7C, 0x7B, 0x3C, 0xFF,
  0xC3, 0x37, 0x80, 0x3C, 0xC2, 0x3F, 0x20, 0x82, 0x08, 0x20, 0xFF, 0x7C,
  0xF3, 0xCF, 0xF6, 0xC3, 0x78, 0xC3, 0x0F, 0xB7, 0xCF, 0x3C, 0xF3, 0xCC,
  0x30, 0xC0, 0x3C, 0xF0, 0xC3, 0x0C, 0xFF, 0xF0, 0x18, 0xC1, 0xFF, 0x8C,
  0x63, 0x18, 0xCF, 0xE0, 0xC1, 0x83, 0x36, 0xED, 0x9F, 0x36, 0x6E, 0xCE,
  0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0x1E, 0xEE, 0xDB, 0x6D, 0xB6,
  0xDB, 0x40, 0xFB, 0x7C, 0xF3, 0xCF, 0x3C, 0xC0, 0x7B, 0x7C, 0xF3, 0xCF,
  0xF7, 0x80, 0xFB, 0x7C, 0xF3, 0xCF, 0xFF, 0xB0, 0xC0, 0xFF, 0x7C, 0xF3,
  0xCF, 0xF7, 0xC3, 0x0C, 0xFF, 0xBC, 0xF0, 0xC3, 0x0C, 0x00, 0xFB, 0x3C,
  0x1F, 0x0F, 0x3F, 0x80, 0x30, 0x63, 0xFF, 0xF3, 0x06, 0x0C, 0x1F, 0x1E,
  0xCF, 0x3C, 0xF3, 0xCF, 0xF7, 0x80, 0xE6, 0xCD, 0x99, 0x63, 0xC7, 0x86,
  0x00, 0xDB, 0xDA, 0x5A, 0x5A, 0x6A, 0x6E, 0x66, 0xE6, 0x78, 0xF0, 0xC3,
  0xCD, 0xB9, 0x80, 0xE6, 0xCD, 0x99, 0xE3, 0xC3, 0x06, 0x0C, 0x30, 0xFF,
  0xF1, 0x8C, 0x63, 0xFF, 0xC0, 0x1C, 0x73, 0x0C, 0x13, 0xCF, 0x0C, 0x30,
  0xC3, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0x86, 0x18, 0x61, 0xF3, 0xDC, 0x61,
  0x86, 0x38, 0xE6, 0xD9, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 5, 3, 8, 1, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 13, 8, 1, -11 },
  { 25, 8, 10, 8, 0, -10 },
  { 35, 8, 10, 8, 0, -10 },
  { 45, 2, 3, 8, 3, -9 },
  { 46, 4, 13, 8, 2, -11 },
  { 53, 5, 13, 8, 1, -11 },
  { 62, 7, 7, 8, 0, -8 },
  { 69, 6, 6, 8, 1, -7 },
  { 74, 3, 4, 8, 2, -2 },
  { 76, 4, 2, 8, 2, -5 },
  { 77, 2, 3, 8, 3, -3 },
  { 78, 6, 12, 8, 1, -11 },
  { 87, 6, 10, 8, 1, -10 },
  { 95, 6, 9, 8, 1, -9 },
  { 102, 6, 10, 8, 1, -10 },
  { 110, 6, 9, 8, 1, -9 },
  { 117, 6, 9, 8, 1, -9 },
  { 124, 6, 9, 8, 1, -9 },
  { 131, 6, 9, 8, 1, -9 },
  { 138, 6, 9, 8, 1, -9 },
  { 145, 6, 10, 8, 1, -10 },
  { 153, 6, 10, 8, 1, -10 },
  { 161, 2, 7, 8, 3, -7 },
  { 163, 3, 9, 8, 2, -7 },
  { 167, 6, 7, 8, 1, -8 },
  { 173, 6, 5, 8, 1, -7 },
  { 177, 6, 7, 8, 1, -8 },
  { 183, 6, 9, 8, 1, -9 },
  { 190, 8, 12, 8, 0, -10 },
  { 202, 7, 9, 8, 0, -9 },
  { 210, 6, 9, 8, 1, -9 },
  { 217, 6, 10, 8, 1, -10 },
  { 225, 6, 9, 8, 1, -9 },
  { 232, 6, 9, 8, 1, -9 },
  { 239, 6, 9, 8, 1, -9 },
  { 246, 6, 10, 8, 1, -10 },
  { 254, 6, 9, 8, 1, -9 },
  { 261, 6, 9, 8, 1, -9 },
  { 268, 7, 9, 8, 0, -9 },
  { 276, 6, 9, 8, 1, -9 },
  { 283, 6, 9, 8, 1, -9 },
  { 290, 6, 9, 8, 1, -9 },
  { 297, 6, 9, 8, 1, -9 },
  { 304, 6, 10, 8, 1, -10 },
  { 312, 6, 9, 8, 1, -9 },
  { 319, 6, 12, 8, 1, -10 },
  { 328, 6, 9, 8, 1, -9 },
  { 335, 6, 10, 8, 1, -10 },
  { 343, 6, 9, 8, 1, -9 },
  { 350, 6, 9, 8, 1, -9 },
  { 357, 7, 9, 8, 0, -9 },
  { 365, 8, 9, 8, 0, -9 },
  { 374, 8, 9, 8, 0, -9 },
  { 383, 8, 9, 8, 0, -9 },
  { 392, 6, 9, 8, 1, -9 },
  { 399, 4, 12, 8, 2, -11 },
  { 405, 6, 12, 8, 1, -11 },
  { 414, 4, 12, 8, 2, -11 },
  { 420, 6, 5, 8, 1, -9 },
  { 424, 6, 2, 8, 1, 0 },
  { 426, 3, 2, 8, 2, -10 },
  { 427, 6, 7, 8, 1, -7 },
  { 433, 6, 9, 8, 1, -9 },
  { 440, 6, 7, 8, 1, -7 },
  { 446, 6, 9, 8, 1, -9 },
  { 453, 6, 7, 8, 1, -7 },
  { 459, 6, 9, 8, 1, -9 },
  { 466, 6, 9, 8, 1, -7 },
  { 473, 6, 9, 8, 1, -9 },
  { 480, 6, 10, 8, 1, -10 },
  { 488, 5, 12, 8, 1, -10 },
  { 496, 7, 9, 8, 1, -9 },
  { 504, 7, 9, 8, 0, -9 },
  { 512, 6, 7, 8, 1, -7 },
  { 518, 6, 7, 8, 1, -7 },
  { 524, 6, 7, 8, 1, -7 },
  { 530, 6, 9, 8, 1, -7 },
  { 537, 6, 9, 8, 1, -7 },
  { 544, 6, 7, 8, 1, -7 },
  { 550, 6, 7, 8, 1, -7 },
  { 556, 7, 9, 8, 0, -9 },
  { 564, 6, 7, 8, 1, -7 },
  { 570, 7, 7, 8, 0, -7 },
  { 577, 8, 7, 8, 0, -7 },
  { 584, 7, 7, 8, 0, -7 },
  { 591, 7, 9, 8, 0, -7 },
  { 599, 6, 7, 8, 1, -7 },
  { 605, 6, 12, 8, 1, -11 },
  { 614, 2, 12, 8, 3, -11 },
  { 617, 6, 12, 8, 1, -11 },
  { 626, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_ExtraBold13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_EXTRABOLD13PT7B_H_
