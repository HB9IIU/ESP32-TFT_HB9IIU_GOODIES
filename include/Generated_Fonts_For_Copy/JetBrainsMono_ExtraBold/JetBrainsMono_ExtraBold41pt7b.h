#ifndef _JETBRAINSMONO_EXTRABOLD41PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x31, 0xFB,
  0xFF, 0xFF, 0xEF, 0x80, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x3C,
  0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1,
  0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x0F, 0x07, 0xC0,
  0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFE,
  0xDF, 0xEF, 0xE6, 0x3F, 0x7F, 0x31, 0xFB, 0xF9, 0x80, 0x1F, 0xCC, 0x00,
  0x7E, 0x60, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x6F, 0xF0,
  0x03, 0x1F, 0x80, 0x18, 0xFE, 0x00, 0xC7, 0xFF, 0xC6, 0x3F, 0xFF, 0x31,
  0xFB, 0xFD, 0x9F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xC7, 0xFC, 0x01, 0xE3, 0xFF, 0x80, 0xF0, 0xF1, 0xE0, 0x3C, 0x7C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC7, 0xC1, 0xE0, 0xF1, 0xE0, 0x78,
  0x3C, 0xF0, 0x0F, 0x1F, 0x78, 0x03, 0xFF, 0xBE, 0x00, 0x7F, 0xEF, 0x00,
  0x0F, 0xE7, 0x80, 0x00, 0x43, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x30, 0x00, 0x1F, 0x7F, 0x80, 0x07, 0xBF, 0xF0, 0x03,
  0xDF, 0xFE, 0x01, 0xE7, 0x87, 0x80, 0x79, 0xE1, 0xE0, 0x3C, 0x78, 0x78,
  0x1E, 0x1E, 0x1E, 0x0F, 0x87, 0x87, 0x83, 0xC1, 0xE1, 0xE1, 0xE0, 0x7C,
  0xF8, 0xF0, 0x0F, 0xFC, 0x7C, 0x03, 0xFF, 0x3E, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x08, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0x7F, 0xF8, 0xFD,
  0xF9, 0xF9, 0xF3, 0xF1, 0xFF, 0xE7, 0xE3, 0xFF, 0x8F, 0xC3, 0xFF, 0x1F,
  0x83, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xC1, 0xFF,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x00,
  0x1C, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0x0F,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xE0, 0x07, 0xC0, 0x3F,
  0x01, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0xC3, 0xFC,
  0xFF, 0xC7, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0x78, 0x02, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x04, 0x0F, 0x03, 0x1F, 0x1E, 0x1E, 0x3F, 0x1C, 0xFE, 0x7F,
  0xBB, 0xFD, 0xFF, 0xEF, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3D, 0xC0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7,
  0xC0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7C, 0x1F, 0x00, 0x70, 0x18,
  0x00, 0x20, 0x20, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7,
  0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0x7F,
  0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x73, 0xFF, 0xCF, 0xBF, 0xFD, 0xFB, 0xFF, 0xDF,
  0xBF, 0xFC, 0xFB, 0xFF, 0xC7, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0x8F, 0xC0, 0xF0, 0xFC, 0x0E, 0x0F,
  0xC0, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x1C, 0x07, 0xEF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F,
  0x7F, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF3,
  0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0x8F, 0xF7,
  0xF0, 0x3F, 0xBF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7E, 0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0x7F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xE3, 0xF8, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xF8, 0xFE, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x83, 0xFB,
  0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x3F, 0xC7, 0xF9, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7E, 0x0F, 0x83, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x23, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x78, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0xFC, 0xFF, 0xC3, 0xFD, 0xFF, 0x87, 0xFD, 0xFF,
  0x1F, 0x8F, 0xFE, 0x3E, 0x1F, 0xFC, 0x7C, 0x1F, 0xF8, 0xF8, 0x3F, 0xF1,
  0xF0, 0x7F, 0xE3, 0xE0, 0xFF, 0xC7, 0xC1, 0xFF, 0x8F, 0x83, 0xFF, 0x1F,
  0x07, 0xFE, 0x3E, 0x0F, 0xFC, 0x7E, 0x3F, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xBF, 0xE0, 0xFE, 0xFF, 0xC0, 0x70, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F,
  0xDF, 0x00, 0x1F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF8,
  0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x07,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xC1, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xFE, 0x03,
  0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x0F, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F,
  0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFC,
  0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC,
  0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1,
  0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F,
  0x83, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x3F, 0x03, 0xF9, 0xF8, 0x0F,
  0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFB, 0x87, 0xFF, 0xDE, 0x3F, 0xFF, 0xF1, 0xDF, 0xFF,
  0x8E, 0xFF, 0xDC, 0xF7, 0xFE, 0xF7, 0xBF, 0xF7, 0xB9, 0xFF, 0xBF, 0xCF,
  0xFC, 0xFE, 0x7F, 0xE7, 0xF7, 0xFF, 0x3F, 0x3F, 0xF9, 0xF9, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xBC, 0x1F, 0xFB, 0xC1, 0xFF, 0xFE, 0x1F, 0xFD, 0xE1,
  0xFF, 0xDE, 0x1F, 0xFD, 0xF1, 0xFF, 0xDF, 0x1F, 0xFC, 0xF1, 0xFF, 0xCF,
  0x9F, 0xFC, 0xF9, 0xFF, 0xC7, 0x9F, 0xFC, 0x7D, 0xFF, 0xC7, 0xDF, 0xFC,
  0x3D, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xF0, 0xFF, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x7F,
  0x7F, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x87, 0xF9, 0xF8, 0x1F,
  0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xFC,
  0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E,
  0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xE0,
  0x3F, 0x7F, 0x01, 0xFB, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7F, 0x07, 0xF3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC3, 0xFE, 0xFC,
  0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0x87, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7E, 0xFF, 0x07, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0,
  0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x3E, 0x1F, 0x7C, 0x3E,
  0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x7E, 0x1F, 0x7C, 0x7E,
  0x1F, 0x7C, 0x7E, 0x1F, 0x7C, 0x76, 0x1E, 0x7C, 0x77, 0x1E, 0x7C, 0x77,
  0x3E, 0x7C, 0x77, 0x3E, 0x7C, 0x77, 0x3E, 0x3C, 0x77, 0x3E, 0x3C, 0x67,
  0x3E, 0x3E, 0xE7, 0x3E, 0x3E, 0xE7, 0x3E, 0x3E, 0xE7, 0x3E, 0x3E, 0xE3,
  0xBC, 0x3E, 0xE3, 0xBC, 0x3E, 0xE3, 0xBC, 0x3E, 0xE3, 0xBC, 0x3E, 0xE3,
  0xBC, 0x1E, 0xC3, 0xBC, 0x1F, 0xC3, 0xBC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3,
  0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0xC1,
  0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F,
  0x81, 0xF8, 0x7F, 0x03, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87,
  0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F,
  0xDF, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0xFD,
  0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0xC3, 0xF0, 0x7C, 0x3F,
  0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x03, 0xEF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF0, 0x7F,
  0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFB, 0xF3, 0xFF, 0xBF, 0x1F, 0xE3, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE3, 0xE0, 0xFD, 0xFF, 0x1F, 0xBF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFB, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xDF, 0xF9, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFD, 0xFF, 0x7E, 0x07,
  0xF7, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x3F, 0x1F, 0xF3, 0xF3, 0xFF, 0xBF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0x9F, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xBF, 0x1F, 0xFB, 0xF0, 0xFF, 0x3F, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x7F, 0x9F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE3, 0xF1,
  0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF9, 0xFF,
  0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0,
  0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF1, 0xFF, 0xBF, 0x0F,
  0xF3, 0xF0, 0x3C, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0xFD, 0xFF, 0x1F, 0xBF, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFB, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xC0,
  0x00, 0x20, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x04, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x3F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFC, 0x07, 0xF7,
  0xE0, 0x3F, 0x3F, 0x03, 0xF9, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x7E, 0x1F,
  0xC3, 0xF0, 0xFE, 0x1F, 0x8F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0xFE,
  0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x03, 0xF9, 0xF8,
  0x1F, 0xCF, 0xC0, 0x7F, 0x7E, 0x03, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0xF9, 0xC3, 0xC7, 0xDF, 0x3F, 0xBF,
  0xFD, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0x9F, 0xFC, 0x7C, 0x7F, 0xE3, 0xC3,
  0xFF, 0x1E, 0x1F, 0xF8, 0xF0, 0xFF, 0xC7, 0x87, 0xFE, 0x3C, 0x3F, 0xF1,
  0xE1, 0xFF, 0x8F, 0x0F, 0xFC, 0x78, 0x7F, 0xE3, 0xC3, 0xFF, 0x1E, 0x1F,
  0xF8, 0xF0, 0xFF, 0xC7, 0x87, 0xFE, 0x3C, 0x3F, 0xF1, 0xE1, 0xFF, 0x8F,
  0x0F, 0xFC, 0x78, 0x7F, 0xE3, 0xC3, 0xE0, 0xFC, 0x7C, 0x1F, 0xBF, 0xE3,
  0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE7, 0xF9, 0xFE, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0x7F, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00,
  0xFC, 0x7C, 0x1F, 0xBF, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFB, 0xFF, 0x3F, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xBF, 0x7F, 0xFF,
  0xF7, 0xF9, 0xFF, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFB, 0xF1, 0xFF, 0xBF, 0x0F, 0xE3, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xDF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0x03, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xBF, 0xC3, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x0F, 0xE7, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x3C, 0x1F,
  0x78, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F,
  0x7C, 0x7E, 0x1E, 0x7C, 0x76, 0x1E, 0x7C, 0x77, 0x3E, 0x3C, 0x77, 0x3E,
  0x3E, 0x77, 0x3E, 0x3E, 0x77, 0x3E, 0x3E, 0xE7, 0x3E, 0x3E, 0xE7, 0x3C,
  0x3E, 0xE7, 0x3C, 0x3E, 0xE3, 0xFC, 0x1E, 0xE3, 0xFC, 0x1E, 0xE3, 0xFC,
  0x1E, 0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x7E, 0x01, 0xFC, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xFC, 0x7E, 0x01, 0xFD, 0xFC, 0x01,
  0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0xBF, 0x80, 0x7F,
  0x80, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x7F, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFC, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x7F, 0xF7, 0xC0,
  0xFF, 0x00, 0x01, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 30, 25, 9, -30 },
  { 28, 15, 12, 25, 5, -30 },
  { 51, 23, 30, 25, 1, -30 },
  { 138, 21, 42, 25, 2, -36 },
  { 249, 26, 30, 25, -1, -30 },
  { 347, 23, 30, 25, 1, -30 },
  { 434, 6, 12, 25, 9, -30 },
  { 443, 14, 39, 25, 6, -34 },
  { 512, 13, 39, 25, 5, -34 },
  { 576, 23, 22, 25, 1, -25 },
  { 640, 20, 19, 25, 2, -23 },
  { 688, 10, 13, 25, 6, -6 },
  { 705, 13, 5, 25, 6, -16 },
  { 714, 8, 8, 25, 8, -8 },
  { 722, 21, 39, 25, 2, -34 },
  { 825, 20, 30, 25, 2, -30 },
  { 900, 20, 30, 25, 3, -30 },
  { 975, 20, 30, 25, 2, -30 },
  { 1050, 20, 30, 25, 2, -30 },
  { 1125, 20, 30, 25, 2, -30 },
  { 1200, 20, 30, 25, 2, -30 },
  { 1275, 21, 30, 25, 2, -30 },
  { 1354, 21, 30, 25, 2, -30 },
  { 1433, 20, 30, 25, 2, -30 },
  { 1508, 21, 30, 25, 2, -30 },
  { 1587, 8, 23, 25, 8, -23 },
  { 1610, 11, 30, 25, 6, -23 },
  { 1652, 19, 23, 25, 3, -25 },
  { 1707, 18, 16, 25, 3, -22 },
  { 1743, 19, 23, 25, 3, -25 },
  { 1798, 16, 30, 25, 5, -30 },
  { 1858, 23, 37, 25, 1, -30 },
  { 1965, 23, 30, 25, 1, -30 },
  { 2052, 20, 30, 25, 3, -30 },
  { 2127, 20, 30, 25, 2, -30 },
  { 2202, 20, 30, 25, 3, -30 },
  { 2277, 19, 30, 25, 3, -30 },
  { 2349, 19, 30, 25, 3, -30 },
  { 2421, 20, 30, 25, 2, -30 },
  { 2496, 19, 30, 25, 3, -30 },
  { 2568, 18, 30, 25, 3, -30 },
  { 2636, 20, 30, 25, 1, -30 },
  { 2711, 21, 30, 25, 3, -30 },
  { 2790, 18, 30, 25, 4, -30 },
  { 2858, 21, 30, 25, 2, -30 },
  { 2937, 20, 30, 25, 2, -30 },
  { 3012, 20, 30, 25, 2, -30 },
  { 3087, 20, 30, 25, 3, -30 },
  { 3162, 21, 37, 25, 2, -30 },
  { 3260, 20, 30, 25, 3, -30 },
  { 3335, 21, 30, 25, 2, -30 },
  { 3414, 21, 30, 25, 2, -30 },
  { 3493, 20, 30, 25, 2, -30 },
  { 3568, 23, 30, 25, 1, -30 },
  { 3655, 24, 30, 25, 0, -30 },
  { 3745, 23, 30, 25, 1, -30 },
  { 3832, 23, 30, 25, 1, -30 },
  { 3919, 19, 30, 25, 3, -30 },
  { 3991, 12, 39, 25, 7, -34 },
  { 4050, 21, 39, 25, 2, -34 },
  { 4153, 13, 39, 25, 5, -34 },
  { 4217, 20, 16, 25, 2, -30 },
  { 4257, 20, 6, 25, 2, 1 },
  { 4272, 11, 6, 25, 6, -32 },
  { 4281, 20, 23, 25, 2, -23 },
  { 4339, 19, 30, 25, 3, -30 },
  { 4411, 20, 23, 25, 2, -23 },
  { 4469, 20, 30, 25, 2, -30 },
  { 4544, 20, 23, 25, 2, -23 },
  { 4602, 20, 30, 25, 2, -30 },
  { 4677, 20, 30, 25, 2, -23 },
  { 4752, 19, 30, 25, 3, -30 },
  { 4824, 20, 33, 25, 3, -33 },
  { 4907, 17, 40, 25, 3, -33 },
  { 4992, 21, 30, 25, 3, -30 },
  { 5071, 22, 30, 25, 1, -30 },
  { 5154, 21, 23, 25, 2, -23 },
  { 5215, 19, 23, 25, 3, -23 },
  { 5270, 20, 23, 25, 2, -23 },
  { 5328, 19, 30, 25, 3, -23 },
  { 5400, 20, 30, 25, 2, -23 },
  { 5475, 20, 23, 25, 3, -23 },
  { 5533, 21, 23, 25, 2, -23 },
  { 5594, 21, 29, 25, 1, -29 },
  { 5671, 19, 23, 25, 3, -23 },
  { 5726, 23, 23, 25, 1, -23 },
  { 5793, 24, 23, 25, 0, -23 },
  { 5862, 23, 23, 25, 1, -23 },
  { 5929, 23, 30, 25, 1, -23 },
  { 6016, 19, 23, 25, 3, -23 },
  { 6071, 19, 39, 25, 3, -34 },
  { 6164, 6, 39, 25, 9, -34 },
  { 6194, 19, 39, 25, 3, -34 },
  { 6287, 21, 11, 25, 2, -20 },
};

const GFXfont JetBrainsMono_ExtraBold41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_EXTRABOLD41PT7B_H_
