#ifndef _JETBRAINSMONO_EXTRABOLD17PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x03, 0xE0, 0xCF, 0x3C, 0xF3, 0xCC, 0x19, 0x86,
  0x67, 0xFD, 0xFF, 0x33, 0x0C, 0xC3, 0x33, 0xFE, 0xFF, 0x88, 0x86, 0x61,
  0x98, 0x18, 0x18, 0x18, 0x7E, 0xFF, 0xFB, 0xF8, 0xF8, 0x7E, 0x3F, 0x1F,
  0x1B, 0xFB, 0xFF, 0x7E, 0x18, 0x18, 0x20, 0x1E, 0x3C, 0x9B, 0x24, 0xDB,
  0x1F, 0x80, 0xC0, 0x24, 0x1F, 0xCD, 0xB2, 0x6D, 0x9B, 0xC3, 0x80, 0x18,
  0x3F, 0x1F, 0x8C, 0xE6, 0x03, 0x83, 0xC1, 0xB7, 0xDF, 0x67, 0x31, 0x9F,
  0xE7, 0xB8, 0xFF, 0xC0, 0x19, 0xDF, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0xCE,
  0x3C, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0x86, 0x3B,
  0xCE, 0x30, 0x0C, 0x03, 0x06, 0xDB, 0xDF, 0x0C, 0x07, 0x83, 0xB0, 0xCE,
  0x12, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x3B, 0x9C,
  0xE6, 0x70, 0xFF, 0xFF, 0xC0, 0x7F, 0x70, 0x07, 0x07, 0x06, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x18,
  0x7E, 0xFF, 0xE3, 0xC3, 0xC3, 0xDB, 0xDB, 0xC3, 0xC3, 0xE7, 0x7F, 0x3E,
  0x3C, 0x3E, 0x3F, 0x13, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F,
  0xFF, 0xF0, 0x18, 0x7E, 0xFF, 0xE7, 0x03, 0x07, 0x0E, 0x1E, 0x3C, 0x78,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x1C, 0x1F, 0x07, 0x03, 0x03,
  0xE7, 0xFF, 0x7E, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE7, 0xE7, 0xC7, 0xFF,
  0xFF, 0x07, 0x07, 0xFF, 0xFF, 0xE0, 0xE0, 0xFE, 0xFF, 0x07, 0x03, 0x03,
  0xE7, 0xFF, 0x7E, 0x1E, 0x18, 0x38, 0x70, 0x6C, 0xFF, 0xE7, 0xC3, 0xC3,
  0xE7, 0x7F, 0x3E, 0xFF, 0xFF, 0xC3, 0xC7, 0x06, 0x0E, 0x0C, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0x18, 0x7E, 0xFF, 0xE3, 0xE7, 0x77, 0x3C, 0x7E, 0xE7,
  0xC3, 0xE7, 0xFF, 0x7E, 0x18, 0x7E, 0xFF, 0xC3, 0xC3, 0xE3, 0xFF, 0x7F,
  0x06, 0x0E, 0x1C, 0x18, 0x38, 0x2F, 0xF2, 0x00, 0x06, 0xF7, 0x13, 0xDE,
  0x20, 0x00, 0x07, 0x33, 0x9C, 0xCE, 0x00, 0x03, 0x0F, 0x3E, 0xF0, 0xC0,
  0xF8, 0x3E, 0x0F, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x7C, 0x0F, 0x03, 0x1F, 0x7C, 0xF0, 0xC0, 0xFD, 0xF8, 0x38, 0x71,
  0xEF, 0x9E, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x0C, 0x0F, 0xE7, 0x19, 0x83,
  0xE0, 0xF3, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xDF, 0x3B, 0x60, 0x18,
  0x03, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x3B, 0x0C, 0xC3, 0x30,
  0xFE, 0x7F, 0x9C, 0x66, 0x1B, 0x87, 0xFE, 0x7F, 0xB8, 0xDC, 0x6E, 0x77,
  0xC3, 0xFD, 0xC6, 0xE3, 0xF3, 0xBF, 0xDF, 0xC0, 0x18, 0x7E, 0xFF, 0xE3,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE3, 0xE7, 0x7F, 0x3E, 0xFE, 0xFF, 0xE7,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x18, 0x7E, 0xFF,
  0xE3, 0xE0, 0xE0, 0xEF, 0xEF, 0xE3, 0xE3, 0xE7, 0x7F, 0x3E, 0xE3, 0xE3,
  0xE3, 0xE3, 0xFF, 0xFF, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x1F, 0x8F,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xE3, 0xB1, 0xDF, 0xC7, 0xC0,
  0xE3, 0xF3, 0xB9, 0x9D, 0xCF, 0xE7, 0xE3, 0xF9, 0xDC, 0xE6, 0x73, 0xB9,
  0xDC, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF,
  0xF0, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xDF, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE3, 0xF3, 0xF3, 0xF3, 0xDB, 0xDB, 0xDB, 0xCF, 0xCF, 0xCF, 0xC7,
  0xC7, 0x18, 0x7E, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7,
  0x7F, 0x3E, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0xFB, 0xF9, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x00, 0x18, 0x7E, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE7, 0x7F, 0x3E, 0x0E, 0x06, 0x07, 0xFE, 0x7F, 0xB8, 0xDC,
  0x6E, 0x37, 0xFB, 0xF9, 0xDC, 0xEE, 0x73, 0x39, 0xDC, 0x70, 0x18, 0x7E,
  0xFF, 0xE3, 0xE0, 0xF0, 0x7E, 0x3F, 0x07, 0x03, 0xE3, 0xFF, 0x7E, 0xFF,
  0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0x7F,
  0x3E, 0xE1, 0xD8, 0x67, 0x19, 0xCE, 0x33, 0x8C, 0xC3, 0xB0, 0xEC, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0xCC, 0xF3, 0x3C, 0xCD, 0xBB, 0x6E, 0xDF, 0xA7,
  0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xCC, 0xE3, 0xF0, 0x7C,
  0x1E, 0x03, 0x81, 0xE0, 0x7C, 0x3F, 0x0C, 0xE7, 0x3B, 0x87, 0xE1, 0xDC,
  0x63, 0x38, 0xEC, 0x3F, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFF, 0xFF, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xFF, 0xE0,
  0xE0, 0x60, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E,
  0x06, 0x07, 0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF,
  0xFF, 0x3C, 0x3C, 0x3E, 0x66, 0x66, 0xE3, 0xFF, 0xFF, 0xFF, 0xE7, 0x08,
  0x7E, 0xFF, 0xE3, 0x3F, 0xFF, 0xE3, 0xC7, 0xFF, 0x7B, 0xE0, 0xE0, 0xE4,
  0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0x08, 0x7E, 0xFF,
  0xE3, 0xE0, 0xE0, 0xE0, 0xE7, 0x7F, 0x3E, 0x03, 0x03, 0x13, 0x7B, 0xFF,
  0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0x7B, 0x08, 0x7E, 0xE7, 0xE3, 0xFF,
  0xFF, 0xC0, 0xE3, 0x7F, 0x3E, 0x1F, 0x3F, 0x38, 0x38, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x10, 0x7B, 0xFF, 0xE7, 0xE3, 0xE3, 0xE7,
  0xFF, 0x7B, 0x03, 0x07, 0x7F, 0x7E, 0xE0, 0xE0, 0xE4, 0xFE, 0xFF, 0xE7,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0x0E, 0x1C, 0x00,
  0x07, 0xEF, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xFF, 0xFC, 0xE0,
  0x70, 0x38, 0x3C, 0xEE, 0x77, 0x73, 0xF9, 0xF8, 0xEE, 0x73, 0x39, 0xDC,
  0x70, 0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xFC, 0x1F, 0x12, 0x7F, 0xB6, 0xDB, 0x7D, 0xBE, 0xDF, 0x6F,
  0xB7, 0xDB, 0xED, 0xC0, 0x04, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0x08, 0x7E, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0x7F, 0x3E,
  0x04, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0xE0, 0xE0,
  0xE0, 0x10, 0x7B, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xFB, 0x7B, 0x03,
  0x03, 0x03, 0x04, 0x7F, 0xBF, 0xDC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x00, 0x08, 0x7F, 0xE7, 0xE0, 0xFC, 0x7F, 0x07, 0xC3, 0xFF, 0x7E,
  0x38, 0x38, 0x38, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0x7F, 0x3E, 0xE1, 0xDC, 0x67,
  0x38, 0xCC, 0x3B, 0x0F, 0xC1, 0xF0, 0x78, 0x1E, 0x00, 0xCC, 0xF3, 0x36,
  0xCD, 0xBA, 0x7B, 0x9E, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x73, 0xCE, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xF1, 0xCE, 0xF1, 0xC0, 0xF1, 0xDC, 0xE3,
  0x38, 0xEC, 0x3B, 0x07, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x0F, 0x0F, 0x1C,
  0x1C, 0x0C, 0x0C, 0x1C, 0xF8, 0xFC, 0x1C, 0x0C, 0x0C, 0x1C, 0x1F, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x1F, 0x1F, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xE0, 0xF3, 0xFD, 0xF7,
  0xD9, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 4, -12 },
  { 6, 6, 5, 10, 2, -12 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 8, 17, 10, 1, -15 },
  { 42, 10, 13, 10, 0, -13 },
  { 59, 9, 13, 10, 1, -13 },
  { 74, 2, 5, 10, 4, -12 },
  { 76, 5, 16, 10, 3, -14 },
  { 86, 6, 16, 10, 2, -14 },
  { 98, 10, 9, 10, 0, -10 },
  { 110, 8, 8, 10, 1, -10 },
  { 118, 5, 6, 10, 2, -3 },
  { 122, 6, 3, 10, 2, -7 },
  { 125, 4, 3, 10, 3, -3 },
  { 127, 8, 16, 10, 1, -14 },
  { 143, 8, 13, 10, 1, -13 },
  { 156, 9, 12, 10, 1, -12 },
  { 170, 8, 13, 10, 1, -13 },
  { 183, 8, 12, 10, 1, -12 },
  { 195, 8, 12, 10, 1, -12 },
  { 207, 8, 12, 10, 1, -12 },
  { 219, 8, 12, 10, 1, -12 },
  { 231, 8, 12, 10, 1, -12 },
  { 243, 8, 13, 10, 1, -13 },
  { 256, 8, 13, 10, 1, -13 },
  { 269, 4, 10, 10, 3, -10 },
  { 274, 5, 13, 10, 2, -10 },
  { 283, 8, 9, 10, 1, -10 },
  { 292, 8, 7, 10, 1, -9 },
  { 299, 8, 9, 10, 1, -10 },
  { 308, 7, 12, 10, 2, -12 },
  { 319, 10, 16, 10, 0, -13 },
  { 339, 10, 12, 10, 0, -12 },
  { 354, 9, 12, 10, 1, -12 },
  { 368, 8, 13, 10, 1, -13 },
  { 381, 8, 12, 10, 1, -12 },
  { 393, 8, 12, 10, 1, -12 },
  { 405, 8, 12, 10, 1, -12 },
  { 417, 8, 13, 10, 1, -13 },
  { 430, 8, 12, 10, 1, -12 },
  { 442, 8, 12, 10, 1, -12 },
  { 454, 9, 12, 10, 0, -12 },
  { 468, 9, 12, 10, 1, -12 },
  { 482, 7, 12, 10, 2, -12 },
  { 493, 8, 12, 10, 1, -12 },
  { 505, 8, 12, 10, 1, -12 },
  { 517, 8, 13, 10, 1, -13 },
  { 530, 9, 12, 10, 1, -12 },
  { 544, 8, 16, 10, 1, -13 },
  { 560, 9, 12, 10, 1, -12 },
  { 574, 8, 13, 10, 1, -13 },
  { 587, 9, 12, 10, 1, -12 },
  { 601, 8, 12, 10, 1, -12 },
  { 613, 10, 12, 10, 0, -12 },
  { 628, 10, 12, 10, 0, -12 },
  { 643, 10, 12, 10, 0, -12 },
  { 658, 10, 12, 10, 0, -12 },
  { 673, 8, 12, 10, 1, -12 },
  { 685, 5, 16, 10, 3, -14 },
  { 695, 8, 16, 10, 1, -14 },
  { 711, 5, 16, 10, 2, -14 },
  { 721, 8, 6, 10, 1, -12 },
  { 727, 8, 3, 10, 1, 0 },
  { 730, 4, 2, 10, 3, -13 },
  { 731, 8, 10, 10, 1, -10 },
  { 741, 8, 12, 10, 1, -12 },
  { 753, 8, 10, 10, 1, -10 },
  { 763, 8, 12, 10, 1, -12 },
  { 775, 8, 10, 10, 1, -10 },
  { 785, 8, 12, 10, 1, -12 },
  { 797, 8, 13, 10, 1, -10 },
  { 810, 8, 12, 10, 1, -12 },
  { 822, 9, 13, 10, 1, -13 },
  { 837, 7, 16, 10, 1, -13 },
  { 851, 9, 12, 10, 1, -12 },
  { 865, 10, 12, 10, 0, -12 },
  { 880, 9, 10, 10, 1, -10 },
  { 892, 8, 10, 10, 1, -10 },
  { 902, 8, 10, 10, 1, -10 },
  { 912, 8, 13, 10, 1, -10 },
  { 925, 8, 13, 10, 1, -10 },
  { 938, 9, 10, 10, 1, -10 },
  { 950, 8, 10, 10, 1, -10 },
  { 960, 8, 12, 10, 1, -12 },
  { 972, 8, 9, 10, 1, -9 },
  { 981, 10, 9, 10, 0, -9 },
  { 993, 10, 9, 10, 0, -9 },
  { 1005, 10, 9, 10, 0, -9 },
  { 1017, 10, 12, 10, 0, -9 },
  { 1032, 8, 9, 10, 1, -9 },
  { 1041, 8, 16, 10, 1, -14 },
  { 1057, 2, 16, 10, 4, -14 },
  { 1061, 8, 16, 10, 1, -14 },
  { 1077, 9, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_ExtraBold17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_EXTRABOLD17PT7B_H_
