#ifndef _JETBRAINSMONO_EXTRABOLD35PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x1F, 0x7F, 0xFE, 0xF8,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3E, 0x03, 0xC3, 0xC0, 0x70, 0x70, 0x1E,
  0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xE0,
  0xE0, 0x1C, 0x1C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x1F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE3, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x38, 0x38, 0x0F, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF,
  0xFE, 0x7F, 0xFF, 0x7E, 0xEF, 0xFE, 0x73, 0xFF, 0x38, 0x0F, 0x9C, 0x07,
  0xEE, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1D, 0xF8, 0x0E, 0x7C, 0x07, 0x3F, 0xF3, 0x9F, 0xF9,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x1E, 0x3F, 0x80, 0x78, 0xFF, 0x81, 0xE1, 0xE7, 0x83, 0x87, 0x8F,
  0x0F, 0x0F, 0x1E, 0x3C, 0x1E, 0x3C, 0x70, 0x3C, 0x79, 0xC0, 0x78, 0xF7,
  0x80, 0x7F, 0xDE, 0x00, 0x7F, 0xB8, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x20, 0x00, 0x7B, 0xF8, 0x01, 0xEF, 0xF8,
  0x03, 0xBE, 0xF0, 0x0E, 0x78, 0xF0, 0x3C, 0xF1, 0xE0, 0xF1, 0xE3, 0xC1,
  0xC3, 0xC7, 0x87, 0x87, 0x8F, 0x1E, 0x07, 0xFC, 0x38, 0x0F, 0xF9, 0xE0,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x81,
  0xFB, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xCF, 0xBE, 0xF8, 0xFF, 0xDF, 0x1F, 0xF3, 0xE1, 0xFE, 0x7C,
  0x1F, 0x8F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC3, 0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x70, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x0F, 0x00,
  0x30, 0xE0, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F,
  0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x06, 0x0E, 0x0C, 0xF1, 0xC7, 0x9F, 0xBB, 0xF7, 0xFA, 0xFF, 0x7F, 0xFF,
  0xC0, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x1E, 0x3C,
  0x07, 0xC7, 0xC1, 0xF8, 0xFC, 0x0E, 0x0E, 0x00, 0x80, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3F,
  0x9F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF7,
  0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x39, 0xFF, 0xBE, 0xFF, 0xDF, 0x7F, 0xEF, 0xBF, 0xF1, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xF1, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x81,
  0xC7, 0xC0, 0xC3, 0xE0, 0x41, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x1F, 0x7E, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x78, 0x1F, 0x7F,
  0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFB, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x8C, 0x0F, 0xFF, 0x87, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xF1, 0xFD, 0xFF, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF7,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x8F,
  0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFC, 0x7E, 0xFC,
  0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xF1, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xF7, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF8, 0xFF, 0x7C, 0x3F, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xFF, 0xFB, 0xE0, 0x04,
  0x0F, 0x8F, 0xE7, 0xF3, 0xF8, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00, 0x78,
  0x00, 0x30, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0xFF,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xCF,
  0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7,
  0xE0, 0x7C, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xBF, 0xC3, 0xFB, 0xF8, 0xFF, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xFC,
  0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8,
  0xF0, 0xFF, 0x1F, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xBF, 0x83, 0xEF, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01,
  0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7C, 0xFF, 0x80, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBE, 0x07, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x0F, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x01, 0xFF, 0xC1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xF1, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFC, 0x00,
  0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF3, 0xF0,
  0xFC, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0xFC, 0x3F, 0x3F,
  0x07, 0xCF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xF1, 0xDF, 0xEE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFB, 0xBB,
  0xFF, 0x77, 0x7F, 0xEE, 0xEF, 0xFD, 0xDD, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7,
  0xFE, 0x7C, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7C, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xEF, 0x1F, 0xF7, 0x8F,
  0xFB, 0xC7, 0xFE, 0xF3, 0xFF, 0x79, 0xFF, 0xBC, 0xFF, 0xCF, 0x7F, 0xE7,
  0xBF, 0xF3, 0xDF, 0xF8, 0xF7, 0xFC, 0x7B, 0xFE, 0x3D, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF7,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xF1, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E,
  0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xF1, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBE, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x1F,
  0xBE, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xF1, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xF8,
  0x78, 0xFF, 0xC7, 0xC7, 0xDE, 0x3E, 0x3C, 0xF1, 0xF1, 0xE7, 0x8D, 0x8F,
  0x3C, 0x6C, 0x79, 0xE3, 0x63, 0xCF, 0x1B, 0x1E, 0x78, 0xD8, 0xF3, 0xC6,
  0xC7, 0x9E, 0x77, 0x3C, 0xF3, 0xB9, 0xE7, 0xDD, 0xDE, 0x1E, 0xEE, 0xF0,
  0xF7, 0x77, 0x87, 0xB1, 0xBC, 0x3D, 0x8D, 0xE1, 0xEC, 0x6F, 0x0F, 0x63,
  0x78, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07,
  0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x3E, 0x00, 0xFC, 0x07, 0xEF, 0x80,
  0xF9, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xEF,
  0xC0, 0x7D, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x81, 0xF1, 0xF0, 0x7E, 0x3F,
  0x0F, 0x83, 0xE3, 0xF0, 0x7E, 0xFC, 0x07, 0xFF, 0x80, 0xFC, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xE0, 0xFC, 0x7C, 0x1F,
  0x0F, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xF0, 0x3E,
  0x78, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x07, 0x8F, 0x83, 0xE7, 0xC1, 0xF7,
  0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x0F, 0xC1, 0xF0, 0x3F, 0x00, 0x80, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xE0, 0xFD, 0xF0, 0x7E, 0x00, 0x1F, 0x01,
  0xFF, 0x8F, 0xFF, 0xDF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0xFB, 0xE7, 0xF9,
  0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0xC1, 0xFB, 0xF8, 0xFB, 0xFE, 0x7D, 0xFF, 0xBF, 0xFF,
  0xDF, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFD, 0xF7, 0xFE, 0xFB, 0xFE, 0x7C, 0xFE, 0x00, 0x00, 0x80, 0x07,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF7, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x7F, 0xF0, 0x7E, 0xFC, 0x7F, 0x7F, 0xFF, 0x1F, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x18, 0x7E, 0x3F, 0x9F, 0x3F, 0xEF, 0xBF,
  0xF7, 0xDF, 0xFF, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xF1, 0xFD, 0xFF, 0xBE, 0xFF, 0xDF, 0x3F, 0xEF, 0x8F, 0xE7, 0xC0,
  0x00, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF7, 0xF7, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0x7F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x06, 0x00, 0x0F, 0xEF, 0xCF, 0xFB, 0xEF, 0xFD, 0xF7,
  0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xFF, 0xFE, 0xFF,
  0xDF, 0x7F, 0xEF, 0x9F, 0xE7, 0xC3, 0xE3, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF1, 0x81, 0xFB, 0xF8, 0xFF, 0xFE, 0x7D, 0xFF, 0xBF, 0xFF, 0xDF, 0xC7,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xF0,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xF0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x83, 0x1F, 0x79, 0xF3, 0xFF, 0xBF, 0x7F, 0xFF, 0xEF, 0x9F, 0x3F, 0xF1,
  0xC7, 0xFE, 0x38, 0xFF, 0xC7, 0x1F, 0xF8, 0xE3, 0xFF, 0x1C, 0x7F, 0xE3,
  0x8F, 0xFC, 0x71, 0xFF, 0x8E, 0x3F, 0xF1, 0xC7, 0xFE, 0x38, 0xFF, 0xC7,
  0x1F, 0xF8, 0xE3, 0xFF, 0x1C, 0x7F, 0xE3, 0x8F, 0xFC, 0x71, 0xF0, 0x00,
  0x60, 0x7C, 0xFE, 0x3E, 0xFF, 0x9F, 0x7F, 0xEF, 0xFF, 0xF7, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF0, 0x00, 0x80, 0x07, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xF7, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7E, 0xFC, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x30, 0x7C, 0xFE, 0x3E, 0xFF, 0x9F, 0x7F, 0xEF, 0xFF, 0xF7,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFF,
  0xFF, 0x7D, 0xFF, 0xBE, 0xFF, 0x9F, 0x3F, 0x8F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xE7, 0xCF, 0xFB, 0xEF, 0xFD, 0xF7, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0x7F, 0xEF, 0xBF, 0xF7, 0xCF,
  0xFB, 0xE3, 0xFB, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x30, 0x7C, 0xFE, 0x3E, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xBF, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF8, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x07, 0xEF,
  0x80, 0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F,
  0x83, 0xE1, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7E, 0x7C, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x70, 0xFB, 0xC7, 0xC7,
  0x9E, 0x3E, 0x3C, 0xF1, 0xF1, 0xE7, 0x8D, 0x8F, 0x3C, 0x6C, 0x79, 0xE3,
  0x63, 0xCF, 0x9B, 0x3E, 0x3D, 0xDD, 0xE1, 0xEE, 0xEF, 0x0F, 0x77, 0x78,
  0x7B, 0x1B, 0xC3, 0xD8, 0xDE, 0x1E, 0xC6, 0xF0, 0xF6, 0x37, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0xFE, 0x0F, 0xE7,
  0xC1, 0xF0, 0xFC, 0x7E, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xC1, 0xF8, 0xFC, 0x3E,
  0x0F, 0x8F, 0xC1, 0xFB, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xEF, 0x80, 0xF9,
  0xF8, 0x1F, 0x3F, 0x07, 0xE3, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC7, 0xE0,
  0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x03, 0xDF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x07, 0xF8, 0x7D, 0xFF, 0x0F, 0xBF, 0xF1, 0xFF, 0x9F,
  0x3F, 0xF1, 0xFF, 0xBE, 0x3F, 0xF7, 0xC3, 0xFC, 0x00, 0x3F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 26, 21, 7, -26 },
  { 24, 13, 11, 21, 4, -26 },
  { 42, 19, 26, 21, 1, -26 },
  { 104, 17, 35, 21, 2, -30 },
  { 179, 23, 26, 21, -1, -26 },
  { 254, 19, 26, 21, 1, -26 },
  { 316, 5, 11, 21, 8, -26 },
  { 323, 12, 33, 21, 5, -29 },
  { 373, 12, 33, 21, 4, -29 },
  { 423, 19, 18, 21, 1, -21 },
  { 466, 17, 17, 21, 2, -20 },
  { 503, 9, 11, 21, 5, -5 },
  { 516, 11, 5, 21, 5, -14 },
  { 523, 7, 7, 21, 7, -7 },
  { 530, 17, 33, 21, 2, -29 },
  { 601, 17, 26, 21, 2, -26 },
  { 657, 17, 26, 21, 3, -26 },
  { 713, 17, 26, 21, 2, -26 },
  { 769, 17, 26, 21, 2, -26 },
  { 825, 16, 26, 21, 2, -26 },
  { 877, 17, 26, 21, 2, -26 },
  { 933, 17, 26, 21, 2, -26 },
  { 989, 17, 26, 21, 2, -26 },
  { 1045, 17, 26, 21, 2, -26 },
  { 1101, 17, 26, 21, 2, -26 },
  { 1157, 7, 20, 21, 7, -20 },
  { 1175, 9, 26, 21, 5, -20 },
  { 1205, 17, 19, 21, 2, -21 },
  { 1246, 15, 13, 21, 3, -18 },
  { 1271, 17, 19, 21, 2, -21 },
  { 1312, 14, 26, 21, 4, -26 },
  { 1358, 19, 32, 21, 1, -26 },
  { 1434, 19, 26, 21, 1, -26 },
  { 1496, 18, 26, 21, 2, -26 },
  { 1555, 17, 26, 21, 2, -26 },
  { 1611, 17, 26, 21, 2, -26 },
  { 1667, 16, 26, 21, 3, -26 },
  { 1719, 17, 26, 21, 2, -26 },
  { 1775, 17, 26, 21, 2, -26 },
  { 1831, 17, 26, 21, 2, -26 },
  { 1887, 15, 26, 21, 3, -26 },
  { 1936, 17, 26, 21, 1, -26 },
  { 1992, 18, 26, 21, 2, -26 },
  { 2051, 16, 26, 21, 3, -26 },
  { 2103, 19, 26, 21, 1, -26 },
  { 2165, 17, 26, 21, 2, -26 },
  { 2221, 17, 26, 21, 2, -26 },
  { 2277, 18, 26, 21, 2, -26 },
  { 2336, 17, 32, 21, 2, -26 },
  { 2404, 18, 26, 21, 2, -26 },
  { 2463, 17, 26, 21, 2, -26 },
  { 2519, 19, 26, 21, 1, -26 },
  { 2581, 17, 26, 21, 2, -26 },
  { 2637, 19, 26, 21, 1, -26 },
  { 2699, 21, 26, 21, 0, -26 },
  { 2768, 19, 26, 21, 1, -26 },
  { 2830, 19, 26, 21, 1, -26 },
  { 2892, 15, 26, 21, 3, -26 },
  { 2941, 11, 33, 21, 6, -29 },
  { 2987, 17, 33, 21, 2, -29 },
  { 3058, 11, 33, 21, 4, -29 },
  { 3104, 17, 14, 21, 2, -26 },
  { 3134, 17, 5, 21, 2, 1 },
  { 3145, 10, 4, 21, 5, -27 },
  { 3150, 17, 20, 21, 2, -20 },
  { 3193, 17, 26, 21, 2, -26 },
  { 3249, 17, 20, 21, 2, -20 },
  { 3292, 17, 26, 21, 2, -26 },
  { 3348, 17, 20, 21, 2, -20 },
  { 3391, 17, 26, 21, 2, -26 },
  { 3447, 17, 26, 21, 2, -20 },
  { 3503, 17, 26, 21, 2, -26 },
  { 3559, 18, 28, 21, 2, -28 },
  { 3622, 14, 34, 21, 3, -28 },
  { 3682, 18, 26, 21, 2, -26 },
  { 3741, 19, 26, 21, 1, -26 },
  { 3803, 19, 20, 21, 1, -20 },
  { 3851, 17, 20, 21, 2, -20 },
  { 3894, 17, 20, 21, 2, -20 },
  { 3937, 17, 26, 21, 2, -20 },
  { 3993, 17, 26, 21, 2, -20 },
  { 4049, 17, 20, 21, 3, -20 },
  { 4092, 17, 20, 21, 2, -20 },
  { 4135, 18, 25, 21, 1, -25 },
  { 4192, 17, 19, 21, 2, -19 },
  { 4233, 19, 19, 21, 1, -19 },
  { 4279, 21, 19, 21, 0, -19 },
  { 4329, 19, 19, 21, 1, -19 },
  { 4375, 19, 25, 21, 1, -19 },
  { 4435, 17, 19, 21, 2, -19 },
  { 4476, 15, 33, 21, 3, -29 },
  { 4538, 5, 33, 21, 8, -29 },
  { 4559, 15, 33, 21, 3, -29 },
  { 4621, 19, 9, 21, 1, -17 },
};

const GFXfont JetBrainsMono_ExtraBold35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_EXTRABOLD35PT7B_H_
