#ifndef _JETBRAINSMONO_EXTRABOLD22PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x0E, 0xFE, 0xF3, 0xF9, 0xFC,
  0xFE, 0x77, 0x3B, 0x1D, 0x8E, 0x0E, 0x70, 0x63, 0x03, 0x18, 0x18, 0xC7,
  0xFF, 0xBF, 0xFC, 0x63, 0x83, 0x18, 0x18, 0xC0, 0xC6, 0x3F, 0xFD, 0xFF,
  0xE3, 0x1C, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x04, 0x00, 0x80, 0x10, 0x1F,
  0xC7, 0xFC, 0xFF, 0xFD, 0x7F, 0xA0, 0xF4, 0x0F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x7E, 0x0B, 0xC1, 0x3F, 0xA7, 0xFF, 0xEF, 0xF8, 0xFE, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x7C, 0x1F, 0xF8, 0xCC, 0x67, 0x31, 0x98, 0xC6, 0xC3, 0xFF,
  0x07, 0xD8, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xC0, 0xDF, 0x86, 0xE6, 0x33,
  0x99, 0xCE, 0x66, 0x1F, 0xB0, 0x3C, 0x1F, 0x03, 0xF8, 0x7B, 0xC7, 0x1C,
  0x70, 0x07, 0x00, 0x38, 0x07, 0xC0, 0xFE, 0xFE, 0xEE, 0xE7, 0xCE, 0x7C,
  0xE3, 0x8F, 0x7C, 0xFF, 0xE7, 0xEF, 0xFF, 0xFF, 0xF8, 0x07, 0x0F, 0x1F,
  0x3C, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70,
  0x78, 0x3C, 0x3F, 0x1F, 0x07, 0x01, 0xC1, 0xE3, 0xE3, 0xC3, 0xC3, 0x87,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x1E, 0x7D, 0xF3, 0xC6, 0x08,
  0x00, 0x0E, 0x00, 0xE0, 0x8E, 0x2E, 0x6E, 0xFD, 0xF7, 0xFC, 0x0E, 0x01,
  0xB8, 0x3B, 0x87, 0x1C, 0x31, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x3D, 0xE7,
  0x9C, 0x73, 0x8E, 0x00, 0xFF, 0xFF, 0xF8, 0x77, 0xFE, 0xE0, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x78, 0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0x78, 0x7E, 0x0F, 0xC1, 0xF9, 0x3F,
  0x77, 0xEE, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1E, 0xFF, 0x9F, 0xF0, 0xFC,
  0x1E, 0x1F, 0x8F, 0xE3, 0xB8, 0xCE, 0x23, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xF9, 0xFF,
  0x78, 0xFE, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xCF, 0xF9, 0xFF, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x7F, 0x1E,
  0xFF, 0xDF, 0xF1, 0xFC, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78,
  0x0E, 0x03, 0xCF, 0xF1, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0,
  0x78, 0x0F, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE4, 0x1F, 0xF3,
  0xFE, 0x71, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0x1E, 0xFF, 0xDF, 0xF1, 0xFC,
  0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1F, 0xE3, 0xFE, 0xFF,
  0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0x0E, 0xFF, 0xDF, 0xF0, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7E, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3F, 0x8F, 0xF9, 0xEF,
  0xF8, 0xFF, 0x0E, 0xE3, 0xDE, 0xF1, 0xFC, 0x3F, 0x8F, 0x3B, 0xC3, 0xF0,
  0x7F, 0x0F, 0xFF, 0xDF, 0xF1, 0xFC, 0x3F, 0x8F, 0xF9, 0xEF, 0xF8, 0x7E,
  0x0F, 0xC1, 0xFC, 0x7B, 0xFF, 0x7F, 0xE3, 0xB8, 0x0E, 0x03, 0xC0, 0x70,
  0x1E, 0x07, 0x81, 0xE0, 0x77, 0xDE, 0x60, 0x00, 0x00, 0x73, 0xFE, 0xE0,
  0x39, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x9E, 0x71, 0xCE, 0x38,
  0x00, 0xC1, 0xF1, 0xFD, 0xFC, 0xF8, 0x38, 0x0F, 0x03, 0xF0, 0x3F, 0x83,
  0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xC0, 0x3C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0, 0x7C, 0x7E,
  0x7E, 0x3E, 0x0E, 0x02, 0x00, 0xFE, 0x7F, 0xBF, 0xE0, 0x70, 0x38, 0x1C,
  0xFE, 0x7F, 0x3E, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x70, 0x1F,
  0x87, 0xFE, 0xF0, 0xEE, 0x07, 0xC0, 0x7C, 0x77, 0xCF, 0xFC, 0xE7, 0xCC,
  0x7C, 0xC7, 0xCC, 0x7C, 0xC7, 0xCE, 0x7C, 0xFB, 0xC7, 0x7E, 0x00, 0xE0,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xB8, 0x3B,
  0x83, 0xB8, 0x3B, 0x83, 0xBC, 0x71, 0xC7, 0x1C, 0x7F, 0xC7, 0xFE, 0xF0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0F, 0xFF, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x0F,
  0xE3, 0xFF, 0xF7, 0xF8, 0xFF, 0xDE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF,
  0xFF, 0xF7, 0xFC, 0x1F, 0x8F, 0xF9, 0xFF, 0xF8, 0x7F, 0x0F, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x7F, 0x1E, 0xFF, 0xDF, 0xF0,
  0xFC, 0xFF, 0x1F, 0xFB, 0xFF, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xFF, 0xBF, 0xF7, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xFF, 0xB8, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x1F, 0x8F, 0xF9, 0xFF, 0xF8, 0x7F, 0x0F, 0xE0, 0x3C,
  0x07, 0xBF, 0xF7, 0xFE, 0xFF, 0xC3, 0xF8, 0x7F, 0x1E, 0xFF, 0xDF, 0xF0,
  0xFC, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC7, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xF8, 0x77, 0x0E, 0xFF,
  0xCF, 0xF0, 0xFC, 0xF0, 0xFF, 0x1E, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0x38,
  0xFF, 0x8F, 0xF0, 0xFF, 0x8F, 0x78, 0xF3, 0x8F, 0x3C, 0xF1, 0xCF, 0x1E,
  0xF1, 0xEF, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFE, 0x3F, 0xC7, 0xEC, 0xBF, 0xB7, 0xF6, 0xFA, 0xFF, 0x77, 0xEE, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0xCF, 0xD9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xDF, 0x9F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0x1F, 0x8F, 0xF9, 0xFF, 0x78,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x1E, 0xFF, 0x9F, 0xF0, 0xFC, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x0E, 0xF0,
  0xFF, 0x0F, 0xF0, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0x78, 0xFF, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1E, 0xFF,
  0x9F, 0xF0, 0xFC, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0xFF, 0x9F, 0xFB,
  0xFF, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x7F, 0xFF, 0xFF, 0xDF, 0xE3, 0xDE,
  0x79, 0xCF, 0x3D, 0xE3, 0xBC, 0x7F, 0x87, 0x3F, 0x8F, 0xF9, 0xFF, 0xF8,
  0xFF, 0x01, 0xE0, 0x1F, 0x83, 0xFC, 0x3F, 0xC0, 0xFC, 0x07, 0x80, 0x7F,
  0x0F, 0xFF, 0xDF, 0xF1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1E, 0xFF, 0x9F, 0xF0,
  0xFC, 0xE0, 0xFE, 0x0E, 0xF0, 0xEF, 0x0E, 0x71, 0xE7, 0x1C, 0x71, 0xC7,
  0x9C, 0x39, 0xC3, 0xB8, 0x3B, 0x83, 0xB8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0xE7, 0x3F, 0x39, 0xF9, 0xCE, 0xCE, 0x76, 0x53, 0xB2, 0x99, 0x96,
  0xCC, 0xB6, 0x7D, 0xB3, 0xED, 0x9F, 0x6C, 0xFB, 0xE7, 0xCF, 0x3C, 0x78,
  0xE3, 0xC7, 0x1C, 0x78, 0x71, 0xC7, 0x8F, 0x38, 0x3B, 0xC1, 0xDC, 0x07,
  0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3B, 0x83, 0xDE,
  0x1C, 0x71, 0xE3, 0xDE, 0x0F, 0xF0, 0x7B, 0x83, 0x9E, 0x3C, 0x71, 0xC3,
  0xCE, 0x0E, 0xE0, 0x77, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xBF, 0xEF, 0xF8, 0x1E,
  0x07, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0xFF, 0xFF,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF,
  0xFF, 0x0E, 0x03, 0xE0, 0x7C, 0x1D, 0xC3, 0xB8, 0x73, 0x9C, 0x73, 0x8E,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0xE1, 0xC0, 0x1F, 0x8F,
  0xF9, 0xE7, 0xB8, 0xF0, 0x1E, 0x7F, 0xDF, 0xFF, 0x8F, 0xE1, 0xFE, 0x3D,
  0xFB, 0xBF, 0x70, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x79, 0xFF, 0xBF,
  0xFF, 0x8F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xFF, 0xFF, 0xF7,
  0xBC, 0x3F, 0x8F, 0xF9, 0xFF, 0xF8, 0x7F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF1, 0xEF, 0xFD, 0xFF, 0x0F, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF3,
  0xFE, 0xFD, 0xDF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1E,
  0xFF, 0xDF, 0xB9, 0xF7, 0x3F, 0x8F, 0xF9, 0xC7, 0x78, 0x7E, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x3D, 0xFF, 0x0F, 0xC0, 0x07, 0xE1, 0xFC,
  0x7F, 0x8F, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3F, 0xEF, 0xDD, 0xFF, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0x7F, 0xEF, 0xDC, 0xFB, 0x80, 0x70,
  0x1E, 0x7F, 0x8F, 0xF1, 0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x79,
  0xFF, 0xBF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0x1E, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE3,
  0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x07, 0xFB, 0xFD, 0xFE, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xBF, 0xDF, 0xCF,
  0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xC7, 0xB8, 0xE7, 0x3C,
  0xFF, 0x1F, 0xC3, 0xFC, 0x73, 0x8E, 0x79, 0xC7, 0x38, 0xF7, 0x0F, 0xFE,
  0x1F, 0xC3, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1F, 0xC3, 0xF8, 0x3F, 0xFD, 0xFF, 0xFF,
  0xBB, 0xF7, 0x7E, 0xEF, 0xDD, 0xFB, 0xBF, 0x77, 0xEE, 0xFD, 0xDF, 0xBB,
  0xF7, 0x70, 0xF7, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF0, 0x3F, 0x8F, 0xF9, 0xFF, 0x78,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xEF, 0xF9, 0xFF, 0x0F, 0xC0,
  0xF7, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1,
  0xFF, 0xFF, 0xFF, 0x7B, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x3E, 0xEF,
  0xDD, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xEF, 0xFD,
  0xFB, 0x9F, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xEF, 0x9F, 0xFB, 0xCF,
  0x70, 0xFE, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x00, 0x3F, 0x8F, 0xF9, 0xC7, 0xF8, 0x07, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xE0, 0xFE, 0x3D, 0xFF, 0x9F, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0xC3, 0xF8, 0x3F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0x71, 0xEF, 0xF9, 0xFF, 0x0F, 0xC0, 0xE0, 0xFE, 0x0E,
  0xF1, 0xE7, 0x1C, 0x71, 0xC7, 0x9C, 0x3B, 0x83, 0xB8, 0x3B, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0xE7, 0x3F, 0x39, 0xD9, 0xCE, 0xCA, 0x66, 0x53, 0x3A,
  0xD9, 0xF7, 0xCF, 0xBE, 0x7D, 0xF1, 0xE7, 0x8F, 0x38, 0x71, 0xC0, 0xF1,
  0xE7, 0x9C, 0x3B, 0xC3, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x3B,
  0x87, 0xBC, 0x71, 0xEF, 0x0F, 0xE0, 0xFF, 0x0E, 0x71, 0xE7, 0x1C, 0x79,
  0xC3, 0xBC, 0x3B, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0xFF, 0xBF, 0xEF, 0xF8, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xC3, 0xF0, 0xFC,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x3F, 0x0F, 0xC3, 0xF8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xF0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3E, 0x0F, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3C, 0x07, 0xF1, 0xFC, 0xFF, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x3E, 0x0F, 0x83, 0xC0, 0x10, 0x0F, 0x8F, 0xF9, 0xF7, 0xFE,
  0x7E, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 16, 13, 5, -16 },
  { 9, 9, 7, 13, 2, -16 },
  { 17, 13, 16, 13, 0, -16 },
  { 43, 11, 22, 13, 1, -19 },
  { 74, 14, 16, 13, 0, -16 },
  { 102, 12, 16, 13, 1, -16 },
  { 126, 3, 7, 13, 5, -16 },
  { 129, 8, 21, 13, 3, -18 },
  { 150, 7, 21, 13, 3, -18 },
  { 169, 12, 11, 13, 1, -13 },
  { 186, 11, 11, 13, 1, -13 },
  { 202, 6, 7, 13, 3, -3 },
  { 208, 7, 3, 13, 3, -9 },
  { 211, 5, 4, 13, 4, -4 },
  { 214, 11, 20, 13, 1, -18 },
  { 242, 11, 16, 13, 1, -16 },
  { 264, 10, 16, 13, 2, -16 },
  { 284, 11, 16, 13, 1, -16 },
  { 306, 11, 16, 13, 1, -16 },
  { 328, 11, 16, 13, 1, -16 },
  { 350, 11, 16, 13, 1, -16 },
  { 372, 11, 16, 13, 1, -16 },
  { 394, 11, 16, 13, 1, -16 },
  { 416, 11, 16, 13, 1, -16 },
  { 438, 11, 16, 13, 1, -16 },
  { 460, 5, 12, 13, 4, -12 },
  { 468, 6, 16, 13, 3, -12 },
  { 480, 10, 12, 13, 2, -13 },
  { 495, 9, 9, 13, 2, -12 },
  { 506, 10, 12, 13, 2, -13 },
  { 521, 9, 16, 13, 2, -16 },
  { 539, 12, 20, 13, 1, -16 },
  { 569, 12, 16, 13, 1, -16 },
  { 593, 11, 16, 13, 1, -16 },
  { 615, 11, 16, 13, 1, -16 },
  { 637, 11, 16, 13, 1, -16 },
  { 659, 10, 16, 13, 2, -16 },
  { 679, 10, 16, 13, 2, -16 },
  { 699, 11, 16, 13, 1, -16 },
  { 721, 11, 16, 13, 1, -16 },
  { 743, 9, 16, 13, 2, -16 },
  { 761, 11, 16, 13, 0, -16 },
  { 783, 12, 16, 13, 1, -16 },
  { 807, 10, 16, 13, 2, -16 },
  { 827, 11, 16, 13, 1, -16 },
  { 849, 11, 16, 13, 1, -16 },
  { 871, 11, 16, 13, 1, -16 },
  { 893, 12, 16, 13, 1, -16 },
  { 917, 11, 20, 13, 1, -16 },
  { 945, 11, 16, 13, 1, -16 },
  { 967, 11, 16, 13, 1, -16 },
  { 989, 11, 16, 13, 1, -16 },
  { 1011, 11, 16, 13, 1, -16 },
  { 1033, 12, 16, 13, 1, -16 },
  { 1057, 13, 16, 13, 0, -16 },
  { 1083, 13, 16, 13, 0, -16 },
  { 1109, 13, 16, 13, 0, -16 },
  { 1135, 10, 16, 13, 2, -16 },
  { 1155, 6, 20, 13, 4, -18 },
  { 1170, 11, 20, 13, 1, -18 },
  { 1198, 6, 20, 13, 3, -18 },
  { 1213, 11, 9, 13, 1, -16 },
  { 1226, 11, 3, 13, 1, 1 },
  { 1231, 6, 3, 13, 3, -17 },
  { 1234, 11, 12, 13, 1, -12 },
  { 1251, 11, 16, 13, 1, -16 },
  { 1273, 11, 12, 13, 1, -12 },
  { 1290, 11, 16, 13, 1, -16 },
  { 1312, 11, 12, 13, 1, -12 },
  { 1329, 11, 16, 13, 1, -16 },
  { 1351, 11, 16, 13, 1, -12 },
  { 1373, 11, 16, 13, 1, -16 },
  { 1395, 10, 17, 13, 2, -17 },
  { 1417, 9, 21, 13, 2, -17 },
  { 1441, 11, 16, 13, 2, -16 },
  { 1463, 11, 16, 13, 1, -16 },
  { 1485, 11, 12, 13, 1, -12 },
  { 1502, 11, 12, 13, 1, -12 },
  { 1519, 11, 12, 13, 1, -12 },
  { 1536, 11, 16, 13, 1, -12 },
  { 1558, 11, 16, 13, 1, -12 },
  { 1580, 11, 12, 13, 2, -12 },
  { 1597, 11, 12, 13, 1, -12 },
  { 1614, 11, 16, 13, 1, -16 },
  { 1636, 11, 12, 13, 1, -12 },
  { 1653, 12, 12, 13, 1, -12 },
  { 1671, 13, 12, 13, 0, -12 },
  { 1691, 12, 12, 13, 1, -12 },
  { 1709, 12, 16, 13, 1, -12 },
  { 1733, 10, 12, 13, 2, -12 },
  { 1748, 10, 20, 13, 2, -18 },
  { 1773, 3, 20, 13, 5, -18 },
  { 1781, 10, 20, 13, 2, -18 },
  { 1806, 11, 6, 13, 1, -11 },
};

const GFXfont JetBrainsMono_ExtraBold22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_EXTRABOLD22PT7B_H_
