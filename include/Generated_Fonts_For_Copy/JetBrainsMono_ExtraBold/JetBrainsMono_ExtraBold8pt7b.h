#ifndef _JETBRAINSMONO_EXTRABOLD8PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x57, 0xD4, 0xAF, 0x30, 0x27, 0xF6, 0x3F, 0x72,
  0xCD, 0xB8, 0x66, 0xDC, 0x72, 0x91, 0x7B, 0x3C, 0xE0, 0x2F, 0x49, 0x91,
  0x99, 0x36, 0xD4, 0x27, 0xC8, 0xA0, 0x22, 0xF2, 0x60, 0xE0, 0xC0, 0x11,
  0x32, 0x26, 0x4C, 0x75, 0xDF, 0xD7, 0x59, 0x25, 0xC0, 0x7D, 0x13, 0x47,
  0x73, 0x31, 0xD7, 0x32, 0x4D, 0xF1, 0x74, 0x71, 0xD7, 0x36, 0x6D, 0xD7,
  0xFD, 0x12, 0x26, 0x7D, 0x57, 0xD7, 0x7D, 0xD7, 0x26, 0x90, 0x41, 0xC0,
  0x3E, 0x32, 0xE3, 0x80, 0x9C, 0xE8, 0xC7, 0xE1, 0x80, 0x74, 0x6F, 0x5A,
  0xD9, 0x80, 0x23, 0x14, 0xA7, 0x6C, 0xF7, 0xDB, 0xC0, 0x75, 0xCC, 0xD7,
  0xFD, 0xDD, 0xDF, 0xF3, 0xF9, 0xC0, 0xF2, 0x79, 0x00, 0x75, 0xCF, 0xD7,
  0xB7, 0xFB, 0x40, 0xE9, 0x25, 0xC0, 0x31, 0x11, 0x97, 0xBA, 0xEE, 0xAB,
  0x92, 0x49, 0xC0, 0xDD, 0xBB, 0x99, 0xDD, 0xFF, 0xFD, 0x75, 0xDD, 0xD7,
  0xEB, 0xBE, 0x88, 0x75, 0xDD, 0xD7, 0x10, 0xEA, 0xAE, 0xAB, 0x7D, 0x63,
  0xD7, 0xF2, 0x22, 0x22, 0xDD, 0xDD, 0xD7, 0xDA, 0x94, 0xA7, 0x10, 0xAD,
  0x7B, 0xAD, 0x28, 0xDA, 0x98, 0xC5, 0x6C, 0xDA, 0x94, 0x42, 0x10, 0xE5,
  0x69, 0xC0, 0xFB, 0x6D, 0xB7, 0xC4, 0x42, 0x23, 0x11, 0xD5, 0x57, 0x25,
  0xD0, 0xF0, 0xC0, 0x77, 0xD7, 0x93, 0xDB, 0xC0, 0x7C, 0xD7, 0x11, 0x7D,
  0xD7, 0x7F, 0xC7, 0x32, 0xF2, 0x22, 0x7D, 0x57, 0x70, 0x93, 0xDB, 0x40,
  0x43, 0x25, 0xC0, 0x63, 0x92, 0x78, 0x89, 0xAE, 0xEB, 0xE1, 0x08, 0x42,
  0x1C, 0xFB, 0xBB, 0xF6, 0xD0, 0x7D, 0xD7, 0xF6, 0xF8, 0x7D, 0xD7, 0x10,
  0xEB, 0x88, 0x76, 0x97, 0x66, 0xF6, 0x63, 0xB6, 0xF0, 0xDA, 0x94, 0xC0,
  0xAF, 0xB4, 0xA0, 0xD1, 0x1D, 0xB0, 0xDA, 0x9C, 0x46, 0x00, 0xEA, 0x70,
  0x2D, 0x2C, 0x93, 0xFF, 0x9B, 0x67, 0xB4, 0x5B,
};

const GFXglyph JetBrainsMono_ExtraBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 0, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 3, 5, 2, -6 },
  { 21, 3, 8, 5, 1, -7 },
  { 24, 3, 8, 5, 1, -7 },
  { 27, 5, 4, 5, 0, -5 },
  { 30, 4, 4, 5, 0, -5 },
  { 32, 2, 2, 5, 1, -1 },
  { 33, 3, 1, 5, 1, -3 },
  { 34, 1, 2, 5, 2, -2 },
  { 35, 4, 8, 5, 0, -7 },
  { 39, 4, 6, 5, 0, -6 },
  { 42, 3, 6, 5, 1, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 4, 6, 5, 0, -6 },
  { 51, 4, 6, 5, 0, -6 },
  { 54, 4, 6, 5, 0, -6 },
  { 57, 4, 6, 5, 0, -6 },
  { 60, 4, 6, 5, 0, -6 },
  { 63, 4, 6, 5, 0, -6 },
  { 66, 4, 6, 5, 0, -6 },
  { 69, 1, 4, 5, 2, -4 },
  { 70, 2, 5, 5, 1, -4 },
  { 72, 3, 5, 5, 1, -5 },
  { 74, 3, 3, 5, 1, -4 },
  { 76, 3, 5, 5, 1, -5 },
  { 78, 3, 6, 5, 1, -6 },
  { 81, 5, 7, 5, 0, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 4, 6, 5, 0, -6 },
  { 96, 4, 6, 5, 0, -6 },
  { 99, 3, 6, 5, 1, -6 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 4, 6, 5, 0, -6 },
  { 108, 3, 6, 5, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 4, 6, 5, 0, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 4, 6, 5, 0, -6 },
  { 126, 4, 6, 5, 0, -6 },
  { 129, 4, 6, 5, 0, -6 },
  { 132, 4, 6, 5, 1, -6 },
  { 135, 4, 7, 5, 0, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 4, 6, 5, 0, -6 },
  { 145, 4, 6, 5, 0, -6 },
  { 148, 4, 6, 5, 0, -6 },
  { 151, 5, 6, 5, 0, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 5, 6, 5, 0, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 3, 6, 5, 1, -6 },
  { 170, 3, 8, 5, 1, -7 },
  { 173, 4, 8, 5, 0, -7 },
  { 177, 2, 8, 5, 1, -7 },
  { 179, 4, 3, 5, 0, -6 },
  { 181, 4, 1, 5, 0, 0 },
  { 182, 2, 1, 5, 1, -6 },
  { 183, 4, 4, 5, 0, -4 },
  { 185, 3, 6, 5, 1, -6 },
  { 188, 4, 4, 5, 0, -4 },
  { 190, 4, 6, 5, 0, -6 },
  { 193, 4, 4, 5, 0, -4 },
  { 195, 4, 6, 5, 0, -6 },
  { 198, 4, 5, 5, 0, -4 },
  { 201, 3, 6, 5, 1, -6 },
  { 204, 3, 6, 5, 1, -6 },
  { 207, 3, 7, 5, 1, -6 },
  { 210, 4, 6, 5, 1, -6 },
  { 213, 5, 6, 5, 0, -6 },
  { 217, 4, 4, 5, 0, -4 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 4, 4, 5, 0, -4 },
  { 223, 3, 5, 5, 1, -4 },
  { 225, 4, 5, 5, 0, -4 },
  { 228, 4, 4, 5, 1, -4 },
  { 230, 4, 4, 5, 0, -4 },
  { 232, 4, 6, 5, 0, -6 },
  { 235, 3, 4, 5, 1, -4 },
  { 237, 5, 4, 5, 0, -4 },
  { 240, 5, 4, 5, 0, -4 },
  { 243, 5, 4, 5, 0, -4 },
  { 246, 5, 5, 5, 0, -4 },
  { 250, 3, 4, 5, 1, -4 },
  { 252, 3, 8, 5, 1, -7 },
  { 255, 1, 8, 5, 2, -7 },
  { 256, 3, 8, 5, 1, -7 },
  { 259, 4, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_ExtraBold8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_EXTRABOLD8PT7B_H_
