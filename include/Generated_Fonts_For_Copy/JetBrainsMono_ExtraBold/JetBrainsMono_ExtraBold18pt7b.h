#ifndef _JETBRAINSMONO_EXTRABOLD18PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xC0, 0x7E, 0xEF, 0xDF, 0xBF, 0x7C, 0xE0, 0x18,
  0xC6, 0x61, 0x99, 0xFF, 0x7F, 0xC4, 0x63, 0x10, 0xCC, 0xFF, 0xFF, 0xF3,
  0x30, 0x8C, 0x66, 0x00, 0x08, 0x04, 0x02, 0x0F, 0xC7, 0xF7, 0x5F, 0xA1,
  0xD0, 0x7C, 0x3F, 0x87, 0xE1, 0x7E, 0xBF, 0x5F, 0xFC, 0x7C, 0x08, 0x04,
  0x02, 0x00, 0x78, 0x79, 0x1B, 0x36, 0x66, 0x8F, 0xB0, 0x6C, 0x03, 0x00,
  0x7E, 0x1F, 0xC6, 0xCC, 0x99, 0xB3, 0x6C, 0x3C, 0x3E, 0x3F, 0x99, 0xCC,
  0x07, 0x03, 0x83, 0xE1, 0xBF, 0xCF, 0x67, 0xB1, 0xDF, 0xE7, 0xD8, 0xFF,
  0xFE, 0x0C, 0xF7, 0xDC, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x38, 0xE1, 0xC7,
  0xCF, 0x0C, 0xC3, 0x8F, 0x0E, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0xEF, 0xBC, 0xC0, 0x0E, 0x03, 0x84, 0xC5, 0xD7, 0xFF, 0xC3, 0x81, 0xB0,
  0xEE, 0x31, 0x84, 0x40, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0xE0, 0x70,
  0x38, 0x77, 0xEE, 0xCC, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x00, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x3F, 0xDF, 0xFF,
  0xD7, 0xE3, 0xF1, 0xF8, 0xEF, 0xE3, 0xE0, 0x1C, 0x3E, 0x3F, 0x19, 0x88,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0xFF, 0xF8, 0x3E, 0x3F,
  0xB9, 0xDC, 0x70, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1F, 0xFF,
  0xF8, 0x7F, 0x3F, 0x81, 0xC1, 0xC1, 0xC0, 0xF8, 0x7C, 0x07, 0x03, 0xF1,
  0xF8, 0xEF, 0xE3, 0xE0, 0x0F, 0x0E, 0x1C, 0x38, 0x38, 0x73, 0xE3, 0xE3,
  0xFF, 0xFF, 0xFF, 0x03, 0x03, 0xFF, 0x7F, 0xB8, 0x1C, 0x0E, 0xC7, 0xFB,
  0xFC, 0x07, 0x03, 0x81, 0xF8, 0xEF, 0xE3, 0xE0, 0x0E, 0x0E, 0x0E, 0x07,
  0x07, 0x03, 0x73, 0xFD, 0xC7, 0xC3, 0xE1, 0xF8, 0xEF, 0xE3, 0xE0, 0xFF,
  0xFF, 0xF8, 0xFC, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07,
  0x07, 0x80, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x33, 0xF8, 0xF8, 0xEE, 0xE3,
  0xF1, 0xF8, 0xEF, 0xE3, 0xE0, 0x3E, 0x3F, 0xB8, 0xF8, 0x7E, 0x3F, 0x1D,
  0xFE, 0x7E, 0x07, 0x07, 0x07, 0x03, 0x83, 0x80, 0xFF, 0x80, 0x07, 0xFC,
  0x77, 0x70, 0x00, 0x07, 0x7E, 0xEE, 0xC0, 0x00, 0x83, 0xC7, 0xEF, 0x8F,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x78, 0x3F, 0x03, 0xE0, 0x78, 0x3C, 0x7C, 0xF8, 0xF0,
  0x60, 0x00, 0xF9, 0xFC, 0x38, 0x30, 0xEF, 0xDF, 0x38, 0x70, 0x00, 0x03,
  0x87, 0x00, 0x1F, 0x9F, 0xF6, 0x0D, 0x83, 0xE7, 0xFB, 0xFE, 0xCF, 0xB3,
  0xEC, 0xFB, 0x3E, 0xFF, 0x9F, 0x60, 0x1C, 0x03, 0xE0, 0x78, 0x0E, 0x07,
  0x81, 0xF0, 0x6C, 0x1B, 0x0E, 0xC3, 0xB8, 0xCE, 0x3F, 0x9F, 0xE7, 0x1D,
  0xC7, 0xE1, 0xC0, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0xFB, 0xF9, 0xCF,
  0xE3, 0xF1, 0xF8, 0xFF, 0xEF, 0xE0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x71, 0xF8, 0xEF, 0xE3, 0xE0, 0xFE, 0x7F, 0xB9,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xEF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0xFB, 0xFD, 0xC0, 0xE0, 0x70, 0x38,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0xFB, 0xFD, 0xFE,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x07,
  0x03, 0xBF, 0xDF, 0xE3, 0xF1, 0xF8, 0xEF, 0xE3, 0xE0, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38,
  0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF,
  0xFF, 0x0F, 0x87, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF0,
  0xDC, 0xEF, 0xF3, 0xF0, 0xE3, 0xF1, 0xF9, 0xDC, 0xEE, 0xE7, 0xF3, 0xF9,
  0xDC, 0xE7, 0x73, 0xB9, 0xDC, 0x7E, 0x38, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xFD, 0xFE,
  0xFF, 0x5E, 0xEF, 0x77, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xE3,
  0xF9, 0xFC, 0xFE, 0x7D, 0xBE, 0xDF, 0x6F, 0x9F, 0xCD, 0xE6, 0xF1, 0xF8,
  0xFC, 0x78, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xEF, 0xE3, 0xE0, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x1F, 0x1F,
  0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3E, 0x3F, 0xB8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xEF, 0xE3, 0xE0, 0x30,
  0x1C, 0x07, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x3F, 0xFD, 0xFC, 0xEE,
  0x73, 0xB9, 0xDC, 0x6E, 0x38, 0x7E, 0x3F, 0xB8, 0xFC, 0x0E, 0x03, 0xE1,
  0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0xFF, 0xE3, 0xE0, 0xFF, 0xFF, 0xC7, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xEF,
  0xE3, 0xE0, 0xE1, 0xDC, 0x77, 0x1D, 0xC6, 0x31, 0x8C, 0xE3, 0xB8, 0xEC,
  0x1B, 0x06, 0xC1, 0xF0, 0x78, 0x0E, 0x00, 0xCE, 0xFD, 0xDB, 0xBB, 0x35,
  0x66, 0xAC, 0xD5, 0x9A, 0xB3, 0x56, 0x7A, 0xCF, 0x59, 0xEF, 0x39, 0xC7,
  0x38, 0x71, 0xDC, 0x63, 0xB8, 0xEC, 0x1F, 0x03, 0x80, 0xE0, 0x7C, 0x1F,
  0x0E, 0xE3, 0x39, 0xC7, 0xF1, 0xC0, 0xE1, 0xEE, 0x39, 0xC6, 0x1D, 0xC3,
  0xB0, 0x36, 0x07, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0xFF, 0xFF, 0x07, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F,
  0xFF, 0xFC, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xFF, 0xFF,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0xFC, 0x1C,
  0x1E, 0x0D, 0x86, 0xC7, 0x73, 0x1B, 0x8E, 0xFF, 0xFF, 0xFF, 0xE0, 0xE3,
  0xC0, 0x3E, 0x3F, 0xB8, 0xE0, 0x73, 0xFF, 0xFF, 0x8F, 0xC7, 0xFF, 0xBD,
  0xC0, 0xE0, 0x70, 0x38, 0x1D, 0xCF, 0xF7, 0xBF, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFF, 0xEE, 0xE0, 0x3E, 0x3F, 0xB9, 0xFC, 0x7E, 0x07, 0x03, 0x8F,
  0xC7, 0x7F, 0x1F, 0x00, 0x03, 0x81, 0xC0, 0xEF, 0x77, 0xFF, 0x3F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF9, 0xEF, 0xF7, 0xB8, 0x3E, 0x3F, 0xB8, 0xFC, 0x7F,
  0xFF, 0xFF, 0x81, 0xC7, 0x7F, 0x1F, 0x00, 0x0F, 0x8F, 0xC6, 0x03, 0x0F,
  0xFF, 0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x7B, 0xBF,
  0xF9, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0x7F, 0x81, 0xC0, 0xE7, 0xE3,
  0xE0, 0xE0, 0x70, 0x38, 0x1D, 0xCF, 0xF7, 0xBF, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x38, 0x1C, 0x0E, 0x02, 0x00, 0x07, 0xC3, 0xE1, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x07, 0x0F, 0x02, 0x00,
  0x7F, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0xFE,
  0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x7E, 0x3F, 0x3B, 0xB9, 0xFC, 0xFE, 0x77,
  0x39, 0xDC, 0x7E, 0x38, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x3F, 0x07, 0xC0, 0xFB, 0x7F, 0xF6,
  0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xD9, 0xEC, 0xC0, 0xEE, 0x7F, 0xBD,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x3E, 0x3F, 0xB9,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F, 0x1F, 0x00, 0xEE, 0x7F, 0xBD,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0x77, 0x38, 0x1C, 0x0E, 0x00,
  0x7B, 0xBF, 0xF9, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0x7F, 0xBD, 0xC0,
  0xE0, 0x70, 0x38, 0xEF, 0x7F, 0xFC, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x00, 0x7E, 0x3F, 0xB8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7,
  0xFF, 0xBF, 0x80, 0x38, 0x1C, 0x0E, 0x1F, 0xFF, 0xFF, 0xFC, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0xE0, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xCE, 0x7F, 0x1F, 0x00, 0xE1, 0xDC, 0x77, 0x1C, 0xC6, 0x3B,
  0x8E, 0xE1, 0xB0, 0x7C, 0x1F, 0x03, 0x80, 0xCC, 0xFD, 0xD9, 0xBB, 0x35,
  0x66, 0xAC, 0xD5, 0x9A, 0xB3, 0xD6, 0x7B, 0x86, 0x70, 0x71, 0xCE, 0xE3,
  0xB8, 0x7C, 0x0E, 0x07, 0x81, 0xF0, 0xEE, 0x73, 0xBC, 0x70, 0xF1, 0xDC,
  0x77, 0x18, 0xEE, 0x3B, 0x86, 0xC1, 0xB0, 0x7C, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x00, 0xFF, 0x7F, 0x81, 0xC1, 0xC1, 0xC1, 0xC1, 0xE1, 0xE0,
  0xFF, 0xFF, 0xC0, 0x07, 0x0F, 0x0F, 0x0C, 0x0C, 0x0E, 0x0E, 0xFC, 0xF8,
  0xFC, 0x0E, 0x0E, 0x0C, 0x0C, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x0F,
  0x1F, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xF0, 0x70, 0x7C, 0xF7, 0x79,
  0xF0, 0x70,
};

const GFXglyph JetBrainsMono_ExtraBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 7, 5, 11, 2, -13 },
  { 11, 10, 13, 11, 0, -13 },
  { 28, 9, 19, 11, 1, -16 },
  { 50, 11, 13, 11, 0, -13 },
  { 68, 9, 13, 11, 1, -13 },
  { 83, 3, 5, 11, 4, -13 },
  { 85, 6, 17, 11, 3, -15 },
  { 98, 6, 17, 11, 2, -15 },
  { 111, 10, 10, 11, 0, -11 },
  { 124, 9, 8, 11, 1, -10 },
  { 133, 4, 6, 11, 3, -3 },
  { 136, 5, 2, 11, 3, -7 },
  { 138, 3, 3, 11, 4, -3 },
  { 140, 9, 17, 11, 1, -15 },
  { 160, 9, 13, 11, 1, -13 },
  { 175, 9, 13, 11, 1, -13 },
  { 190, 9, 13, 11, 1, -13 },
  { 205, 9, 13, 11, 1, -13 },
  { 220, 8, 13, 11, 1, -13 },
  { 233, 9, 13, 11, 1, -13 },
  { 248, 9, 13, 11, 1, -13 },
  { 263, 9, 13, 11, 1, -13 },
  { 278, 9, 13, 11, 1, -13 },
  { 293, 9, 13, 11, 1, -13 },
  { 308, 3, 10, 11, 4, -10 },
  { 312, 4, 13, 11, 3, -10 },
  { 319, 9, 10, 11, 1, -11 },
  { 331, 8, 7, 11, 1, -9 },
  { 338, 9, 10, 11, 1, -11 },
  { 350, 7, 13, 11, 2, -13 },
  { 362, 10, 16, 11, 0, -13 },
  { 382, 10, 13, 11, 0, -13 },
  { 399, 9, 13, 11, 1, -13 },
  { 414, 9, 13, 11, 1, -13 },
  { 429, 9, 13, 11, 1, -13 },
  { 444, 9, 13, 11, 1, -13 },
  { 459, 9, 13, 11, 1, -13 },
  { 474, 9, 13, 11, 1, -13 },
  { 489, 9, 13, 11, 1, -13 },
  { 504, 8, 13, 11, 1, -13 },
  { 517, 9, 13, 11, 0, -13 },
  { 532, 9, 13, 11, 1, -13 },
  { 547, 8, 13, 11, 2, -13 },
  { 560, 9, 13, 11, 1, -13 },
  { 575, 9, 13, 11, 1, -13 },
  { 590, 9, 13, 11, 1, -13 },
  { 605, 9, 13, 11, 1, -13 },
  { 620, 9, 16, 11, 1, -13 },
  { 638, 9, 13, 11, 1, -13 },
  { 653, 9, 13, 11, 1, -13 },
  { 668, 9, 13, 11, 1, -13 },
  { 683, 9, 13, 11, 1, -13 },
  { 698, 10, 13, 11, 0, -13 },
  { 715, 11, 13, 11, 0, -13 },
  { 733, 10, 13, 11, 0, -13 },
  { 750, 11, 13, 11, 0, -13 },
  { 768, 8, 13, 11, 1, -13 },
  { 781, 6, 17, 11, 3, -15 },
  { 794, 9, 17, 11, 1, -15 },
  { 814, 6, 17, 11, 2, -15 },
  { 827, 9, 7, 11, 1, -13 },
  { 835, 9, 3, 11, 1, 0 },
  { 839, 5, 2, 11, 3, -14 },
  { 841, 9, 10, 11, 1, -10 },
  { 853, 9, 13, 11, 1, -13 },
  { 868, 9, 10, 11, 1, -10 },
  { 880, 9, 13, 11, 1, -13 },
  { 895, 9, 10, 11, 1, -10 },
  { 907, 9, 13, 11, 1, -13 },
  { 922, 9, 13, 11, 1, -10 },
  { 937, 9, 13, 11, 1, -13 },
  { 952, 9, 14, 11, 1, -14 },
  { 968, 8, 17, 11, 1, -14 },
  { 985, 9, 13, 11, 1, -13 },
  { 1000, 10, 13, 11, 0, -13 },
  { 1017, 9, 10, 11, 1, -10 },
  { 1029, 9, 10, 11, 1, -10 },
  { 1041, 9, 10, 11, 1, -10 },
  { 1053, 9, 13, 11, 1, -10 },
  { 1068, 9, 13, 11, 1, -10 },
  { 1083, 9, 10, 11, 1, -10 },
  { 1095, 9, 10, 11, 1, -10 },
  { 1107, 9, 13, 11, 1, -13 },
  { 1122, 9, 10, 11, 1, -10 },
  { 1134, 10, 10, 11, 0, -10 },
  { 1147, 11, 10, 11, 0, -10 },
  { 1161, 10, 10, 11, 0, -10 },
  { 1174, 10, 13, 11, 0, -10 },
  { 1191, 9, 10, 11, 1, -10 },
  { 1203, 8, 17, 11, 1, -15 },
  { 1220, 3, 17, 11, 4, -15 },
  { 1227, 8, 17, 11, 1, -15 },
  { 1244, 9, 5, 11, 1, -9 },
};

const GFXfont JetBrainsMono_ExtraBold18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_EXTRABOLD18PT7B_H_
