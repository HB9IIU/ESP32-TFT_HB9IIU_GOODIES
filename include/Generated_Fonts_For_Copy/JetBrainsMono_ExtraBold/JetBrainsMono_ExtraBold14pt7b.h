#ifndef _JETBRAINSMONO_EXTRABOLD14PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDE, 0xF7, 0x30, 0x12, 0x32, 0x7F, 0x7F, 0x26,
  0x24, 0xFF, 0xFF, 0x6C, 0x6C, 0x10, 0x21, 0xF7, 0xED, 0xFA, 0x3E, 0x1E,
  0x1F, 0xAF, 0xF3, 0xE1, 0x02, 0x00, 0xF1, 0xE9, 0x35, 0x9F, 0x80, 0x80,
  0xB0, 0xFC, 0x52, 0x49, 0x63, 0x80, 0x3C, 0x76, 0x60, 0x30, 0x70, 0x7B,
  0xCE, 0xCE, 0x7E, 0x7B, 0xFF, 0x09, 0xDC, 0xCC, 0x63, 0x18, 0xC6, 0x18,
  0xF3, 0x84, 0x8C, 0xE7, 0x33, 0x33, 0x33, 0x7E, 0xC8, 0x18, 0x18, 0x5B,
  0xFF, 0x08, 0x3C, 0x76, 0x24, 0x30, 0x63, 0xFF, 0xF3, 0x06, 0x0C, 0x00,
  0x76, 0xEC, 0xFF, 0xDF, 0x00, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0C, 0x18,
  0x30, 0xC1, 0x87, 0x0C, 0x18, 0x00, 0x7D, 0xDB, 0x1E, 0x3F, 0x7E, 0xF1,
  0xE3, 0xFC, 0xF0, 0x79, 0xF3, 0x64, 0xC1, 0x83, 0x06, 0x0C, 0xFF, 0xFC,
  0x7D, 0xFB, 0x30, 0x60, 0xC3, 0x0C, 0x30, 0xFF, 0xFC, 0xFD, 0xF8, 0x61,
  0x83, 0xC1, 0x83, 0xE7, 0xFC, 0xF0, 0x1C, 0xE3, 0x18, 0xEF, 0x3F, 0xFF,
  0x0C, 0x30, 0xFD, 0xFB, 0x06, 0xCF, 0xC1, 0xC3, 0xE7, 0xFC, 0xF0, 0x38,
  0x61, 0x83, 0x0F, 0xD9, 0xF1, 0xE3, 0xFC, 0xF0, 0xFF, 0xFF, 0x30, 0x61,
  0xC3, 0x0E, 0x18, 0x30, 0xC0, 0x7D, 0xDB, 0x3E, 0x67, 0x9F, 0xB3, 0xE3,
  0xFC, 0xF8, 0x7D, 0xDB, 0x1E, 0x3F, 0xEF, 0x87, 0x0C, 0x30, 0xE0, 0xDF,
  0x00, 0x3E, 0x67, 0x60, 0x00, 0x76, 0xEC, 0x04, 0x33, 0xFC, 0xC3, 0xC3,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x0F, 0x0F, 0x0C, 0xFF, 0x30, 0xF7,
  0xC6, 0x3F, 0xB9, 0x00, 0xC7, 0x00, 0x3E, 0x63, 0xC3, 0xCD, 0xDB, 0xDB,
  0xDB, 0xDB, 0xDD, 0xC0, 0x60, 0x3C, 0x0C, 0x1C, 0x3C, 0x3C, 0x34, 0x36,
  0x66, 0x7E, 0x7E, 0x63, 0xE3, 0xFD, 0x9B, 0x3E, 0x6F, 0x9F, 0xB1, 0xE3,
  0xFD, 0xF0, 0x7D, 0xDB, 0x1E, 0x0C, 0x18, 0x30, 0x63, 0xFC, 0xF0, 0xFD,
  0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xFD, 0xF0, 0xFF, 0xFC, 0x30, 0xFF,
  0xFC, 0x30, 0xFF, 0xF0, 0xFF, 0xFF, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1,
  0x80, 0x7D, 0xDB, 0x1E, 0x0D, 0xFB, 0xF1, 0xE3, 0xFC, 0xF0, 0xCF, 0x3C,
  0xF3, 0xFF, 0xFC, 0xF3, 0xCF, 0x30, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0xFF, 0xF0, 0x1E, 0x3C, 0x18, 0x30, 0x60, 0xC1, 0xE3, 0x7E, 0xF8, 0xCF,
  0x9B, 0x36, 0xCF, 0x9F, 0x37, 0x66, 0xCD, 0x8C, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xFF, 0xFC, 0xCF, 0x9F, 0xBD, 0xFB, 0x76, 0xE1, 0xE3,
  0xC7, 0x8C, 0xE7, 0xCF, 0x9F, 0xBF, 0x7A, 0xF7, 0xEF, 0xCF, 0x9C, 0x7D,
  0xDB, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xFC, 0xF0, 0xFD, 0xFF, 0x1E, 0x3F,
  0xFF, 0xB0, 0x60, 0xC1, 0x80, 0x7D, 0xDB, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xFC, 0xF0, 0x70, 0x60, 0x60, 0xFD, 0xFB, 0x1E, 0x3F, 0xDF, 0xB6, 0x66,
  0xCD, 0x9C, 0x7D, 0xDB, 0x3E, 0x0F, 0x87, 0x83, 0xE3, 0xFC, 0xF8, 0xFF,
  0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xFC, 0xF0, 0xE3, 0x63, 0x66, 0x66, 0x36, 0x36, 0x34,
  0x3C, 0x1C, 0x1C, 0xDB, 0xDB, 0xDB, 0xDB, 0x57, 0x57, 0x57, 0x56, 0x66,
  0x66, 0xE7, 0x76, 0x3E, 0x3C, 0x18, 0x1C, 0x3C, 0x36, 0x66, 0xE3, 0xE3,
  0x66, 0x76, 0x36, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xF1, 0xC6,
  0x38, 0xC6, 0x38, 0xFF, 0xF0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8F, 0xFC, 0xC1, 0x83, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x70,
  0x60, 0xC1, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x38, 0xF1,
  0xA2, 0x6C, 0xE0, 0xFF, 0xFC, 0xE7, 0x39, 0xFB, 0x31, 0xFF, 0xF9, 0xF3,
  0xFF, 0xC1, 0x83, 0x67, 0xEC, 0xF9, 0xF3, 0xE7, 0xFD, 0xF8, 0x39, 0xFB,
  0x3E, 0x0C, 0x18, 0xFF, 0x3E, 0x0C, 0x37, 0xFF, 0xCF, 0x3C, 0xF3, 0xFD,
  0xF0, 0x39, 0xFB, 0x37, 0xFF, 0xF8, 0x3B, 0x3C, 0x3E, 0x7C, 0xC7, 0xFF,
  0xE6, 0x0C, 0x18, 0x30, 0x60, 0x7F, 0xFC, 0xF3, 0xCF, 0x3F, 0xCB, 0x0D,
  0xF7, 0x00, 0xC1, 0x83, 0x67, 0xEC, 0xD9, 0xF3, 0xE7, 0xCF, 0x9C, 0x38,
  0x70, 0x07, 0xCF, 0x83, 0x06, 0x0C, 0x19, 0xFF, 0xF8, 0x1C, 0x70, 0x1F,
  0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0xFB, 0x80, 0xC1, 0x83, 0x1E, 0x6C,
  0xDF, 0x3E, 0x6E, 0xCD, 0x9C, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x1F, 0x0F, 0xAD, 0xFE, 0xDD, 0xBB, 0x76, 0xED, 0xDB, 0xD9, 0xFB,
  0x36, 0x7C, 0xF9, 0xF3, 0xE7, 0x39, 0xFB, 0x36, 0x7C, 0xF9, 0xFF, 0x3C,
  0xD9, 0xFB, 0x3E, 0x7C, 0xF9, 0xFF, 0x7E, 0xC1, 0x83, 0x00, 0x7F, 0xFC,
  0xF3, 0xCF, 0x3F, 0xDF, 0x0C, 0x30, 0xC0, 0xDD, 0xFF, 0x1E, 0x3C, 0x18,
  0x30, 0x60, 0x79, 0xFB, 0x0F, 0xC7, 0xC0, 0xFF, 0xBE, 0x18, 0x33, 0xFF,
  0xF1, 0x83, 0x06, 0x0C, 0x1E, 0x3C, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xBF,
  0x3C, 0xE3, 0x63, 0x66, 0x76, 0x36, 0x3C, 0x3C, 0x1C, 0xD9, 0xDB, 0xDB,
  0x5B, 0x57, 0x56, 0x76, 0x66, 0x67, 0x76, 0x3C, 0x1C, 0x1C, 0x3C, 0x76,
  0xE7, 0xE3, 0x67, 0x66, 0x36, 0x3E, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x30,
  0xFF, 0xF1, 0xCE, 0x31, 0x8F, 0xFF, 0x0C, 0x71, 0x86, 0x18, 0x6F, 0x3C,
  0x18, 0x61, 0x86, 0x1C, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x87, 0x0C,
  0x30, 0xC3, 0xCF, 0x30, 0xC3, 0x1C, 0xE3, 0x00, 0x61, 0xEE, 0x78, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 5, 4, 8, 2, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 14, 8, 1, -12 },
  { 30, 9, 10, 8, 0, -10 },
  { 42, 8, 10, 8, 0, -10 },
  { 52, 2, 4, 8, 3, -10 },
  { 53, 5, 14, 8, 2, -12 },
  { 62, 4, 14, 8, 2, -12 },
  { 69, 8, 8, 8, 0, -9 },
  { 77, 7, 7, 8, 1, -8 },
  { 84, 4, 4, 8, 2, -2 },
  { 86, 4, 2, 8, 2, -6 },
  { 87, 3, 3, 8, 3, -3 },
  { 89, 7, 14, 8, 1, -12 },
  { 102, 7, 10, 8, 1, -10 },
  { 111, 7, 10, 8, 1, -10 },
  { 120, 7, 10, 8, 1, -10 },
  { 129, 7, 10, 8, 1, -10 },
  { 138, 6, 10, 8, 1, -10 },
  { 146, 7, 10, 8, 1, -10 },
  { 155, 7, 10, 8, 1, -10 },
  { 164, 7, 10, 8, 1, -10 },
  { 173, 7, 10, 8, 1, -10 },
  { 182, 7, 10, 8, 1, -10 },
  { 191, 3, 8, 8, 3, -8 },
  { 194, 4, 10, 8, 2, -8 },
  { 199, 6, 8, 8, 1, -9 },
  { 205, 6, 5, 8, 1, -7 },
  { 209, 6, 8, 8, 1, -9 },
  { 215, 5, 10, 8, 2, -10 },
  { 222, 8, 13, 8, 0, -10 },
  { 235, 8, 10, 8, 0, -10 },
  { 245, 7, 10, 8, 1, -10 },
  { 254, 7, 10, 8, 1, -10 },
  { 263, 7, 10, 8, 1, -10 },
  { 272, 6, 10, 8, 1, -10 },
  { 280, 7, 10, 8, 1, -10 },
  { 289, 7, 10, 8, 1, -10 },
  { 298, 6, 10, 8, 1, -10 },
  { 306, 6, 10, 8, 1, -10 },
  { 314, 7, 10, 8, 0, -10 },
  { 323, 7, 10, 8, 1, -10 },
  { 332, 7, 10, 8, 1, -10 },
  { 341, 7, 10, 8, 1, -10 },
  { 350, 7, 10, 8, 1, -10 },
  { 359, 7, 10, 8, 1, -10 },
  { 368, 7, 10, 8, 1, -10 },
  { 377, 7, 13, 8, 1, -10 },
  { 389, 7, 10, 8, 1, -10 },
  { 398, 7, 10, 8, 1, -10 },
  { 407, 7, 10, 8, 1, -10 },
  { 416, 7, 10, 8, 1, -10 },
  { 425, 8, 10, 8, 0, -10 },
  { 435, 8, 10, 8, 0, -10 },
  { 445, 8, 10, 8, 0, -10 },
  { 455, 8, 10, 8, 0, -10 },
  { 465, 6, 10, 8, 1, -10 },
  { 473, 5, 14, 8, 2, -12 },
  { 482, 7, 14, 8, 1, -12 },
  { 495, 4, 14, 8, 2, -12 },
  { 502, 7, 5, 8, 1, -10 },
  { 507, 7, 2, 8, 1, 0 },
  { 509, 4, 2, 8, 2, -11 },
  { 510, 7, 8, 8, 1, -8 },
  { 517, 7, 10, 8, 1, -10 },
  { 526, 7, 8, 8, 1, -8 },
  { 533, 6, 10, 8, 1, -10 },
  { 541, 7, 8, 8, 1, -8 },
  { 548, 7, 10, 8, 1, -10 },
  { 557, 6, 11, 8, 1, -8 },
  { 566, 7, 10, 8, 1, -10 },
  { 575, 7, 11, 8, 1, -11 },
  { 585, 6, 14, 8, 1, -11 },
  { 596, 7, 10, 8, 1, -10 },
  { 605, 8, 10, 8, 0, -10 },
  { 615, 7, 8, 8, 1, -8 },
  { 622, 7, 8, 8, 1, -8 },
  { 629, 7, 8, 8, 1, -8 },
  { 636, 7, 11, 8, 1, -8 },
  { 646, 6, 11, 8, 1, -8 },
  { 655, 7, 8, 8, 1, -8 },
  { 662, 7, 8, 8, 1, -8 },
  { 669, 7, 10, 8, 0, -10 },
  { 678, 7, 8, 8, 1, -8 },
  { 685, 8, 8, 8, 0, -8 },
  { 693, 8, 8, 8, 0, -8 },
  { 701, 8, 8, 8, 0, -8 },
  { 709, 8, 11, 8, 0, -8 },
  { 720, 6, 8, 8, 1, -8 },
  { 726, 6, 14, 8, 1, -12 },
  { 737, 2, 14, 8, 3, -12 },
  { 741, 6, 14, 8, 1, -12 },
  { 752, 7, 4, 8, 1, -7 },
};

const GFXfont JetBrainsMono_ExtraBold14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_EXTRABOLD14PT7B_H_
