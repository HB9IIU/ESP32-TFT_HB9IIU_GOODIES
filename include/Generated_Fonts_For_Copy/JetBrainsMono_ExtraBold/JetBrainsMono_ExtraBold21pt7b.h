#ifndef _JETBRAINSMONO_EXTRABOLD21PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x76, 0x00, 0x7F, 0x70, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x67, 0x0C, 0x60, 0xC6, 0x0C, 0xE7, 0xFF, 0x7F, 0xF1, 0x8C,
  0x18, 0xC1, 0x8C, 0x19, 0xCF, 0xFF, 0xFF, 0xF3, 0x18, 0x31, 0x83, 0x18,
  0x73, 0x80, 0x04, 0x00, 0x80, 0x10, 0x1F, 0xC7, 0xFD, 0xEB, 0xB9, 0x77,
  0x20, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x5C, 0x0B, 0xF9, 0x7F, 0xFE,
  0x7F, 0xC7, 0xE0, 0x10, 0x02, 0x00, 0x40, 0x7C, 0x3F, 0x63, 0xB3, 0x99,
  0x9D, 0x8C, 0xD8, 0x3E, 0xC0, 0xCC, 0x00, 0xC0, 0x0F, 0xE0, 0x7F, 0x86,
  0xCC, 0x66, 0x67, 0x33, 0x31, 0xFB, 0x07, 0x80, 0x0C, 0x07, 0xE1, 0xFE,
  0x39, 0xC7, 0x04, 0xE0, 0x0E, 0x03, 0xC0, 0xFC, 0xFD, 0xDF, 0xBF, 0x73,
  0xEE, 0x39, 0xCF, 0x3F, 0xF3, 0xF7, 0xFF, 0xFF, 0xC0, 0x02, 0x1C, 0x79,
  0xF7, 0x8E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x1C, 0x38, 0x78,
  0x7C, 0x78, 0x30, 0x20, 0x81, 0xC3, 0xE7, 0xE3, 0xC3, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x3D, 0xFB, 0xE7, 0x08, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x66, 0x6F, 0x5F, 0xFF, 0x83, 0x80, 0xD8, 0x3B, 0x8E,
  0x78, 0xC6, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFC,
  0x38, 0x0E, 0x03, 0x80, 0x7B, 0xDC, 0xEE, 0x70, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF7, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x00, 0x0C, 0x0F, 0xE7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0xBF, 0xEF, 0xFB, 0x7E, 0x1F, 0x87, 0xE1, 0xDF, 0xF7, 0xF8, 0xFC,
  0x3E, 0x1F, 0x8F, 0xE3, 0x38, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x0F, 0xE7, 0xFF, 0xCF,
  0xE1, 0xC0, 0x70, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xF0, 0x3C, 0x1C, 0x0E, 0x07, 0xC1, 0xF8,
  0x7F, 0x01, 0xC0, 0x70, 0x1F, 0x87, 0xFB, 0xDF, 0xE3, 0xF0, 0x07, 0x81,
  0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x9F, 0xC7, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x7F, 0xDF, 0xF7, 0xFD, 0xC0, 0x70, 0x1F,
  0xE7, 0xFD, 0xEF, 0x01, 0xC0, 0x70, 0x1F, 0xC7, 0x7F, 0xDF, 0xE3, 0xF0,
  0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1F, 0xE7, 0xFE, 0xF1,
  0xDC, 0x3F, 0x83, 0xF0, 0xF7, 0xBC, 0xFF, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xEE, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x0C, 0x07, 0xF1, 0xFF, 0x78, 0xEE,
  0x1D, 0xE3, 0x9C, 0xF1, 0xFC, 0x3F, 0x0F, 0x7B, 0xC7, 0x70, 0xEE, 0x1F,
  0xF7, 0x9F, 0xF1, 0xF8, 0x0C, 0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x1F, 0xC1,
  0xF8, 0x7F, 0x9E, 0x7F, 0xC7, 0xF8, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x81, 0xE0, 0x6F, 0xF7, 0x00, 0x00, 0x2F, 0xF7, 0x39, 0xE7, 0x8E, 0x00,
  0x00, 0x00, 0x04, 0xE7, 0x9C, 0x71, 0xCE, 0x00, 0x00, 0x40, 0x70, 0x7C,
  0x7E, 0x7E, 0x3E, 0x0F, 0x03, 0xF0, 0x3F, 0x81, 0xF0, 0x1C, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0xC1,
  0xFC, 0x0F, 0xC0, 0xF0, 0x3C, 0x3F, 0x3F, 0x3F, 0x0F, 0x02, 0x00, 0xFE,
  0x7F, 0xBF, 0xE0, 0x70, 0x38, 0x3C, 0xFC, 0x7C, 0x38, 0x18, 0x00, 0x00,
  0x03, 0x83, 0xC1, 0xE0, 0x04, 0x07, 0xF1, 0xFF, 0x70, 0x7C, 0x0F, 0x80,
  0xF3, 0xDE, 0x77, 0xCC, 0x79, 0x8F, 0x31, 0xE6, 0x3C, 0xCF, 0x9F, 0xF1,
  0xDE, 0x00, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0x00, 0x1E, 0x03, 0xE0, 0x7C,
  0x1F, 0x83, 0xB0, 0x77, 0x0E, 0xE3, 0x9C, 0x73, 0x8F, 0xF9, 0xFF, 0x7F,
  0xEE, 0x1D, 0xC1, 0xF8, 0x38, 0xFF, 0x9F, 0xFB, 0x8F, 0x70, 0xEE, 0x1D,
  0xC3, 0xBF, 0xE7, 0xFC, 0xE3, 0xDC, 0x3F, 0x83, 0xF0, 0xFF, 0xFD, 0xFF,
  0xBF, 0xC0, 0x04, 0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x1F, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1F, 0x1C, 0xFF, 0x9F, 0xF1, 0xF8,
  0xFF, 0x1F, 0xFB, 0xFF, 0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xEF, 0xFD, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x04, 0x07, 0xF1,
  0xFF, 0x38, 0xEE, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE7, 0xFC, 0xFF, 0x87,
  0xF0, 0xFF, 0x1C, 0xFF, 0x9F, 0xF1, 0xF8, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC3, 0xB8, 0x77,
  0xFE, 0xFF, 0x87, 0xE0, 0xF1, 0xFE, 0x3B, 0xCF, 0x79, 0xCF, 0x79, 0xEE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1E, 0xF3, 0xCE, 0x79, 0xEF, 0x1D, 0xE3, 0xBC,
  0x78, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xF1, 0xFE, 0x3F, 0xCF, 0xED, 0xFD,
  0xBF, 0xF5, 0xFF, 0xBF, 0x77, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x38, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFB, 0x3E, 0xCF,
  0xBB, 0xE6, 0xF9, 0xBE, 0x7F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1C, 0x0C, 0x0F,
  0xE7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xF1, 0xDF, 0xF7, 0xF8, 0xFC, 0xFF, 0x9F, 0xFB, 0xFF, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0xFF, 0xFE, 0xFF, 0x9E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x00, 0x0C, 0x07, 0xF1, 0xFF, 0x79, 0xEE, 0x1D, 0xC3, 0xB8,
  0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEF, 0x1C, 0xFF, 0x9F, 0xE1,
  0xF8, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0xFF, 0x9F, 0xFB, 0xCF, 0x78,
  0xFF, 0x1F, 0xE3, 0xFF, 0xF7, 0xFE, 0xFF, 0x1E, 0xE3, 0xCE, 0x79, 0xCF,
  0x3D, 0xE3, 0xBC, 0x78, 0x0C, 0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x1D, 0xC0,
  0x3E, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0x00, 0xFE, 0x1F, 0xFF, 0x9F,
  0xF1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0xC7, 0x7F, 0xDF, 0xE3, 0xF0, 0xE0, 0xFC, 0x1F, 0x87, 0x78, 0xE7,
  0x1C, 0xE3, 0x9C, 0xE3, 0xDC, 0x3B, 0x87, 0x70, 0xEC, 0x1F, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xE7, 0x3E, 0x73, 0xE7, 0x36, 0x73, 0x65, 0x76, 0xD7,
  0x6D, 0x76, 0xD7, 0x6D, 0x77, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x38, 0xE0, 0x78, 0xF3, 0x8E, 0x39, 0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1D, 0xC3, 0xDC, 0x39, 0xE7, 0x8E, 0xF0,
  0xF0, 0xF0, 0x77, 0x0E, 0x38, 0xE3, 0x9E, 0x3D, 0xC1, 0xDC, 0x1F, 0x80,
  0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C,
  0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0xFF,
  0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF,
  0xFF, 0xC0, 0x1E, 0x07, 0xC1, 0xF0, 0xEC, 0x3B, 0x9C, 0xE7, 0x1F, 0x87,
  0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0x0E, 0x0F, 0xE7, 0xFD, 0xC7, 0x01, 0xCF,
  0xF7, 0xFF, 0x87, 0xE1, 0xFC, 0xFF, 0xFD, 0xF7, 0xF0, 0x3C, 0x0F, 0x03,
  0xDC, 0xEF, 0xBB, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF,
  0xFB, 0xFE, 0xF8, 0x1E, 0x0F, 0xE7, 0xFF, 0xC7, 0xE1, 0xF8, 0x0E, 0x03,
  0x80, 0xF1, 0xDF, 0xF7, 0xFC, 0xFC, 0x01, 0xC0, 0x70, 0x1C, 0x77, 0x7F,
  0xDF, 0xFF, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0x7F, 0xDF, 0xF3,
  0xDC, 0x1E, 0x0F, 0xE7, 0xFF, 0xC7, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x1C, 0x77, 0xF8, 0xFC, 0x0F, 0xC3, 0xF1, 0xE0, 0x70, 0x1C, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x1D,
  0xDF, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0xF3, 0xDF, 0xF3,
  0xDC, 0x07, 0x01, 0xCF, 0xF3, 0xF8, 0xF8, 0xF0, 0x3C, 0x0F, 0x03, 0xDC,
  0xEF, 0xBB, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1C, 0x06, 0x01, 0xE0, 0x3C, 0x03, 0x00, 0x00, 0xFC, 0x1F, 0x83,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x06, 0x0F, 0x0F, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFE, 0xFE, 0xF8, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x7F, 0x1D, 0xE7, 0xBC, 0xE7, 0xBC, 0xFF, 0x1F,
  0xE3, 0xDE, 0x79, 0xCF, 0x3D, 0xE3, 0xBC, 0x78, 0xFC, 0x1F, 0x83, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xFE, 0x1F, 0xC1, 0xF8, 0xD9, 0x9B, 0xBB, 0xBB, 0xF6, 0x7E, 0xCF,
  0xD9, 0xFB, 0x3F, 0x67, 0xEC, 0xFD, 0x9F, 0xB3, 0xF6, 0x70, 0xE7, 0x3B,
  0xEE, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0x1E, 0x0F, 0xE7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1,
  0xDF, 0xF7, 0xF8, 0xFC, 0xE7, 0x3B, 0xEE, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFF, 0xFE, 0xFF, 0xBE, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x1D, 0xDF, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xDF,
  0xF7, 0xFC, 0xF7, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xEF, 0x3F, 0xEF, 0xFF,
  0x8F, 0xE1, 0xF8, 0x7E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1F,
  0x0F, 0xF1, 0xFF, 0x70, 0xEF, 0x00, 0xFE, 0x0F, 0xF0, 0x0E, 0x01, 0xFE,
  0x39, 0xFF, 0x1F, 0xC0, 0x1C, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xC7, 0xF0, 0xFC, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xDF, 0xF7,
  0xF8, 0xFC, 0xE0, 0xFC, 0x1F, 0x87, 0x38, 0xE7, 0x1C, 0xE7, 0x0E, 0xE1,
  0xDC, 0x3B, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xE6, 0x3E, 0x73, 0x67, 0x36,
  0x73, 0x65, 0x76, 0xD7, 0x7D, 0x67, 0xD6, 0x7D, 0xE3, 0x9E, 0x39, 0xE3,
  0x9E, 0xE1, 0xEE, 0x39, 0xEE, 0x1F, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xF8,
  0x3F, 0x8F, 0x71, 0xC7, 0x70, 0xF0, 0xE0, 0xFC, 0x3F, 0xC7, 0x38, 0xE7,
  0x3C, 0x77, 0x0E, 0xE1, 0xDC, 0x1F, 0x03, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x7F, 0xDF, 0xF7, 0xFC, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0x87, 0xC7, 0xE3, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0xFC, 0x7C, 0x3F, 0x03, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x0F, 0x87, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x7C, 0x3E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0x87,
  0xCF, 0xE7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0xF8, 0x7C, 0x3C, 0x00, 0x78,
  0x1F, 0x9F, 0xBB, 0xE7, 0xFC, 0x7C,
};

const GFXglyph JetBrainsMono_ExtraBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 15, 13, 4, -15 },
  { 9, 8, 6, 13, 2, -15 },
  { 15, 12, 15, 13, 0, -15 },
  { 38, 11, 21, 13, 1, -18 },
  { 67, 13, 15, 13, 0, -15 },
  { 92, 11, 16, 13, 1, -16 },
  { 114, 3, 6, 13, 5, -15 },
  { 117, 7, 21, 13, 3, -18 },
  { 136, 7, 21, 13, 2, -18 },
  { 155, 11, 11, 13, 1, -13 },
  { 171, 10, 10, 13, 1, -12 },
  { 184, 5, 6, 13, 3, -3 },
  { 188, 7, 3, 13, 3, -8 },
  { 191, 4, 4, 13, 4, -4 },
  { 193, 11, 19, 13, 1, -17 },
  { 220, 10, 16, 13, 1, -16 },
  { 240, 10, 15, 13, 2, -15 },
  { 259, 10, 16, 13, 1, -16 },
  { 279, 10, 15, 13, 1, -15 },
  { 298, 10, 15, 13, 1, -15 },
  { 317, 10, 15, 13, 1, -15 },
  { 336, 11, 15, 13, 1, -15 },
  { 357, 11, 15, 13, 1, -15 },
  { 378, 11, 16, 13, 1, -16 },
  { 400, 11, 16, 13, 1, -16 },
  { 422, 4, 12, 13, 4, -12 },
  { 428, 6, 15, 13, 3, -12 },
  { 440, 10, 12, 13, 1, -13 },
  { 455, 9, 8, 13, 2, -11 },
  { 464, 10, 12, 13, 1, -13 },
  { 479, 9, 15, 13, 2, -15 },
  { 496, 11, 20, 13, 1, -16 },
  { 524, 11, 15, 13, 1, -15 },
  { 545, 11, 15, 13, 1, -15 },
  { 566, 11, 16, 13, 1, -16 },
  { 588, 11, 15, 13, 1, -15 },
  { 609, 9, 15, 13, 2, -15 },
  { 626, 10, 15, 13, 1, -15 },
  { 645, 11, 16, 13, 1, -16 },
  { 667, 10, 15, 13, 1, -15 },
  { 686, 9, 15, 13, 2, -15 },
  { 703, 11, 15, 13, 0, -15 },
  { 724, 11, 15, 13, 1, -15 },
  { 745, 9, 15, 13, 2, -15 },
  { 762, 11, 15, 13, 1, -15 },
  { 783, 10, 15, 13, 1, -15 },
  { 802, 10, 16, 13, 1, -16 },
  { 822, 11, 15, 13, 1, -15 },
  { 843, 11, 20, 13, 1, -16 },
  { 871, 11, 15, 13, 1, -15 },
  { 892, 11, 16, 13, 1, -16 },
  { 914, 11, 15, 13, 1, -15 },
  { 935, 10, 15, 13, 1, -15 },
  { 954, 11, 15, 13, 1, -15 },
  { 975, 12, 15, 13, 0, -15 },
  { 998, 12, 15, 13, 0, -15 },
  { 1021, 12, 15, 13, 0, -15 },
  { 1044, 9, 15, 13, 2, -15 },
  { 1061, 6, 19, 13, 4, -17 },
  { 1076, 11, 19, 13, 1, -17 },
  { 1103, 6, 19, 13, 3, -17 },
  { 1118, 10, 8, 13, 1, -15 },
  { 1128, 10, 2, 13, 1, 1 },
  { 1131, 6, 2, 13, 3, -16 },
  { 1133, 10, 12, 13, 1, -12 },
  { 1148, 10, 15, 13, 1, -15 },
  { 1167, 10, 12, 13, 1, -12 },
  { 1182, 10, 15, 13, 1, -15 },
  { 1201, 10, 12, 13, 1, -12 },
  { 1216, 10, 15, 13, 1, -15 },
  { 1235, 10, 16, 13, 1, -12 },
  { 1255, 10, 15, 13, 1, -15 },
  { 1274, 11, 17, 13, 1, -17 },
  { 1298, 8, 21, 13, 2, -17 },
  { 1319, 11, 15, 13, 1, -15 },
  { 1340, 11, 15, 13, 1, -15 },
  { 1361, 11, 12, 13, 1, -12 },
  { 1378, 10, 12, 13, 1, -12 },
  { 1393, 10, 12, 13, 1, -12 },
  { 1408, 10, 16, 13, 1, -12 },
  { 1428, 10, 16, 13, 1, -12 },
  { 1448, 10, 12, 13, 2, -12 },
  { 1463, 11, 12, 13, 1, -12 },
  { 1480, 10, 15, 13, 1, -15 },
  { 1499, 10, 12, 13, 1, -12 },
  { 1514, 11, 12, 13, 1, -12 },
  { 1531, 12, 12, 13, 0, -12 },
  { 1549, 11, 12, 13, 1, -12 },
  { 1566, 11, 16, 13, 1, -12 },
  { 1588, 10, 12, 13, 1, -12 },
  { 1603, 9, 19, 13, 2, -17 },
  { 1625, 3, 19, 13, 5, -17 },
  { 1633, 9, 19, 13, 2, -17 },
  { 1655, 11, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_ExtraBold21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_EXTRABOLD21PT7B_H_
