#ifndef _JETBRAINSMONO_EXTRABOLD7PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0xC0, 0xF0, 0x5F, 0x6F, 0xA0, 0x27, 0xC6, 0xB7, 0x20, 0xDE,
  0x27, 0xB0, 0x65, 0xDB, 0xF0, 0xC0, 0x7A, 0xB4, 0xB5, 0x78, 0x2F, 0x70,
  0x2F, 0x20, 0xE0, 0xC0, 0xC0, 0x12, 0x22, 0x44, 0xC0, 0x79, 0xB9, 0x60,
  0xD9, 0x2E, 0x79, 0x24, 0xF0, 0x72, 0x79, 0x60, 0x34, 0xDF, 0x10, 0x74,
  0x79, 0x60, 0x24, 0xF9, 0x70, 0xF9, 0x22, 0x40, 0x7D, 0x69, 0x70, 0x79,
  0x72, 0x60, 0xC3, 0xC3, 0x80, 0x3C, 0x61, 0xE3, 0x80, 0xC3, 0x68, 0xC7,
  0x08, 0x7B, 0xDD, 0xB6, 0x66, 0x67, 0x90, 0xF9, 0xE9, 0xF0, 0x78, 0x88,
  0x70, 0xF9, 0x99, 0xE0, 0xF3, 0x4E, 0xFC, 0xFC, 0xC0, 0x78, 0xB9, 0x70,
  0xDD, 0xFD, 0xD0, 0xE9, 0x2E, 0x71, 0x19, 0xE0, 0xDE, 0xEE, 0xD0, 0x92,
  0x4E, 0xDF, 0xB9, 0x90, 0xDD, 0xBB, 0xB0, 0x79, 0x99, 0x60, 0xFD, 0xFC,
  0xC0, 0x79, 0x99, 0x63, 0xFD, 0xFE, 0xD0, 0x78, 0x69, 0x70, 0xF2, 0x22,
  0x20, 0x99, 0x99, 0x60, 0x95, 0x66, 0x60, 0xBB, 0xFF, 0xF0, 0xD6, 0x66,
  0xD0, 0x96, 0x62, 0x20, 0xEB, 0x4E, 0xEA, 0xAC, 0xC4, 0x42, 0x22, 0x10,
  0xD5, 0x5C, 0x66, 0x90, 0xF0, 0xC0, 0x69, 0xFF, 0xCA, 0xDD, 0xB0, 0x69,
  0x87, 0x17, 0x99, 0x70, 0x69, 0xE7, 0x74, 0xF4, 0x40, 0x79, 0xD7, 0x70,
  0xCE, 0xDD, 0xD0, 0x22, 0x62, 0x2F, 0x5D, 0x5C, 0xCD, 0xEE, 0xD0, 0xC4,
  0x44, 0x30, 0xDB, 0xBB, 0xAD, 0xDD, 0x69, 0x96, 0xAD, 0xDB, 0xC0, 0x79,
  0x97, 0x10, 0xF6, 0x40, 0x7C, 0x3F, 0x4F, 0x44, 0x70, 0xDD, 0xD6, 0x95,
  0x66, 0xBB, 0xF7, 0xD6, 0x6D, 0x97, 0x62, 0x40, 0x72, 0x4F, 0x69, 0x44,
  0x98, 0xFE, 0x92, 0x39, 0x20, 0xF0,
};

const GFXglyph JetBrainsMono_ExtraBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 2, -5 },
  { 18, 2, 7, 4, 1, -6 },
  { 20, 2, 7, 4, 1, -6 },
  { 22, 4, 3, 4, 0, -4 },
  { 24, 4, 3, 4, 0, -4 },
  { 26, 2, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -3 },
  { 28, 2, 1, 4, 1, -1 },
  { 29, 4, 7, 4, 0, -6 },
  { 33, 4, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 1, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 5, 4, 1, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 3, 4, 1, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 3, 5, 4, 1, -5 },
  { 73, 4, 6, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 3, 5, 4, 1, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 3, 5, 4, 1, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 4, 6, 4, 0, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 4, 5, 4, 0, -5 },
  { 145, 4, 5, 4, 0, -5 },
  { 148, 3, 5, 4, 1, -5 },
  { 150, 2, 7, 4, 1, -6 },
  { 152, 4, 7, 4, 0, -6 },
  { 156, 2, 7, 4, 1, -6 },
  { 158, 4, 3, 4, 0, -5 },
  { 160, 4, 1, 4, 0, 0 },
  { 161, 2, 1, 4, 1, -6 },
  { 162, 4, 4, 4, 0, -4 },
  { 164, 4, 5, 4, 0, -5 },
  { 167, 4, 4, 4, 0, -4 },
  { 169, 4, 5, 4, 0, -5 },
  { 172, 4, 4, 4, 0, -4 },
  { 174, 4, 5, 4, 0, -5 },
  { 177, 4, 5, 4, 0, -4 },
  { 180, 4, 5, 4, 0, -5 },
  { 183, 4, 6, 4, 0, -6 },
  { 186, 2, 7, 4, 1, -6 },
  { 188, 4, 5, 4, 0, -5 },
  { 191, 4, 5, 4, 0, -5 },
  { 194, 4, 4, 4, 0, -4 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 4, 4, 4, 0, -4 },
  { 200, 4, 5, 4, 0, -4 },
  { 203, 4, 5, 4, 0, -4 },
  { 206, 3, 4, 4, 1, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 5, 4, 0, -5 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 4, 5, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 3, 7, 4, 1, -6 },
  { 229, 1, 7, 4, 2, -6 },
  { 230, 3, 7, 4, 1, -6 },
  { 233, 4, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_ExtraBold7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_EXTRABOLD7PT7B_H_
