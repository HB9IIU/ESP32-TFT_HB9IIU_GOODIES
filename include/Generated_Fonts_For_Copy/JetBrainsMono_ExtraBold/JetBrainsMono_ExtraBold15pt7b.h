#ifndef _JETBRAINSMONO_EXTRABOLD15PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x90, 0x1F, 0x80, 0xDE, 0xF7, 0xBD, 0x80, 0x1B, 0x09,
  0x84, 0xCF, 0xF3, 0x21, 0xB0, 0x99, 0xFE, 0x66, 0x32, 0x1B, 0x00, 0x10,
  0x21, 0xF7, 0xFD, 0x7A, 0x3C, 0x3E, 0x1E, 0x2F, 0x5F, 0xF7, 0xC2, 0x04,
  0x00, 0x71, 0xEC, 0xB6, 0x9B, 0xC7, 0xC0, 0x40, 0x7C, 0x7B, 0x2D, 0xA6,
  0xF1, 0xC0, 0x78, 0x7C, 0xCE, 0x60, 0x60, 0xF1, 0xFE, 0xDE, 0xCC, 0xFE,
  0xFF, 0xFF, 0xF4, 0x08, 0xCE, 0xE6, 0x73, 0x9C, 0xE7, 0x18, 0xC7, 0x8C,
  0x20, 0x86, 0x38, 0xE3, 0x1C, 0xE7, 0x39, 0xCC, 0x6F, 0x62, 0x00, 0x08,
  0x04, 0x1A, 0xDF, 0xF1, 0xC1, 0xB1, 0xDC, 0x44, 0x38, 0x70, 0xE7, 0xFF,
  0xE7, 0x0E, 0x1C, 0x76, 0x6C, 0xFF, 0xC0, 0xFF, 0x80, 0x06, 0x1C, 0x30,
  0xE1, 0x83, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0E, 0x18, 0x00, 0x7D, 0xFF,
  0x1E, 0x3D, 0x7F, 0xF5, 0xE3, 0xC7, 0xFD, 0xF0, 0x38, 0xF3, 0x64, 0xC1,
  0x83, 0x06, 0x0C, 0x19, 0xFF, 0xF8, 0x7D, 0xFF, 0x18, 0x30, 0xE1, 0x86,
  0x38, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0xC7, 0xC1, 0x83, 0xC7,
  0xFD, 0xF0, 0x0C, 0x30, 0xE3, 0x86, 0x1C, 0xF1, 0xFF, 0xFE, 0x0C, 0x18,
  0xFF, 0xFF, 0x06, 0x0D, 0xDF, 0xC1, 0x83, 0xC7, 0xFD, 0xF0, 0x1C, 0x70,
  0xC3, 0x0F, 0xDF, 0xF1, 0xE3, 0xC7, 0xFD, 0xF0, 0xFF, 0xFF, 0x1E, 0x70,
  0xC3, 0x86, 0x0C, 0x30, 0x61, 0xC0, 0x7D, 0xFF, 0x1E, 0x36, 0xCF, 0xBB,
  0xE3, 0xC7, 0xFD, 0xF0, 0x7D, 0xFF, 0x1E, 0x3C, 0x7F, 0xDF, 0x86, 0x18,
  0x71, 0xC0, 0xFC, 0x00, 0xBF, 0x77, 0x00, 0x00, 0x76, 0x6E, 0x02, 0x3D,
  0xF7, 0x0E, 0x0F, 0x07, 0x83, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81,
  0xE1, 0xF0, 0x70, 0xE7, 0xBC, 0x60, 0xF3, 0xE1, 0xC7, 0x7D, 0xE6, 0x18,
  0x03, 0x8E, 0x00, 0x3E, 0x3B, 0x98, 0x78, 0x3C, 0xFE, 0xCF, 0x67, 0xB3,
  0xD9, 0xE7, 0xF0, 0x0C, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x0D, 0x86, 0xC3,
  0x61, 0xB1, 0xDC, 0xFE, 0x7F, 0x31, 0xB8, 0xE0, 0xFD, 0xFF, 0x1E, 0x3F,
  0xFF, 0xB1, 0xE3, 0xC7, 0xFF, 0xF0, 0x7D, 0xFF, 0x1E, 0x0C, 0x18, 0x30,
  0x60, 0xC7, 0xFD, 0xF0, 0xFD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFF, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0xFF, 0xF8,
  0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83, 0x00, 0x7D, 0xFF,
  0x1E, 0x0C, 0x1B, 0xF7, 0xE3, 0xC7, 0xFD, 0xF0, 0xC7, 0x8F, 0x1E, 0x3F,
  0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x39, 0xFF, 0xF8, 0x1F, 0x1F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0xE7, 0x7E, 0x3C, 0xC7, 0xCE, 0xCC, 0xCC, 0xFC, 0xF8, 0xDC, 0xCC, 0xCE,
  0xC6, 0xC7, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8,
  0xC7, 0xDE, 0xAD, 0x5E, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xE7, 0xCF,
  0x9F, 0xBF, 0x7A, 0xF7, 0xEF, 0xCF, 0x9F, 0x38, 0x7D, 0xFF, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0xFD, 0xF0, 0xFC, 0xFE, 0xC6, 0xC7, 0xC6, 0xFE,
  0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x7D, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xFD, 0xF0, 0x60, 0xE0, 0xC0, 0xFD, 0xFF, 0x1E, 0x3C, 0x7F, 0xFE,
  0x66, 0xCD, 0x9F, 0x18, 0x7D, 0xFF, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC7,
  0xFD, 0xF0, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFD, 0xF0, 0xE3, 0xB1,
  0x98, 0xCC, 0x67, 0x71, 0xB0, 0xD8, 0x6C, 0x3E, 0x0E, 0x07, 0x00, 0xC9,
  0xEA, 0xF5, 0x7A, 0xA5, 0x52, 0xA9, 0x54, 0xEE, 0x77, 0x3B, 0x9D, 0xC0,
  0xE3, 0xBB, 0x8D, 0x87, 0xC1, 0xC0, 0xE0, 0x70, 0x6C, 0x36, 0x33, 0xB8,
  0xE0, 0xE3, 0xB1, 0x9D, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x00, 0xFF, 0xFC, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0xE1, 0xFF, 0xF8,
  0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC1, 0xC1, 0x83, 0x83, 0x06,
  0x0E, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0xC0, 0xFF, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFF, 0x38, 0x71, 0xB3, 0x66, 0xD8, 0xC0, 0xFF, 0xFC, 0xE7,
  0x7D, 0xDC, 0x1B, 0xFC, 0x78, 0xFF, 0xFB, 0xC1, 0x83, 0x06, 0xEF, 0xF8,
  0xF1, 0xE3, 0xC7, 0xFF, 0x70, 0x7D, 0xFF, 0x1E, 0x0C, 0x18, 0xFF, 0xBE,
  0x06, 0x0C, 0x1B, 0xBF, 0xF8, 0xF1, 0xE3, 0xC7, 0xFD, 0xD8, 0x7D, 0xDF,
  0x1F, 0xFC, 0x18, 0x3F, 0xBE, 0x1E, 0x7C, 0xC1, 0x8F, 0xFF, 0xCC, 0x18,
  0x30, 0x60, 0xC0, 0x77, 0xFF, 0x1E, 0x3C, 0x7D, 0xDF, 0x93, 0x06, 0xF9,
  0xE0, 0xC1, 0x83, 0x06, 0xEF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x18,
  0x70, 0x00, 0x0F, 0x9F, 0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x0C, 0x30,
  0x00, 0x7D, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x1F, 0xFF, 0x00, 0xC0, 0xC0,
  0xC1, 0xC6, 0xCE, 0xCC, 0xF8, 0xFC, 0xCC, 0xCE, 0xC7, 0xF8, 0xF8, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0x0F, 0xBF, 0xAF, 0x5E, 0xBD,
  0x7A, 0xF5, 0xEB, 0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x7D, 0xFF,
  0x1E, 0x3C, 0x78, 0xFF, 0xBE, 0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xFF, 0xEE,
  0xC1, 0x83, 0x00, 0x77, 0xFF, 0x1E, 0x3C, 0x78, 0xFF, 0xBB, 0x06, 0x0C,
  0x18, 0xDE, 0xEE, 0xE7, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7D, 0x9F, 0x07,
  0xE1, 0xE0, 0xFF, 0xBE, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x30,
  0x7C, 0x78, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xBE, 0xE3, 0xB1, 0x9D,
  0xC6, 0xC3, 0x61, 0xB0, 0x70, 0x38, 0xC9, 0xEA, 0xD5, 0x4A, 0xA7, 0x73,
  0xB9, 0xDC, 0xEE, 0x77, 0x1B, 0x0F, 0x83, 0x81, 0xC1, 0xB1, 0xDD, 0xC7,
  0xE3, 0xB1, 0x9D, 0xC6, 0xC3, 0x60, 0xF0, 0x70, 0x38, 0x18, 0x0C, 0x0E,
  0x00, 0xFF, 0xFC, 0x71, 0xC7, 0x0C, 0x3F, 0xFF, 0x1E, 0x3C, 0x60, 0xC1,
  0x87, 0x3C, 0x7C, 0x18, 0x30, 0x60, 0xE1, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF1, 0xE0, 0xC1, 0x83, 0x07, 0x07, 0x9F, 0x30, 0x60,
  0xC3, 0x8F, 0x18, 0x00, 0xF3, 0xE6, 0x78, 0x60,
};

const GFXglyph JetBrainsMono_ExtraBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 2, -11 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 7, 15, 9, 1, -13 },
  { 37, 9, 11, 9, 0, -11 },
  { 50, 8, 11, 9, 1, -11 },
  { 61, 3, 5, 9, 3, -11 },
  { 63, 5, 15, 9, 2, -13 },
  { 73, 5, 15, 9, 2, -13 },
  { 83, 9, 8, 9, 0, -9 },
  { 92, 7, 8, 9, 1, -9 },
  { 99, 4, 4, 9, 2, -2 },
  { 101, 5, 2, 9, 2, -6 },
  { 103, 3, 3, 9, 3, -3 },
  { 105, 7, 14, 9, 1, -12 },
  { 118, 7, 11, 9, 1, -11 },
  { 128, 7, 11, 9, 1, -11 },
  { 138, 7, 11, 9, 1, -11 },
  { 148, 7, 11, 9, 1, -11 },
  { 158, 7, 11, 9, 1, -11 },
  { 168, 7, 11, 9, 1, -11 },
  { 178, 7, 11, 9, 1, -11 },
  { 188, 7, 11, 9, 1, -11 },
  { 198, 7, 11, 9, 1, -11 },
  { 208, 7, 11, 9, 1, -11 },
  { 218, 3, 8, 9, 3, -8 },
  { 221, 4, 10, 9, 2, -8 },
  { 226, 7, 8, 9, 1, -9 },
  { 233, 7, 6, 9, 1, -8 },
  { 239, 7, 8, 9, 1, -9 },
  { 246, 6, 11, 9, 2, -11 },
  { 255, 9, 14, 9, 0, -11 },
  { 271, 9, 11, 9, 0, -11 },
  { 284, 7, 11, 9, 1, -11 },
  { 294, 7, 11, 9, 1, -11 },
  { 304, 7, 11, 9, 1, -11 },
  { 314, 7, 11, 9, 1, -11 },
  { 324, 7, 11, 9, 1, -11 },
  { 334, 7, 11, 9, 1, -11 },
  { 344, 7, 11, 9, 1, -11 },
  { 354, 7, 11, 9, 1, -11 },
  { 364, 8, 11, 9, 0, -11 },
  { 375, 8, 11, 9, 1, -11 },
  { 386, 7, 11, 9, 1, -11 },
  { 396, 7, 11, 9, 1, -11 },
  { 406, 7, 11, 9, 1, -11 },
  { 416, 7, 11, 9, 1, -11 },
  { 426, 8, 11, 9, 1, -11 },
  { 437, 7, 14, 9, 1, -11 },
  { 450, 7, 11, 9, 1, -11 },
  { 460, 7, 11, 9, 1, -11 },
  { 470, 7, 11, 9, 1, -11 },
  { 480, 7, 11, 9, 1, -11 },
  { 490, 9, 11, 9, 0, -11 },
  { 503, 9, 11, 9, 0, -11 },
  { 516, 9, 11, 9, 0, -11 },
  { 529, 9, 11, 9, 0, -11 },
  { 542, 7, 11, 9, 1, -11 },
  { 552, 4, 14, 9, 3, -12 },
  { 559, 7, 14, 9, 1, -12 },
  { 572, 4, 14, 9, 2, -12 },
  { 579, 7, 6, 9, 1, -11 },
  { 585, 7, 2, 9, 1, 0 },
  { 587, 4, 2, 9, 2, -12 },
  { 588, 7, 8, 9, 1, -8 },
  { 595, 7, 11, 9, 1, -11 },
  { 605, 7, 8, 9, 1, -8 },
  { 612, 7, 11, 9, 1, -11 },
  { 622, 7, 8, 9, 1, -8 },
  { 629, 7, 11, 9, 1, -11 },
  { 639, 7, 11, 9, 1, -8 },
  { 649, 7, 11, 9, 1, -11 },
  { 659, 7, 12, 9, 1, -12 },
  { 670, 6, 15, 9, 1, -12 },
  { 682, 8, 11, 9, 1, -11 },
  { 693, 8, 11, 9, 0, -11 },
  { 704, 7, 8, 9, 1, -8 },
  { 711, 7, 8, 9, 1, -8 },
  { 718, 7, 8, 9, 1, -8 },
  { 725, 7, 11, 9, 1, -8 },
  { 735, 7, 11, 9, 1, -8 },
  { 745, 8, 8, 9, 1, -8 },
  { 753, 7, 8, 9, 1, -8 },
  { 760, 7, 11, 9, 1, -11 },
  { 770, 7, 8, 9, 1, -8 },
  { 777, 9, 8, 9, 0, -8 },
  { 786, 9, 8, 9, 0, -8 },
  { 795, 9, 8, 9, 0, -8 },
  { 804, 9, 11, 9, 0, -8 },
  { 817, 7, 8, 9, 1, -8 },
  { 824, 7, 14, 9, 1, -12 },
  { 837, 3, 14, 9, 3, -12 },
  { 843, 7, 14, 9, 1, -12 },
  { 856, 7, 4, 9, 1, -7 },
};

const GFXfont JetBrainsMono_ExtraBold15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_EXTRABOLD15PT7B_H_
