#ifndef _JETBRAINSMONO_EXTRABOLD32PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1E, 0xF1, 0xE0, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0x70,
  0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x3C, 0x07,
  0x0F, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE3, 0x87,
  0x80, 0xE1, 0xE0, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7F, 0xC0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFF, 0x3E, 0xEF, 0x9F, 0x77, 0xCF, 0xB8, 0x07,
  0xDC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x3B, 0xE0, 0x1C, 0xFC, 0x0E, 0x7D, 0xE7, 0x3E, 0xFB,
  0xBE, 0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x04, 0x00, 0x13, 0xF0, 0x0E, 0x7F,
  0x81, 0xCF, 0x3C, 0x3C, 0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0xE1, 0xCE, 0x0F,
  0x1D, 0xE0, 0x7F, 0xDC, 0x07, 0xFB, 0x80, 0x3F, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x20, 0x03, 0xDF, 0x80, 0x3B, 0xFC, 0x07, 0x79,
  0xE0, 0xE7, 0x0E, 0x1E, 0x70, 0xE1, 0xC7, 0x0E, 0x38, 0x78, 0xE7, 0x83,
  0xFE, 0x70, 0x3F, 0xCE, 0x01, 0xF8, 0x01, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3E, 0x3E, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC7, 0xBE,
  0xF3, 0xEF, 0xBE, 0xF3, 0xE7, 0xFC, 0xF8, 0xFE, 0x3E, 0x3F, 0x8F, 0x87,
  0xC3, 0xE1, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x78, 0x00, 0x60, 0x3C, 0x1F, 0x87, 0xF1,
  0xFE, 0x7F, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x87, 0xF0, 0x7E, 0x03, 0xC0,
  0x18, 0x80, 0x38, 0x0F, 0x83, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x1F, 0x9F, 0xCF, 0xE3, 0xF0,
  0xF8, 0x38, 0x08, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x04, 0x1C, 0x13, 0x8E, 0x3B, 0xF7, 0x7F, 0xFD, 0x7F, 0xFF, 0xFF, 0x83,
  0xF8, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0xF9, 0xE0, 0xF8, 0xF8,
  0x3C, 0x3C, 0x0C, 0x18, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x8F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0xEF, 0xFF, 0x07,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xCE, 0x7F, 0xBE, 0xFF,
  0x7D, 0xFE, 0x7B, 0xFC, 0x47, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xF7, 0xFF, 0xEF, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0x07, 0xE0,
  0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF3, 0xE0, 0xE3, 0xE0,
  0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x03, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x07, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0xFF, 0xE1, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7B, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xF7, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF,
  0xC7, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x7E, 0x1F, 0x7F, 0x8F, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xFB, 0xE0,
  0x3F, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDF, 0x07, 0xCF, 0xFF, 0xE3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xFC, 0xFE, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0x7C, 0x7C, 0x3F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7C,
  0x7E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFF,
  0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xBC, 0x07, 0xDF, 0x07, 0xEF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFE,
  0xF8, 0x3E, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x38, 0xFB,
  0xFF, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0xFF,
  0x7E, 0xF8, 0x1C, 0x3E, 0x7F, 0x7F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xF0,
  0xF0, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xFC,
  0x3F, 0xE0, 0x7F, 0x00, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xF0, 0x03,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00,
  0x1E, 0x01, 0xFC, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x3F, 0x80,
  0x7C, 0x00, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0x03, 0xF0,
  0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0x83,
  0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0xF3, 0xFC,
  0x7E, 0xFF, 0x1F, 0xFF, 0xCF, 0x1F, 0xF3, 0xC3, 0xFC, 0xF0, 0xFF, 0x3C,
  0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0xF0, 0xFF, 0x3C, 0x7F, 0xCF, 0xFF,
  0xF1, 0xFB, 0xFC, 0x3E, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0x9E, 0x07, 0x8F, 0x03, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0x03, 0xCF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E,
  0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xC0,
  0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1E,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x1E,
  0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x1F,
  0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xFF, 0xF9, 0xFF, 0xF9,
  0xFF, 0xF9, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFC,
  0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E,
  0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF9, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xF9, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xB1, 0xFF,
  0xDD, 0xDF, 0xEE, 0xEF, 0xF7, 0x77, 0xF9, 0xFB, 0xFC, 0xF9, 0xFF, 0x7C,
  0xFF, 0xBE, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0xC7, 0xFB, 0x8F, 0xF7, 0x1F, 0xEF, 0x3F, 0xCE, 0x7F, 0x9C, 0xFF, 0x3D,
  0xFE, 0x3B, 0xFC, 0x77, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xDF, 0xC3, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0x80, 0x03, 0x80, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xEF, 0xEF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xF7, 0xFF, 0xEF,
  0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFE,
  0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x1F, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xF3,
  0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x07, 0xDE, 0x03, 0xEF, 0x83, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF0, 0xFB, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x03, 0xFC,
  0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x81, 0xE7, 0xC0, 0xF3,
  0xE0, 0xF9, 0xF0, 0x7C, 0x78, 0x3C, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F,
  0x78, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0xF0, 0xF1, 0xFE, 0x1E, 0x3D, 0xC7, 0xC7, 0xBC, 0xF8, 0xF7,
  0x9B, 0x1C, 0xF3, 0x67, 0x9E, 0x6C, 0xF3, 0xCD, 0x9E, 0x79, 0xB3, 0xCF,
  0x37, 0x79, 0xE6, 0xEF, 0x3D, 0xDD, 0xE3, 0xBB, 0xBC, 0x77, 0x37, 0x8E,
  0xC6, 0xE1, 0xD8, 0xDC, 0x3B, 0x1B, 0x87, 0xE3, 0x70, 0xFC, 0x6E, 0x1F,
  0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x0F, 0x9F,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x1F, 0x7C, 0x0F,
  0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0x7C, 0x7C, 0x1F, 0x3F, 0x03, 0xEF, 0x80,
  0xFC, 0xFC, 0x07, 0xEF, 0x80, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC1, 0xF0,
  0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x00, 0xF7,
  0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xEF, 0x03, 0xDE, 0x0F,
  0x9E, 0x1E, 0x3C, 0x7C, 0x7C, 0xF0, 0x79, 0xE0, 0xFF, 0xC1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xC3, 0xFF, 0x07, 0xC0, 0x0F,
  0x81, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x1F, 0xFF, 0xEF, 0x7F, 0xDE, 0x7F, 0x3C, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x3E, 0x3E, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x7F, 0xBE, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x83, 0xFF, 0x87, 0xDF, 0xFF, 0xBF, 0xFE, 0x3F,
  0xF8, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE1, 0xE7, 0xCF, 0xEF, 0xBF, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xFF, 0xF7, 0xFF, 0xE7, 0xFF, 0xC7, 0xEF, 0x80, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0x83, 0xFF, 0x07, 0xFE, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x07, 0xDF, 0xBF, 0xBF, 0xFE, 0x3F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x3E, 0x7F, 0x7D, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0xFF, 0xDF, 0xFF, 0x9F, 0xDF, 0x1F,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE,
  0x0F, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x3E, 0x3E, 0xFE, 0x7F, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xBF, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F,
  0xE3, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0xFB, 0xE0, 0xFD, 0xF0, 0x7C, 0xF8, 0x7E, 0x7C, 0x3E,
  0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0xCF, 0x83, 0xE7,
  0xC1, 0xFB, 0xE0, 0x7E, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0xF3, 0x8E, 0x7B, 0xEF, 0xBF, 0xFF, 0xFF,
  0x7D, 0xFF, 0x9C, 0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7,
  0xF8, 0xE3, 0xFC, 0x71, 0xFE, 0x38, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7,
  0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xC0, 0xF9, 0xF1, 0xF7, 0xF3,
  0xFF, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7C, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xEF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xDF, 0xFF, 0xBF, 0xFE,
  0x3F, 0xF8, 0x1F, 0xE0, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xFD,
  0xF3, 0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x0F, 0x3E, 0x7F, 0x7D, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF1, 0xF1,
  0xEF, 0xF3, 0xDF, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x1F,
  0xFE, 0x7E, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xDF, 0xFF, 0xBF, 0xFE,
  0x3F, 0xF8, 0x1F, 0xE0, 0xF8, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x81,
  0xE7, 0xC1, 0xF1, 0xE0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x1E, 0x3E, 0x0F,
  0x9E, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0xE1, 0xFE, 0x1C, 0x3D,
  0xC3, 0xC7, 0xBC, 0xF8, 0xE7, 0x9F, 0x1C, 0xF3, 0x67, 0x9E, 0x6C, 0xF3,
  0xCD, 0x9E, 0x79, 0xB3, 0xC7, 0x37, 0x78, 0xEE, 0xEE, 0x1F, 0xCD, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x83,
  0xE3, 0xE0, 0xFC, 0x0F, 0xBE, 0x0F, 0x8F, 0x8F, 0xC7, 0xE7, 0xC1, 0xF7,
  0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFF, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0xF8, 0xF8, 0xFC, 0x7E,
  0x7C, 0x1F, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x03, 0xEF,
  0x83, 0xE7, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0xBE, 0x03, 0xDF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3C, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xC3, 0xDF, 0xF1, 0xFF, 0x7C, 0xFF, 0x1F, 0xFF, 0x87,
  0xFB, 0xC3, 0xFC, 0x00, 0x78,
};

const GFXglyph JetBrainsMono_ExtraBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 12, 9, 19, 4, -23 },
  { 30, 18, 23, 19, 1, -23 },
  { 82, 17, 32, 19, 1, -28 },
  { 150, 20, 24, 19, 0, -24 },
  { 210, 18, 24, 19, 1, -24 },
  { 264, 5, 9, 19, 7, -23 },
  { 270, 11, 31, 19, 5, -27 },
  { 313, 10, 31, 19, 4, -27 },
  { 352, 17, 17, 19, 1, -20 },
  { 389, 15, 15, 19, 2, -18 },
  { 418, 9, 10, 19, 4, -5 },
  { 430, 11, 5, 19, 4, -13 },
  { 437, 7, 6, 19, 6, -6 },
  { 443, 16, 31, 19, 2, -27 },
  { 505, 15, 24, 19, 2, -24 },
  { 550, 16, 23, 19, 2, -23 },
  { 596, 15, 24, 19, 2, -24 },
  { 641, 15, 23, 19, 2, -23 },
  { 685, 15, 23, 19, 2, -23 },
  { 729, 15, 23, 19, 2, -23 },
  { 773, 17, 23, 19, 1, -23 },
  { 822, 17, 23, 19, 1, -23 },
  { 871, 16, 24, 19, 2, -24 },
  { 919, 17, 24, 19, 1, -24 },
  { 970, 7, 18, 19, 6, -18 },
  { 986, 8, 23, 19, 5, -18 },
  { 1009, 15, 17, 19, 2, -19 },
  { 1041, 14, 13, 19, 3, -17 },
  { 1064, 15, 17, 19, 2, -19 },
  { 1096, 12, 23, 19, 4, -23 },
  { 1131, 18, 30, 19, 1, -24 },
  { 1199, 17, 23, 19, 1, -23 },
  { 1248, 16, 23, 19, 2, -23 },
  { 1294, 16, 24, 19, 2, -24 },
  { 1342, 16, 23, 19, 2, -23 },
  { 1388, 14, 23, 19, 3, -23 },
  { 1429, 15, 23, 19, 2, -23 },
  { 1473, 16, 24, 19, 2, -24 },
  { 1521, 15, 23, 19, 2, -23 },
  { 1565, 14, 23, 19, 3, -23 },
  { 1606, 16, 23, 19, 1, -23 },
  { 1652, 16, 23, 19, 2, -23 },
  { 1698, 14, 23, 19, 3, -23 },
  { 1739, 17, 23, 19, 1, -23 },
  { 1788, 15, 23, 19, 2, -23 },
  { 1832, 15, 24, 19, 2, -24 },
  { 1877, 16, 23, 19, 2, -23 },
  { 1923, 16, 30, 19, 2, -24 },
  { 1983, 16, 23, 19, 2, -23 },
  { 2029, 17, 24, 19, 1, -24 },
  { 2080, 17, 23, 19, 1, -23 },
  { 2129, 15, 23, 19, 2, -23 },
  { 2173, 17, 23, 19, 1, -23 },
  { 2222, 19, 23, 19, 0, -23 },
  { 2277, 18, 23, 19, 1, -23 },
  { 2329, 19, 23, 19, 0, -23 },
  { 2384, 15, 23, 19, 2, -23 },
  { 2428, 10, 31, 19, 5, -27 },
  { 2467, 16, 31, 19, 2, -27 },
  { 2529, 10, 31, 19, 4, -27 },
  { 2568, 15, 12, 19, 2, -23 },
  { 2591, 15, 4, 19, 2, 1 },
  { 2599, 8, 4, 19, 5, -25 },
  { 2603, 15, 18, 19, 2, -18 },
  { 2637, 15, 23, 19, 2, -23 },
  { 2681, 15, 18, 19, 2, -18 },
  { 2715, 15, 23, 19, 2, -23 },
  { 2759, 15, 18, 19, 2, -18 },
  { 2793, 15, 23, 19, 2, -23 },
  { 2837, 15, 24, 19, 2, -18 },
  { 2882, 15, 23, 19, 2, -23 },
  { 2926, 16, 25, 19, 2, -25 },
  { 2976, 13, 31, 19, 3, -25 },
  { 3027, 17, 23, 19, 2, -23 },
  { 3076, 17, 23, 19, 1, -23 },
  { 3125, 17, 18, 19, 1, -18 },
  { 3164, 15, 18, 19, 2, -18 },
  { 3198, 15, 18, 19, 2, -18 },
  { 3232, 15, 24, 19, 2, -18 },
  { 3277, 15, 24, 19, 2, -18 },
  { 3322, 15, 18, 19, 3, -18 },
  { 3356, 16, 18, 19, 2, -18 },
  { 3392, 16, 23, 19, 1, -23 },
  { 3438, 15, 18, 19, 2, -18 },
  { 3472, 17, 18, 19, 1, -18 },
  { 3511, 19, 18, 19, 0, -18 },
  { 3554, 17, 18, 19, 1, -18 },
  { 3593, 17, 24, 19, 1, -18 },
  { 3644, 15, 18, 19, 2, -18 },
  { 3678, 15, 31, 19, 2, -27 },
  { 3737, 5, 31, 19, 7, -27 },
  { 3757, 15, 31, 19, 2, -27 },
  { 3816, 17, 8, 19, 1, -15 },
};

const GFXfont JetBrainsMono_ExtraBold32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_EXTRABOLD32PT7B_H_
