#ifndef _JETBRAINSMONO_EXTRABOLD23PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0x60, 0x00, 0xFF, 0xF0, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x0E, 0x30, 0x71, 0x83, 0x9C, 0x18, 0xE7,
  0xFF, 0xBF, 0xFC, 0x71, 0x83, 0x8C, 0x18, 0xE0, 0xC7, 0x06, 0x31, 0xFF,
  0xFF, 0xFF, 0x9C, 0xE0, 0xC7, 0x06, 0x38, 0x31, 0x80, 0x06, 0x00, 0x60,
  0x06, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0xF6, 0xEF, 0x6E, 0xF6, 0x07, 0xE0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x06, 0xFF, 0x6F, 0xF6, 0xF7, 0xFE,
  0x7F, 0xE1, 0xF8, 0x06, 0x00, 0x60, 0x06, 0x00, 0x38, 0x0D, 0xF8, 0x6E,
  0x63, 0x39, 0x9C, 0xE6, 0x63, 0x9B, 0x07, 0xFC, 0x0E, 0x60, 0x03, 0x00,
  0x19, 0x80, 0xFF, 0x83, 0x66, 0x19, 0x9C, 0xE6, 0x77, 0x19, 0xD8, 0x7E,
  0xC0, 0xF0, 0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x1C, 0x70, 0x27, 0x00, 0x38,
  0x07, 0xC0, 0xFC, 0x0E, 0xE7, 0xEF, 0xEE, 0x7E, 0xE3, 0xCE, 0x1C, 0xFF,
  0xE7, 0xFE, 0x3E, 0x70, 0xFF, 0xFF, 0xFE, 0xE0, 0x06, 0x3C, 0xFB, 0xE7,
  0x9E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF0, 0xF0,
  0xF8, 0xF0, 0xE0, 0x40, 0xC1, 0xE3, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0xFB, 0xE7, 0x8E, 0x10, 0x00,
  0x0E, 0x00, 0xE0, 0x06, 0x0E, 0x66, 0xF6, 0xFF, 0xFF, 0x06, 0x00, 0xF0,
  0x1B, 0x83, 0x9C, 0x79, 0xE1, 0x08, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0xE7, 0x9E, 0x71, 0xCE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x1F, 0x87, 0xF9, 0xFF, 0xB8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xB7, 0xFF, 0xFE, 0xDF, 0xC3, 0xF8, 0x7F,
  0x0E, 0xE1, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0x1F, 0x07, 0xE3, 0xFC, 0x7F,
  0x8E, 0xF1, 0x1E, 0x23, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x87, 0xF9, 0xFF, 0xF8,
  0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x1F, 0xFB, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFD, 0xFF, 0x80,
  0xE0, 0x38, 0x1E, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0x3C, 0x03, 0x80, 0x7F,
  0x0F, 0xE1, 0xDF, 0xFB, 0xFE, 0x1F, 0x80, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC7, 0x78, 0xFE, 0x1F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x7F, 0xEF, 0xFD, 0xFF, 0xB8,
  0x07, 0x00, 0xE0, 0x1D, 0xE3, 0xFF, 0x7F, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0xE1, 0xDF, 0xFB, 0xFE, 0x1F, 0x80, 0x07, 0x80, 0x70, 0x0F, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0xFC, 0x7F, 0xEF, 0x9E, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFF, 0x0F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x00, 0x1F,
  0x83, 0xFC, 0x7F, 0xE7, 0x1E, 0xF0, 0xE7, 0x0E, 0x79, 0xE3, 0xFC, 0x1F,
  0x87, 0xFC, 0x71, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0x7F, 0xE7, 0xFE, 0x1F,
  0x80, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0E, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x1F, 0x7F, 0xE3, 0xFE, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xE0, 0x1E, 0x00, 0xEF, 0xFF, 0x00, 0x00, 0x0E, 0xFF, 0xF0, 0x38, 0xF3,
  0xCF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCE, 0x79, 0xE7, 0x1C, 0xE0, 0x00,
  0x40, 0x70, 0x7C, 0xFE, 0xFE, 0x3E, 0x0C, 0x03, 0xE0, 0x7E, 0x07, 0xF0,
  0x7C, 0x07, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0x1F, 0xC1, 0xF0,
  0x1C, 0x1F, 0x3F, 0xBF, 0x8F, 0x83, 0x80, 0x80, 0x00, 0xF8, 0x7F, 0x3F,
  0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0xFE, 0x7F, 0x3E, 0x1C, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0xF0, 0x70, 0x00, 0x1F, 0x83, 0xFE, 0x79, 0xFE, 0x07, 0xE0,
  0x7C, 0x03, 0xC7, 0xBC, 0xFF, 0xCE, 0x7C, 0xE3, 0xCE, 0x3C, 0xE3, 0xCE,
  0x3C, 0xE7, 0xC7, 0xBC, 0x33, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0xF0, 0x1F,
  0x00, 0x0F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x39, 0xC3,
  0x9C, 0x39, 0xC7, 0x9C, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0x0E, 0xF0, 0xFE,
  0x0F, 0xE0, 0x70, 0xFE, 0x1F, 0xF3, 0xFF, 0x71, 0xEE, 0x1F, 0xC3, 0xB8,
  0xF7, 0xFC, 0xFF, 0x1F, 0xFB, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xF7,
  0xFE, 0xFF, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xF7, 0x0E,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0xF0, 0xF7, 0x0E,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x8F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xF0, 0xF7, 0x0F, 0x7F, 0xE3,
  0xFE, 0x1F, 0x80, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C,
  0xF3, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF3, 0xCF, 0x3C, 0xF1, 0xCF, 0x1E,
  0xF1, 0xEF, 0x0F, 0xF0, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0xB7,
  0xEF, 0x7E, 0xF7, 0xEF, 0x7E, 0xE7, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xF8, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xCF,
  0xD9, 0xFB, 0xBF, 0x77, 0xE6, 0xFC, 0xFF, 0x9D, 0xF1, 0xBE, 0x3F, 0xC7,
  0xF8, 0x7F, 0x0F, 0xE1, 0xE0, 0x1F, 0x87, 0xF9, 0xFF, 0xB8, 0xFF, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0xE1,
  0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xF3, 0xFF, 0x71, 0xFE, 0x1F,
  0xC1, 0xF8, 0x7F, 0x0F, 0xFF, 0xDF, 0xF3, 0xFC, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x1E, 0xF0,
  0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0,
  0xE7, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x38, 0xF3, 0xCF, 0x1C, 0xF1, 0xEF,
  0x0E, 0xF0, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0E, 0xF0, 0xEF, 0x00,
  0x78, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x01, 0xE0, 0x0F, 0xF0, 0xFF, 0x0F,
  0x7F, 0xE7, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0E, 0xE1, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0xE0, 0x7E, 0x0F, 0xF0, 0xFF,
  0x0E, 0x70, 0xE7, 0x0E, 0x79, 0xE7, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC3,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xE3, 0x1F, 0x9C,
  0x6E, 0x71, 0x99, 0xEE, 0x67, 0xB9, 0x9E, 0xE7, 0x7B, 0x9D, 0x6E, 0x75,
  0xB9, 0xD2, 0xE7, 0xCB, 0x9F, 0x2C, 0x7C, 0xF1, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x38, 0xF0, 0x78, 0x7B, 0xC3, 0x8F, 0x3C, 0x79, 0xC1, 0xFE, 0x07,
  0xE0, 0x3F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x81, 0xDE,
  0x1E, 0x78, 0xE3, 0xCF, 0x0F, 0xF0, 0x78, 0xF0, 0x3B, 0x83, 0xDE, 0x1C,
  0x70, 0xE3, 0xCF, 0x0E, 0x70, 0x7F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x01,
  0xE0, 0x7E, 0x0F, 0xC3, 0xB8, 0x73, 0x8E, 0x73, 0x87, 0xF0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x70, 0x78, 0x0F, 0x07, 0xF9, 0xFF, 0xB8,
  0x70, 0x0E, 0x1F, 0xDF, 0xFB, 0xC7, 0xF0, 0xFE, 0x1F, 0xE7, 0xBF, 0xF3,
  0xEE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x3F, 0xEF, 0xFF, 0xCF, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xEF, 0x80, 0x0F,
  0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x17, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x71, 0xCE, 0x7D, 0xDF, 0xFB, 0xCF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE3, 0xDF, 0xFB, 0xFF, 0x3E, 0xE0, 0x0F, 0x07, 0xF9, 0xFF, 0xB8,
  0x7F, 0x0F, 0xE3, 0xFF, 0xFF, 0x80, 0xF0, 0x0E, 0x01, 0xE7, 0x9F, 0xE1,
  0xF8, 0x03, 0xF0, 0xFF, 0x0F, 0xF0, 0xE0, 0x1E, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0x1C, 0xE7, 0xDD, 0xFF, 0xBC, 0xFF, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xEF, 0xFD, 0xFF, 0x9F, 0x70, 0x0E, 0x01, 0xCF, 0xF9,
  0xFE, 0x3F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE7, 0x3F, 0xEF, 0xFF,
  0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xC0, 0x0E, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0xFF, 0x7F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF,
  0xEF, 0xF7, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xC3, 0xF8,
  0xF7, 0x1C, 0xE7, 0x9F, 0xE3, 0xFC, 0x7F, 0x8E, 0x79, 0xC7, 0x38, 0xF7,
  0x0E, 0xE1, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0xEC, 0xEF, 0xFE, 0xFF, 0xFE, 0x67, 0xE6,
  0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6,
  0x70, 0xE7, 0x3F, 0xEF, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x0F, 0x07, 0xF9, 0xFF, 0xBC, 0xFF,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xEE, 0x1D, 0xFF, 0x9F, 0xE1, 0xF8,
  0xEF, 0x3F, 0xEF, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7F, 0xFF, 0xFF, 0xEF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0xE7,
  0xDD, 0xFF, 0xBC, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3D,
  0xFF, 0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xE7, 0x9D,
  0xFB, 0xFF, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0x1F, 0x87, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0x07,
  0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x0F, 0xF9, 0xE7, 0xFE, 0x3F, 0xC0,
  0x1E, 0x03, 0xC0, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xC3, 0xF8, 0x3F, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xEE, 0x3D,
  0xFF, 0x9F, 0xE1, 0xF8, 0xE0, 0x7F, 0x0F, 0xF0, 0xE7, 0x0E, 0x71, 0xE7,
  0x9E, 0x39, 0xC3, 0x9C, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00,
  0xE3, 0x1F, 0x8C, 0x66, 0x71, 0x99, 0xEE, 0x77, 0xB9, 0xDE, 0xE7, 0x5B,
  0x9D, 0x2E, 0x7C, 0xB0, 0xF2, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF0,
  0xF7, 0x1E, 0x79, 0xC3, 0xFC, 0x1F, 0x81, 0xF0, 0x0F, 0x01, 0xF8, 0x1F,
  0x83, 0xFC, 0x79, 0xE7, 0x1E, 0xF0, 0xF0, 0xE0, 0x7F, 0x0F, 0xF0, 0xE7,
  0x0E, 0x79, 0xE3, 0x9C, 0x39, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xC1, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xF0, 0x3C,
  0x0F, 0x3F, 0x8F, 0xC3, 0xF8, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x0F, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x07, 0xF0, 0xFC, 0x7F, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x0F, 0xC3, 0xE0, 0xF8, 0x30, 0x00, 0x7C, 0x0F, 0xE7,
  0xFE, 0x7E, 0x7F, 0xE7, 0xE0, 0x1C,
};

const GFXglyph JetBrainsMono_ExtraBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 8, 7, 14, 3, -17 },
  { 17, 13, 17, 14, 0, -17 },
  { 45, 12, 23, 14, 1, -20 },
  { 80, 14, 17, 14, 0, -17 },
  { 110, 12, 17, 14, 1, -17 },
  { 136, 4, 7, 14, 5, -17 },
  { 140, 7, 22, 14, 4, -19 },
  { 160, 7, 22, 14, 3, -19 },
  { 180, 12, 12, 14, 1, -14 },
  { 198, 12, 11, 14, 1, -13 },
  { 215, 6, 7, 14, 3, -3 },
  { 221, 8, 3, 14, 3, -9 },
  { 224, 4, 4, 14, 5, -4 },
  { 226, 12, 22, 14, 1, -19 },
  { 259, 11, 17, 14, 1, -17 },
  { 283, 11, 17, 14, 2, -17 },
  { 307, 11, 17, 14, 1, -17 },
  { 331, 11, 17, 14, 1, -17 },
  { 355, 11, 17, 14, 1, -17 },
  { 379, 11, 17, 14, 1, -17 },
  { 403, 12, 17, 14, 1, -17 },
  { 429, 12, 17, 14, 1, -17 },
  { 455, 12, 17, 14, 1, -17 },
  { 481, 12, 17, 14, 1, -17 },
  { 507, 4, 13, 14, 5, -13 },
  { 514, 6, 17, 14, 3, -13 },
  { 527, 10, 13, 14, 2, -14 },
  { 544, 10, 9, 14, 2, -12 },
  { 556, 10, 13, 14, 2, -14 },
  { 573, 9, 17, 14, 3, -17 },
  { 593, 12, 21, 14, 1, -17 },
  { 625, 12, 17, 14, 1, -17 },
  { 651, 11, 17, 14, 2, -17 },
  { 675, 12, 17, 14, 1, -17 },
  { 701, 12, 17, 14, 1, -17 },
  { 727, 10, 17, 14, 2, -17 },
  { 749, 10, 17, 14, 2, -17 },
  { 771, 12, 17, 14, 1, -17 },
  { 797, 10, 17, 14, 2, -17 },
  { 819, 10, 17, 14, 2, -17 },
  { 841, 12, 17, 14, 0, -17 },
  { 867, 12, 17, 14, 1, -17 },
  { 893, 10, 17, 14, 2, -17 },
  { 915, 12, 17, 14, 1, -17 },
  { 941, 11, 17, 14, 1, -17 },
  { 965, 11, 17, 14, 1, -17 },
  { 989, 11, 17, 14, 2, -17 },
  { 1013, 12, 21, 14, 1, -17 },
  { 1045, 12, 17, 14, 1, -17 },
  { 1071, 12, 17, 14, 1, -17 },
  { 1097, 12, 17, 14, 1, -17 },
  { 1123, 11, 17, 14, 1, -17 },
  { 1147, 12, 17, 14, 1, -17 },
  { 1173, 14, 17, 14, 0, -17 },
  { 1203, 13, 17, 14, 0, -17 },
  { 1231, 13, 17, 14, 0, -17 },
  { 1259, 10, 17, 14, 2, -17 },
  { 1281, 7, 22, 14, 4, -19 },
  { 1301, 12, 22, 14, 1, -19 },
  { 1334, 7, 22, 14, 3, -19 },
  { 1354, 11, 9, 14, 1, -17 },
  { 1367, 11, 3, 14, 1, 1 },
  { 1372, 7, 3, 14, 3, -18 },
  { 1375, 11, 13, 14, 1, -13 },
  { 1393, 10, 17, 14, 2, -17 },
  { 1415, 12, 13, 14, 1, -13 },
  { 1435, 11, 17, 14, 1, -17 },
  { 1459, 11, 13, 14, 1, -13 },
  { 1477, 12, 17, 14, 1, -17 },
  { 1503, 11, 17, 14, 1, -13 },
  { 1527, 10, 17, 14, 2, -17 },
  { 1549, 11, 18, 14, 2, -18 },
  { 1574, 9, 22, 14, 2, -18 },
  { 1599, 11, 17, 14, 2, -17 },
  { 1623, 12, 17, 14, 1, -17 },
  { 1649, 12, 13, 14, 1, -13 },
  { 1669, 10, 13, 14, 2, -13 },
  { 1686, 11, 13, 14, 1, -13 },
  { 1704, 10, 17, 14, 2, -13 },
  { 1726, 11, 17, 14, 1, -13 },
  { 1750, 11, 13, 14, 2, -13 },
  { 1768, 12, 13, 14, 1, -13 },
  { 1788, 11, 16, 14, 1, -16 },
  { 1810, 11, 13, 14, 1, -13 },
  { 1828, 12, 13, 14, 1, -13 },
  { 1848, 14, 13, 14, 0, -13 },
  { 1871, 12, 13, 14, 1, -13 },
  { 1891, 12, 17, 14, 1, -13 },
  { 1917, 10, 13, 14, 2, -13 },
  { 1934, 10, 22, 14, 2, -19 },
  { 1962, 4, 22, 14, 5, -19 },
  { 1973, 10, 22, 14, 2, -19 },
  { 2001, 12, 6, 14, 1, -11 },
};

const GFXfont JetBrainsMono_ExtraBold23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_EXTRABOLD23PT7B_H_
