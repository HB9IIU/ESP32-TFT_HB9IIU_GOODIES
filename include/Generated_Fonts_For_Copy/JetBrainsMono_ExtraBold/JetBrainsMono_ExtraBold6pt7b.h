#ifndef _JETBRAINSMONO_EXTRABOLD6PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0xEF, 0xD0, 0x55, 0x1E, 0x80, 0xFA, 0x6B, 0xEA, 0xF0,
  0x80, 0x6A, 0x90, 0x95, 0xA0, 0x55, 0xA0, 0x5C, 0xC0, 0xC0, 0x80, 0x25,
  0x25, 0x00, 0xFE, 0xB0, 0xE4, 0xF0, 0xE5, 0x70, 0x6C, 0xF0, 0x6F, 0x90,
  0xFC, 0xF0, 0x7E, 0xB0, 0xE5, 0x20, 0xEE, 0xB0, 0xFC, 0xA0, 0xA0, 0xB0,
  0x2B, 0x10, 0xFC, 0x8D, 0xC0, 0xFA, 0xFF, 0xD4, 0x6D, 0xD0, 0xFE, 0xF0,
  0xF2, 0x30, 0xF6, 0xF0, 0xFE, 0x70, 0xFE, 0x40, 0xF2, 0xB0, 0xBE, 0xD0,
  0xE9, 0x70, 0x64, 0xF0, 0xBE, 0xD0, 0xAB, 0xFE, 0xD0, 0xFE, 0xD0, 0xF6,
  0xB0, 0xF7, 0x40, 0xF6, 0xB2, 0xFE, 0xD0, 0xE8, 0xF0, 0xE9, 0x20, 0xB6,
  0xB0, 0xAD, 0xA0, 0xDD, 0xEA, 0xE9, 0xD0, 0xB6, 0x44, 0xE9, 0x70, 0xEA,
  0xB0, 0x89, 0x12, 0x40, 0xD5, 0x70, 0x74, 0xE0, 0xC0, 0xFF, 0x80, 0x9E,
  0xF0, 0xF1, 0x80, 0x3E, 0xB0, 0xFD, 0x80, 0x7D, 0x20, 0xF5, 0xB0, 0x9E,
  0xD0, 0x41, 0x2E, 0x21, 0x93, 0xC0, 0x97, 0xD0, 0xC9, 0x30, 0xFF, 0x80,
  0xF6, 0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF5, 0x90, 0xF2, 0x00, 0xEF, 0x80,
  0x5D, 0x30, 0xB5, 0x80, 0xAD, 0x80, 0xDE, 0xE0, 0xEA, 0x80, 0xAD, 0x20,
  0xEB, 0x80, 0x27, 0x12, 0x40, 0xFC, 0xC9, 0xA5, 0x80, 0xE4,
};

const GFXglyph JetBrainsMono_ExtraBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 2, 6, 4, 1, -5 },
  { 17, 3, 4, 4, 0, -4 },
  { 19, 3, 2, 4, 0, -3 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 3, 6, 4, 0, -5 },
  { 26, 3, 4, 4, 0, -4 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 3, 4, 4, 0, -4 },
  { 40, 3, 4, 4, 0, -4 },
  { 42, 3, 4, 4, 0, -4 },
  { 44, 3, 4, 4, 0, -4 },
  { 46, 1, 3, 4, 1, -3 },
  { 47, 1, 4, 4, 1, -3 },
  { 48, 3, 4, 4, 0, -4 },
  { 50, 3, 2, 4, 0, -3 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 2, 4, 4, 1, -4 },
  { 54, 3, 5, 4, 0, -4 },
  { 56, 3, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 2, 4, 4, 1, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 3, 4, 4, 0, -4 },
  { 87, 3, 5, 4, 0, -4 },
  { 89, 3, 4, 4, 0, -4 },
  { 91, 3, 4, 4, 0, -4 },
  { 93, 3, 4, 4, 0, -4 },
  { 95, 3, 4, 4, 0, -4 },
  { 97, 3, 4, 4, 0, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 3, 4, 4, 0, -4 },
  { 103, 4, 4, 4, 0, -4 },
  { 105, 3, 4, 4, 0, -4 },
  { 107, 2, 6, 4, 1, -5 },
  { 109, 3, 6, 4, 0, -5 },
  { 112, 2, 6, 4, 1, -5 },
  { 114, 3, 2, 4, 0, -4 },
  { 115, 3, 1, 4, 0, 0 },
  { 116, 2, 1, 4, 1, -5 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 3, 4, 4, 0, -4 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 4, 4, 0, -4 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 3, 4, 4, 0, -4 },
  { 129, 3, 4, 4, 0, -3 },
  { 131, 3, 4, 4, 0, -4 },
  { 133, 3, 5, 4, 0, -5 },
  { 135, 3, 6, 4, 0, -5 },
  { 138, 3, 4, 4, 0, -4 },
  { 140, 3, 4, 4, 0, -4 },
  { 142, 3, 3, 4, 0, -3 },
  { 144, 3, 3, 4, 0, -3 },
  { 146, 3, 3, 4, 0, -3 },
  { 148, 3, 4, 4, 0, -3 },
  { 150, 3, 4, 4, 0, -3 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 3, 4, 4, 0, -4 },
  { 158, 3, 3, 4, 0, -3 },
  { 160, 3, 3, 4, 0, -3 },
  { 162, 4, 3, 4, 0, -3 },
  { 164, 3, 3, 4, 0, -3 },
  { 166, 3, 4, 4, 0, -3 },
  { 168, 3, 3, 4, 0, -3 },
  { 170, 3, 6, 4, 0, -5 },
  { 173, 1, 6, 4, 1, -5 },
  { 174, 3, 6, 4, 0, -5 },
  { 177, 3, 2, 4, 0, -3 },
};

const GFXfont JetBrainsMono_ExtraBold6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_EXTRABOLD6PT7B_H_
