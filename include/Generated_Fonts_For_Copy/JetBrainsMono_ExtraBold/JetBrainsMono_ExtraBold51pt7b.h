#ifndef _JETBRAINSMONO_EXTRABOLD51PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xBF, 0x83, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x9F, 0xF7, 0xBF, 0xE7, 0xF9, 0xE7, 0xF9, 0xFE,
  0x78, 0xFF, 0x7F, 0x9E, 0x3F, 0xDF, 0xE7, 0x80, 0x07, 0xF9, 0xE0, 0x01,
  0xFF, 0x78, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xE7, 0xFC, 0x00, 0x78, 0xFF, 0x00, 0x1E, 0x3F, 0xC0, 0x07, 0x87,
  0xFF, 0xF1, 0xE3, 0xFF, 0xFC, 0x78, 0xFF, 0x7F, 0x9E, 0x3F, 0xDF, 0xFF,
  0xBF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0x0F, 0xFE, 0x00, 0x3E, 0x1F, 0xFF, 0x00, 0x7C, 0x3F, 0xFF, 0x00, 0xFC,
  0x3E, 0x1F, 0x80, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x83, 0xF0,
  0x3E, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x8F, 0x80,
  0x3E, 0x0F, 0x9F, 0x80, 0x3E, 0x1F, 0x9F, 0x00, 0x3F, 0xFF, 0x3E, 0x00,
  0x1F, 0xFF, 0x7C, 0x00, 0x1F, 0xFE, 0xFC, 0x00, 0x07, 0xFC, 0xF8, 0x00,
  0x00, 0x41, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x9F, 0xF0,
  0x00, 0x1F, 0x7F, 0xF8, 0x00, 0x3E, 0x7F, 0xFC, 0x00, 0x7C, 0xFE, 0xFE,
  0x00, 0x7C, 0xF8, 0x3E, 0x00, 0xF8, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x3E,
  0x03, 0xF0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x1F, 0x80, 0xFC, 0x7E, 0x1F, 0x00, 0xFF, 0xFC,
  0x3E, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x0F, 0xEF, 0xF7, 0xF1, 0xFC, 0xFE, 0x7F, 0x9F, 0xCF, 0xE3, 0xFB, 0xF8,
  0xFE, 0x1F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0x0F, 0xE0,
  0x7F, 0xE0, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0x9F, 0xE0, 0x7F, 0xE0,
  0xFF, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x01, 0x80, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x1F,
  0x80, 0x43, 0xC0, 0xF8, 0x3C, 0x3F, 0x0F, 0x8F, 0xE7, 0xFC, 0xF1, 0xFE,
  0x7F, 0xE7, 0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x07,
  0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x80, 0x10, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x0F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0xCF, 0xE0, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0x3F, 0xBF, 0xFF,
  0x9F, 0xDF, 0xFF, 0xCF, 0xEF, 0xFF, 0xE7, 0xF7, 0xFF, 0xF3, 0xF3, 0xFF,
  0xF8, 0x71, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF8, 0x03,
  0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x7E, 0x3F, 0xC0,
  0x3C, 0x1F, 0xE0, 0x1C, 0x0F, 0xF0, 0x0C, 0x07, 0xF8, 0x04, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF,
  0x87, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0x80, 0x3F, 0xDF,
  0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xF7, 0xF8, 0x07, 0xFB, 0xFE, 0x07,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x81, 0xFD, 0xFF,
  0xE0, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xCF, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF7, 0xFC, 0x07, 0xF9,
  0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x3E, 0x00, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF,
  0xE0, 0x1F, 0xF7, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC,
  0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE1, 0xFF, 0x8F, 0xF8, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0x80,
  0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x7F, 0xDF, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x00,
  0x87, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0C, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0x83,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F,
  0x83, 0x00, 0x01, 0x80, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x01, 0xF8, 0xFF, 0xF0, 0x3F, 0xE7, 0xFF, 0x81, 0xFF, 0xBF,
  0xFC, 0x1F, 0xFD, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF8,
  0x7F, 0x07, 0xFF, 0xC3, 0xF0, 0x3F, 0xFE, 0x1F, 0x81, 0xFF, 0xF0, 0xFC,
  0x0F, 0xFF, 0x87, 0xE0, 0x7F, 0xFC, 0x3F, 0x03, 0xFF, 0xE1, 0xF8, 0x1F,
  0xFF, 0x0F, 0xC0, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0xC3, 0xF0, 0x3F, 0xFE,
  0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFD, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0x80, 0xFC, 0x7E, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xF8,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F,
  0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0,
  0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F,
  0xC0, 0x7F, 0xCF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F,
  0xBF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0xFF, 0x00,
  0x7F, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xE7, 0xFE, 0x1F,
  0xF9, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x03,
  0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0x7F, 0xFF,
  0x83, 0xDF, 0xFD, 0xE1, 0xFF, 0xFF, 0x7C, 0x7F, 0xFF, 0xDF, 0x1E, 0xFF,
  0xF7, 0xCF, 0xBF, 0xFC, 0xF3, 0xEF, 0xFF, 0xBE, 0xFB, 0xFF, 0xEF, 0xBC,
  0xFF, 0xF9, 0xEF, 0x3F, 0xFE, 0x7F, 0xCF, 0xFF, 0x9F, 0xF3, 0xFF, 0xE7,
  0xF8, 0xFF, 0xF8, 0xFE, 0x3F, 0xFE, 0x3F, 0x8F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFE, 0xF8, 0x1F, 0xFF, 0x7E, 0x0F, 0xFF,
  0xBF, 0x07, 0xFF, 0xDF, 0x83, 0xFF, 0xE7, 0xE1, 0xFF, 0xFB, 0xF0, 0xFF,
  0xFD, 0xF8, 0x7F, 0xFE, 0x7E, 0x3F, 0xFF, 0x3F, 0x1F, 0xFF, 0x9F, 0x8F,
  0xFF, 0xC7, 0xE7, 0xFF, 0xE3, 0xF3, 0xFF, 0xF1, 0xF9, 0xFF, 0xF8, 0x7E,
  0xFF, 0xFC, 0x3F, 0x7F, 0xFE, 0x1F, 0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xF7, 0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFC, 0xFF, 0x87,
  0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFC, 0x03,
  0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFE, 0xFF, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0x83,
  0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF7, 0xF8, 0x07, 0xFB, 0xFE, 0x03,
  0xFC, 0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0,
  0x7F, 0xF3, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF,
  0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xFB, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFF, 0x83, 0xFE,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xFC,
  0x07, 0xF9, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFC, 0x1F, 0x81, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x7F,
  0xF8, 0x3F, 0x87, 0xFF, 0xC1, 0xFC, 0x3F, 0xFE, 0x0F, 0xE1, 0xFF, 0xF0,
  0x7F, 0x0F, 0xDF, 0x83, 0xB8, 0x7E, 0xFC, 0x3D, 0xC3, 0xF7, 0xF1, 0xEE,
  0x1F, 0x9F, 0x8F, 0x70, 0xFC, 0xFC, 0x7B, 0xC7, 0xE7, 0xE3, 0xDE, 0x3F,
  0x3F, 0x1E, 0xF1, 0xF9, 0xF8, 0xE7, 0x8F, 0xCF, 0xC7, 0x3C, 0x7E, 0x7E,
  0x39, 0xE3, 0xE3, 0xF3, 0xCF, 0x1F, 0x1F, 0x9E, 0x39, 0xF8, 0xFC, 0xF1,
  0xCF, 0xC7, 0xE7, 0x8E, 0x7E, 0x1F, 0x3C, 0x7B, 0xF0, 0xFD, 0xE3, 0xDF,
  0x87, 0xEE, 0x1E, 0xFC, 0x3F, 0x70, 0xF7, 0xE1, 0xFB, 0x87, 0xBF, 0x0F,
  0xFC, 0x3D, 0xF0, 0x7F, 0xE1, 0xEF, 0x83, 0xFF, 0x07, 0x7C, 0x1F, 0xF8,
  0x3B, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF,
  0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x9F,
  0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xC0, 0x1F,
  0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03,
  0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xDF, 0xCF, 0xFF, 0xEF, 0xE3, 0xFF, 0xE7, 0xF0, 0x7F, 0xC3, 0xF8, 0x03,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0x00, 0x7F, 0x8F, 0xF8, 0x3F, 0xCF, 0xFE,
  0x1F, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFD, 0xFF, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF7, 0xFC, 0x07, 0xFB,
  0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xDF, 0xFF, 0x1F, 0xE7, 0xFF, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF,
  0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x07,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x40, 0x7F, 0x07, 0xFC, 0x7F, 0x0F, 0xFE, 0x7F, 0x1F, 0xFF, 0x7F, 0x3F,
  0xFF, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x7F, 0x07,
  0xFC, 0x7F, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1,
  0xFF, 0x8F, 0xF8, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x03, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0xE7, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFC, 0x7F, 0x0F, 0xFE,
  0x7F, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xC3, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x7F, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01,
  0x80, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xF8, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xDF, 0xC0, 0x3F, 0xEF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xF3, 0xF8,
  0x0F, 0xF1, 0xFC, 0x0F, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0x87, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x87, 0xF0, 0x3F,
  0xC3, 0xF8, 0x1F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFE, 0x7F, 0x00,
  0xFF, 0xBF, 0x80, 0x7F, 0xDF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xF8, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x30, 0x08,
  0x1F, 0x9F, 0x87, 0xE3, 0xF7, 0xF9, 0xFE, 0x7E, 0xFF, 0x7F, 0xEF, 0xDF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0x8F, 0xC3, 0xF7, 0xF0, 0xF8, 0x7F,
  0xFE, 0x1F, 0x0F, 0xFF, 0xC3, 0xE1, 0xFF, 0xF8, 0x7C, 0x3F, 0xFF, 0x0F,
  0x87, 0xFF, 0xE1, 0xF0, 0xFF, 0xFC, 0x3E, 0x1F, 0xFF, 0x87, 0xC3, 0xFF,
  0xF0, 0xF8, 0x7F, 0xFE, 0x1F, 0x0F, 0xFF, 0xC3, 0xE1, 0xFF, 0xF8, 0x7C,
  0x3F, 0xFF, 0x0F, 0x87, 0xFF, 0xE1, 0xF0, 0xFF, 0xFC, 0x3E, 0x1F, 0xFF,
  0x87, 0xC3, 0xFF, 0xF0, 0xF8, 0x7F, 0xFE, 0x1F, 0x0F, 0xFF, 0xC3, 0xE1,
  0xFF, 0xF8, 0x7C, 0x3F, 0xFF, 0x0F, 0x87, 0xFF, 0xE1, 0xF0, 0xFE, 0x00,
  0x01, 0x80, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xF8, 0xFF, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F,
  0xDF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xFC, 0x07, 0xF9, 0xFF,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x7F, 0x8F, 0xF8, 0x3F, 0xCF, 0xFE, 0x1F, 0xEF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0x83,
  0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFF, 0x0F, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xDF, 0xFF,
  0x1F, 0xE7, 0xFF, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0x18, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xFC, 0x7F, 0x0F, 0xFE, 0x7F, 0x1F, 0xFF, 0x7F, 0x3F,
  0xFF, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0x7F, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x7F, 0x07,
  0xFC, 0x7F, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x00, 0x7F, 0x0F, 0xF8, 0x3F,
  0x9F, 0xFF, 0x1F, 0xCF, 0xFF, 0xCF, 0xEF, 0xFF, 0xE7, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F, 0xFD, 0xFE, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFD, 0xFC,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0x0F, 0x81, 0xFF,
  0xE0, 0xFC, 0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0xF8, 0x3F, 0x83, 0xFF, 0xC1,
  0xFC, 0x3F, 0x7E, 0x0F, 0xE1, 0xFB, 0xF8, 0x7F, 0x0F, 0xCF, 0xC3, 0xB8,
  0x7E, 0x7E, 0x3D, 0xC3, 0xF3, 0xF1, 0xEE, 0x1F, 0x9F, 0x8F, 0x78, 0xFC,
  0xFC, 0x7B, 0xCF, 0xC7, 0xE3, 0x9E, 0x7E, 0x3F, 0x1C, 0xF3, 0xF0, 0xFD,
  0xE3, 0x9F, 0x87, 0xEF, 0x1C, 0xFC, 0x3F, 0x78, 0xE7, 0xE1, 0xFB, 0xC7,
  0xBF, 0x0F, 0xDE, 0x3D, 0xF0, 0x7E, 0xE1, 0xFF, 0x83, 0xF7, 0x0F, 0xFC,
  0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xE0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x81, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F,
  0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xDF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0x01, 0xFD, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x0F, 0xF7, 0xF7, 0xE0,
  0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xDF, 0x81, 0xFF, 0xF3, 0xF0, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 37, 31, 11, -37 },
  { 43, 19, 15, 31, 6, -37 },
  { 79, 29, 37, 31, 1, -37 },
  { 214, 26, 51, 31, 2, -44 },
  { 380, 32, 37, 31, -1, -37 },
  { 528, 28, 39, 31, 2, -38 },
  { 665, 7, 15, 31, 12, -37 },
  { 679, 17, 49, 31, 8, -43 },
  { 784, 17, 49, 31, 6, -43 },
  { 889, 28, 27, 31, 1, -31 },
  { 984, 25, 24, 31, 3, -29 },
  { 1059, 13, 16, 31, 7, -8 },
  { 1085, 16, 7, 31, 7, -20 },
  { 1099, 10, 11, 31, 10, -10 },
  { 1113, 25, 48, 31, 3, -42 },
  { 1263, 25, 39, 31, 3, -38 },
  { 1385, 25, 37, 31, 4, -37 },
  { 1501, 25, 38, 31, 3, -38 },
  { 1620, 25, 38, 31, 3, -37 },
  { 1739, 24, 37, 31, 3, -37 },
  { 1850, 25, 38, 31, 3, -37 },
  { 1969, 26, 38, 31, 2, -37 },
  { 2093, 26, 37, 31, 2, -37 },
  { 2214, 25, 39, 31, 3, -38 },
  { 2336, 26, 38, 31, 2, -38 },
  { 2460, 10, 30, 31, 10, -29 },
  { 2498, 14, 37, 31, 7, -29 },
  { 2563, 23, 29, 31, 4, -31 },
  { 2647, 23, 20, 31, 4, -27 },
  { 2705, 23, 29, 31, 4, -31 },
  { 2789, 20, 37, 31, 6, -37 },
  { 2882, 29, 47, 31, 1, -38 },
  { 3053, 28, 37, 31, 1, -37 },
  { 3183, 26, 37, 31, 3, -37 },
  { 3304, 25, 39, 31, 3, -38 },
  { 3426, 25, 37, 31, 3, -37 },
  { 3542, 23, 37, 31, 4, -37 },
  { 3649, 24, 37, 31, 4, -37 },
  { 3760, 25, 39, 31, 3, -38 },
  { 3882, 24, 37, 31, 3, -37 },
  { 3993, 23, 37, 31, 4, -37 },
  { 4100, 26, 38, 31, 1, -37 },
  { 4224, 26, 37, 31, 3, -37 },
  { 4345, 23, 37, 31, 5, -37 },
  { 4452, 26, 37, 31, 2, -37 },
  { 4573, 25, 37, 31, 3, -37 },
  { 4689, 25, 39, 31, 3, -38 },
  { 4811, 26, 37, 31, 3, -37 },
  { 4932, 25, 47, 31, 3, -38 },
  { 5079, 26, 37, 31, 3, -37 },
  { 5200, 26, 39, 31, 2, -38 },
  { 5327, 27, 37, 31, 2, -37 },
  { 5452, 25, 38, 31, 3, -37 },
  { 5571, 28, 37, 31, 1, -37 },
  { 5701, 29, 37, 31, 1, -37 },
  { 5836, 29, 37, 31, 1, -37 },
  { 5971, 29, 37, 31, 1, -37 },
  { 6106, 23, 37, 31, 4, -37 },
  { 6213, 15, 48, 31, 9, -42 },
  { 6303, 26, 48, 31, 2, -42 },
  { 6459, 16, 48, 31, 6, -42 },
  { 6555, 25, 20, 31, 3, -37 },
  { 6618, 25, 7, 31, 3, 1 },
  { 6640, 13, 7, 31, 8, -40 },
  { 6652, 25, 30, 31, 2, -29 },
  { 6746, 25, 38, 31, 3, -37 },
  { 6865, 25, 30, 31, 3, -29 },
  { 6959, 24, 38, 31, 3, -37 },
  { 7073, 25, 30, 31, 3, -29 },
  { 7167, 26, 37, 31, 2, -37 },
  { 7288, 24, 38, 31, 3, -29 },
  { 7402, 24, 37, 31, 3, -37 },
  { 7513, 25, 40, 31, 4, -40 },
  { 7638, 21, 49, 31, 4, -40 },
  { 7767, 25, 37, 31, 4, -37 },
  { 7883, 28, 37, 31, 1, -37 },
  { 8013, 27, 29, 31, 2, -29 },
  { 8111, 24, 29, 31, 3, -29 },
  { 8198, 25, 30, 31, 3, -29 },
  { 8292, 25, 38, 31, 3, -29 },
  { 8411, 24, 38, 31, 3, -29 },
  { 8525, 25, 29, 31, 4, -29 },
  { 8616, 25, 30, 31, 3, -29 },
  { 8710, 25, 36, 31, 2, -36 },
  { 8823, 24, 29, 31, 3, -28 },
  { 8910, 28, 28, 31, 1, -28 },
  { 9008, 29, 28, 31, 1, -28 },
  { 9110, 28, 28, 31, 1, -28 },
  { 9208, 28, 37, 31, 1, -28 },
  { 9338, 23, 28, 31, 4, -28 },
  { 9419, 23, 48, 31, 4, -42 },
  { 9557, 8, 48, 31, 11, -42 },
  { 9605, 23, 48, 31, 4, -42 },
  { 9743, 27, 13, 31, 2, -24 },
};

const GFXfont JetBrainsMono_ExtraBold51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_EXTRABOLD51PT7B_H_
