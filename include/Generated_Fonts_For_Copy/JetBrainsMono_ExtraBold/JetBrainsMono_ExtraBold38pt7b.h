#ifndef _JETBRAINSMONO_EXTRABOLD38PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFB, 0xE0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7C, 0xF8, 0xF9, 0xE1, 0xF3, 0xC1,
  0xE0, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x78,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x78,
  0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xFB, 0xFB, 0xBF, 0x7E, 0x73, 0xEF, 0xCE, 0x7F, 0xF9, 0xC0,
  0x3F, 0x38, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0x3F,
  0x00, 0xE7, 0xFF, 0x1C, 0xFF, 0xF3, 0x9F, 0xFE, 0x77, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0x1F, 0xE0, 0x0E, 0x3F, 0xF0, 0x1E, 0x3C, 0xF8, 0x3C, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0x79, 0xE0, 0x78, 0x79,
  0xC0, 0x3F, 0xF3, 0xC0, 0x3F, 0xF7, 0x80, 0x1F, 0xEF, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x60, 0x00, 0x7B,
  0xF8, 0x00, 0xF7, 0xFC, 0x01, 0xEF, 0xFE, 0x01, 0xCF, 0x1E, 0x03, 0xCF,
  0x0E, 0x07, 0x8F, 0x0E, 0x0F, 0x0F, 0x0E, 0x0F, 0x0F, 0x0E, 0x1E, 0x0F,
  0x1E, 0x3C, 0x07, 0xFE, 0x38, 0x07, 0xFC, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0x87, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC7, 0xEF, 0xBE, 0x3E, 0xFD, 0xFB, 0xF7, 0xE7, 0xFF, 0x3F, 0x1F, 0xF9,
  0xF8, 0x7F, 0x8F, 0xC3, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC7,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0x7C, 0x1F, 0xE3, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x3F, 0x01,
  0xF0, 0x07, 0x00, 0x10, 0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x0F, 0xE0, 0x7E, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x3E,
  0x01, 0xC0, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x04, 0x0F, 0x82, 0x3C, 0x78, 0x71, 0xF1, 0xC7, 0xCF,
  0xEE, 0xFE, 0xFF, 0xEF, 0xFB, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x3D, 0xC0, 0x03, 0xEF, 0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xF0, 0x1F,
  0x8F, 0xC1, 0xF8, 0x3E, 0x03, 0x81, 0xC0, 0x04, 0x04, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x63, 0xFF, 0xDF, 0x7F, 0xFB,
  0xEF, 0xFF, 0x7D, 0xFF, 0xEF, 0xBF, 0xFC, 0xE7, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0x9F, 0x83, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xDF, 0x83, 0xC7, 0xE0, 0xE1, 0xF8, 0x30, 0x7E, 0x08, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFD, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xBF, 0x03, 0xF3, 0xF9, 0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0xDF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF3, 0xF8, 0x3E, 0xFF, 0x87,
  0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC7, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xBF,
  0x83, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x07, 0xEF, 0xF0, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF7, 0xF8, 0xFE, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFB, 0xFD, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xCF, 0x81, 0xF9, 0xF8, 0x3F, 0x1F, 0xDF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0x1F, 0x8F, 0xC1, 0xFB, 0xF0,
  0x1F, 0x7E, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xFD,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFD, 0xFC,
  0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF,
  0x7E, 0x0F, 0xDF, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x8C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xF7,
  0xC0, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE0, 0xFF, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x01,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0x80, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xE7, 0xFE, 0x1F, 0xDF, 0xF1,
  0xFE, 0xFF, 0x8F, 0xDF, 0xFC, 0x78, 0x7F, 0xE7, 0xC3, 0xFF, 0x3E, 0x1F,
  0xF9, 0xF0, 0xFF, 0xCF, 0x87, 0xFE, 0x7C, 0x3F, 0xF3, 0xE1, 0xFF, 0x9F,
  0x0F, 0xFC, 0xF8, 0x7F, 0xE3, 0xE7, 0xFF, 0x1F, 0xEF, 0xF8, 0x7F, 0x7F,
  0xC1, 0xE3, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0xBF, 0x00,
  0x7D, 0xF8, 0x03, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBE, 0x07, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF,
  0x83, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x83, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x83, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFE, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0x7F, 0xB8, 0xEF, 0xF7, 0x3D, 0xFE, 0xF7, 0xFF,
  0xDE, 0xEF, 0xF9, 0xDD, 0xFF, 0x3F, 0xBF, 0xF7, 0xF7, 0xFE, 0x7C, 0xFF,
  0xCF, 0x9F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0x78, 0xFF, 0xEF, 0x1F, 0xFD, 0xF3, 0xFF,
  0x9E, 0x7F, 0xF3, 0xC7, 0xFE, 0x7C, 0xFF, 0xC7, 0x9F, 0xF8, 0xF3, 0xFF,
  0x1F, 0x7F, 0xE1, 0xEF, 0xFC, 0x3D, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0x9F, 0x83, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF0, 0x7F, 0xBE,
  0x03, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xEF, 0x81, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0x9F, 0x83, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xE7, 0xE0,
  0xFC, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xF0, 0x07,
  0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFD, 0xFC,
  0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0x9F, 0x83, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xDF, 0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF0, 0x3E, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x7C,
  0x3F, 0xE1, 0xF0, 0xF7, 0x87, 0xC3, 0xDE, 0x1F, 0x1F, 0x78, 0x7C, 0x7D,
  0xE1, 0xB1, 0xF7, 0xC6, 0xC7, 0xDF, 0x3B, 0x1F, 0x7C, 0xEC, 0x7D, 0xF3,
  0xB9, 0xF7, 0xCE, 0xE7, 0x9F, 0x3B, 0x9E, 0x3C, 0xEE, 0x78, 0xF3, 0xB9,
  0xE3, 0xCC, 0xE7, 0x8F, 0x33, 0x9E, 0x3D, 0xC6, 0x78, 0xF7, 0x1B, 0xE3,
  0xDC, 0x7F, 0x8F, 0x71, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xFC,
  0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x01, 0xFB, 0xF0,
  0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x9F,
  0x80, 0xFD, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00,
  0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xF7, 0xE0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xF8,
  0xF8, 0x0F, 0xBF, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC0,
  0x07, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x7F, 0x1F, 0xDF,
  0x83, 0xF7, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0x7C, 0xFF, 0xDF, 0x1F, 0xC7, 0xC0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE7, 0xF0, 0xFB, 0xFE, 0x3E, 0xFF, 0xCF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xEF, 0xC1, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0xFF, 0xCF, 0xBF,
  0xE3, 0xE7, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x3F, 0x1F, 0x1F,
  0xF7, 0xCF, 0xFD, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFD, 0xF3, 0xFF, 0x7C, 0x3F, 0x9F, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xE1, 0xFC, 0xF8, 0x1F, 0xBF, 0x01,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x3E, 0x7E, 0x0F,
  0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0x7D,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xF7, 0xE1, 0xFD, 0xFF, 0xFF, 0x7F, 0xF7, 0xCF, 0xFD, 0xF1, 0xFE, 0x7C,
  0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF1,
  0xF8, 0xFB, 0xFE, 0x7D, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x81, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF,
  0x03, 0xF3, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0xFC, 0x3E,
  0x3F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0x8F, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8,
  0x1F, 0x9F, 0x03, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF3, 0xC7, 0x9E, 0xFD, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3F, 0xF3, 0xC7, 0xFE, 0x78, 0xFF,
  0xCF, 0x1F, 0xF9, 0xE3, 0xFF, 0x3C, 0x7F, 0xE7, 0x8F, 0xFC, 0xF1, 0xFF,
  0x9E, 0x3F, 0xF3, 0xC7, 0xFE, 0x78, 0xFF, 0xCF, 0x1F, 0xF9, 0xE3, 0xFF,
  0x3C, 0x7F, 0xE7, 0x8F, 0xFC, 0xF1, 0xFF, 0x9E, 0x3E, 0xF8, 0xFC, 0x7D,
  0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0,
  0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF3, 0xF0, 0x7E, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xF9, 0xFC, 0x3E, 0xFF,
  0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0x80, 0xFB,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xBF, 0xF3, 0xEF, 0xF8, 0xF9, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x0F,
  0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xDF, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C, 0xFF, 0xDF, 0x0F, 0xE7, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0xFE, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xE0, 0xFC, 0xF8, 0x0F, 0xDF, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF8, 0x3F, 0x7F,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFC, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x78, 0x3D, 0xE1, 0xF0,
  0xF7, 0x87, 0xC3, 0xDE, 0x1F, 0x1F, 0x7C, 0x7C, 0x7D, 0xF1, 0xB1, 0xF7,
  0xCE, 0xC7, 0x9F, 0x3B, 0x9E, 0x3C, 0xEE, 0x78, 0xF3, 0xB9, 0xE3, 0xCE,
  0xEF, 0x8F, 0x33, 0xBE, 0x3E, 0xC6, 0xF8, 0xFF, 0x1B, 0xC3, 0xFC, 0x6F,
  0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xE1, 0xFC, 0x1F, 0x83, 0xE0, 0xFE, 0x03, 0xF3, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF8, 0x3F, 0x1F, 0x81, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F,
  0x8F, 0xC1, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xEF, 0xE0, 0x3F,
  0x80, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0x7C, 0x7C, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x0F,
  0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x3F, 0x1F, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 15, 12, 23, 4, -28 },
  { 49, 21, 28, 23, 1, -28 },
  { 123, 19, 38, 23, 2, -33 },
  { 214, 24, 28, 23, -1, -28 },
  { 298, 21, 28, 23, 1, -28 },
  { 372, 5, 12, 23, 9, -28 },
  { 380, 12, 37, 23, 6, -32 },
  { 436, 13, 37, 23, 4, -32 },
  { 497, 21, 20, 23, 1, -23 },
  { 550, 19, 19, 23, 2, -22 },
  { 596, 10, 12, 23, 5, -6 },
  { 611, 12, 5, 23, 5, -15 },
  { 619, 7, 7, 23, 8, -7 },
  { 626, 19, 36, 23, 2, -32 },
  { 712, 19, 28, 23, 2, -28 },
  { 779, 18, 28, 23, 3, -28 },
  { 842, 19, 28, 23, 2, -28 },
  { 909, 19, 28, 23, 2, -28 },
  { 976, 18, 28, 23, 2, -28 },
  { 1039, 19, 28, 23, 2, -28 },
  { 1106, 19, 28, 23, 2, -28 },
  { 1173, 19, 28, 23, 2, -28 },
  { 1240, 19, 28, 23, 2, -28 },
  { 1307, 19, 28, 23, 2, -28 },
  { 1374, 7, 21, 23, 8, -21 },
  { 1393, 9, 27, 23, 6, -21 },
  { 1424, 17, 21, 23, 3, -23 },
  { 1469, 17, 15, 23, 3, -20 },
  { 1501, 17, 21, 23, 3, -23 },
  { 1546, 16, 28, 23, 4, -28 },
  { 1602, 21, 35, 23, 1, -28 },
  { 1694, 21, 28, 23, 1, -28 },
  { 1768, 18, 28, 23, 3, -28 },
  { 1831, 19, 28, 23, 2, -28 },
  { 1898, 19, 28, 23, 2, -28 },
  { 1965, 17, 28, 23, 3, -28 },
  { 2025, 18, 28, 23, 3, -28 },
  { 2088, 19, 28, 23, 2, -28 },
  { 2155, 17, 28, 23, 3, -28 },
  { 2215, 17, 28, 23, 3, -28 },
  { 2275, 19, 28, 23, 1, -28 },
  { 2342, 20, 28, 23, 2, -28 },
  { 2412, 17, 28, 23, 4, -28 },
  { 2472, 19, 28, 23, 2, -28 },
  { 2539, 19, 28, 23, 2, -28 },
  { 2606, 19, 28, 23, 2, -28 },
  { 2673, 19, 28, 23, 3, -28 },
  { 2740, 19, 35, 23, 2, -28 },
  { 2824, 19, 28, 23, 2, -28 },
  { 2891, 19, 28, 23, 2, -28 },
  { 2958, 19, 28, 23, 2, -28 },
  { 3025, 19, 28, 23, 2, -28 },
  { 3092, 21, 28, 23, 1, -28 },
  { 3166, 22, 28, 23, 0, -28 },
  { 3243, 21, 28, 23, 1, -28 },
  { 3317, 21, 28, 23, 1, -28 },
  { 3391, 17, 28, 23, 3, -28 },
  { 3451, 12, 36, 23, 6, -32 },
  { 3505, 19, 36, 23, 2, -32 },
  { 3591, 11, 36, 23, 5, -32 },
  { 3641, 19, 15, 23, 2, -28 },
  { 3677, 19, 5, 23, 2, 1 },
  { 3689, 10, 5, 23, 6, -30 },
  { 3696, 18, 21, 23, 2, -21 },
  { 3744, 18, 28, 23, 3, -28 },
  { 3807, 19, 21, 23, 2, -21 },
  { 3857, 18, 28, 23, 2, -28 },
  { 3920, 19, 21, 23, 2, -21 },
  { 3970, 19, 28, 23, 2, -28 },
  { 4037, 18, 28, 23, 2, -21 },
  { 4100, 17, 28, 23, 3, -28 },
  { 4160, 18, 30, 23, 3, -30 },
  { 4228, 15, 37, 23, 3, -30 },
  { 4298, 19, 28, 23, 3, -28 },
  { 4365, 20, 28, 23, 1, -28 },
  { 4435, 19, 21, 23, 2, -21 },
  { 4485, 17, 21, 23, 3, -21 },
  { 4530, 19, 21, 23, 2, -21 },
  { 4580, 18, 28, 23, 3, -21 },
  { 4643, 18, 28, 23, 2, -21 },
  { 4706, 19, 21, 23, 3, -21 },
  { 4756, 19, 21, 23, 2, -21 },
  { 4806, 19, 27, 23, 1, -27 },
  { 4871, 18, 21, 23, 2, -21 },
  { 4919, 21, 21, 23, 1, -21 },
  { 4975, 22, 21, 23, 0, -21 },
  { 5033, 21, 21, 23, 1, -21 },
  { 5089, 21, 28, 23, 1, -21 },
  { 5163, 17, 21, 23, 3, -21 },
  { 5208, 17, 36, 23, 3, -32 },
  { 5285, 5, 36, 23, 9, -32 },
  { 5308, 17, 36, 23, 3, -32 },
  { 5385, 19, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_ExtraBold38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_EXTRABOLD38PT7B_H_
