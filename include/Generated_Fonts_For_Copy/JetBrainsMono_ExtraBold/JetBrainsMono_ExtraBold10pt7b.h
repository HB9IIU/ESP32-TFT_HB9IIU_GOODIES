#ifndef _JETBRAINSMONO_EXTRABOLD10PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xCC, 0xFF, 0x90, 0x2B, 0xF6, 0x92, 0xFD, 0x45, 0x00, 0x20,
  0x87, 0x9A, 0x61, 0xE2, 0xFA, 0x78, 0x80, 0xE6, 0xAF, 0x08, 0x3D, 0x59,
  0xC0, 0x79, 0x26, 0x3B, 0xDB, 0x67, 0xC0, 0xFC, 0x7A, 0x49, 0x26, 0x60,
  0xCC, 0x92, 0x4B, 0xC0, 0x31, 0xAF, 0xCC, 0x48, 0x66, 0xF6, 0x60, 0x6D,
  0x60, 0xF0, 0xF0, 0x0C, 0x61, 0x04, 0x30, 0x86, 0x18, 0xC0, 0xF9, 0x9F,
  0x99, 0xF0, 0xE5, 0x08, 0x42, 0x13, 0xE0, 0x7E, 0x42, 0x33, 0x31, 0xE0,
  0xF3, 0x67, 0x19, 0xF0, 0x36, 0xC9, 0xFF, 0x10, 0xF8, 0xBF, 0x19, 0xF0,
  0x30, 0x86, 0x1E, 0xCD, 0x27, 0x80, 0xFF, 0x21, 0x84, 0x30, 0xC6, 0x00,
  0xF9, 0xFF, 0x99, 0xF0, 0x7B, 0x2C, 0xDE, 0x18, 0x43, 0x00, 0xB0, 0xF0,
  0x6C, 0x06, 0xD6, 0x17, 0xCE, 0x31, 0xF0, 0xFF, 0x8E, 0x37, 0xC8, 0xF1,
  0x36, 0x40, 0x40, 0x7B, 0x19, 0x6B, 0xA6, 0xFC, 0x10, 0x30, 0x30, 0xC7,
  0x9E, 0x79, 0x2C, 0xC0, 0xF4, 0xA5, 0xE9, 0xCF, 0xC0, 0xF9, 0x88, 0x89,
  0xF0, 0xF4, 0xA7, 0x39, 0xDB, 0xC0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F,
  0x88, 0x80, 0xF9, 0x8B, 0x99, 0xF0, 0x99, 0xFF, 0x99, 0x90, 0xF6, 0x66,
  0x66, 0xF0, 0x38, 0x42, 0x10, 0xED, 0xE0, 0x9D, 0xA9, 0xCB, 0x5A, 0x60,
  0x88, 0x88, 0x88, 0xF0, 0xCF, 0xFF, 0xFF, 0xCF, 0x3C, 0xC0, 0xDD, 0xDF,
  0xBB, 0xB0, 0xF9, 0x99, 0x99, 0xF0, 0xF4, 0xE7, 0xE8, 0x42, 0x00, 0xF4,
  0xA5, 0x29, 0x4B, 0xC6, 0x18, 0xF4, 0xE5, 0xEA, 0x5A, 0x60, 0x79, 0x26,
  0x1E, 0x0F, 0x27, 0x80, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x99, 0x99,
  0x99, 0xF0, 0xCD, 0x24, 0x9E, 0x78, 0xC3, 0x00, 0xB6, 0xDF, 0xFF, 0x79,
  0xE4, 0x80, 0xCD, 0xE3, 0x0C, 0x79, 0xEC, 0xC0, 0xCD, 0x27, 0x8C, 0x30,
  0xC3, 0x00, 0xF3, 0x26, 0xCC, 0xF0, 0xF2, 0x49, 0x24, 0xE0, 0xC3, 0x08,
  0x43, 0x08, 0x63, 0x08, 0xE4, 0x92, 0x49, 0xE0, 0x67, 0x99, 0xFF, 0xC4,
  0x33, 0xC2, 0xFC, 0xBC, 0x8A, 0xF9, 0x99, 0xF0, 0x6F, 0x88, 0x9F, 0x15,
  0xF9, 0x99, 0xF0, 0x6F, 0x9F, 0x9F, 0x39, 0x3F, 0xF2, 0x10, 0x80, 0x5F,
  0x99, 0xF5, 0x3E, 0x8A, 0xF9, 0x99, 0x90, 0x61, 0x39, 0xC2, 0x10, 0x9F,
  0x32, 0xFF, 0x33, 0x33, 0xFE, 0x84, 0xE5, 0x6E, 0x5A, 0x60, 0xE0, 0x82,
  0x08, 0x20, 0xC1, 0xC0, 0xEB, 0xFF, 0xFF, 0xFF, 0xF0, 0xAF, 0x99, 0x99,
  0x6F, 0x99, 0x9F, 0xAF, 0x99, 0x9F, 0x88, 0x5F, 0x99, 0x9F, 0x11, 0xA7,
  0xE7, 0x08, 0x40, 0x31, 0xE4, 0x0E, 0xCD, 0xE0, 0x27, 0xFE, 0x42, 0x10,
  0xE0, 0x99, 0x99, 0x9F, 0xCD, 0x24, 0x9E, 0x30, 0xC0, 0xB6, 0xDF, 0xDE,
  0x79, 0x20, 0xCD, 0xE3, 0x0C, 0x7B, 0x30, 0xCD, 0x26, 0x9E, 0x30, 0xC3,
  0x08, 0xFF, 0x36, 0xCF, 0x32, 0x22, 0xC2, 0x22, 0x30, 0xFF, 0xFF, 0xC0,
  0xC4, 0x44, 0x34, 0x44, 0xC0, 0x6F, 0xF1, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 10, 6, 0, -9 },
  { 19, 6, 7, 6, 0, -7 },
  { 25, 6, 7, 6, 0, -7 },
  { 31, 2, 3, 6, 2, -7 },
  { 32, 3, 9, 6, 2, -8 },
  { 36, 3, 9, 6, 1, -8 },
  { 40, 6, 5, 6, 0, -6 },
  { 44, 4, 5, 6, 1, -6 },
  { 47, 3, 4, 6, 1, -2 },
  { 49, 4, 1, 6, 1, -4 },
  { 50, 2, 2, 6, 2, -2 },
  { 51, 6, 9, 6, 0, -8 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 1, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 4, 7, 6, 1, -7 },
  { 76, 4, 7, 6, 1, -7 },
  { 80, 4, 7, 6, 1, -7 },
  { 84, 6, 7, 6, 0, -7 },
  { 90, 6, 7, 6, 0, -7 },
  { 96, 4, 7, 6, 1, -7 },
  { 100, 6, 7, 6, 0, -7 },
  { 106, 2, 6, 6, 2, -6 },
  { 108, 3, 8, 6, 1, -6 },
  { 111, 4, 6, 6, 1, -6 },
  { 114, 4, 4, 6, 1, -5 },
  { 116, 4, 6, 6, 1, -6 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 6, 9, 6, 0, -7 },
  { 130, 6, 7, 6, 0, -7 },
  { 136, 5, 7, 6, 1, -7 },
  { 141, 4, 7, 6, 1, -7 },
  { 145, 5, 7, 6, 1, -7 },
  { 150, 4, 7, 6, 1, -7 },
  { 154, 4, 7, 6, 1, -7 },
  { 158, 4, 7, 6, 1, -7 },
  { 162, 4, 7, 6, 1, -7 },
  { 166, 4, 7, 6, 1, -7 },
  { 170, 5, 7, 6, 0, -7 },
  { 175, 5, 7, 6, 1, -7 },
  { 180, 4, 7, 6, 1, -7 },
  { 184, 6, 7, 6, 0, -7 },
  { 190, 4, 7, 6, 1, -7 },
  { 194, 4, 7, 6, 1, -7 },
  { 198, 5, 7, 6, 1, -7 },
  { 203, 5, 9, 6, 1, -7 },
  { 209, 5, 7, 6, 1, -7 },
  { 214, 6, 7, 6, 0, -7 },
  { 220, 6, 7, 6, 0, -7 },
  { 226, 4, 7, 6, 1, -7 },
  { 230, 6, 7, 6, 0, -7 },
  { 236, 6, 7, 6, 0, -7 },
  { 242, 6, 7, 6, 0, -7 },
  { 248, 6, 7, 6, 0, -7 },
  { 254, 4, 7, 6, 1, -7 },
  { 258, 3, 9, 6, 2, -8 },
  { 262, 5, 9, 6, 0, -8 },
  { 268, 3, 9, 6, 1, -8 },
  { 272, 4, 4, 6, 1, -7 },
  { 274, 4, 2, 6, 1, 0 },
  { 275, 3, 2, 6, 1, -8 },
  { 276, 5, 6, 6, 0, -6 },
  { 280, 4, 7, 6, 1, -7 },
  { 284, 4, 6, 6, 1, -6 },
  { 287, 4, 7, 6, 1, -7 },
  { 291, 4, 6, 6, 1, -6 },
  { 294, 5, 7, 6, 0, -7 },
  { 299, 4, 8, 6, 1, -6 },
  { 303, 4, 7, 6, 1, -7 },
  { 307, 5, 8, 6, 1, -8 },
  { 312, 4, 10, 6, 1, -8 },
  { 317, 5, 7, 6, 1, -7 },
  { 322, 6, 7, 6, 0, -7 },
  { 328, 6, 6, 6, 0, -6 },
  { 333, 4, 6, 6, 1, -6 },
  { 336, 4, 6, 6, 1, -6 },
  { 339, 4, 8, 6, 1, -6 },
  { 343, 4, 8, 6, 1, -6 },
  { 347, 5, 6, 6, 1, -6 },
  { 351, 6, 6, 6, 0, -6 },
  { 356, 5, 7, 6, 0, -7 },
  { 361, 4, 6, 6, 1, -6 },
  { 364, 6, 6, 6, 0, -6 },
  { 369, 6, 6, 6, 0, -6 },
  { 374, 6, 6, 6, 0, -6 },
  { 379, 6, 8, 6, 0, -6 },
  { 385, 4, 6, 6, 1, -6 },
  { 388, 4, 9, 6, 1, -8 },
  { 393, 2, 9, 6, 2, -8 },
  { 396, 4, 9, 6, 1, -8 },
  { 401, 6, 3, 6, 0, -5 },
};

const GFXfont JetBrainsMono_ExtraBold10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_EXTRABOLD10PT7B_H_
