#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/JetBrainsMono_ExtraBold
// Headers: 67

#include "JetBrainsMono_ExtraBold6pt7b.h"
#include "JetBrainsMono_ExtraBold7pt7b.h"
#include "JetBrainsMono_ExtraBold8pt7b.h"
#include "JetBrainsMono_ExtraBold9pt7b.h"
#include "JetBrainsMono_ExtraBold10pt7b.h"
#include "JetBrainsMono_ExtraBold11pt7b.h"
#include "JetBrainsMono_ExtraBold12pt7b.h"
#include "JetBrainsMono_ExtraBold13pt7b.h"
#include "JetBrainsMono_ExtraBold14pt7b.h"
#include "JetBrainsMono_ExtraBold15pt7b.h"
#include "JetBrainsMono_ExtraBold16pt7b.h"
#include "JetBrainsMono_ExtraBold17pt7b.h"
#include "JetBrainsMono_ExtraBold18pt7b.h"
#include "JetBrainsMono_ExtraBold19pt7b.h"
#include "JetBrainsMono_ExtraBold20pt7b.h"
#include "JetBrainsMono_ExtraBold21pt7b.h"
#include "JetBrainsMono_ExtraBold22pt7b.h"
#include "JetBrainsMono_ExtraBold23pt7b.h"
#include "JetBrainsMono_ExtraBold24pt7b.h"
#include "JetBrainsMono_ExtraBold25pt7b.h"
#include "JetBrainsMono_ExtraBold26pt7b.h"
#include "JetBrainsMono_ExtraBold27pt7b.h"
#include "JetBrainsMono_ExtraBold28pt7b.h"
#include "JetBrainsMono_ExtraBold29pt7b.h"
#include "JetBrainsMono_ExtraBold30pt7b.h"
#include "JetBrainsMono_ExtraBold31pt7b.h"
#include "JetBrainsMono_ExtraBold32pt7b.h"
#include "JetBrainsMono_ExtraBold33pt7b.h"
#include "JetBrainsMono_ExtraBold34pt7b.h"
#include "JetBrainsMono_ExtraBold35pt7b.h"
#include "JetBrainsMono_ExtraBold36pt7b.h"
#include "JetBrainsMono_ExtraBold37pt7b.h"
#include "JetBrainsMono_ExtraBold38pt7b.h"
#include "JetBrainsMono_ExtraBold39pt7b.h"
#include "JetBrainsMono_ExtraBold40pt7b.h"
#include "JetBrainsMono_ExtraBold41pt7b.h"
#include "JetBrainsMono_ExtraBold42pt7b.h"
#include "JetBrainsMono_ExtraBold43pt7b.h"
#include "JetBrainsMono_ExtraBold44pt7b.h"
#include "JetBrainsMono_ExtraBold45pt7b.h"
#include "JetBrainsMono_ExtraBold46pt7b.h"
#include "JetBrainsMono_ExtraBold47pt7b.h"
#include "JetBrainsMono_ExtraBold48pt7b.h"
#include "JetBrainsMono_ExtraBold49pt7b.h"
#include "JetBrainsMono_ExtraBold50pt7b.h"
#include "JetBrainsMono_ExtraBold51pt7b.h"
#include "JetBrainsMono_ExtraBold52pt7b.h"
#include "JetBrainsMono_ExtraBold53pt7b.h"
#include "JetBrainsMono_ExtraBold54pt7b.h"
#include "JetBrainsMono_ExtraBold55pt7b.h"
#include "JetBrainsMono_ExtraBold56pt7b.h"
#include "JetBrainsMono_ExtraBold57pt7b.h"
#include "JetBrainsMono_ExtraBold58pt7b.h"
#include "JetBrainsMono_ExtraBold59pt7b.h"
#include "JetBrainsMono_ExtraBold60pt7b.h"
#include "JetBrainsMono_ExtraBold61pt7b.h"
#include "JetBrainsMono_ExtraBold62pt7b.h"
#include "JetBrainsMono_ExtraBold63pt7b.h"
#include "JetBrainsMono_ExtraBold64pt7b.h"
#include "JetBrainsMono_ExtraBold65pt7b.h"
#include "JetBrainsMono_ExtraBold66pt7b.h"
#include "JetBrainsMono_ExtraBold67pt7b.h"
#include "JetBrainsMono_ExtraBold68pt7b.h"
#include "JetBrainsMono_ExtraBold69pt7b.h"
#include "JetBrainsMono_ExtraBold70pt7b.h"
#include "JetBrainsMono_ExtraBold71pt7b.h"
#include "JetBrainsMono_ExtraBold72pt7b.h"
