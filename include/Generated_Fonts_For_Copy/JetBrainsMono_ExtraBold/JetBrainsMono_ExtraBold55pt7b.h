#ifndef _JETBRAINSMONO_EXTRABOLD55PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFE, 0x73, 0xFE, 0xFF, 0x8E, 0x3F,
  0xFF, 0xE1, 0xC7, 0xFF, 0xFC, 0x38, 0xFF, 0xFF, 0x87, 0x00, 0x0F, 0xF8,
  0xE0, 0x01, 0xFF, 0x1C, 0x00, 0x1F, 0xF3, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0E, 0xFF, 0xE0, 0x01, 0xCF, 0xFC, 0x00, 0x38,
  0xFF, 0x80, 0x07, 0x0F, 0xF0, 0x00, 0xE1, 0xFF, 0xFE, 0x1C, 0x3F, 0xFF,
  0xC3, 0x87, 0xFF, 0xFC, 0x71, 0xFF, 0xFF, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xE1, 0xFF, 0xE0, 0x01, 0xF8, 0x7F, 0xFE, 0x00,
  0x7E, 0x1F, 0xFF, 0xC0, 0x0F, 0x83, 0xF1, 0xFC, 0x03, 0xE0, 0x7C, 0x1F,
  0x80, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC1, 0xF8, 0x07, 0xC0, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x1F, 0x80,
  0x1F, 0x03, 0xE3, 0xE0, 0x03, 0xF0, 0xFC, 0xFC, 0x00, 0x7F, 0xFF, 0xBF,
  0x00, 0x07, 0xFF, 0xE7, 0xC0, 0x00, 0xFF, 0xF9, 0xF8, 0x00, 0x07, 0xFE,
  0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0xF0, 0x00, 0x1F, 0x9F,
  0xFF, 0x00, 0x03, 0xE7, 0xFF, 0xE0, 0x00, 0xFD, 0xFE, 0xFE, 0x00, 0x3F,
  0x3F, 0x07, 0xC0, 0x0F, 0xC7, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x1F, 0x00,
  0x7E, 0x1F, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x01, 0xF8, 0x3E, 0x0F, 0xC0, 0x3F,
  0x9F, 0xC1, 0xF0, 0x03, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0xFE, 0x1F, 0x80,
  0x03, 0xFF, 0x87, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xBF, 0xCF, 0xF1,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0xBF, 0x8F, 0xF0, 0xFF, 0xFE,
  0x3F, 0xC3, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xC3, 0xFC, 0x0F, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF1,
  0xFE, 0x07, 0xFF, 0x83, 0xFC, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x40, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x08, 0x07, 0xF0, 0x08, 0x3E, 0x07,
  0xC0, 0xF8, 0x7F, 0x0F, 0x87, 0xF0, 0xFF, 0x1F, 0x1F, 0xE3, 0xFF, 0x1C,
  0xFF, 0xE7, 0xFF, 0xBB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06,
  0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF8, 0xFE, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xDF, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF0, 0x07, 0xFB, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE3, 0xE3,
  0xFF, 0xFC, 0xFE, 0x7F, 0xFF, 0x9F, 0xCF, 0xFF, 0xF3, 0xF9, 0xFF, 0xFE,
  0x7F, 0x3F, 0xFF, 0xCF, 0xE7, 0xFF, 0xF8, 0xF8, 0xFF, 0xFF, 0x0E, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF,
  0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x7C,
  0x0F, 0xF0, 0x0F, 0x01, 0xFE, 0x01, 0x80, 0x3F, 0xC0, 0x20, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xC0, 0x7F, 0xCF,
  0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x14, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x0F, 0xF3, 0xFE, 0x03, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0xFF, 0xF0, 0x7F, 0xBF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0x0F, 0xFC,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x14, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x08, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x03, 0xFE, 0x7F,
  0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xCF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0xE7, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFE,
  0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xC0,
  0x1F, 0xEF, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3,
  0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0xEF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0xFC,
  0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0xFF,
  0x9F, 0xF8, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xF8, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F,
  0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE3, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xE0, 0x70, 0x03, 0xE0, 0x1F, 0xC0,
  0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF0,
  0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0x01, 0xFF, 0x3F, 0xFE, 0x07, 0xFF,
  0x7F, 0xFC, 0x1F, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xC3, 0xF8, 0x1F, 0xFF, 0x87, 0xF0, 0x3F,
  0xFF, 0x0F, 0xE0, 0x7F, 0xFE, 0x1F, 0xC0, 0xFF, 0xFC, 0x3F, 0x81, 0xFF,
  0xF8, 0x7F, 0x03, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF,
  0xC3, 0xF8, 0x1F, 0xFF, 0x87, 0xF0, 0x3F, 0xFF, 0x0F, 0xE0, 0x7F, 0xFE,
  0x1F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFD, 0xFF, 0xF0,
  0x3F, 0xFB, 0xFF, 0xE0, 0x3F, 0xE7, 0xEF, 0xC0, 0x1F, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFE,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xF8, 0x07, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x3F,
  0xC0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x07, 0xFE, 0xFF, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE,
  0xFF, 0x00, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0xFE, 0x7F, 0xC0, 0x7F, 0xEF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x0F, 0xFD, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0xFE, 0x7F, 0xC0,
  0x7F, 0xEF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF8,
  0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xE7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00,
  0x7F, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F,
  0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1E, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xDF, 0xFF, 0xBE, 0x3E, 0xFF, 0xFD, 0xF1, 0xF7, 0xFF,
  0xEF, 0x8F, 0xBF, 0xFF, 0x3E, 0xF9, 0xFF, 0xF9, 0xF7, 0xCF, 0xFF, 0xCF,
  0xBE, 0x7F, 0xFE, 0x7D, 0xF3, 0xFF, 0xF1, 0xEF, 0x1F, 0xFF, 0x8F, 0xF9,
  0xFF, 0xFE, 0x7F, 0xCF, 0xFF, 0xF3, 0xFE, 0x7F, 0xFF, 0x8F, 0xE3, 0xFF,
  0xFC, 0x7F, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x7E, 0x0F, 0xFF, 0xEF, 0xC1,
  0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0x9F, 0x87, 0xFF, 0xF3, 0xF0, 0xFF, 0xFE,
  0x7E, 0x1F, 0xFF, 0xC7, 0xE3, 0xFF, 0xF8, 0xFC, 0x7F, 0xFF, 0x1F, 0x8F,
  0xFF, 0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0x1F, 0xFF, 0xC7, 0xF3, 0xFF, 0xF8,
  0x7E, 0x7F, 0xFF, 0x0F, 0xCF, 0xFF, 0xE1, 0xFD, 0xFF, 0xFC, 0x1F, 0xBF,
  0xFF, 0x83, 0xF7, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xFE, 0x7F,
  0xC0, 0x7F, 0xCF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xCF,
  0xF8, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xBF,
  0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03,
  0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F, 0xFE, 0xFF,
  0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xDF, 0xE0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xDF, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0xC0,
  0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0xC1, 0xDC, 0x1F, 0xFF, 0x83, 0xB8, 0x3F, 0xFF, 0x07, 0x70, 0x7F, 0xFE,
  0x1E, 0xF0, 0xFF, 0xFC, 0x3D, 0xE1, 0xFD, 0xF8, 0x7B, 0xC3, 0xF3, 0xF0,
  0xF7, 0x87, 0xE7, 0xE1, 0xEF, 0x0F, 0xCF, 0xC3, 0xDE, 0x1F, 0x9F, 0x87,
  0xBC, 0x3F, 0x3F, 0x0F, 0x78, 0x7E, 0x7F, 0x1E, 0xF1, 0xFC, 0xFE, 0x78,
  0xF3, 0xF9, 0xFC, 0xF1, 0xE7, 0xF3, 0xF9, 0xE3, 0xCF, 0xE7, 0xF3, 0xC7,
  0x9F, 0x87, 0xE7, 0x8F, 0x3F, 0x0F, 0xCF, 0x1E, 0x7E, 0x1F, 0x9E, 0x3C,
  0xFC, 0x3F, 0x3C, 0x79, 0xF8, 0x7E, 0x78, 0xF3, 0xF0, 0xFD, 0xE1, 0xF7,
  0xE1, 0xFB, 0xC1, 0xEF, 0xC3, 0xF7, 0x83, 0xDF, 0x87, 0xEF, 0x07, 0xBF,
  0x0F, 0xFE, 0x0F, 0x7C, 0x0F, 0xFC, 0x1E, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01,
  0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x01,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFF,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0xC7,
  0xFF, 0xCF, 0xF0, 0xFF, 0xE3, 0xFC, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC1, 0xF0, 0x0F, 0xF1, 0xFF, 0x83, 0xFC, 0xFF, 0xF0,
  0xFF, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF3, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xDF, 0xFF,
  0x8F, 0xF3, 0xFF, 0xC3, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFE, 0x7F, 0xC0, 0x7F, 0xEF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3E, 0x0F, 0xF0, 0x7F, 0xE3, 0xFC, 0x3F,
  0xFC, 0xFF, 0x1F, 0xFF, 0xBF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xEF, 0xF0, 0xFF, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF,
  0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x7F, 0xE0,
  0x7F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0xFF,
  0xF3, 0xFC, 0x7F, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xCF, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F,
  0xDF, 0xF8, 0x3F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xEF, 0xF1, 0xFF, 0xFB, 0xFC, 0x3F, 0xFC, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x83,
  0xE0, 0x3F, 0xC7, 0xFE, 0x1F, 0xE7, 0xFF, 0x8F, 0xF7, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0x04, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFE, 0xFF, 0x00,
  0x7F, 0xCF, 0xF0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00,
  0x7F, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x07, 0x87, 0xF3, 0xF0,
  0xFE, 0x3F, 0xBF, 0xCF, 0xF9, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0xE1, 0xF0, 0x7F, 0xFE,
  0x0F, 0x83, 0xFF, 0xF0, 0x7C, 0x1F, 0xFF, 0x83, 0xE0, 0xFF, 0xFC, 0x1F,
  0x07, 0xFF, 0xE0, 0xF8, 0x3F, 0xFF, 0x07, 0xC1, 0xFF, 0xF8, 0x3E, 0x0F,
  0xFF, 0xC1, 0xF0, 0x7F, 0xFE, 0x0F, 0x83, 0xFF, 0xF0, 0x7C, 0x1F, 0xFF,
  0x83, 0xE0, 0xFF, 0xFC, 0x1F, 0x07, 0xFF, 0xE0, 0xF8, 0x3F, 0xFF, 0x07,
  0xC1, 0xFF, 0xF8, 0x3E, 0x0F, 0xFF, 0xC1, 0xF0, 0x7F, 0xFE, 0x0F, 0x83,
  0xFF, 0xF0, 0x7C, 0x1F, 0xFF, 0x83, 0xE0, 0xFF, 0xFC, 0x1F, 0x07, 0xFF,
  0xE0, 0xF8, 0x3F, 0xFF, 0x07, 0xC1, 0xFF, 0xF8, 0x3E, 0x0F, 0xE0, 0x00,
  0x07, 0xC0, 0x7F, 0x8F, 0xFC, 0x3F, 0xCF, 0xFF, 0x1F, 0xEF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF0, 0x07, 0xFB, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0xC7, 0xFE, 0x0F, 0xF3, 0xFF, 0xC3, 0xFD, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xCF, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xFE, 0x3F, 0xCF,
  0xFF, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0xFF, 0xF3, 0xFC,
  0x7F, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xCF, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xBF,
  0xC3, 0xFF, 0xCF, 0xF0, 0x3F, 0xE3, 0xFC, 0x00, 0xC0, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x87, 0xFE, 0x0F, 0xE7,
  0xFF, 0xE3, 0xF9, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xBF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFC, 0x01, 0xFF,
  0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0x7C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0xF8,
  0x1F, 0xC0, 0xFF, 0xF8, 0x3F, 0x81, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xDF, 0x83, 0xB8, 0x3F, 0x3F, 0x0F,
  0x78, 0x7E, 0x7E, 0x1E, 0xF0, 0xFC, 0xFC, 0x3D, 0xE1, 0xF9, 0xFC, 0x7B,
  0xC7, 0xF3, 0xF8, 0xF7, 0x8F, 0xE7, 0xF1, 0xEF, 0x1F, 0xC7, 0xE3, 0x8E,
  0x3F, 0x0F, 0xCF, 0x1E, 0x7E, 0x1F, 0x9E, 0x3C, 0xFC, 0x3F, 0x3C, 0x79,
  0xF8, 0x7F, 0x78, 0xF3, 0xF0, 0xFE, 0xF1, 0xEF, 0xE1, 0xFD, 0xE3, 0xDF,
  0xC1, 0xFB, 0xC7, 0xBF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0x80, 0xFE, 0xFF, 0xFE,
  0x07, 0xF7, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xBF,
  0x81, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0E, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 9, 40, 33, 12, -40 },
  { 46, 21, 16, 33, 6, -40 },
  { 88, 31, 40, 33, 1, -40 },
  { 243, 27, 56, 33, 3, -48 },
  { 432, 35, 40, 33, -1, -40 },
  { 607, 30, 42, 33, 2, -41 },
  { 765, 9, 16, 33, 12, -40 },
  { 783, 18, 53, 33, 9, -46 },
  { 903, 18, 53, 33, 6, -46 },
  { 1023, 31, 29, 33, 1, -34 },
  { 1136, 27, 26, 33, 3, -31 },
  { 1224, 14, 17, 33, 8, -8 },
  { 1254, 17, 8, 33, 8, -22 },
  { 1271, 11, 12, 33, 11, -11 },
  { 1288, 27, 52, 33, 3, -46 },
  { 1464, 27, 42, 33, 3, -41 },
  { 1606, 27, 40, 33, 4, -40 },
  { 1741, 27, 41, 33, 3, -41 },
  { 1880, 27, 41, 33, 3, -40 },
  { 2019, 26, 40, 33, 3, -40 },
  { 2149, 27, 41, 33, 3, -40 },
  { 2288, 29, 41, 33, 2, -40 },
  { 2437, 28, 40, 33, 2, -40 },
  { 2577, 27, 42, 33, 3, -41 },
  { 2719, 29, 41, 33, 2, -41 },
  { 2868, 11, 32, 33, 11, -31 },
  { 2912, 14, 40, 33, 8, -31 },
  { 2982, 25, 31, 33, 4, -34 },
  { 3079, 25, 22, 33, 4, -29 },
  { 3148, 25, 31, 33, 4, -34 },
  { 3245, 22, 40, 33, 6, -40 },
  { 3355, 31, 51, 33, 1, -41 },
  { 3553, 31, 40, 33, 1, -40 },
  { 3708, 27, 40, 33, 4, -40 },
  { 3843, 27, 42, 33, 3, -41 },
  { 3985, 27, 40, 33, 3, -40 },
  { 4120, 25, 40, 33, 4, -40 },
  { 4245, 26, 40, 33, 4, -40 },
  { 4375, 27, 42, 33, 3, -41 },
  { 4517, 25, 40, 33, 4, -40 },
  { 4642, 25, 40, 33, 4, -40 },
  { 4767, 28, 41, 33, 1, -40 },
  { 4911, 28, 40, 33, 4, -40 },
  { 5051, 25, 40, 33, 5, -40 },
  { 5176, 29, 40, 33, 2, -40 },
  { 5321, 27, 40, 33, 3, -40 },
  { 5456, 27, 42, 33, 3, -41 },
  { 5598, 27, 40, 33, 4, -40 },
  { 5733, 28, 51, 33, 3, -41 },
  { 5912, 27, 40, 33, 4, -40 },
  { 6047, 27, 42, 33, 3, -41 },
  { 6189, 29, 40, 33, 2, -40 },
  { 6334, 27, 41, 33, 3, -40 },
  { 6473, 31, 40, 33, 1, -40 },
  { 6628, 31, 40, 33, 1, -40 },
  { 6783, 31, 40, 33, 1, -40 },
  { 6938, 31, 40, 33, 1, -40 },
  { 7093, 25, 40, 33, 4, -40 },
  { 7218, 17, 52, 33, 9, -46 },
  { 7329, 27, 52, 33, 3, -46 },
  { 7505, 17, 52, 33, 7, -46 },
  { 7616, 27, 21, 33, 3, -40 },
  { 7687, 27, 8, 33, 3, 1 },
  { 7714, 15, 8, 33, 8, -43 },
  { 7729, 26, 32, 33, 3, -31 },
  { 7833, 26, 41, 33, 4, -40 },
  { 7967, 27, 32, 33, 3, -31 },
  { 8075, 26, 41, 33, 3, -40 },
  { 8209, 27, 32, 33, 3, -31 },
  { 8317, 27, 40, 33, 3, -40 },
  { 8452, 26, 41, 33, 3, -31 },
  { 8586, 25, 40, 33, 4, -40 },
  { 8711, 27, 44, 33, 4, -44 },
  { 8860, 23, 54, 33, 4, -44 },
  { 9016, 28, 40, 33, 4, -40 },
  { 9156, 30, 40, 33, 1, -40 },
  { 9306, 29, 31, 33, 2, -31 },
  { 9419, 25, 31, 33, 4, -31 },
  { 9516, 27, 32, 33, 3, -31 },
  { 9624, 26, 41, 33, 4, -31 },
  { 9758, 26, 41, 33, 3, -31 },
  { 9892, 26, 31, 33, 5, -31 },
  { 9993, 27, 32, 33, 3, -31 },
  { 10101, 27, 39, 33, 2, -39 },
  { 10233, 25, 31, 33, 4, -30 },
  { 10330, 31, 30, 33, 1, -30 },
  { 10447, 31, 30, 33, 1, -30 },
  { 10564, 31, 30, 33, 1, -30 },
  { 10681, 31, 40, 33, 1, -30 },
  { 10836, 25, 30, 33, 4, -30 },
  { 10930, 25, 52, 33, 4, -46 },
  { 11093, 9, 52, 33, 12, -46 },
  { 11152, 25, 52, 33, 4, -46 },
  { 11315, 29, 14, 33, 2, -26 },
};

const GFXfont JetBrainsMono_ExtraBold55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_EXTRABOLD55PT7B_H_
