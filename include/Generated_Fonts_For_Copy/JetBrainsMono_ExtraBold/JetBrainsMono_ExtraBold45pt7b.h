#ifndef _JETBRAINSMONO_EXTRABOLD45PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF7, 0xFF, 0xFE,
  0xFE, 0x3E, 0x00, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF8, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1E, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE7, 0xF3, 0x9F, 0xCF, 0xE7, 0x3F, 0x9F, 0x8E, 0x3F,
  0x3F, 0x1C, 0x00, 0x7F, 0x38, 0x00, 0xFE, 0x70, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xEF, 0xF0, 0x01,
  0xCF, 0xF0, 0x03, 0x8F, 0xE0, 0x07, 0x1F, 0xFF, 0x8E, 0x3F, 0xFF, 0x1C,
  0x7F, 0xFF, 0x39, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0xFF, 0xC0, 0x0F, 0x8F, 0xFF,
  0x00, 0xF8, 0x7F, 0xF8, 0x07, 0x83, 0xC3, 0xE0, 0x7C, 0x3E, 0x1F, 0x07,
  0xC1, 0xF0, 0xF8, 0x7C, 0x0F, 0x87, 0xC3, 0xC0, 0x7C, 0x3E, 0x3E, 0x03,
  0xE1, 0xF3, 0xE0, 0x0F, 0x0F, 0x9E, 0x00, 0x7F, 0xF9, 0xE0, 0x01, 0xFF,
  0xDF, 0x00, 0x07, 0xFD, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x7D, 0xFF, 0x00, 0x07, 0xDF, 0xFC, 0x00, 0x3C, 0xFF, 0xF0, 0x03,
  0xEF, 0x87, 0x80, 0x3E, 0x7C, 0x3E, 0x03, 0xE3, 0xE1, 0xF0, 0x1E, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x3E, 0x1E,
  0x0F, 0x01, 0xFF, 0xF0, 0xF8, 0x07, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0xF8,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x83, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFD, 0xFC, 0x7E,
  0xFC, 0xFE, 0xFE, 0xFC, 0x7E, 0xFC, 0xFC, 0x3F, 0xFC, 0xFC, 0x3F, 0xF8,
  0xFC, 0x1F, 0xF8, 0xFC, 0x0F, 0xF0, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xF0,
  0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFE, 0x7E, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xE7, 0xCF, 0x80, 0x00, 0x02, 0x00, 0x3C, 0x01,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x38, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x03, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x01, 0x81, 0xF0, 0x30, 0xF0, 0xF8, 0x78, 0xFE,
  0x38, 0xFE, 0x7F, 0x9C, 0xFF, 0x3F, 0xEE, 0xFF, 0xBF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xDE, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x3C, 0x07, 0x80, 0x04, 0x01,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x08, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x38, 0xFF, 0xF3, 0xE7, 0xFF, 0xBF, 0xBF, 0xFD, 0xFD, 0xFF, 0xEF,
  0xEF, 0xFF, 0x3E, 0x7F, 0xF8, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0x9F, 0xC0, 0xF8, 0xFE, 0x07, 0x87, 0xF0, 0x30, 0x3F, 0x81, 0x01, 0xFC,
  0x08, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xF8, 0x3F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xE1, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x7F, 0x81, 0xFD, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x18,
  0x07, 0xE7, 0xF8, 0x3F, 0x7F, 0xF1, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x0F, 0xEF, 0xF8, 0x3F, 0xBF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFB,
  0xFE, 0x0F, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC,
  0x07, 0xF3, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xF3,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0x9F,
  0xC0, 0xFF, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xFC,
  0x07, 0xF3, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x83, 0xFD, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFE, 0x3F, 0xC7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x3F,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xF3,
  0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0x9F, 0xC0,
  0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xE0, 0xFF,
  0xBF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFB, 0xF8, 0x7F, 0xFF, 0xE0,
  0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x00, 0x0F, 0x83, 0xF8,
  0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F,
  0xF1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0x3F, 0xE1, 0xFC, 0x03, 0xF9, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x81, 0xF9, 0xFF, 0xC1, 0xFE, 0xFF, 0xE1, 0xFF, 0x7F, 0xF1,
  0xFF, 0xFF, 0xF8, 0xFC, 0x3F, 0xFC, 0x7E, 0x1F, 0xFE, 0x3E, 0x07, 0xFF,
  0x1F, 0x03, 0xFF, 0x8F, 0x81, 0xFF, 0xC7, 0xC0, 0xFF, 0xE3, 0xE0, 0x7F,
  0xF1, 0xF0, 0x3F, 0xF8, 0xF8, 0x1F, 0xFC, 0x7C, 0x0F, 0xFE, 0x3F, 0x0F,
  0xFF, 0x1F, 0xCF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xE0, 0xFE,
  0x7F, 0xF0, 0x0C, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03,
  0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01,
  0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xEF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF,
  0xE0, 0x1F, 0xBF, 0x80, 0xFE, 0xFE, 0x07, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x87,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xBF, 0x80,
  0xFE, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xEF, 0xF0, 0x3F, 0xBF, 0xF7, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xEF, 0xE1, 0xFF, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xF0, 0x3F, 0xBF, 0xF7, 0xFE,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xDF, 0xF3, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F,
  0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F,
  0x3F, 0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFD, 0xE3, 0xDF, 0xFB, 0xC7, 0xBF, 0xF7, 0x8F,
  0x7F, 0xEF, 0x9E, 0xFF, 0xCF, 0x7B, 0xFF, 0xDE, 0xF7, 0xFF, 0xBD, 0xEF,
  0xFF, 0x7B, 0xDF, 0xFE, 0x7F, 0x3F, 0xFC, 0xFE, 0x7F, 0xF9, 0xFC, 0xFF,
  0xF1, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xDF, 0x0F, 0xFE, 0xF8, 0x7F,
  0xF7, 0xC3, 0xFF, 0x9F, 0x1F, 0xFC, 0xF8, 0xFF, 0xF7, 0xC7, 0xFF, 0x9F,
  0x3F, 0xFC, 0xF9, 0xFF, 0xE7, 0xCF, 0xFF, 0x1F, 0x3F, 0xF8, 0xF9, 0xFF,
  0xC7, 0xCF, 0xFE, 0x1F, 0x7F, 0xF0, 0xFB, 0xFF, 0x87, 0xDF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xF7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0xFE,
  0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x81, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0xBF, 0xF7, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F,
  0xBF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x07,
  0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x01, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7E,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0x7F, 0xE7, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xBF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7F,
  0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x1F, 0x07,
  0xEF, 0x83, 0xE0, 0xF9, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F, 0x83, 0xE7, 0xC3,
  0xB8, 0x7C, 0xF8, 0x77, 0x0F, 0x9F, 0x0E, 0xE1, 0xF3, 0xF1, 0xDC, 0x7E,
  0x7E, 0x3B, 0x8F, 0xCF, 0xC7, 0x71, 0xF9, 0xF8, 0xEE, 0x3F, 0x1F, 0x1D,
  0xC7, 0xC3, 0xE3, 0xB8, 0xF8, 0x7C, 0xF7, 0x9F, 0x0F, 0x9E, 0xF3, 0xE1,
  0xF3, 0xDE, 0x7C, 0x3E, 0x71, 0xCF, 0x87, 0xCE, 0x39, 0xF0, 0xF9, 0xC7,
  0x3E, 0x1F, 0x38, 0xE7, 0xC3, 0xF7, 0x1C, 0xF8, 0x7E, 0xE3, 0xBE, 0x07,
  0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F,
  0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF8,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0,
  0xFF, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF1, 0xFC,
  0x03, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xCF, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xF7, 0xF0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFB, 0xF3, 0xFF, 0xEF, 0xCF, 0xFF, 0x3F, 0x0F, 0xF8,
  0xFC, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x3F,
  0x87, 0xF7, 0xFE, 0x3F, 0xBF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xDF,
  0xF8, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xBF,
  0x80, 0xFE, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xF7, 0xFE, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE3,
  0xF8, 0xFF, 0xDF, 0xCF, 0xFE, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0x7F, 0x0F, 0xF3, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0xFF, 0xDF, 0xCF, 0xFE, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFD, 0xFC, 0x3F, 0xCF, 0xE0, 0x70, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x87,
  0xF7, 0xFE, 0x3F, 0xBF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1,
  0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0x1F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x8F, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F,
  0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF9,
  0xF0, 0xF9, 0xF7, 0xF3, 0xFB, 0xEF, 0xEF, 0xF7, 0xFF, 0xDF, 0xFF, 0xEF,
  0xEF, 0xFF, 0x8F, 0x8F, 0xFF, 0x1F, 0x1F, 0xFE, 0x3E, 0x3F, 0xFC, 0x7C,
  0x7F, 0xF8, 0xF8, 0xFF, 0xF1, 0xF1, 0xFF, 0xE3, 0xE3, 0xFF, 0xC7, 0xC7,
  0xFF, 0x8F, 0x8F, 0xFF, 0x1F, 0x1F, 0xFE, 0x3E, 0x3F, 0xFC, 0x7C, 0x7F,
  0xF8, 0xF8, 0xFF, 0xF1, 0xF1, 0xFF, 0xE3, 0xE3, 0xFF, 0xC7, 0xC7, 0xFF,
  0x8F, 0x8F, 0xFF, 0x1F, 0x1F, 0xFE, 0x3E, 0x3F, 0xFC, 0x7C, 0x7E, 0xFE,
  0x3F, 0x87, 0xF7, 0xFE, 0x3F, 0xBF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFE,
  0x3F, 0x87, 0xF7, 0xFE, 0x3F, 0xBF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F,
  0xDF, 0xF8, 0xFE, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0xFF, 0xDF, 0xCF, 0xFE, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x7F, 0x83, 0xF3, 0xFF, 0x8F, 0xDF,
  0xFF, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xF0, 0x7F,
  0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFE, 0xFF, 0xBF, 0xE7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE3, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x01,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xFC,
  0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x1F, 0x07, 0xEF, 0x83,
  0xE0, 0xF9, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F, 0x83, 0xE7, 0xC1, 0xF8, 0x7C,
  0xFC, 0x77, 0x0F, 0x9F, 0x8E, 0xE3, 0xF1, 0xF1, 0xDC, 0x7E, 0x3E, 0x3B,
  0x8F, 0x87, 0xC7, 0x71, 0xF0, 0xF8, 0xEE, 0x3E, 0x1F, 0x3D, 0xE7, 0xC3,
  0xE7, 0x9C, 0xF8, 0x7E, 0xE3, 0xBF, 0x07, 0xDC, 0x77, 0xC0, 0xFB, 0x8E,
  0xF8, 0x1F, 0x71, 0xDF, 0x03, 0xEE, 0x3B, 0xE0, 0x7F, 0xC7, 0x7C, 0x0F,
  0xF8, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0xFB, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0x9F, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFB, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 33, 27, 9, -33 },
  { 39, 17, 14, 27, 5, -33 },
  { 69, 25, 33, 27, 1, -33 },
  { 173, 23, 45, 27, 2, -39 },
  { 303, 29, 33, 27, -1, -33 },
  { 423, 24, 33, 27, 2, -33 },
  { 522, 7, 14, 27, 10, -33 },
  { 535, 15, 43, 27, 7, -38 },
  { 616, 15, 43, 27, 5, -38 },
  { 697, 25, 23, 27, 1, -27 },
  { 769, 23, 22, 27, 2, -26 },
  { 833, 12, 14, 27, 6, -7 },
  { 854, 15, 6, 27, 6, -18 },
  { 866, 9, 9, 27, 9, -9 },
  { 877, 23, 42, 27, 2, -37 },
  { 998, 21, 33, 27, 3, -33 },
  { 1085, 21, 33, 27, 4, -33 },
  { 1172, 22, 33, 27, 2, -33 },
  { 1263, 22, 33, 27, 2, -33 },
  { 1354, 22, 33, 27, 2, -33 },
  { 1445, 21, 33, 27, 3, -33 },
  { 1532, 23, 33, 27, 2, -33 },
  { 1627, 23, 33, 27, 2, -33 },
  { 1722, 23, 33, 27, 2, -33 },
  { 1817, 23, 33, 27, 2, -33 },
  { 1912, 9, 25, 27, 9, -25 },
  { 1941, 11, 32, 27, 7, -25 },
  { 1985, 21, 25, 27, 3, -27 },
  { 2051, 19, 18, 27, 4, -24 },
  { 2094, 21, 25, 27, 3, -27 },
  { 2160, 18, 33, 27, 5, -33 },
  { 2235, 25, 41, 27, 1, -33 },
  { 2364, 25, 33, 27, 1, -33 },
  { 2468, 22, 33, 27, 3, -33 },
  { 2559, 22, 33, 27, 3, -33 },
  { 2650, 22, 33, 27, 3, -33 },
  { 2741, 20, 33, 27, 4, -33 },
  { 2824, 21, 33, 27, 3, -33 },
  { 2911, 22, 33, 27, 3, -33 },
  { 3002, 21, 33, 27, 3, -33 },
  { 3089, 19, 33, 27, 4, -33 },
  { 3168, 22, 34, 27, 1, -33 },
  { 3262, 23, 33, 27, 3, -33 },
  { 3357, 20, 33, 27, 4, -33 },
  { 3440, 23, 33, 27, 2, -33 },
  { 3535, 21, 33, 27, 3, -33 },
  { 3622, 21, 33, 27, 3, -33 },
  { 3709, 23, 33, 27, 3, -33 },
  { 3804, 22, 41, 27, 3, -33 },
  { 3917, 22, 33, 27, 3, -33 },
  { 4008, 23, 33, 27, 2, -33 },
  { 4103, 23, 33, 27, 2, -33 },
  { 4198, 21, 33, 27, 3, -33 },
  { 4285, 25, 33, 27, 1, -33 },
  { 4389, 27, 33, 27, 0, -33 },
  { 4501, 25, 33, 27, 1, -33 },
  { 4605, 25, 33, 27, 1, -33 },
  { 4709, 21, 33, 27, 3, -33 },
  { 4796, 13, 42, 27, 8, -37 },
  { 4865, 23, 42, 27, 2, -37 },
  { 4986, 13, 42, 27, 6, -37 },
  { 5055, 21, 18, 27, 3, -33 },
  { 5103, 21, 6, 27, 3, 1 },
  { 5119, 12, 6, 27, 7, -35 },
  { 5128, 22, 25, 27, 2, -25 },
  { 5197, 21, 33, 27, 3, -33 },
  { 5284, 22, 25, 27, 3, -25 },
  { 5353, 21, 33, 27, 3, -33 },
  { 5440, 21, 25, 27, 3, -25 },
  { 5506, 23, 33, 27, 2, -33 },
  { 5601, 21, 33, 27, 3, -25 },
  { 5688, 21, 33, 27, 3, -33 },
  { 5775, 22, 36, 27, 3, -36 },
  { 5874, 18, 44, 27, 4, -36 },
  { 5973, 23, 33, 27, 3, -33 },
  { 6068, 24, 33, 27, 1, -33 },
  { 6167, 23, 25, 27, 2, -25 },
  { 6239, 21, 25, 27, 3, -25 },
  { 6305, 21, 25, 27, 3, -25 },
  { 6371, 21, 33, 27, 3, -25 },
  { 6458, 21, 33, 27, 3, -25 },
  { 6545, 22, 25, 27, 4, -25 },
  { 6614, 23, 25, 27, 2, -25 },
  { 6686, 22, 32, 27, 2, -32 },
  { 6774, 21, 25, 27, 3, -25 },
  { 6840, 25, 25, 27, 1, -25 },
  { 6919, 27, 25, 27, 0, -25 },
  { 7004, 25, 25, 27, 1, -25 },
  { 7083, 25, 33, 27, 1, -25 },
  { 7187, 21, 25, 27, 3, -25 },
  { 7253, 21, 42, 27, 3, -37 },
  { 7364, 7, 42, 27, 10, -37 },
  { 7401, 21, 42, 27, 3, -37 },
  { 7512, 23, 12, 27, 2, -22 },
};

const GFXfont JetBrainsMono_ExtraBold45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_EXTRABOLD45PT7B_H_
