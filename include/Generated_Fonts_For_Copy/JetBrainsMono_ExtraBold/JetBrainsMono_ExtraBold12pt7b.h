#ifndef _JETBRAINSMONO_EXTRABOLD12PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xA2, 0xC0, 0xDE, 0xF7, 0xB0, 0x34, 0x49, 0xF9, 0x22, 0xCD,
  0x3F, 0xA4, 0x48, 0x21, 0xCF, 0xAA, 0xE3, 0xE3, 0x8B, 0xFB, 0xE2, 0x08,
  0x63, 0x6A, 0x57, 0x41, 0x07, 0xCE, 0xAD, 0x8E, 0x38, 0xF9, 0x83, 0x07,
  0x1B, 0xF7, 0x26, 0x7E, 0xF0, 0x37, 0xCC, 0xCC, 0xCC, 0xC6, 0x30, 0xCE,
  0x33, 0x11, 0x13, 0x36, 0xC0, 0x10, 0xAB, 0xF8, 0xC6, 0xC5, 0x80, 0x30,
  0xCF, 0xFF, 0x30, 0xC0, 0x7B, 0x40, 0xFF, 0xEC, 0x0C, 0x61, 0x8C, 0x30,
  0xC6, 0x18, 0x43, 0x0C, 0x00, 0x77, 0xE3, 0x1A, 0xC6, 0x3B, 0x78, 0x33,
  0xCB, 0x2C, 0x30, 0xC3, 0x3F, 0xFC, 0x73, 0xE8, 0x86, 0x18, 0xC6, 0x3F,
  0xFC, 0xFF, 0xCC, 0x63, 0x84, 0x3B, 0xF8, 0x19, 0x98, 0xCD, 0xCF, 0xE3,
  0x18, 0xFF, 0xF1, 0xEF, 0x84, 0x3B, 0x78, 0x30, 0xC6, 0x30, 0xFB, 0x38,
  0xF6, 0x78, 0xFF, 0xF8, 0x86, 0x10, 0xC3, 0x18, 0x60, 0x73, 0xEC, 0xB6,
  0x73, 0x68, 0xF6, 0xF8, 0x73, 0xE8, 0xE3, 0xF9, 0x63, 0x0C, 0x60, 0x5C,
  0x00, 0xF8, 0x5C, 0x00, 0xF6, 0x80, 0x0B, 0xF9, 0x87, 0x8C, 0xF8, 0x01,
  0xF0, 0xC7, 0x86, 0x3F, 0x60, 0xF7, 0xC6, 0x37, 0xB0, 0x0C, 0x60, 0x3C,
  0xCF, 0x1E, 0xDD, 0x7A, 0x74, 0xEF, 0xC0, 0xC0, 0xE0, 0x38, 0x70, 0xA1,
  0x66, 0xCD, 0x9F, 0x23, 0xC6, 0xF3, 0xEC, 0xF6, 0xF3, 0x3C, 0xF7, 0xF8,
  0x73, 0xEC, 0xF0, 0xC3, 0x0C, 0xF6, 0x78, 0xF3, 0xEC, 0xF3, 0xCF, 0x3C,
  0xFE, 0xF0, 0xFF, 0xF1, 0x8F, 0xE3, 0x1F, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF,
  0x18, 0xC0, 0x73, 0xEC, 0xF0, 0xFF, 0xFC, 0xF6, 0x78, 0xCE, 0x73, 0x9F,
  0xE7, 0x39, 0xC8, 0xFF, 0xCC, 0x63, 0x18, 0xDF, 0xF8, 0x3C, 0xF0, 0xC3,
  0x0C, 0x3C, 0xFB, 0x78, 0xCF, 0x6D, 0xBC, 0xF3, 0x4D, 0xB6, 0xCC, 0xC6,
  0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xE7, 0xDF, 0xBF, 0x7D, 0xF8, 0xF1, 0xE3,
  0xC6, 0xCE, 0x7B, 0x5A, 0xDE, 0x73, 0x98, 0x77, 0xF3, 0x9C, 0xE7, 0x3B,
  0x78, 0xF3, 0xEC, 0xF3, 0xFB, 0xCC, 0x30, 0xC0, 0x73, 0xEC, 0xB2, 0xCB,
  0x2C, 0xB6, 0x78, 0x61, 0xC0, 0xF3, 0xEC, 0xF3, 0xFB, 0xCD, 0xB6, 0xCC,
  0x73, 0xE8, 0xB0, 0xF8, 0x60, 0xF6, 0xF8, 0xFF, 0xFC, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0x78, 0xC6, 0x8D, 0x93,
  0x66, 0xC5, 0x8E, 0x1C, 0x38, 0xD3, 0xA7, 0x7F, 0x76, 0xED, 0xDB, 0x36,
  0x6C, 0xE6, 0xD8, 0xB1, 0xC1, 0x87, 0x0B, 0x36, 0xC6, 0xC6, 0xC9, 0xB1,
  0x63, 0x83, 0x06, 0x0C, 0x18, 0xFF, 0xC6, 0x63, 0x33, 0x1F, 0xF8, 0xFF,
  0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC3, 0x0C, 0x18, 0x60, 0x83, 0x0C, 0x18,
  0x61, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x33, 0x95, 0xBC, 0x80,
  0xFF, 0xC0, 0xE0, 0x77, 0xC3, 0xF8, 0xEF, 0xA0, 0xC6, 0x3D, 0xFC, 0xE7,
  0x3B, 0xF8, 0x73, 0xEC, 0xF0, 0xC7, 0x67, 0x80, 0x08, 0x5B, 0xFC, 0xE7,
  0x3B, 0xE8, 0x77, 0xE3, 0xF8, 0x6D, 0xE0, 0x3D, 0xF6, 0x3F, 0xFD, 0x86,
  0x18, 0x60, 0x6F, 0xF3, 0x9C, 0xFD, 0xA3, 0x78, 0xC6, 0x3D, 0xFC, 0xE7,
  0x39, 0xC8, 0x20, 0xC0, 0x3C, 0xF0, 0xC3, 0x0C, 0xFF, 0xF0, 0x10, 0xC1,
  0xFF, 0x8C, 0x63, 0x18, 0xFF, 0xE0, 0xC3, 0x0C, 0xF6, 0xDB, 0xCD, 0xB6,
  0xCC, 0xF1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0x1E, 0xF5, 0xFF, 0x5E,
  0xBD, 0x7A, 0xF5, 0x80, 0xF7, 0xF3, 0x9C, 0xE7, 0x20, 0x77, 0xF3, 0x9C,
  0xED, 0xE0, 0xF7, 0xF3, 0x9C, 0xEF, 0xF8, 0xC0, 0x6F, 0xF3, 0x9C, 0xEF,
  0xA1, 0x08, 0xDB, 0xFC, 0xF0, 0xC3, 0x0C, 0x00, 0x73, 0xEC, 0x3E, 0x0F,
  0x3F, 0x80, 0x33, 0xFF, 0xCC, 0x30, 0xC3, 0xC7, 0xCE, 0x73, 0x9C, 0xED,
  0xE0, 0xC6, 0xCD, 0xB3, 0x62, 0xC7, 0x0E, 0x00, 0xD3, 0xA7, 0x7B, 0x76,
  0xCD, 0x9B, 0x00, 0xE6, 0xD8, 0xE0, 0xC3, 0x8D, 0xB9, 0x80, 0xC6, 0xCD,
  0xB1, 0x63, 0x87, 0x06, 0x18, 0x30, 0xFF, 0xC6, 0x66, 0x7F, 0xE0, 0x19,
  0xCC, 0x63, 0x73, 0xC6, 0x31, 0x8E, 0xFF, 0xFF, 0xFC, 0xC7, 0x18, 0xC6,
  0x1D, 0xEC, 0x63, 0x38, 0x60, 0xEF, 0x78,
};

const GFXglyph JetBrainsMono_ExtraBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 9, 7, 3, -9 },
  { 4, 5, 4, 7, 1, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 12, 7, 1, -10 },
  { 24, 7, 9, 7, 0, -9 },
  { 32, 7, 9, 7, 0, -9 },
  { 40, 1, 4, 7, 3, -9 },
  { 41, 4, 11, 7, 2, -10 },
  { 47, 4, 11, 7, 1, -10 },
  { 53, 7, 6, 7, 0, -7 },
  { 59, 6, 6, 7, 1, -7 },
  { 64, 3, 4, 7, 2, -2 },
  { 66, 4, 2, 7, 2, -5 },
  { 67, 3, 2, 7, 2, -2 },
  { 68, 6, 11, 7, 1, -10 },
  { 77, 5, 9, 7, 1, -9 },
  { 83, 6, 9, 7, 1, -9 },
  { 90, 6, 9, 7, 1, -9 },
  { 97, 5, 9, 7, 1, -9 },
  { 103, 5, 9, 7, 1, -9 },
  { 109, 5, 9, 7, 1, -9 },
  { 115, 6, 9, 7, 1, -9 },
  { 122, 6, 9, 7, 1, -9 },
  { 129, 6, 9, 7, 1, -9 },
  { 136, 6, 9, 7, 1, -9 },
  { 143, 3, 7, 7, 2, -7 },
  { 146, 3, 9, 7, 2, -7 },
  { 150, 5, 6, 7, 1, -7 },
  { 154, 5, 4, 7, 1, -6 },
  { 157, 5, 6, 7, 1, -7 },
  { 161, 5, 9, 7, 1, -9 },
  { 167, 7, 11, 7, 0, -9 },
  { 177, 7, 9, 7, 0, -9 },
  { 185, 6, 9, 7, 1, -9 },
  { 192, 6, 9, 7, 1, -9 },
  { 199, 6, 9, 7, 1, -9 },
  { 206, 5, 9, 7, 1, -9 },
  { 212, 5, 9, 7, 1, -9 },
  { 218, 6, 9, 7, 1, -9 },
  { 225, 5, 9, 7, 1, -9 },
  { 231, 5, 9, 7, 1, -9 },
  { 237, 6, 9, 7, 0, -9 },
  { 244, 6, 9, 7, 1, -9 },
  { 251, 5, 9, 7, 1, -9 },
  { 257, 7, 9, 7, 0, -9 },
  { 265, 5, 9, 7, 1, -9 },
  { 271, 5, 9, 7, 1, -9 },
  { 277, 6, 9, 7, 1, -9 },
  { 284, 6, 11, 7, 1, -9 },
  { 293, 6, 9, 7, 1, -9 },
  { 300, 6, 9, 7, 1, -9 },
  { 307, 7, 9, 7, 0, -9 },
  { 315, 5, 9, 7, 1, -9 },
  { 321, 7, 9, 7, 0, -9 },
  { 329, 7, 9, 7, 0, -9 },
  { 337, 7, 9, 7, 0, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 5, 9, 7, 1, -9 },
  { 359, 4, 11, 7, 2, -10 },
  { 365, 6, 11, 7, 1, -10 },
  { 374, 4, 11, 7, 1, -10 },
  { 380, 5, 5, 7, 1, -9 },
  { 384, 5, 2, 7, 1, 0 },
  { 386, 3, 1, 7, 2, -9 },
  { 387, 5, 7, 7, 1, -7 },
  { 392, 5, 9, 7, 1, -9 },
  { 398, 6, 7, 7, 1, -7 },
  { 404, 5, 9, 7, 1, -9 },
  { 410, 5, 7, 7, 1, -7 },
  { 415, 6, 9, 7, 1, -9 },
  { 422, 5, 9, 7, 1, -7 },
  { 428, 5, 9, 7, 1, -9 },
  { 434, 6, 10, 7, 1, -10 },
  { 442, 5, 12, 7, 1, -10 },
  { 450, 6, 9, 7, 1, -9 },
  { 457, 7, 9, 7, 0, -9 },
  { 465, 7, 7, 7, 0, -7 },
  { 472, 5, 7, 7, 1, -7 },
  { 477, 5, 7, 7, 1, -7 },
  { 482, 5, 9, 7, 1, -7 },
  { 488, 5, 9, 7, 1, -7 },
  { 494, 6, 7, 7, 1, -7 },
  { 500, 6, 7, 7, 1, -7 },
  { 506, 6, 8, 7, 0, -8 },
  { 512, 5, 7, 7, 1, -7 },
  { 517, 7, 7, 7, 0, -7 },
  { 524, 7, 7, 7, 0, -7 },
  { 531, 7, 7, 7, 0, -7 },
  { 538, 7, 9, 7, 0, -7 },
  { 546, 5, 7, 7, 1, -7 },
  { 551, 5, 11, 7, 1, -10 },
  { 558, 2, 11, 7, 3, -10 },
  { 561, 5, 11, 7, 1, -10 },
  { 568, 7, 3, 7, 0, -6 },
};

const GFXfont JetBrainsMono_ExtraBold12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_EXTRABOLD12PT7B_H_
