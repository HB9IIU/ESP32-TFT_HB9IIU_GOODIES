#ifndef _JETBRAINSMONO_EXTRABOLD9PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x8C, 0xB6, 0x80, 0x29, 0x7E, 0xA5, 0x7D, 0x40, 0x21, 0x9E,
  0xC7, 0x1F, 0xAE, 0x20, 0x46, 0xAB, 0x18, 0x39, 0x69, 0x80, 0x32, 0x92,
  0xCE, 0xE9, 0xE0, 0xE0, 0x2D, 0x6D, 0xB3, 0x20, 0x99, 0x92, 0x5A, 0x80,
  0x27, 0xCC, 0xB0, 0x27, 0xFE, 0x40, 0x78, 0xFC, 0xB0, 0x18, 0x8C, 0x42,
  0x31, 0x18, 0x6F, 0x9D, 0x99, 0xE0, 0x6E, 0xE6, 0x66, 0xF0, 0x33, 0xE6,
  0x23, 0x31, 0xE0, 0x7B, 0xCC, 0x70, 0xED, 0xC0, 0x11, 0x88, 0xBD, 0xFC,
  0x60, 0xFF, 0x8F, 0x1B, 0xE0, 0x31, 0x18, 0xEC, 0xE5, 0xC0, 0xFF, 0xF6,
  0x23, 0x11, 0x80, 0x32, 0xD6, 0xE5, 0xE5, 0xC0, 0x32, 0xF2, 0xF1, 0x19,
  0x80, 0xE2, 0xC0, 0x68, 0x15, 0x80, 0x3C, 0xC7, 0x10, 0xFF, 0x0F, 0xC7,
  0x3C, 0x80, 0xCE, 0x36, 0x40, 0xC0, 0x32, 0x67, 0x5A, 0xD6, 0x48, 0x30,
  0x31, 0x9C, 0xA7, 0xBF, 0x20, 0xCF, 0x9E, 0x99, 0xE0, 0x6F, 0x88, 0x89,
  0xE0, 0xCF, 0x99, 0x9B, 0xE0, 0xFF, 0x8E, 0x88, 0xF0, 0xFF, 0x8F, 0x88,
  0x80, 0x6F, 0x8B, 0xB9, 0xE0, 0xBB, 0xBF, 0xBB, 0xB0, 0xFF, 0x44, 0x44,
  0xF0, 0x39, 0xC6, 0x31, 0xED, 0xC0, 0x9B, 0xAE, 0xAB, 0xB0, 0x88, 0x88,
  0x88, 0xF0, 0xDE, 0xEF, 0xDC, 0xE7, 0x20, 0x99, 0xDD, 0xDB, 0xB0, 0x6F,
  0x99, 0x9B, 0xE0, 0xCF, 0x9F, 0xE8, 0x80, 0x6F, 0x99, 0x9B, 0xE2, 0x10,
  0xCF, 0x9F, 0xEA, 0xB0, 0x33, 0xD0, 0xE1, 0xE5, 0xC0, 0xFF, 0xC8, 0x42,
  0x10, 0x80, 0x99, 0x99, 0x9B, 0xE0, 0xCE, 0x56, 0xA7, 0x38, 0xC0, 0xAD,
  0x6B, 0x7D, 0xAD, 0x60, 0xCA, 0xDC, 0x67, 0x2B, 0x60, 0xCA, 0xD4, 0x62,
  0x10, 0x80, 0xFF, 0x26, 0xC8, 0xF0, 0xEA, 0xAB, 0xC3, 0x08, 0x43, 0x08,
  0x43, 0xE4, 0x92, 0x4F, 0x46, 0xAB, 0xF0, 0xE0, 0x72, 0xDF, 0xB6, 0x80,
  0x88, 0xEB, 0x9B, 0xE0, 0xEB, 0x8B, 0xE0, 0x33, 0xFB, 0xBB, 0xF0, 0xE9,
  0xF9, 0xE0, 0x19, 0xC9, 0xF2, 0x10, 0x80, 0xFB, 0xBB, 0xF3, 0xE0, 0x88,
  0xEB, 0xBB, 0xB0, 0x60, 0xE6, 0x66, 0xF0, 0x23, 0x92, 0x4F, 0xC0, 0x88,
  0xBA, 0xEA, 0xB0, 0xE7, 0x08, 0x42, 0x10, 0xE0, 0xBF, 0x7B, 0xDE, 0x80,
  0xEB, 0xBB, 0xB0, 0xEB, 0x9B, 0xE0, 0xEB, 0x9B, 0xE8, 0x80, 0xFB, 0xBB,
  0xF3, 0x30, 0xF9, 0x88, 0x80, 0x7A, 0x1F, 0x17, 0x80, 0x27, 0xC8, 0x42,
  0x1C, 0xBB, 0xBB, 0xE0, 0xCA, 0xD4, 0xE3, 0x00, 0xAD, 0x6E, 0xB5, 0x80,
  0xDB, 0x8C, 0xED, 0x80, 0xCA, 0xDC, 0x63, 0x11, 0x80, 0xF2, 0x4C, 0xF0,
  0x76, 0x6C, 0x66, 0x63, 0xFF, 0xC4, 0x47, 0x44, 0x4C, 0xEC, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 3, 3, 5, 1, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 6, 7, 5, 0, -7 },
  { 22, 5, 7, 5, 0, -7 },
  { 27, 1, 3, 5, 2, -7 },
  { 28, 3, 9, 5, 1, -8 },
  { 32, 3, 9, 5, 1, -8 },
  { 36, 5, 4, 5, 0, -5 },
  { 39, 5, 4, 5, 0, -5 },
  { 42, 3, 2, 5, 1, -1 },
  { 43, 3, 2, 5, 1, -4 },
  { 44, 2, 2, 5, 2, -2 },
  { 45, 5, 8, 5, 0, -7 },
  { 50, 4, 7, 5, 1, -7 },
  { 54, 4, 7, 5, 1, -7 },
  { 58, 5, 7, 5, 0, -7 },
  { 63, 5, 7, 5, 0, -7 },
  { 68, 5, 7, 5, 0, -7 },
  { 73, 4, 7, 5, 1, -7 },
  { 77, 5, 7, 5, 0, -7 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 5, 7, 5, 0, -7 },
  { 92, 5, 7, 5, 0, -7 },
  { 97, 2, 5, 5, 2, -5 },
  { 99, 3, 6, 5, 1, -5 },
  { 102, 4, 5, 5, 1, -5 },
  { 105, 4, 4, 5, 1, -5 },
  { 107, 4, 5, 5, 1, -5 },
  { 110, 4, 7, 5, 1, -7 },
  { 114, 5, 9, 5, 0, -7 },
  { 120, 5, 7, 5, 0, -7 },
  { 125, 4, 7, 5, 1, -7 },
  { 129, 4, 7, 5, 1, -7 },
  { 133, 4, 7, 5, 1, -7 },
  { 137, 4, 7, 5, 1, -7 },
  { 141, 4, 7, 5, 1, -7 },
  { 145, 4, 7, 5, 1, -7 },
  { 149, 4, 7, 5, 1, -7 },
  { 153, 4, 7, 5, 1, -7 },
  { 157, 5, 7, 5, 0, -7 },
  { 162, 4, 7, 5, 1, -7 },
  { 166, 4, 7, 5, 1, -7 },
  { 170, 5, 7, 5, 0, -7 },
  { 175, 4, 7, 5, 1, -7 },
  { 179, 4, 7, 5, 1, -7 },
  { 183, 4, 7, 5, 1, -7 },
  { 187, 4, 9, 5, 1, -7 },
  { 192, 4, 7, 5, 1, -7 },
  { 196, 5, 7, 5, 0, -7 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 4, 7, 5, 1, -7 },
  { 210, 5, 7, 5, 0, -7 },
  { 215, 5, 7, 5, 0, -7 },
  { 220, 5, 7, 5, 0, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 4, 7, 5, 1, -7 },
  { 234, 2, 8, 5, 2, -7 },
  { 236, 5, 8, 5, 0, -7 },
  { 241, 3, 8, 5, 1, -7 },
  { 244, 4, 4, 5, 1, -7 },
  { 246, 4, 1, 5, 1, 0 },
  { 247, 3, 1, 5, 1, -7 },
  { 248, 5, 5, 5, 0, -5 },
  { 252, 4, 7, 5, 1, -7 },
  { 256, 4, 5, 5, 1, -5 },
  { 259, 4, 7, 5, 1, -7 },
  { 263, 4, 5, 5, 1, -5 },
  { 266, 5, 7, 5, 0, -7 },
  { 271, 4, 7, 5, 1, -5 },
  { 275, 4, 7, 5, 1, -7 },
  { 279, 4, 7, 5, 1, -7 },
  { 283, 3, 9, 5, 1, -7 },
  { 287, 4, 7, 5, 1, -7 },
  { 291, 5, 7, 5, 0, -7 },
  { 296, 5, 5, 5, 0, -5 },
  { 300, 4, 5, 5, 1, -5 },
  { 303, 4, 5, 5, 1, -5 },
  { 306, 4, 7, 5, 1, -5 },
  { 310, 4, 7, 5, 1, -5 },
  { 314, 4, 5, 5, 1, -5 },
  { 317, 5, 5, 5, 0, -5 },
  { 321, 5, 6, 5, 0, -6 },
  { 325, 4, 5, 5, 1, -5 },
  { 328, 5, 5, 5, 0, -5 },
  { 332, 5, 5, 5, 0, -5 },
  { 336, 5, 5, 5, 0, -5 },
  { 340, 5, 7, 5, 0, -5 },
  { 345, 4, 5, 5, 1, -5 },
  { 348, 4, 8, 5, 1, -7 },
  { 352, 1, 8, 5, 2, -7 },
  { 353, 4, 8, 5, 1, -7 },
  { 357, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_ExtraBold9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_EXTRABOLD9PT7B_H_
