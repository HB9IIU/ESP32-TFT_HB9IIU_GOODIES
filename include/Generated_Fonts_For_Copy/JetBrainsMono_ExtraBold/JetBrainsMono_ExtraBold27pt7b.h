#ifndef _JETBRAINSMONO_EXTRABOLD27PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE7, 0x00, 0x00, 0x67,
  0xBF, 0xE0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7,
  0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xC3, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x8E,
  0x1F, 0xFF, 0xBF, 0xFF, 0x1C, 0x70, 0x70, 0xE0, 0xE1, 0x81, 0xC7, 0x03,
  0x8E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xF0, 0x3F, 0xF1, 0xFF,
  0xE7, 0xFF, 0x9E, 0xDF, 0x7B, 0x3D, 0xEC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0x3C, 0x0C, 0xFF, 0xB3, 0xDF,
  0xDF, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x1C, 0x03, 0xBF, 0x83, 0xBD, 0xC3, 0x9C, 0x61, 0x8E, 0x31,
  0xC7, 0x19, 0xC3, 0x9D, 0xC0, 0xFE, 0xC0, 0x3E, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x77, 0x80, 0x77, 0xE0, 0x77, 0x78, 0x33, 0x9C, 0x39, 0xCE,
  0x38, 0xE7, 0x38, 0x73, 0x98, 0x3F, 0x9C, 0x0F, 0x80, 0x0F, 0xC0, 0x3F,
  0xC0, 0xFF, 0xC1, 0xE7, 0x83, 0x87, 0x07, 0x01, 0x0E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xFC, 0x7F, 0xBD, 0xEF, 0x7B, 0x9E, 0x7F, 0x3C,
  0x7C, 0x78, 0x78, 0xF1, 0xF1, 0xFF, 0xF1, 0xFF, 0xF1, 0xFD, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x81, 0xC3, 0xE3, 0xF3, 0xF9, 0xF1, 0xF0, 0xF0,
  0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E,
  0x0F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x07, 0x80, 0xC0, 0x80, 0x70, 0x3E,
  0x1F, 0x87, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE1, 0xF1, 0xF3, 0xF9, 0xF8,
  0xF0, 0x60, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x18, 0xC7, 0xF3, 0x3F,
  0xFF, 0xF7, 0xFF, 0x80, 0xE0, 0x0F, 0xC0, 0x7B, 0x83, 0xCF, 0x1F, 0x3E,
  0x38, 0x70, 0x21, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x79, 0xF3, 0xC7, 0x9E, 0x3C, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x0F, 0x70, 0x3F,
  0x81, 0xFC, 0x0F, 0xE6, 0x7F, 0x7B, 0xFB, 0xDF, 0xCC, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x0E, 0xF9, 0xF7, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0x0F,
  0x80, 0xFC, 0x0F, 0xE1, 0xFF, 0x0F, 0x78, 0x73, 0xC3, 0x1E, 0x10, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xFE, 0x1F, 0x78,
  0x79, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE3, 0xDE, 0x1F,
  0xF0, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0xF8, 0xFF, 0xE7, 0xFF, 0xBE, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xFE, 0x1F, 0xF9, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x80,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x3D, 0xE1, 0xFF, 0xC7, 0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x0F, 0x7C, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0xC0,
  0xFF, 0xC3, 0xFF, 0x9F, 0xBE, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9F, 0x1E,
  0x3F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xFE, 0x78, 0x79, 0xE0, 0xFF, 0x03,
  0xFE, 0x0F, 0x7C, 0x7D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0x9F, 0x3E, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x7D, 0xFF, 0xF7, 0xFF, 0x87, 0xDE, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x79, 0xFF, 0xDE, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x1E, 0xFF, 0xF7, 0x80, 0x3C, 0x7D, 0xF9, 0xF1,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xCF, 0x9E, 0x3C, 0x79, 0xE3,
  0xC0, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFF, 0x7F, 0x8F, 0xE0, 0xF8, 0x0F,
  0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xF0, 0x03, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x01, 0xF0, 0x0F, 0x03, 0xF1, 0xFE, 0x7F, 0x8F, 0xE0, 0xF8, 0x0C, 0x00,
  0x80, 0x00, 0xFC, 0x1F, 0xF3, 0xFF, 0x7F, 0xE0, 0x3E, 0x03, 0xC0, 0x78,
  0x1F, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3,
  0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF1, 0xF7, 0xE7, 0xEF, 0xCF,
  0x3F, 0x9C, 0x7F, 0x38, 0xFE, 0x71, 0xFC, 0xE3, 0xF9, 0xC7, 0xF3, 0x8F,
  0xE7, 0xFF, 0xC7, 0xDF, 0x82, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xB8, 0x0E, 0x70, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xE3, 0x83, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x78,
  0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xF0, 0xFF, 0x07, 0xFF, 0x3F, 0xFD,
  0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x1E, 0xFF, 0xE7, 0xFE, 0x3F,
  0xF9, 0xE3, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF,
  0xBF, 0xF9, 0xFF, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x0F,
  0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC1, 0xFE, 0x1F, 0xF9, 0xF7, 0xFF, 0x9F, 0xF8, 0x3F,
  0x80, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xF9, 0xF7, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF8, 0xFF, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F,
  0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0xF3, 0xC3, 0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0,
  0xF3, 0xC3, 0xEF, 0x0F, 0xBC, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0xFF, 0xB3, 0x7E, 0xED,
  0xFB, 0xF7, 0xF7, 0xDF, 0xDE, 0xFF, 0x7B, 0xFD, 0xEF, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFD, 0xCF,
  0xEE, 0x7F, 0x73, 0xF9, 0xDF, 0xCE, 0xFE, 0x77, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xF0, 0x1F, 0x81, 0xFF, 0x1F,
  0xFD, 0xFF, 0xEF, 0x0F, 0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0xF9, 0xF7,
  0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xCF, 0xF8, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x0F, 0x78, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x1E, 0xF9, 0xF7, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0xFF, 0x07, 0xFF, 0x3F, 0xFD,
  0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xBF,
  0xF9, 0xFF, 0x8F, 0xFC, 0x79, 0xE3, 0xC7, 0x9E, 0x3C, 0xF1, 0xF7, 0x87,
  0xBC, 0x3F, 0xE0, 0xF0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x78,
  0x7D, 0xE0, 0xF7, 0x80, 0x1F, 0x00, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x81,
  0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x0F, 0x7C, 0x7D, 0xFF, 0xE3,
  0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x1E, 0xF9, 0xF7, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xF0,
  0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xEF, 0x03,
  0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF1, 0xC7, 0xF3, 0xCF, 0xF3, 0xCF, 0x73, 0xCF, 0x73, 0xCF, 0x73,
  0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0x6E, 0x73, 0x6E, 0x76, 0x6E, 0x76,
  0x6E, 0x7E, 0x6E, 0x3E, 0x6E, 0x3E, 0x6E, 0x3E, 0x6C, 0x3E, 0x6C, 0x3E,
  0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0xF0, 0x3C, 0xF0, 0xF9, 0xE1, 0xE1, 0xE7,
  0xC3, 0xCF, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xBC, 0x1E, 0x78, 0x7C,
  0xF8, 0xF0, 0xF3, 0xE1, 0xF7, 0x81, 0xF0, 0xF8, 0x1F, 0x78, 0x1E, 0x7C,
  0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x7C, 0x07, 0xE0,
  0x3F, 0x03, 0xFC, 0x1C, 0xE1, 0xE7, 0x8F, 0x1C, 0x70, 0xF7, 0x87, 0xBC,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0xF8, 0xF0, 0x0F, 0xE1,
  0xFF, 0x8F, 0xFE, 0xF8, 0xF7, 0x87, 0x80, 0x3C, 0x3F, 0xE7, 0xFF, 0x7C,
  0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0xF7, 0xFF, 0xBF, 0xDC, 0xFC, 0xE0, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xE3, 0xFF, 0x9F, 0xFE,
  0xFD, 0xF7, 0x87, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1F, 0xF9, 0xF7, 0xFF, 0xBF, 0xF9, 0xEF, 0x80, 0x1F, 0x83, 0xFF, 0x1F,
  0xFD, 0xF3, 0xEF, 0x0F, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x3F, 0xF3, 0xEF, 0xFF, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF3, 0xEF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF,
  0x7F, 0xF3, 0xEF, 0x1F, 0x83, 0xFF, 0x1F, 0xFD, 0xE1, 0xEF, 0x07, 0x70,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xE1, 0xEF, 0xFF,
  0x3F, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x3E, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x7F, 0xF3, 0xEF,
  0x00, 0xF0, 0x0F, 0x01, 0xF3, 0xFF, 0x3F, 0xE3, 0xF8, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x7C, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x1F, 0xFB,
  0xFF, 0x7F, 0xEF, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xF7, 0xFE, 0xFF,
  0x9F, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1,
  0xFF, 0x0F, 0xBC, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x3C, 0x3F, 0xF0, 0xFF,
  0x83, 0xFF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC,
  0x1F, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0xEF, 0x7B, 0xBD, 0xFF, 0xFF, 0xFC, 0xE7, 0xF3, 0x9F, 0xCE, 0x7F, 0x39,
  0xFC, 0xE7, 0xF3, 0x9F, 0xCE, 0x7F, 0x39, 0xFC, 0xE7, 0xF3, 0x9F, 0xCE,
  0x7F, 0x39, 0xC0, 0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x1F, 0x83, 0xFF, 0x1F, 0xFD, 0xF3, 0xEF, 0x0F, 0x78, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xF3, 0xEF, 0xFF, 0x3F,
  0xF0, 0x7F, 0x00, 0xF7, 0xC7, 0xFF, 0x3F, 0xFD, 0xFB, 0xEF, 0x0F, 0x78,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xF3, 0xEF, 0xFF,
  0x7F, 0xF3, 0xDF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00,
  0x3E, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF3, 0xE7, 0xBF, 0xBF, 0xFF, 0xF1,
  0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF,
  0x9E, 0x1F, 0x78, 0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x01,
  0xF0, 0x03, 0xFE, 0x0F, 0x7F, 0xF9, 0xFF, 0xE1, 0xFF, 0x00, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFE, 0x1F, 0xC0, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x1E, 0x78,
  0x79, 0xF1, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0x7B, 0x81, 0xFE, 0x07,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF1, 0xC7, 0xF3, 0xC7, 0x73,
  0xCF, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0x4E, 0x73, 0x6E, 0x7E,
  0x6E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3C, 0xF8, 0x7C, 0xF0, 0xF0, 0xF3, 0xE1, 0xF7, 0x81, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC1, 0xE7, 0x87,
  0xCF, 0x8F, 0x0F, 0xBE, 0x0F, 0x80, 0xF0, 0x3F, 0xF0, 0x79, 0xE1, 0xF3,
  0xC3, 0xC7, 0xC7, 0x87, 0x9F, 0x0F, 0x3C, 0x0F, 0x78, 0x1E, 0xF0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0xFF, 0x8F,
  0xF0, 0xFE, 0x0F, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F,
  0xC0, 0xFE, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0xF0, 0xFF, 0x07, 0xF1, 0xFF, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00,
  0x3C, 0x01, 0xFC, 0x7F, 0xF1, 0xF9, 0xE7, 0xE3, 0xFF, 0x87, 0xE0, 0x0F,
  0x00,
};

const GFXglyph JetBrainsMono_ExtraBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 20, 16, 6, -20 },
  { 14, 10, 8, 16, 3, -20 },
  { 24, 15, 20, 16, 1, -20 },
  { 62, 14, 27, 16, 1, -23 },
  { 110, 17, 20, 16, 0, -20 },
  { 153, 15, 20, 16, 1, -20 },
  { 191, 4, 8, 16, 6, -20 },
  { 195, 9, 26, 16, 4, -23 },
  { 225, 9, 26, 16, 3, -23 },
  { 255, 14, 14, 16, 1, -16 },
  { 280, 14, 13, 16, 1, -15 },
  { 303, 7, 8, 16, 4, -4 },
  { 310, 8, 4, 16, 4, -11 },
  { 314, 6, 5, 16, 5, -5 },
  { 318, 14, 25, 16, 1, -22 },
  { 362, 13, 20, 16, 2, -20 },
  { 395, 13, 20, 16, 2, -20 },
  { 428, 14, 20, 16, 1, -20 },
  { 463, 14, 20, 16, 1, -20 },
  { 498, 13, 20, 16, 1, -20 },
  { 531, 13, 20, 16, 2, -20 },
  { 564, 14, 20, 16, 1, -20 },
  { 599, 14, 20, 16, 1, -20 },
  { 634, 14, 20, 16, 1, -20 },
  { 669, 14, 20, 16, 1, -20 },
  { 704, 6, 15, 16, 5, -15 },
  { 716, 7, 19, 16, 4, -15 },
  { 733, 12, 15, 16, 2, -16 },
  { 756, 12, 10, 16, 2, -14 },
  { 771, 12, 15, 16, 2, -16 },
  { 794, 11, 20, 16, 3, -20 },
  { 822, 15, 25, 16, 1, -20 },
  { 869, 15, 20, 16, 1, -20 },
  { 907, 13, 20, 16, 2, -20 },
  { 940, 13, 20, 16, 2, -20 },
  { 973, 13, 20, 16, 2, -20 },
  { 1006, 12, 20, 16, 2, -20 },
  { 1036, 13, 20, 16, 2, -20 },
  { 1069, 13, 20, 16, 2, -20 },
  { 1102, 12, 20, 16, 2, -20 },
  { 1132, 12, 20, 16, 2, -20 },
  { 1162, 13, 20, 16, 1, -20 },
  { 1195, 14, 20, 16, 2, -20 },
  { 1230, 12, 20, 16, 3, -20 },
  { 1260, 14, 20, 16, 1, -20 },
  { 1295, 13, 20, 16, 2, -20 },
  { 1328, 13, 20, 16, 2, -20 },
  { 1361, 13, 20, 16, 2, -20 },
  { 1394, 13, 25, 16, 2, -20 },
  { 1435, 13, 20, 16, 2, -20 },
  { 1468, 14, 20, 16, 1, -20 },
  { 1503, 14, 20, 16, 1, -20 },
  { 1538, 13, 20, 16, 2, -20 },
  { 1571, 15, 20, 16, 1, -20 },
  { 1609, 16, 20, 16, 0, -20 },
  { 1649, 15, 20, 16, 1, -20 },
  { 1687, 16, 20, 16, 0, -20 },
  { 1727, 12, 20, 16, 2, -20 },
  { 1757, 8, 25, 16, 5, -22 },
  { 1782, 14, 25, 16, 1, -22 },
  { 1826, 9, 25, 16, 3, -22 },
  { 1855, 13, 11, 16, 2, -20 },
  { 1873, 13, 3, 16, 2, 1 },
  { 1878, 7, 4, 16, 4, -21 },
  { 1882, 13, 15, 16, 1, -15 },
  { 1907, 13, 20, 16, 2, -20 },
  { 1940, 13, 15, 16, 2, -15 },
  { 1965, 12, 20, 16, 2, -20 },
  { 1995, 13, 15, 16, 2, -15 },
  { 2020, 14, 20, 16, 1, -20 },
  { 2055, 12, 20, 16, 2, -15 },
  { 2085, 12, 20, 16, 2, -20 },
  { 2115, 13, 21, 16, 2, -21 },
  { 2150, 11, 26, 16, 2, -21 },
  { 2186, 14, 20, 16, 2, -20 },
  { 2221, 14, 20, 16, 1, -20 },
  { 2256, 14, 15, 16, 1, -15 },
  { 2283, 12, 15, 16, 2, -15 },
  { 2306, 13, 15, 16, 2, -15 },
  { 2331, 13, 20, 16, 2, -15 },
  { 2364, 12, 20, 16, 2, -15 },
  { 2394, 13, 15, 16, 2, -15 },
  { 2419, 14, 15, 16, 1, -15 },
  { 2446, 13, 19, 16, 1, -19 },
  { 2477, 12, 15, 16, 2, -15 },
  { 2500, 14, 15, 16, 1, -15 },
  { 2527, 16, 15, 16, 0, -15 },
  { 2557, 15, 15, 16, 1, -15 },
  { 2586, 15, 20, 16, 1, -15 },
  { 2624, 12, 15, 16, 2, -15 },
  { 2647, 12, 25, 16, 2, -22 },
  { 2685, 4, 25, 16, 6, -22 },
  { 2698, 12, 25, 16, 2, -22 },
  { 2736, 14, 7, 16, 1, -13 },
};

const GFXfont JetBrainsMono_ExtraBold27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_EXTRABOLD27PT7B_H_
