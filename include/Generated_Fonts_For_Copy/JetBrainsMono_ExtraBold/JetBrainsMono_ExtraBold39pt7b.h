#ifndef _JETBRAINSMONO_EXTRABOLD39PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFB, 0xE0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x87, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x83, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x01,
  0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xEE, 0x7E, 0xFC, 0xE7,
  0xEF, 0xCE, 0x00, 0xFC, 0xE0, 0x0F, 0xEE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0E, 0xFE, 0x00, 0xE7, 0xE0, 0x0E, 0x3F, 0xFC, 0xE3, 0xFF,
  0xCE, 0x7E, 0xFE, 0xE7, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x8F, 0xF0, 0x07,
  0x8F, 0xFC, 0x03, 0xC7, 0xFF, 0x03, 0xC7, 0x87, 0x83, 0xC3, 0xC3, 0xC3,
  0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF1, 0xE0, 0x78, 0x79, 0xE0, 0x1E, 0x3D,
  0xF0, 0x0F, 0xFE, 0xF0, 0x03, 0xFE, 0xF0, 0x00, 0xFE, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x3D, 0xFE, 0x00, 0x3D, 0xFF, 0x80, 0x3C, 0xF3, 0xE0, 0x1E, 0xF0, 0xF0,
  0x1E, 0x78, 0x78, 0x1E, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F,
  0x0F, 0x03, 0xCF, 0x8F, 0x01, 0xFF, 0x8F, 0x00, 0x7F, 0xCF, 0x80, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x3E, 0x7D, 0xF9, 0xFB,
  0xF3, 0xF7, 0xCF, 0xC7, 0xFF, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0xE3, 0xF0,
  0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0x3F, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0x7E, 0x0F, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0x80, 0x00, 0x08, 0x03, 0xC0, 0x7E, 0x07,
  0xF0, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x04, 0x80, 0x07, 0x80, 0x3F,
  0x01, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x7F, 0x8F, 0xFC,
  0xFF, 0xC7, 0xFC, 0x3F, 0x81, 0xF8, 0x0F, 0x00, 0x40, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x10,
  0x3C, 0x19, 0xF1, 0xE3, 0xCF, 0xCE, 0x7F, 0xFF, 0x37, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xEF, 0x00, 0x1F,
  0x7C, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0xC0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0,
  0x0E, 0x07, 0x00, 0x20, 0x20, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFE, 0x3F, 0xDF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xCE, 0x3F, 0xFB, 0xE7, 0xFF, 0x7C,
  0xFF, 0xEF, 0x9F, 0xFC, 0xF3, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xF0, 0x7F, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0,
  0x3E, 0x7E, 0x07, 0x8F, 0xC0, 0xC1, 0xF8, 0x10, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0x7F, 0xBF, 0x83, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFB, 0xFD, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x07, 0xDF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC7, 0x81,
  0xFB, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x83, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0xF8, 0x0F, 0xDF, 0x83, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF7,
  0xF0, 0x7E, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFC,
  0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7E, 0xFE, 0x07, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7E,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFE, 0x1F, 0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xEF, 0x80, 0xFD,
  0xF8, 0x3F, 0x3F, 0x8F, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xE1, 0xF9, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF0, 0xFE,
  0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xE7, 0xFB, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0x7C, 0x1F, 0xEF, 0xC0, 0x7D, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x7E,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7C, 0x0F, 0x0F, 0xE3, 0xF8,
  0xFF, 0x3F, 0xCF, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7,
  0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03,
  0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xC7, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0xBE, 0x00,
  0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xF7, 0xFE, 0x1F, 0xDF,
  0xF8, 0xFF, 0xBF, 0xE3, 0xE3, 0xFF, 0x8F, 0x87, 0xFE, 0x3C, 0x1F, 0xF8,
  0xF0, 0x7F, 0xE3, 0xC1, 0xFF, 0x8F, 0x07, 0xFE, 0x3C, 0x1F, 0xF8, 0xF0,
  0x7F, 0xE3, 0xC1, 0xFF, 0x8F, 0x87, 0xFE, 0x3F, 0x7F, 0xF8, 0xFF, 0xBF,
  0xE1, 0xFD, 0xFF, 0x81, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8,
  0x1F, 0x07, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xFB,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x83, 0xFD, 0xF0, 0x1F, 0xBE, 0x03,
  0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x7E, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xF8, 0x0F,
  0xDF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFE, 0x03, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFE, 0x1F, 0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7F,
  0x7F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x3F, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFE, 0x1F, 0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x81, 0xFB, 0xF0,
  0x7F, 0x7F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xF8,
  0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x0F, 0xCF, 0x81, 0xF9, 0xF0,
  0x7F, 0x3E, 0x0F, 0xC7, 0xC3, 0xF8, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE3,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xF8, 0xFE, 0x1F, 0x0F, 0xC3, 0xE1, 0xFC, 0x7C, 0x1F, 0x8F, 0x83,
  0xF1, 0xF0, 0x7F, 0x3E, 0x07, 0xE7, 0xC0, 0xFE, 0xF8, 0x0F, 0xDF, 0x01,
  0xFB, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xF7, 0x1F, 0xFF,
  0x79, 0xDF, 0xF7, 0x9D, 0xFF, 0x3B, 0xDF, 0xFB, 0xBD, 0xFF, 0xBF, 0x9F,
  0xFB, 0xF9, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xFF, 0x9F, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFB,
  0xC3, 0xFF, 0x7C, 0x7F, 0xEF, 0x8F, 0xFC, 0xF1, 0xFF, 0x9F, 0x3F, 0xF3,
  0xE7, 0xFE, 0x3C, 0xFF, 0xC7, 0xDF, 0xF8, 0xFB, 0xFF, 0x0F, 0x7F, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFE,
  0x3F, 0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7F, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFC, 0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xE7, 0xE0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE,
  0x03, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x7C,
  0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0x1F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xF1, 0xF0,
  0x7E, 0x3E, 0x0F, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x9F, 0x01, 0xFB, 0xE0,
  0x3F, 0x7C, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF1, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xEF, 0xE0, 0x7E, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x3F,
  0x07, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x3E,
  0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x01, 0xF7, 0xE0,
  0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0xF8, 0x7C, 0x3E, 0xF0, 0xF8, 0x7D, 0xE1, 0xF0, 0xFB, 0xC3, 0xE1, 0xF7,
  0xC7, 0xE3, 0xEF, 0x8F, 0xC7, 0x9F, 0x1B, 0x8F, 0x3E, 0x37, 0x1E, 0x7C,
  0xEE, 0x3C, 0xF9, 0xDC, 0xF9, 0xF3, 0xB9, 0xF1, 0xE7, 0x73, 0xE3, 0xCE,
  0x67, 0xC7, 0x9C, 0xCF, 0x8F, 0x39, 0xDF, 0x1E, 0x73, 0xBC, 0x3C, 0xC7,
  0x78, 0x7D, 0x8E, 0xF0, 0xFF, 0x1D, 0xE1, 0xFE, 0x3B, 0xC3, 0xFC, 0x77,
  0x87, 0xF8, 0xEF, 0x07, 0xF0, 0xDE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFE, 0x03, 0xF9,
  0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7F,
  0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0xBF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x1F, 0x80,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3F, 0x3E, 0x00, 0xFD, 0xF8, 0x01, 0xF7, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0xFF, 0x01, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x83,
  0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x1F, 0xDF, 0x81, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0x7E, 0x3F, 0xCF, 0xC0, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x87, 0x83, 0xE7, 0xF8, 0xFB, 0xFF, 0x3E, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8,
  0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFF, 0xEF, 0xBF, 0xF3, 0xE3,
  0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFE, 0x3F, 0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC1, 0xF1, 0xF8, 0xFF,
  0x3F, 0x3F, 0xF7, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xDF, 0x87, 0xF3,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFC, 0x1F, 0xDF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xEF, 0xE1, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x03, 0xFC, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFB, 0xF8, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xDF, 0x8F, 0xF3,
  0xF0, 0x78, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x87, 0x83, 0xE7, 0xF8, 0xFB, 0xFF, 0x3E, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xC3, 0x8F, 0x7E, 0x7C,
  0xF7, 0xEF, 0xEF, 0xFE, 0xFF, 0xF9, 0xF3, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1,
  0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F,
  0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8,
  0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF,
  0x8F, 0x1F, 0x00, 0x78, 0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xEF, 0xFE, 0xFF,
  0xFF, 0xBF, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFE, 0x3F, 0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x3E,
  0x7F, 0x8F, 0xBF, 0xF3, 0xEF, 0xFE, 0xFF, 0xFF, 0xBF, 0x8F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xFE, 0xFB, 0xFF, 0x3E, 0x3F, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF1, 0xFF, 0x7E, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x3C, 0x1F, 0xBF, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x0F, 0xDF, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7F, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFC, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x7E,
  0x03, 0xE3, 0xF0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x03, 0xEF, 0xC0, 0x1F,
  0x7E, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x3C, 0x3E, 0xF0, 0xF8, 0x7D,
  0xE1, 0xF0, 0xFB, 0xE3, 0xE1, 0xE7, 0xC7, 0xC3, 0xCF, 0x8D, 0xC7, 0x9F,
  0x1B, 0x9F, 0x1E, 0x77, 0x3E, 0x3C, 0xEE, 0x7C, 0x79, 0xDC, 0xF8, 0xFB,
  0x99, 0xE1, 0xF7, 0x3B, 0xC3, 0xEE, 0x77, 0x87, 0xD8, 0xEF, 0x07, 0xF1,
  0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F,
  0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x7F, 0x03, 0xF9, 0xF8, 0x3F,
  0x8F, 0xE1, 0xF8, 0x3F, 0x1F, 0x80, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xF9,
  0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x3F, 0x0F, 0xC1, 0xFC, 0xFC, 0x07, 0xEF,
  0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC,
  0x0F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x1F, 0x7F,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0x1F, 0x9F, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFE, 0xF0, 0x7F, 0xC0, 0x01, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 15, 11, 23, 4, -28 },
  { 47, 22, 28, 23, 1, -28 },
  { 124, 20, 39, 23, 2, -34 },
  { 222, 25, 29, 23, -1, -29 },
  { 313, 22, 29, 23, 1, -29 },
  { 393, 6, 11, 23, 9, -28 },
  { 402, 13, 38, 23, 6, -33 },
  { 464, 13, 38, 23, 4, -33 },
  { 526, 21, 21, 23, 1, -24 },
  { 582, 19, 18, 23, 2, -22 },
  { 625, 11, 12, 23, 5, -6 },
  { 642, 13, 6, 23, 5, -16 },
  { 652, 8, 7, 23, 8, -7 },
  { 659, 19, 36, 23, 2, -32 },
  { 745, 19, 29, 23, 2, -29 },
  { 814, 19, 28, 23, 3, -28 },
  { 881, 19, 29, 23, 2, -29 },
  { 950, 19, 28, 23, 2, -28 },
  { 1017, 18, 28, 23, 2, -28 },
  { 1080, 19, 28, 23, 2, -28 },
  { 1147, 20, 28, 23, 2, -28 },
  { 1217, 19, 28, 23, 2, -28 },
  { 1284, 19, 29, 23, 2, -29 },
  { 1353, 20, 29, 23, 2, -29 },
  { 1426, 8, 22, 23, 8, -22 },
  { 1448, 10, 28, 23, 6, -22 },
  { 1483, 18, 22, 23, 3, -24 },
  { 1533, 17, 15, 23, 3, -20 },
  { 1565, 18, 22, 23, 3, -24 },
  { 1615, 16, 28, 23, 4, -28 },
  { 1671, 22, 36, 23, 1, -29 },
  { 1770, 21, 28, 23, 1, -28 },
  { 1844, 19, 28, 23, 3, -28 },
  { 1911, 19, 29, 23, 2, -29 },
  { 1980, 20, 28, 23, 2, -28 },
  { 2050, 18, 28, 23, 3, -28 },
  { 2113, 18, 28, 23, 3, -28 },
  { 2176, 19, 29, 23, 2, -29 },
  { 2245, 18, 28, 23, 3, -28 },
  { 2308, 17, 28, 23, 3, -28 },
  { 2368, 19, 28, 23, 1, -28 },
  { 2435, 19, 28, 23, 3, -28 },
  { 2502, 17, 28, 23, 4, -28 },
  { 2562, 20, 28, 23, 2, -28 },
  { 2632, 19, 28, 23, 2, -28 },
  { 2699, 19, 29, 23, 2, -29 },
  { 2768, 19, 28, 23, 3, -28 },
  { 2835, 20, 36, 23, 2, -29 },
  { 2925, 19, 28, 23, 3, -28 },
  { 2992, 20, 29, 23, 2, -29 },
  { 3065, 20, 28, 23, 2, -28 },
  { 3135, 19, 28, 23, 2, -28 },
  { 3202, 21, 28, 23, 1, -28 },
  { 3276, 23, 28, 23, 0, -28 },
  { 3357, 22, 28, 23, 1, -28 },
  { 3434, 22, 28, 23, 1, -28 },
  { 3511, 17, 28, 23, 3, -28 },
  { 3571, 12, 36, 23, 7, -32 },
  { 3625, 19, 36, 23, 2, -32 },
  { 3711, 12, 36, 23, 5, -32 },
  { 3765, 19, 15, 23, 2, -28 },
  { 3801, 19, 5, 23, 2, 1 },
  { 3813, 10, 6, 23, 6, -31 },
  { 3821, 19, 22, 23, 2, -22 },
  { 3874, 18, 28, 23, 3, -28 },
  { 3937, 19, 22, 23, 2, -22 },
  { 3990, 19, 28, 23, 2, -28 },
  { 4057, 19, 22, 23, 2, -22 },
  { 4110, 19, 28, 23, 2, -28 },
  { 4177, 19, 29, 23, 2, -22 },
  { 4246, 18, 28, 23, 3, -28 },
  { 4309, 19, 31, 23, 3, -31 },
  { 4383, 16, 38, 23, 3, -31 },
  { 4459, 20, 28, 23, 3, -28 },
  { 4529, 21, 28, 23, 1, -28 },
  { 4603, 20, 22, 23, 2, -22 },
  { 4658, 18, 22, 23, 3, -22 },
  { 4708, 19, 22, 23, 2, -22 },
  { 4761, 18, 29, 23, 3, -22 },
  { 4827, 19, 29, 23, 2, -22 },
  { 4896, 19, 22, 23, 3, -22 },
  { 4949, 19, 22, 23, 2, -22 },
  { 5002, 20, 28, 23, 1, -28 },
  { 5072, 19, 21, 23, 2, -21 },
  { 5122, 21, 21, 23, 1, -21 },
  { 5178, 23, 21, 23, 0, -21 },
  { 5239, 21, 21, 23, 1, -21 },
  { 5295, 21, 28, 23, 1, -21 },
  { 5369, 18, 21, 23, 3, -21 },
  { 5417, 17, 36, 23, 3, -32 },
  { 5494, 6, 36, 23, 9, -32 },
  { 5521, 17, 36, 23, 3, -32 },
  { 5598, 20, 10, 23, 2, -19 },
};

const GFXfont JetBrainsMono_ExtraBold39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_EXTRABOLD39PT7B_H_
