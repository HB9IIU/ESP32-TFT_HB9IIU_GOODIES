#ifndef _JETBRAINSMONO_EXTRABOLD20PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0x66, 0x66, 0x00, 0x6F, 0xF0, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0x0C, 0xE0, 0xCC, 0x0C, 0xC1, 0x8C, 0x7F, 0xF7, 0xFF,
  0x19, 0xC1, 0x98, 0x19, 0x83, 0x18, 0xFF, 0xEF, 0xFE, 0x33, 0x83, 0x30,
  0x73, 0x00, 0x0C, 0x03, 0x01, 0xE1, 0xFE, 0x7F, 0xBB, 0x7E, 0xC3, 0xF0,
  0x7E, 0x1F, 0xE1, 0xF8, 0x3F, 0x0D, 0xFB, 0x7F, 0xFD, 0xFE, 0x3F, 0x03,
  0x00, 0xC0, 0x30, 0x30, 0x37, 0xC7, 0xCC, 0x6C, 0xCC, 0xCD, 0x8F, 0xD8,
  0x7B, 0x00, 0x60, 0x0C, 0xC0, 0xFE, 0x1B, 0x33, 0x33, 0x33, 0x36, 0x3F,
  0xC1, 0xE0, 0x1E, 0x07, 0xE1, 0xFE, 0x39, 0xC7, 0x00, 0xE0, 0x1E, 0x07,
  0xC0, 0xFD, 0xD9, 0xFB, 0x1E, 0x73, 0xCE, 0x79, 0xFF, 0x9F, 0x78, 0xFF,
  0xF0, 0x02, 0x1C, 0xF9, 0xE7, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x1C, 0x3C, 0x3E, 0x3C, 0x38, 0x81, 0xC3, 0xE3, 0xC1, 0xC3, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x1E, 0xF9, 0xE3, 0x80, 0x0C,
  0x03, 0x08, 0xC7, 0xB7, 0xFB, 0xC3, 0x01, 0xE0, 0xCC, 0x73, 0x8C, 0xC0,
  0x1E, 0x07, 0x81, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0x78, 0x1E, 0x00,
  0x7B, 0x9D, 0xEE, 0x70, 0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x00, 0x1E, 0x1F, 0xE7,
  0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0xDF, 0xB7, 0xED, 0xF8, 0x7E, 0x1F, 0x87,
  0xF3, 0xDF, 0xE3, 0xF0, 0x1C, 0x3E, 0x3F, 0x1F, 0x89, 0xC4, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x1E, 0x1F, 0xE7,
  0xFB, 0x8F, 0xE1, 0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7, 0xF8, 0x1E, 0x0E, 0x07, 0x01,
  0xF0, 0x7E, 0x03, 0xC0, 0x70, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0x03,
  0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x81, 0xCF, 0xE3, 0xF8, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x7F, 0x9F, 0xE7, 0xF9, 0x80, 0x60,
  0x19, 0x86, 0xF9, 0xFE, 0x01, 0xC0, 0x70, 0x1F, 0x87, 0xF3, 0xDF, 0xE3,
  0xF0, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x73, 0xFE, 0xF3,
  0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xE3, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xDC, 0xE7, 0xF8,
  0x7C, 0x7F, 0xBC, 0xFE, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0x1E, 0x1F,
  0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xFF, 0x7F, 0x80, 0xE0, 0x70,
  0x3C, 0x0E, 0x07, 0x03, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x7B,
  0xDE, 0x00, 0x00, 0x00, 0x7B, 0x9C, 0xEE, 0x70, 0x00, 0xC0, 0xF0, 0xFC,
  0xF8, 0xF8, 0x38, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x0F, 0xC0, 0x7E, 0x07,
  0xC0, 0x70, 0xFC, 0xFC, 0xFC, 0x3C, 0x0C, 0x00, 0xF8, 0xFE, 0xFF, 0x07,
  0x07, 0x07, 0x3F, 0x3E, 0x3C, 0x30, 0x30, 0x00, 0x30, 0x78, 0x70, 0x0F,
  0x03, 0xFC, 0x78, 0xE7, 0x06, 0x60, 0x76, 0x37, 0xE7, 0xBE, 0xE7, 0xEE,
  0x7E, 0xE7, 0xEE, 0x7E, 0xE7, 0xE7, 0xF6, 0x37, 0x60, 0x07, 0x00, 0x3F,
  0x01, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x81,
  0xF8, 0x19, 0x83, 0x9C, 0x39, 0xC3, 0xFC, 0x3F, 0xC7, 0xFE, 0x70, 0xE7,
  0x0E, 0xF0, 0xF0, 0xFC, 0x3F, 0xEF, 0xFB, 0x87, 0xE1, 0xF8, 0x7F, 0xFB,
  0xFC, 0xFF, 0xB8, 0x7E, 0x1F, 0x87, 0xE3, 0xFF, 0xEF, 0xF0, 0x1E, 0x1F,
  0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x87, 0x73, 0xDF, 0xE3, 0xF0, 0xFC, 0x3F, 0xCF, 0xFB, 0x8F, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xFF, 0xEF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xFF, 0x70, 0x38,
  0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0F, 0xFB, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x9F, 0xE7, 0xF9,
  0xFE, 0x1F, 0x87, 0x73, 0xDF, 0xE3, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xC7, 0x7B, 0xDF, 0xF3, 0xF0,
  0xE1, 0xDC, 0x3B, 0x8E, 0x71, 0xCE, 0x79, 0xCE, 0x3F, 0xC7, 0xF0, 0xFF,
  0x1C, 0xE3, 0x9E, 0x71, 0xCE, 0x39, 0xC3, 0xB8, 0x78, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFE, 0xE1, 0xFC, 0xFF, 0x3F, 0xCF, 0xD2, 0xF7, 0xBD, 0xEF, 0x7B,
  0xED, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xF1, 0xFC, 0x7F,
  0x1F, 0xE7, 0xF9, 0xFE, 0x7F, 0xDF, 0xB7, 0xED, 0xFB, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF8, 0xFE, 0x3C, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0xFC,
  0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0xBF, 0x8E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0xDF, 0xE3,
  0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0xFC, 0x3F, 0xEF, 0xFB, 0x87, 0xE1,
  0xF8, 0x7E, 0x3F, 0xFE, 0xFF, 0x39, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0xFE,
  0x1C, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE0, 0x3C, 0x07, 0xE1, 0xFE, 0x1F,
  0x80, 0xF0, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0xF0, 0xF7,
  0x0E, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x19, 0xC1,
  0xD8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE6, 0x7E, 0x67,
  0xE6, 0x7E, 0x66, 0x6F, 0x66, 0xF6, 0x6F, 0x66, 0xF6, 0x69, 0x66, 0x96,
  0x69, 0x66, 0x96, 0x79, 0x67, 0x9C, 0x39, 0xC0, 0x70, 0xE7, 0x0E, 0x39,
  0xC3, 0x9C, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F,
  0x83, 0x9C, 0x39, 0xC7, 0x0E, 0xF0, 0xF0, 0xE0, 0x77, 0x0E, 0x70, 0xE3,
  0x9C, 0x39, 0xC1, 0xD8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0x9F, 0xE7, 0xF8, 0x0E, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xF8, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFF, 0xF8, 0x0E,
  0x07, 0x81, 0xE0, 0xFC, 0x33, 0x1C, 0xE7, 0x3B, 0x87, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE3, 0x8E, 0x3F, 0x1F, 0xE7, 0x3E, 0x07, 0x1F, 0xDF, 0xFE, 0x1F,
  0x87, 0xE3, 0xFF, 0xF7, 0xDC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x3F,
  0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xFF, 0xEE, 0xF0,
  0x3F, 0x1F, 0xEF, 0x3F, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x87, 0x73, 0xDF,
  0xE3, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x3D, 0xDF, 0xFF, 0x3F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF3, 0xDC, 0x3F, 0x1F, 0xEF,
  0x3F, 0x87, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xF3, 0xDF, 0xE3, 0xF0, 0x03,
  0xC3, 0xF1, 0xFC, 0x70, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x3D, 0xDF, 0xFF, 0x3F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0xCF, 0x7F, 0xDF, 0x70, 0x1C, 0x07, 0x3F, 0x8F, 0xE3,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x3F, 0xEF, 0x3F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x3F, 0xFF, 0xFF, 0xFF, 0x06, 0x0F, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0xFE, 0xFC, 0xF0,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xC7, 0xB8, 0xE7, 0x3C, 0xFF,
  0x1F, 0xE3, 0xFC, 0x73, 0xCE, 0x39, 0xC7, 0xB8, 0x78, 0xFE, 0x1F, 0xC3,
  0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xFE, 0x0F, 0xC0, 0xF8, 0xDB, 0xFF, 0xFC, 0xCF, 0x33, 0xCC,
  0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCC, 0xEF, 0x3F, 0xEF, 0x3F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x3F, 0x1F,
  0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0,
  0xEF, 0x3F, 0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xFF,
  0xEE, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x3D, 0xDF, 0xFF, 0x3F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF3, 0xDC, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0xDF, 0x6F, 0xF9, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x00, 0x3F, 0x1F, 0xEE, 0x1F, 0x80, 0x7E, 0x1F, 0xE0, 0x7C,
  0x07, 0xE1, 0xDF, 0xF3, 0xF8, 0x1C, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0x1F, 0xC3, 0xF0, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE3,
  0xF0, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x73, 0x9C, 0xE3, 0xB0, 0xFC, 0x3F,
  0x07, 0x81, 0xE0, 0xE6, 0x7E, 0x67, 0x66, 0x66, 0xF6, 0x6F, 0x66, 0xF6,
  0x69, 0x67, 0x9E, 0x79, 0xE3, 0x9C, 0x39, 0xC0, 0xE1, 0xDC, 0xE7, 0xF8,
  0xFC, 0x1E, 0x07, 0x81, 0xF0, 0xFC, 0x73, 0x9C, 0xEE, 0x1C, 0xE1, 0xF8,
  0x77, 0x1D, 0xCE, 0x73, 0x8E, 0xE3, 0xF0, 0xFC, 0x1E, 0x07, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0x7F, 0x9F, 0xE7, 0xF8, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC1, 0xF0, 0xFC, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFE, 0x3F, 0x0F, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xC1, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x3E, 0x0F, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1F, 0xC3, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0xFC, 0x3E, 0x0F, 0x80, 0x30, 0x3E, 0x3F, 0xCF, 0x3F, 0xC7, 0xC0,
  0x40,
};

const GFXglyph JetBrainsMono_ExtraBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 8, 6, 12, 2, -15 },
  { 15, 12, 15, 12, 0, -15 },
  { 38, 10, 20, 12, 1, -17 },
  { 63, 12, 15, 12, 0, -15 },
  { 86, 11, 15, 12, 1, -15 },
  { 107, 2, 6, 12, 5, -15 },
  { 109, 7, 19, 12, 3, -17 },
  { 126, 7, 19, 12, 2, -17 },
  { 143, 10, 10, 12, 1, -12 },
  { 156, 10, 9, 12, 1, -11 },
  { 168, 5, 6, 12, 3, -3 },
  { 172, 6, 3, 12, 3, -8 },
  { 175, 4, 4, 12, 4, -4 },
  { 177, 10, 19, 12, 1, -17 },
  { 201, 10, 15, 12, 1, -15 },
  { 220, 9, 15, 12, 2, -15 },
  { 237, 10, 15, 12, 1, -15 },
  { 256, 10, 15, 12, 1, -15 },
  { 275, 10, 15, 12, 1, -15 },
  { 294, 10, 15, 12, 1, -15 },
  { 313, 10, 15, 12, 1, -15 },
  { 332, 10, 15, 12, 1, -15 },
  { 351, 10, 15, 12, 1, -15 },
  { 370, 10, 15, 12, 1, -15 },
  { 389, 4, 11, 12, 4, -11 },
  { 395, 5, 14, 12, 3, -11 },
  { 404, 10, 11, 12, 1, -12 },
  { 418, 8, 8, 12, 2, -11 },
  { 426, 10, 11, 12, 1, -12 },
  { 440, 8, 15, 12, 2, -15 },
  { 455, 12, 19, 12, 0, -15 },
  { 484, 12, 15, 12, 0, -15 },
  { 507, 10, 15, 12, 1, -15 },
  { 526, 10, 15, 12, 1, -15 },
  { 545, 10, 15, 12, 1, -15 },
  { 564, 9, 15, 12, 2, -15 },
  { 581, 10, 15, 12, 1, -15 },
  { 600, 10, 15, 12, 1, -15 },
  { 619, 10, 15, 12, 1, -15 },
  { 638, 8, 15, 12, 2, -15 },
  { 653, 10, 15, 12, 0, -15 },
  { 672, 11, 15, 12, 1, -15 },
  { 693, 9, 15, 12, 2, -15 },
  { 710, 10, 15, 12, 1, -15 },
  { 729, 10, 15, 12, 1, -15 },
  { 748, 10, 15, 12, 1, -15 },
  { 767, 10, 15, 12, 1, -15 },
  { 786, 10, 19, 12, 1, -15 },
  { 810, 10, 15, 12, 1, -15 },
  { 829, 10, 15, 12, 1, -15 },
  { 848, 10, 15, 12, 1, -15 },
  { 867, 10, 15, 12, 1, -15 },
  { 886, 12, 15, 12, 0, -15 },
  { 909, 12, 15, 12, 0, -15 },
  { 932, 12, 15, 12, 0, -15 },
  { 955, 12, 15, 12, 0, -15 },
  { 978, 10, 15, 12, 1, -15 },
  { 997, 7, 19, 12, 3, -17 },
  { 1014, 10, 19, 12, 1, -17 },
  { 1038, 7, 19, 12, 2, -17 },
  { 1055, 10, 8, 12, 1, -15 },
  { 1065, 10, 3, 12, 1, 0 },
  { 1069, 5, 3, 12, 3, -16 },
  { 1071, 10, 11, 12, 1, -11 },
  { 1085, 10, 15, 12, 1, -15 },
  { 1104, 10, 11, 12, 1, -11 },
  { 1118, 10, 15, 12, 1, -15 },
  { 1137, 10, 11, 12, 1, -11 },
  { 1151, 10, 15, 12, 1, -15 },
  { 1170, 10, 15, 12, 1, -11 },
  { 1189, 10, 15, 12, 1, -15 },
  { 1208, 10, 16, 12, 1, -16 },
  { 1228, 8, 20, 12, 2, -16 },
  { 1248, 11, 15, 12, 1, -15 },
  { 1269, 11, 15, 12, 0, -15 },
  { 1290, 10, 11, 12, 1, -11 },
  { 1304, 10, 11, 12, 1, -11 },
  { 1318, 10, 11, 12, 1, -11 },
  { 1332, 10, 15, 12, 1, -11 },
  { 1351, 10, 15, 12, 1, -11 },
  { 1370, 9, 11, 12, 2, -11 },
  { 1383, 10, 11, 12, 1, -11 },
  { 1397, 10, 14, 12, 1, -14 },
  { 1415, 10, 11, 12, 1, -11 },
  { 1429, 10, 11, 12, 1, -11 },
  { 1443, 12, 11, 12, 0, -11 },
  { 1460, 10, 11, 12, 1, -11 },
  { 1474, 10, 15, 12, 1, -11 },
  { 1493, 10, 11, 12, 1, -11 },
  { 1507, 10, 19, 12, 1, -17 },
  { 1531, 4, 19, 12, 4, -17 },
  { 1541, 10, 19, 12, 1, -17 },
  { 1565, 10, 6, 12, 1, -10 },
};

const GFXfont JetBrainsMono_ExtraBold20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_EXTRABOLD20PT7B_H_
