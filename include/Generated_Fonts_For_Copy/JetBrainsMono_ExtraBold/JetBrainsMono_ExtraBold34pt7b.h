#ifndef _JETBRAINSMONO_EXTRABOLD34PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x33, 0xFF, 0xFF, 0x7C, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xF7, 0x87,
  0x80, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0x80, 0x70,
  0x70, 0x0E, 0x0E, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE1, 0xE1,
  0xC0, 0x38, 0x38, 0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0xE0, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x70, 0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x78, 0x78,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x7F, 0x80, 0x7F, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0xDF, 0xBE, 0x67,
  0xDF, 0x33, 0xEF, 0x98, 0x07, 0xEC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x1B, 0xF0, 0x0C, 0xFC,
  0x06, 0x3F, 0xF3, 0x1F, 0xF9, 0x9F, 0xFE, 0xDF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x3C, 0x7F, 0x01, 0xE3, 0xFE, 0x07,
  0x1E, 0x38, 0x3C, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x07, 0x8F, 0x38, 0x1E,
  0x3D, 0xE0, 0x3D, 0xEF, 0x00, 0xFF, 0xB8, 0x01, 0xFD, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x7E, 0x00, 0x7B, 0xFC,
  0x01, 0xDF, 0xF8, 0x0E, 0x70, 0xE0, 0x79, 0xC3, 0x83, 0xC7, 0x0E, 0x0E,
  0x1C, 0x38, 0x78, 0x71, 0xE3, 0xC1, 0xFF, 0x8E, 0x03, 0xFC, 0xF0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xCF, 0xBE, 0xF9,
  0xF7, 0xCF, 0xFC, 0xF8, 0xFF, 0x9F, 0x0F, 0xE3, 0xE1, 0xFC, 0x7C, 0x1F,
  0x0F, 0xC3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xBE, 0x1F, 0xE3,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x20, 0x1C, 0x07,
  0x83, 0xF0, 0xFE, 0x3F, 0xCF, 0xE1, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xE1, 0xFE,
  0x1F, 0xC0, 0xF8, 0x0F, 0x00, 0x20, 0x80, 0x1C, 0x03, 0xE0, 0x7E, 0x0F,
  0xE1, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x3F, 0xCF, 0xF1, 0xFC, 0x3F,
  0x07, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x41, 0xE0, 0x9C, 0x38, 0xE7, 0xCE, 0xFF, 0xFB, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xC0, 0x1E, 0x00, 0x0F, 0xE0, 0x07, 0xBC, 0x03, 0xCF, 0x81,
  0xF3, 0xF0, 0xF8, 0x7C, 0x1E, 0x1E, 0x01, 0x03, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x9F, 0x8F, 0xC7, 0xC7,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFE, 0x7E, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF9, 0xCF, 0xFB, 0xCF, 0xFB, 0xEF, 0xFB, 0xCF, 0xF9, 0xCF, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFB, 0xE0, 0xF3, 0xE0, 0xC3, 0xE0, 0x83,
  0xE0, 0x83, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7D, 0xF8, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0x7C, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0xBE, 0x0F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0,
  0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xCF, 0xE3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xFC, 0x1F,
  0x3F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xE1, 0xF9,
  0xF9, 0xF8, 0x7E, 0xF8, 0x1F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xF7, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0xFB,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xEF,
  0xE7, 0xFF, 0xF3, 0xFE, 0xF8, 0x7E, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x3F, 0x7F, 0xFF, 0xF9, 0xF0, 0x1E, 0x1F,
  0x8F, 0xE7, 0xF3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1,
  0xF0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07,
  0xFE, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x07, 0xE3,
  0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xDF, 0xC7,
  0xC0, 0x7C, 0xF0, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x79, 0xFE,
  0x1F, 0xBF, 0xC7, 0xFF, 0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE7, 0xC3, 0xFC,
  0xF8, 0x7F, 0x9F, 0x0F, 0xF3, 0xE1, 0xFE, 0x7C, 0x3F, 0xC7, 0x87, 0xF8,
  0xF1, 0xFF, 0x1F, 0xFF, 0xE1, 0xFB, 0xFC, 0x1E, 0x7F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F,
  0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3C,
  0x3E, 0x0F, 0x87, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0xE0, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0x87, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xE0, 0xFD,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF7, 0xE0, 0xFB, 0xE0,
  0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x07, 0xFF, 0x83, 0xEF, 0xC3, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xC1, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF7, 0xE0, 0xFB,
  0xE0, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x07, 0xFF, 0x83, 0xEF, 0xC3, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x03,
  0xEF, 0xC3, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x00,
  0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E,
  0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE3, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0xF8, 0x3F, 0x3E,
  0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x7E, 0xF8, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFD, 0xC7, 0xFF, 0x73, 0xBF,
  0xFC, 0xEF, 0xFF, 0xBB, 0xFE, 0xEE, 0xFF, 0xBF, 0x3F, 0xEF, 0xCF, 0xF9,
  0xF7, 0xFE, 0x7D, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF7,
  0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF9, 0xCF, 0xF9, 0xEF, 0xF9,
  0xEF, 0xF8, 0xEF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xE3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0xC3, 0xF3,
  0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0xFF, 0xE0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0xFF, 0xEF, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E,
  0x1F, 0x1F, 0x0F, 0xCF, 0x83, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F,
  0xF8, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF,
  0xE3, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF7,
  0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8, 0x07, 0xFF, 0x00,
  0xFB, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0x79, 0xF0, 0x0F, 0xBE,
  0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xF8, 0xF0, 0xFF, 0x8F,
  0x0F, 0x78, 0xF0, 0xF7, 0x8F, 0x8F, 0x78, 0xF8, 0xF7, 0x8F, 0x9F, 0x78,
  0xF9, 0xE7, 0x9D, 0x9E, 0x79, 0xD9, 0xE7, 0x9D, 0x9E, 0x79, 0xD9, 0xE7,
  0x9D, 0x9E, 0x79, 0x99, 0xE3, 0xD9, 0xDE, 0x3D, 0x9D, 0xE3, 0xD9, 0xDE,
  0x3F, 0x9D, 0xC3, 0xF8, 0xDC, 0x3F, 0x8D, 0xC3, 0xF8, 0xDC, 0x3F, 0x8D,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0xC0, 0xFC,
  0x07, 0xCF, 0x81, 0xF9, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xF1, 0xF0, 0x3E,
  0x7E, 0x07, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x83, 0xE1,
  0xF0, 0xFC, 0x3F, 0x1F, 0x03, 0xE7, 0xE0, 0x7E, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xFF, 0x00, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xE0, 0xF8, 0x7C,
  0x3F, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3C,
  0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF,
  0x3F, 0x9F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0xF8, 0xFB, 0xFC, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFB, 0xFE,
  0xFB, 0xFE, 0xF9, 0xF8, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xE7, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xE0, 0xFB, 0xF0, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x9F, 0x3F,
  0xDF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x1F, 0x7F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x9F, 0x3F, 0xDF, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0xFB,
  0xFC, 0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x03,
  0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0xFF, 0xFB,
  0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xE0,
  0x7E, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xE1, 0xF8, 0xF8, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0x8F, 0xC3, 0xE1, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0,
  0x7E, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0xF3, 0x8F, 0x3D, 0xF7, 0xEF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xE3,
  0xFE, 0x78, 0xFF, 0x9E, 0x3F, 0xE7, 0x8F, 0xF9, 0xE3, 0xFE, 0x78, 0xFF,
  0x9E, 0x3F, 0xE7, 0x8F, 0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x9E, 0x3F, 0xE7,
  0x8F, 0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x9E, 0x3C, 0xF8, 0xF8, 0xFB, 0xFC,
  0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0,
  0xF8, 0xF8, 0xFB, 0xFC, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFB, 0xFE, 0xFB, 0xFE,
  0xF9, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x0F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF0, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x1F,
  0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xF0,
  0xF0, 0xF7, 0x8F, 0x0F, 0x78, 0xF0, 0xF7, 0x8F, 0x0F, 0x78, 0xF9, 0xE7,
  0x8F, 0x9E, 0x78, 0xD9, 0xE7, 0x9D, 0x9E, 0x3D, 0xD9, 0xE3, 0xDD, 0x9E,
  0x3D, 0x9D, 0xE3, 0xD9, 0xDC, 0x3D, 0x9F, 0xC3, 0xF9, 0xFC, 0x3F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x80, 0xFC,
  0x0F, 0xCF, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x9F, 0x81, 0xFB, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x07, 0xCF, 0xC1, 0xF8,
  0xF8, 0x3E, 0x1F, 0x8F, 0xC1, 0xFB, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF,
  0x80, 0xF9, 0xF0, 0x3F, 0x3F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0x81,
  0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0xF7,
  0xFE, 0x3F, 0xFF, 0x8F, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF8, 0x00,
  0xFC,
};

const GFXglyph JetBrainsMono_ExtraBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 25, 20, 7, -25 },
  { 20, 13, 10, 20, 4, -25 },
  { 37, 19, 25, 20, 1, -25 },
  { 97, 17, 35, 20, 2, -30 },
  { 172, 22, 25, 20, -1, -25 },
  { 241, 19, 25, 20, 1, -25 },
  { 301, 5, 10, 20, 8, -25 },
  { 308, 11, 33, 20, 5, -29 },
  { 354, 11, 33, 20, 4, -29 },
  { 400, 18, 18, 20, 1, -21 },
  { 441, 17, 16, 20, 2, -19 },
  { 475, 9, 10, 20, 5, -5 },
  { 487, 11, 5, 20, 5, -14 },
  { 494, 7, 7, 20, 7, -7 },
  { 501, 17, 32, 20, 2, -28 },
  { 569, 16, 25, 20, 2, -25 },
  { 619, 16, 25, 20, 3, -25 },
  { 669, 16, 25, 20, 2, -25 },
  { 719, 16, 25, 20, 2, -25 },
  { 769, 16, 25, 20, 2, -25 },
  { 819, 16, 25, 20, 2, -25 },
  { 869, 17, 25, 20, 2, -25 },
  { 923, 17, 25, 20, 2, -25 },
  { 977, 17, 25, 20, 2, -25 },
  { 1031, 17, 25, 20, 2, -25 },
  { 1085, 7, 19, 20, 7, -19 },
  { 1102, 9, 24, 20, 5, -19 },
  { 1129, 16, 19, 20, 2, -21 },
  { 1167, 15, 13, 20, 3, -18 },
  { 1192, 16, 19, 20, 2, -21 },
  { 1230, 14, 25, 20, 4, -25 },
  { 1274, 19, 31, 20, 1, -25 },
  { 1348, 19, 25, 20, 1, -25 },
  { 1408, 17, 25, 20, 2, -25 },
  { 1462, 17, 25, 20, 2, -25 },
  { 1516, 17, 25, 20, 2, -25 },
  { 1570, 15, 25, 20, 3, -25 },
  { 1617, 16, 25, 20, 2, -25 },
  { 1667, 17, 25, 20, 2, -25 },
  { 1721, 16, 25, 20, 2, -25 },
  { 1771, 15, 25, 20, 3, -25 },
  { 1818, 17, 25, 20, 1, -25 },
  { 1872, 18, 25, 20, 2, -25 },
  { 1929, 15, 25, 20, 3, -25 },
  { 1976, 18, 25, 20, 1, -25 },
  { 2033, 16, 25, 20, 2, -25 },
  { 2083, 16, 25, 20, 2, -25 },
  { 2133, 17, 25, 20, 2, -25 },
  { 2187, 17, 31, 20, 2, -25 },
  { 2253, 17, 25, 20, 2, -25 },
  { 2307, 17, 25, 20, 2, -25 },
  { 2361, 18, 25, 20, 1, -25 },
  { 2418, 16, 25, 20, 2, -25 },
  { 2468, 19, 25, 20, 1, -25 },
  { 2528, 20, 25, 20, 0, -25 },
  { 2591, 19, 25, 20, 1, -25 },
  { 2651, 19, 25, 20, 1, -25 },
  { 2711, 15, 25, 20, 3, -25 },
  { 2758, 10, 32, 20, 6, -28 },
  { 2798, 17, 32, 20, 2, -28 },
  { 2866, 11, 32, 20, 4, -28 },
  { 2910, 16, 13, 20, 2, -25 },
  { 2936, 16, 5, 20, 2, 1 },
  { 2946, 9, 5, 20, 5, -27 },
  { 2952, 16, 19, 20, 2, -19 },
  { 2990, 16, 25, 20, 2, -25 },
  { 3040, 17, 19, 20, 2, -19 },
  { 3081, 16, 25, 20, 2, -25 },
  { 3131, 16, 19, 20, 2, -19 },
  { 3169, 17, 25, 20, 2, -25 },
  { 3223, 16, 25, 20, 2, -19 },
  { 3273, 16, 25, 20, 2, -25 },
  { 3323, 17, 27, 20, 2, -27 },
  { 3381, 14, 33, 20, 3, -27 },
  { 3439, 18, 25, 20, 2, -25 },
  { 3496, 18, 25, 20, 1, -25 },
  { 3553, 18, 19, 20, 1, -19 },
  { 3596, 16, 19, 20, 2, -19 },
  { 3634, 16, 19, 20, 2, -19 },
  { 3672, 16, 25, 20, 2, -19 },
  { 3722, 16, 25, 20, 2, -19 },
  { 3772, 16, 19, 20, 3, -19 },
  { 3810, 17, 19, 20, 2, -19 },
  { 3851, 17, 24, 20, 1, -24 },
  { 3902, 16, 19, 20, 2, -19 },
  { 3940, 18, 19, 20, 1, -19 },
  { 3983, 20, 19, 20, 0, -19 },
  { 4031, 19, 19, 20, 1, -19 },
  { 4077, 19, 25, 20, 1, -19 },
  { 4137, 16, 19, 20, 2, -19 },
  { 4175, 15, 32, 20, 3, -28 },
  { 4235, 5, 32, 20, 8, -28 },
  { 4255, 15, 32, 20, 3, -28 },
  { 4315, 18, 8, 20, 1, -16 },
};

const GFXfont JetBrainsMono_ExtraBold34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_EXTRABOLD34PT7B_H_
