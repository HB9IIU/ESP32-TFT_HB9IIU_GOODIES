#ifndef _JETBRAINSMONO_EXTRABOLD48PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F, 0xC3,
  0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFB, 0xFD,
  0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xDF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x07, 0xC0,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFC, 0xEF, 0xF9, 0xFC, 0x73,
  0xFC, 0xFE, 0x38, 0xFE, 0x7F, 0x1C, 0x00, 0x3F, 0x8E, 0x00, 0x1F, 0xE7,
  0x00, 0x0F, 0xF3, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xE7, 0xF8,
  0x00, 0x71, 0xFC, 0x00, 0x38, 0xFF, 0xFE, 0x1C, 0x7F, 0xFF, 0x8E, 0x3F,
  0xBF, 0xC7, 0x1F, 0xCF, 0xF3, 0x9F, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x3F, 0xF8, 0x01, 0xF0, 0x7F, 0xF8, 0x03, 0xE1,
  0xFF, 0xF0, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x1F, 0x00, 0xF8,
  0x3E, 0x3E, 0x00, 0xF0, 0x7C, 0xF8, 0x01, 0xF1, 0xFB, 0xE0, 0x03, 0xFF,
  0xE7, 0x80, 0x03, 0xFF, 0x9F, 0x00, 0x03, 0xFE, 0x7C, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF3, 0xFE, 0x00, 0x07, 0xDF,
  0xFE, 0x00, 0x1F, 0x3F, 0xFE, 0x00, 0x3E, 0xFC, 0x7C, 0x00, 0xF9, 0xF0,
  0xF8, 0x03, 0xE3, 0xE0, 0xF0, 0x0F, 0x87, 0xC1, 0xE0, 0x1F, 0x0F, 0x83,
  0xC0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x3E, 0x1F, 0x03, 0xC0, 0x7C, 0x3E,
  0x0F, 0x80, 0xFF, 0xFC, 0x3E, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xC3,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFE, 0x7F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0xFE, 0xFE, 0xFE, 0x3F,
  0xBF, 0x9F, 0xDF, 0xCF, 0xC7, 0xF7, 0xF3, 0xF0, 0xFF, 0xF8, 0xFC, 0x1F,
  0xFE, 0x3F, 0x03, 0xFF, 0x0F, 0xC0, 0xFF, 0xC3, 0xF0, 0x1F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xF9, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF3, 0xF8, 0x3F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0E, 0x07, 0xC0,
  0xE1, 0xF0, 0xF8, 0x7C, 0x7F, 0x9E, 0x3F, 0x8F, 0xF9, 0xCF, 0xF9, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC1, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x80,
  0x20, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x87, 0xF0,
  0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x7F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0x81, 0xFE, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x3C, 0x7F, 0xFE, 0xFC,
  0xFF, 0xFD, 0xFD, 0xFF, 0xFB, 0xFB, 0xFF, 0xF7, 0xF7, 0xFF, 0xE7, 0xCF,
  0xFF, 0xC7, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF0, 0xFE,
  0x03, 0x81, 0xFC, 0x06, 0x03, 0xF8, 0x08, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xC3,
  0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x7F, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF1, 0xF8,
  0x0F, 0xEF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x7F, 0x7F, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8, 0x03,
  0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xE3, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0x80,
  0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xCF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xC0, 0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF1, 0xFF,
  0x1F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x03, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x3C, 0x7F, 0xF8, 0x1F, 0xEF, 0xFF, 0x07, 0xFC, 0xFF, 0xE1,
  0xFF, 0xDF, 0xFC, 0x3F, 0x9F, 0xFF, 0x87, 0xE1, 0xFF, 0xF0, 0xFC, 0x1F,
  0xFE, 0x1F, 0x03, 0xFF, 0xC3, 0xE0, 0x7F, 0xF8, 0x7C, 0x0F, 0xFF, 0x0F,
  0x81, 0xFF, 0xE1, 0xF0, 0x3F, 0xFC, 0x3E, 0x07, 0xFF, 0x87, 0xC0, 0xFF,
  0xF0, 0xF8, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0x9F, 0xFC, 0x07, 0xE3, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x7F,
  0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F,
  0xF1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x83,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xFC,
  0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F,
  0xE3, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x00,
  0x7F, 0xBF, 0x80, 0x3F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xEF, 0x07, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE3, 0xDF, 0xFE, 0xF1, 0xEF, 0xFF, 0x78, 0xF7, 0xFF,
  0xBC, 0xFB, 0xFF, 0xDF, 0x79, 0xFF, 0xE7, 0xBC, 0xFF, 0xF3, 0xDE, 0x7F,
  0xF9, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFE, 0x3F, 0x9F, 0xFF, 0x1F, 0xCF,
  0xFF, 0x8F, 0xE7, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF,
  0x83, 0xFF, 0xDF, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0x3E, 0x1F, 0xFE, 0x7C,
  0x3F, 0xFC, 0xFC, 0x7F, 0xF8, 0xF8, 0xFF, 0xF1, 0xF1, 0xFF, 0xE3, 0xF3,
  0xFF, 0xC3, 0xE7, 0xFF, 0x87, 0xCF, 0xFF, 0x0F, 0xDF, 0xFE, 0x0F, 0xBF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0x9F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x07,
  0xFE, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0x83,
  0xFC, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x07,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x0F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0x03, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF3, 0xFC, 0x07, 0xF9, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE7, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFC, 0x0F, 0x83, 0xF7, 0xE0, 0xF8, 0x3F, 0x7E, 0x1F, 0x83, 0xF7, 0xE1,
  0xFC, 0x3F, 0x7E, 0x1F, 0xC3, 0xF7, 0xE1, 0xDC, 0x3F, 0x7E, 0x1D, 0xC3,
  0xF7, 0xE1, 0xDC, 0x3F, 0x7E, 0x1D, 0xC3, 0xE7, 0xE1, 0xDC, 0x3E, 0x7E,
  0x1D, 0xC3, 0xE3, 0xE3, 0xDC, 0x3E, 0x3E, 0x3D, 0xE7, 0xE3, 0xE3, 0xDE,
  0x7E, 0x3E, 0x3D, 0xE7, 0xE3, 0xF3, 0x9E, 0x7E, 0x3F, 0x39, 0xE7, 0xE3,
  0xF3, 0x8E, 0x7E, 0x3F, 0x38, 0xE7, 0xC3, 0xF3, 0x8E, 0x7C, 0x3F, 0x78,
  0xE7, 0xC3, 0xF7, 0x8E, 0x7C, 0x1F, 0x78, 0xF7, 0xC1, 0xF7, 0x8F, 0x7C,
  0x1F, 0x70, 0xF7, 0xC1, 0xF7, 0x0F, 0x7C, 0x1F, 0x70, 0xF7, 0xC1, 0xF7,
  0x07, 0x7C, 0x1F, 0x70, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F,
  0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF0, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0,
  0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xFB, 0xFC, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0xEF, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F,
  0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE,
  0x7E, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xC0, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0x7F, 0x1F, 0xFE, 0x7F,
  0x0F, 0xFC, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0x81, 0xFC, 0x7F, 0xC3, 0xF9, 0xFF, 0xC7, 0xF7,
  0xFF, 0xCF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFB, 0xFF, 0x7F, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0x7F, 0xFC, 0xFE,
  0xFF, 0xF9, 0xFC, 0xFF, 0xE3, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x03, 0xE1, 0xFE, 0x1F, 0xF1, 0xFC, 0x7F, 0xF3, 0xF9, 0xFF, 0xF7,
  0xF7, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xBF, 0xFF, 0x7F, 0x3F, 0xFE,
  0xFE, 0x3F, 0xF9, 0xFC, 0x3F, 0xE3, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0xC0, 0x7F, 0x7F, 0x80, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xEF, 0xF0, 0x7F, 0x9F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xF3, 0xFC, 0x7F, 0xF3, 0xF9, 0xFF, 0xF7, 0xF7, 0xFF, 0xEF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF, 0xFF,
  0xDF, 0xCF, 0xFF, 0xBF, 0x8F, 0xFE, 0x7F, 0x0F, 0xF8, 0xFE, 0x01, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0x81, 0xFC, 0x7F, 0xC3, 0xF9,
  0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFB,
  0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x03,
  0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xE0, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x70, 0x78, 0x7E, 0xFC, 0x7F, 0x3F,
  0xFF, 0x7F, 0xDF, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF9, 0xFF,
  0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F,
  0xFF, 0x0F, 0x87, 0xFF, 0x87, 0xC3, 0xFF, 0xC3, 0xE1, 0xFF, 0xE1, 0xF0,
  0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F,
  0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0x87, 0xC3, 0xFF, 0xC3, 0xE1, 0xFF, 0xE1,
  0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x3E, 0x1F, 0xFE,
  0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x81, 0xFC, 0x7F, 0xC3,
  0xF9, 0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFB, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF3, 0xFF, 0x7F, 0x80, 0xFE, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x81, 0xFC, 0x7F, 0xC3,
  0xF9, 0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFB, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0x7F, 0xFC, 0xFE, 0xFF, 0xF9, 0xFC, 0xFF, 0xE3, 0xF8, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF1, 0xFC, 0x7F, 0xF3, 0xF9, 0xFF,
  0xF7, 0xF7, 0xFF, 0xEF, 0xEF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xBF, 0xFF, 0x7F, 0x3F,
  0xFE, 0xFE, 0x3F, 0xF9, 0xFC, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x81, 0xFC, 0xFF, 0xC3, 0xFB, 0xFF, 0xE7, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xF3, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0xFC, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x3F, 0x7E, 0x1F, 0x83,
  0xF7, 0xE1, 0xFC, 0x3F, 0x7E, 0x1F, 0xC3, 0xF7, 0xE1, 0xDC, 0x3E, 0x7E,
  0x1D, 0xC3, 0xE3, 0xE1, 0xDC, 0x3E, 0x3E, 0x1D, 0xC7, 0xE3, 0xF3, 0xDC,
  0x7E, 0x3F, 0x3D, 0xE7, 0xE3, 0xF3, 0xDE, 0x7E, 0x3F, 0x39, 0xE7, 0xC3,
  0xF3, 0x8E, 0x7C, 0x1F, 0x38, 0xE7, 0xC1, 0xF3, 0x8E, 0xFC, 0x1F, 0x78,
  0xEF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0xC7, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x07,
  0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x1F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xDF, 0xFE, 0x07, 0xEF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0xFE, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0x7E, 0x0F, 0xFF, 0xBF, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 35, 29, 10, -35 },
  { 41, 19, 14, 29, 5, -35 },
  { 75, 27, 35, 29, 1, -35 },
  { 194, 25, 49, 29, 2, -42 },
  { 348, 31, 35, 29, -1, -35 },
  { 484, 26, 36, 29, 2, -36 },
  { 601, 7, 14, 29, 11, -35 },
  { 614, 16, 46, 29, 7, -40 },
  { 706, 15, 46, 29, 6, -40 },
  { 793, 27, 25, 29, 1, -29 },
  { 878, 23, 23, 29, 3, -27 },
  { 945, 12, 15, 29, 7, -7 },
  { 968, 15, 7, 29, 7, -19 },
  { 982, 9, 9, 29, 10, -9 },
  { 993, 24, 45, 29, 2, -40 },
  { 1128, 23, 36, 29, 3, -36 },
  { 1232, 23, 35, 29, 4, -35 },
  { 1333, 24, 36, 29, 2, -36 },
  { 1441, 24, 35, 29, 2, -35 },
  { 1546, 22, 35, 29, 3, -35 },
  { 1643, 23, 35, 29, 3, -35 },
  { 1744, 25, 35, 29, 2, -35 },
  { 1854, 24, 35, 29, 2, -35 },
  { 1959, 24, 36, 29, 2, -36 },
  { 2067, 25, 36, 29, 2, -36 },
  { 2180, 9, 27, 29, 10, -27 },
  { 2211, 12, 35, 29, 7, -27 },
  { 2264, 22, 27, 29, 3, -29 },
  { 2339, 21, 19, 29, 4, -25 },
  { 2389, 22, 27, 29, 3, -29 },
  { 2464, 20, 35, 29, 5, -35 },
  { 2552, 27, 45, 29, 1, -36 },
  { 2704, 27, 35, 29, 1, -35 },
  { 2823, 24, 35, 29, 3, -35 },
  { 2928, 23, 36, 29, 3, -36 },
  { 3032, 24, 35, 29, 3, -35 },
  { 3137, 21, 35, 29, 4, -35 },
  { 3229, 23, 35, 29, 3, -35 },
  { 3330, 23, 36, 29, 3, -36 },
  { 3434, 23, 35, 29, 3, -35 },
  { 3535, 21, 35, 29, 4, -35 },
  { 3627, 24, 36, 29, 1, -35 },
  { 3735, 25, 35, 29, 3, -35 },
  { 3845, 21, 35, 29, 5, -35 },
  { 3937, 25, 35, 29, 2, -35 },
  { 4047, 23, 35, 29, 3, -35 },
  { 4148, 23, 36, 29, 3, -36 },
  { 4252, 24, 35, 29, 3, -35 },
  { 4357, 24, 45, 29, 3, -36 },
  { 4492, 24, 35, 29, 3, -35 },
  { 4597, 25, 36, 29, 2, -36 },
  { 4710, 25, 35, 29, 2, -35 },
  { 4820, 23, 35, 29, 3, -35 },
  { 4921, 27, 35, 29, 1, -35 },
  { 5040, 28, 35, 29, 0, -35 },
  { 5163, 27, 35, 29, 1, -35 },
  { 5282, 27, 35, 29, 1, -35 },
  { 5401, 21, 35, 29, 4, -35 },
  { 5493, 15, 45, 29, 8, -40 },
  { 5578, 24, 45, 29, 2, -40 },
  { 5713, 15, 45, 29, 6, -40 },
  { 5798, 23, 19, 29, 3, -35 },
  { 5853, 23, 7, 29, 3, 1 },
  { 5874, 13, 7, 29, 7, -38 },
  { 5886, 24, 27, 29, 2, -27 },
  { 5967, 23, 35, 29, 3, -35 },
  { 6068, 23, 27, 29, 3, -27 },
  { 6146, 23, 35, 29, 3, -35 },
  { 6247, 23, 27, 29, 3, -27 },
  { 6325, 24, 35, 29, 2, -35 },
  { 6430, 23, 36, 29, 3, -27 },
  { 6534, 23, 35, 29, 3, -35 },
  { 6635, 24, 38, 29, 3, -38 },
  { 6749, 19, 47, 29, 4, -38 },
  { 6861, 25, 35, 29, 3, -35 },
  { 6971, 26, 35, 29, 1, -35 },
  { 7085, 25, 27, 29, 2, -27 },
  { 7170, 23, 27, 29, 3, -27 },
  { 7248, 23, 27, 29, 3, -27 },
  { 7326, 23, 36, 29, 3, -27 },
  { 7430, 23, 36, 29, 3, -27 },
  { 7534, 23, 27, 29, 4, -27 },
  { 7612, 24, 27, 29, 2, -27 },
  { 7693, 24, 34, 29, 2, -34 },
  { 7795, 23, 26, 29, 3, -26 },
  { 7870, 27, 26, 29, 1, -26 },
  { 7958, 28, 26, 29, 0, -26 },
  { 8049, 27, 26, 29, 1, -26 },
  { 8137, 27, 35, 29, 1, -26 },
  { 8256, 22, 26, 29, 3, -26 },
  { 8328, 21, 45, 29, 4, -40 },
  { 8447, 7, 45, 29, 11, -40 },
  { 8487, 21, 45, 29, 4, -40 },
  { 8606, 25, 12, 29, 2, -23 },
};

const GFXfont JetBrainsMono_ExtraBold48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_EXTRABOLD48PT7B_H_
