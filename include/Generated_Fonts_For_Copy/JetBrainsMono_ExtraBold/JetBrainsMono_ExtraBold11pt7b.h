#ifndef _JETBRAINSMONO_EXTRABOLD11PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x43, 0xDD, 0xD0, 0x24, 0xB7, 0xCA, 0x6B, 0xF4, 0x96, 0x21,
  0x3D, 0xFA, 0x79, 0xE7, 0xFF, 0x88, 0x40, 0xE7, 0x4A, 0xA2, 0x82, 0xC6,
  0x95, 0x46, 0x39, 0xB6, 0x18, 0xF7, 0x7D, 0x9F, 0xF4, 0x2F, 0x49, 0x26,
  0xEC, 0xC6, 0x33, 0x33, 0x33, 0x6C, 0x10, 0x4F, 0xC4, 0x29, 0xB0, 0x63,
  0x3E, 0xC6, 0x00, 0xFE, 0xE0, 0xF0, 0x18, 0x8C, 0x62, 0x31, 0x88, 0xC6,
  0x00, 0xF6, 0xE7, 0x7B, 0xCF, 0x7E, 0x77, 0xAC, 0x63, 0x18, 0xDF, 0xF6,
  0xC6, 0x33, 0x33, 0x1F, 0xF8, 0x88, 0xE1, 0x8F, 0x7E, 0x31, 0x19, 0xB9,
  0xFF, 0xE3, 0xFC, 0x21, 0xF1, 0x8F, 0x7E, 0x18, 0xC2, 0x1E, 0x6F, 0x36,
  0xDE, 0xFF, 0xFC, 0xC6, 0x18, 0x43, 0x18, 0xF6, 0xE7, 0xEF, 0xCF, 0x7E,
  0x79, 0x3C, 0xDB, 0x7C, 0x61, 0x0C, 0xF0, 0xF0, 0xF0, 0xFE, 0x09, 0xF9,
  0x0F, 0x0C, 0xFF, 0xC1, 0xFF, 0x80, 0x86, 0x1E, 0x37, 0x60, 0xF7, 0xC6,
  0xE6, 0x20, 0x0C, 0x79, 0x1C, 0x77, 0xF7, 0xDD, 0xF0, 0x40, 0xC0, 0x30,
  0xE2, 0x9A, 0x69, 0xF4, 0xF1, 0xF4, 0xE7, 0xEF, 0xCE, 0x7E, 0xF6, 0xE1,
  0x08, 0x43, 0x7E, 0xF7, 0xE7, 0x39, 0xCF, 0xFE, 0xFE, 0x31, 0xEF, 0x63,
  0x1F, 0xFF, 0xE1, 0xFF, 0xC2, 0x10, 0xF6, 0xE1, 0x0B, 0xCF, 0x7E, 0x9C,
  0xE7, 0xFF, 0xCE, 0x73, 0xFB, 0x18, 0xC6, 0x31, 0x9F, 0x3C, 0xF0, 0xC3,
  0x0C, 0x3C, 0xDE, 0x9C, 0xED, 0xEF, 0x4A, 0x73, 0xC6, 0x31, 0x8C, 0x63,
  0xFF, 0xCF, 0xBE, 0xFD, 0xD7, 0x1C, 0x71, 0xDE, 0xF7, 0x7A, 0xD6, 0x73,
  0xF6, 0xE7, 0x39, 0xCF, 0x7E, 0xF4, 0xE3, 0x3F, 0x42, 0x10, 0xF6, 0xE7,
  0x39, 0xCF, 0x7E, 0x10, 0xC0, 0xF4, 0xE7, 0x3F, 0x5A, 0x73, 0xF6, 0xE1,
  0xE7, 0x8F, 0x7E, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x9C, 0xE7, 0x39,
  0xCF, 0x7E, 0xC5, 0x36, 0xDA, 0x68, 0xA3, 0x8C, 0xD7, 0x5F, 0x7D, 0x6D,
  0xB6, 0xDB, 0xCD, 0xA3, 0x8C, 0x38, 0xE6, 0xF3, 0xC5, 0xB6, 0x8E, 0x30,
  0xC3, 0x0C, 0xFF, 0xCC, 0x46, 0x63, 0xFF, 0xFB, 0x6D, 0xB6, 0xDC, 0x86,
  0x30, 0xC6, 0x10, 0xC6, 0x10, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x3F, 0x63,
  0xB5, 0xB0, 0xFF, 0xC0, 0xCC, 0xF6, 0xDF, 0x39, 0xFC, 0x84, 0x2D, 0xB9,
  0xCF, 0x76, 0xF6, 0xE1, 0x0D, 0xF8, 0x18, 0xFF, 0xB9, 0xCF, 0x7F, 0xF4,
  0xFF, 0x09, 0xF8, 0x3B, 0x19, 0xF6, 0x31, 0x8C, 0xFE, 0xE7, 0x3F, 0xAC,
  0x6E, 0x84, 0x2D, 0xB9, 0xCE, 0x73, 0x21, 0x81, 0xC2, 0x10, 0x9F, 0xF8,
  0x13, 0x0F, 0x11, 0x11, 0x1F, 0xE0, 0x84, 0x27, 0x2F, 0x7A, 0x73, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x07, 0xFF, 0x5D, 0x75, 0xD7, 0x50, 0xB6, 0xE7,
  0x39, 0xCC, 0xF6, 0xE7, 0x3D, 0xF8, 0xB6, 0xE7, 0x3D, 0xDA, 0x10, 0xFE,
  0xE7, 0x3D, 0xFC, 0x63, 0xBE, 0xF3, 0x8C, 0x60, 0xF4, 0xFC, 0x79, 0xFC,
  0x30, 0xCF, 0xCC, 0x30, 0xC3, 0x07, 0x9C, 0xE7, 0x3D, 0xF8, 0xCD, 0x36,
  0x9A, 0x38, 0xE0, 0xD7, 0xDF, 0x5B, 0x6D, 0xB0, 0xED, 0xE3, 0x0E, 0x6B,
  0x30, 0xCD, 0xB6, 0x8E, 0x38, 0xC3, 0x0C, 0xF8, 0xCC, 0xCC, 0x7C, 0x39,
  0x8C, 0x6E, 0x70, 0xC6, 0x31, 0xC0, 0xFF, 0xFF, 0xF0, 0xC3, 0x18, 0xC7,
  0xBD, 0x8C, 0x66, 0x00, 0x77, 0x70, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 4, 3, 7, 1, -8 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 12, 7, 1, -10 },
  { 19, 7, 8, 7, 0, -8 },
  { 26, 6, 8, 7, 0, -8 },
  { 32, 2, 3, 7, 2, -8 },
  { 33, 3, 10, 7, 2, -9 },
  { 37, 4, 10, 7, 1, -9 },
  { 42, 6, 6, 7, 0, -7 },
  { 47, 5, 5, 7, 1, -6 },
  { 51, 2, 4, 7, 2, -2 },
  { 52, 3, 1, 7, 2, -4 },
  { 53, 2, 2, 7, 2, -2 },
  { 54, 5, 10, 7, 1, -9 },
  { 61, 5, 8, 7, 1, -8 },
  { 66, 5, 8, 7, 1, -8 },
  { 71, 5, 8, 7, 1, -8 },
  { 76, 5, 8, 7, 1, -8 },
  { 81, 5, 8, 7, 1, -8 },
  { 86, 5, 8, 7, 1, -8 },
  { 91, 6, 8, 7, 0, -8 },
  { 97, 6, 8, 7, 0, -8 },
  { 103, 5, 8, 7, 1, -8 },
  { 108, 6, 8, 7, 0, -8 },
  { 114, 2, 6, 7, 2, -6 },
  { 116, 2, 8, 7, 2, -6 },
  { 118, 5, 6, 7, 1, -7 },
  { 122, 5, 5, 7, 1, -6 },
  { 126, 5, 6, 7, 1, -7 },
  { 130, 5, 8, 7, 1, -8 },
  { 135, 6, 10, 7, 0, -8 },
  { 143, 6, 8, 7, 0, -8 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 5, 8, 7, 1, -8 },
  { 159, 5, 8, 7, 1, -8 },
  { 164, 5, 8, 7, 1, -8 },
  { 169, 5, 8, 7, 1, -8 },
  { 174, 5, 8, 7, 1, -8 },
  { 179, 5, 8, 7, 1, -8 },
  { 184, 5, 8, 7, 1, -8 },
  { 189, 6, 8, 7, 0, -8 },
  { 195, 5, 8, 7, 1, -8 },
  { 200, 5, 8, 7, 1, -8 },
  { 205, 6, 8, 7, 0, -8 },
  { 211, 5, 8, 7, 1, -8 },
  { 216, 5, 8, 7, 1, -8 },
  { 221, 5, 8, 7, 1, -8 },
  { 226, 5, 10, 7, 1, -8 },
  { 233, 5, 8, 7, 1, -8 },
  { 238, 5, 8, 7, 1, -8 },
  { 243, 6, 8, 7, 0, -8 },
  { 249, 5, 8, 7, 1, -8 },
  { 254, 6, 8, 7, 0, -8 },
  { 260, 6, 8, 7, 0, -8 },
  { 266, 6, 8, 7, 0, -8 },
  { 272, 6, 8, 7, 0, -8 },
  { 278, 5, 8, 7, 1, -8 },
  { 283, 3, 10, 7, 2, -9 },
  { 287, 5, 10, 7, 1, -9 },
  { 294, 4, 10, 7, 1, -9 },
  { 299, 5, 4, 7, 1, -8 },
  { 302, 5, 2, 7, 1, 0 },
  { 304, 3, 2, 7, 2, -9 },
  { 305, 5, 6, 7, 1, -6 },
  { 309, 5, 8, 7, 1, -8 },
  { 314, 5, 6, 7, 1, -6 },
  { 318, 5, 8, 7, 1, -8 },
  { 323, 5, 6, 7, 1, -6 },
  { 327, 5, 8, 7, 1, -8 },
  { 332, 5, 8, 7, 1, -6 },
  { 337, 5, 8, 7, 1, -8 },
  { 342, 5, 9, 7, 1, -9 },
  { 348, 4, 11, 7, 1, -9 },
  { 354, 5, 8, 7, 1, -8 },
  { 359, 6, 8, 7, 0, -8 },
  { 365, 6, 6, 7, 0, -6 },
  { 370, 5, 6, 7, 1, -6 },
  { 374, 5, 6, 7, 1, -6 },
  { 378, 5, 8, 7, 1, -6 },
  { 383, 5, 8, 7, 1, -6 },
  { 388, 5, 6, 7, 1, -6 },
  { 392, 5, 6, 7, 1, -6 },
  { 396, 6, 8, 7, 0, -8 },
  { 402, 5, 6, 7, 1, -6 },
  { 406, 6, 6, 7, 0, -6 },
  { 411, 6, 6, 7, 0, -6 },
  { 416, 6, 6, 7, 0, -6 },
  { 421, 6, 8, 7, 0, -6 },
  { 427, 5, 6, 7, 1, -6 },
  { 431, 5, 10, 7, 1, -9 },
  { 438, 2, 10, 7, 2, -9 },
  { 441, 5, 10, 7, 1, -9 },
  { 448, 6, 3, 7, 0, -5 },
};

const GFXfont JetBrainsMono_ExtraBold11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_EXTRABOLD11PT7B_H_
