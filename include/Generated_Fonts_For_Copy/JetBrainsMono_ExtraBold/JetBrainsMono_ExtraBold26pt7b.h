#ifndef _JETBRAINSMONO_EXTRABOLD26PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0x9C, 0xE7, 0x00, 0x06, 0x7F,
  0xDE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8E, 0x0E,
  0x38, 0x38, 0xE0, 0xC3, 0x07, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0x1C, 0x18, 0x60, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0x9C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x01, 0xFC, 0x1F, 0xF9, 0xFF, 0xCF, 0x7F, 0xF3, 0x7F,
  0x98, 0x1E, 0xC0, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x03,
  0x78, 0x1B, 0xFC, 0xDF, 0xF6, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x3C, 0x07, 0x7F, 0x0E, 0xE7, 0x0C, 0xE7,
  0x18, 0xE7, 0x38, 0xE7, 0x70, 0x7F, 0x60, 0x7E, 0xE0, 0x09, 0xC0, 0x03,
  0x80, 0x03, 0x10, 0x07, 0x7C, 0x0E, 0xFE, 0x0C, 0xC6, 0x1C, 0xC6, 0x38,
  0xC6, 0x70, 0xCE, 0x60, 0xFE, 0xE0, 0x7C, 0x0F, 0xC0, 0xFF, 0x83, 0xFF,
  0x0E, 0x3C, 0x78, 0xF0, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x7E, 0x03, 0xF8,
  0x0F, 0xF3, 0xFD, 0xFE, 0xF3, 0xFB, 0xCF, 0xCF, 0x1F, 0x3C, 0x7C, 0xFF,
  0xF1, 0xFF, 0xE3, 0xF3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x83, 0xC3,
  0xE3, 0xF3, 0xE3, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE1, 0xFC, 0x7E, 0x0F,
  0x01, 0x80, 0x80, 0x70, 0x3E, 0x1F, 0x87, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC3,
  0xE3, 0xE7, 0xE3, 0xE1, 0xE0, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x11, 0xC2, 0xF3, 0x3B, 0xED, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x77,
  0x03, 0xCE, 0x1F, 0x3C, 0x38, 0x60, 0x41, 0x00, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x3D, 0xF7, 0x9E, 0x7B, 0xCF, 0x38,
  0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x00,
  0x3F, 0x87, 0xFE, 0xFF, 0xEF, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xEE, 0xFE, 0xFF, 0xEE, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F,
  0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x0F, 0x81, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F,
  0x78, 0x63, 0xC2, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF9, 0xFF, 0x07, 0xF8, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xC1, 0xEF, 0x1F, 0x7F, 0xF1, 0xFF,
  0x87, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x78, 0x07, 0xC0, 0x3C, 0x7B, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE,
  0x3F, 0x80, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x98, 0x7B, 0xF3, 0xFF, 0xBF, 0x3F, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC1, 0xEF, 0x0F, 0x7F, 0xF1, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0x1F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF1, 0xF7, 0x87,
  0xB8, 0x3D, 0xE1, 0xEF, 0x9E, 0x3F, 0xE0, 0xFE, 0x0F, 0xFC, 0xF1, 0xF7,
  0x87, 0xF8, 0x3F, 0xC1, 0xEF, 0x1F, 0x7F, 0xF9, 0xFF, 0x87, 0xF0, 0x1F,
  0xC1, 0xFF, 0x9F, 0xFC, 0xF1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0x7C, 0xFB, 0xFF, 0xCF, 0xFC, 0x19, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFD, 0xE0, 0x10, 0x79, 0xF3, 0xE3, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF7, 0xCF, 0x9E, 0x3C, 0xF1, 0xE3, 0x80, 0x00, 0x10, 0x07,
  0x01, 0xF0, 0xFF, 0x3F, 0xCF, 0xF0, 0xF8, 0x0E, 0x00, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xF0, 0x07, 0x03,
  0xF0, 0xFE, 0x7F, 0x8F, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0xFE, 0x3F,
  0xEF, 0xFB, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x3F, 0xCF, 0xE3, 0xF0,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x40, 0x7C, 0x1F, 0x07, 0x80, 0x0F, 0xE0,
  0xFF, 0xC7, 0xFF, 0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x1D, 0xF9, 0xFF,
  0xE7, 0xBF, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71,
  0xF9, 0xFF, 0xE3, 0xFF, 0x82, 0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x77, 0x81, 0xDE, 0x0F, 0x38, 0x3C, 0xE0, 0xF3, 0xC3, 0x8F, 0x1E,
  0x3C, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xBC, 0x1E, 0xF0, 0x7B, 0xC0, 0xFF,
  0x03, 0xC0, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xC3, 0xEE, 0x0F, 0x70, 0x7B,
  0x83, 0xDC, 0x3C, 0xFF, 0xC7, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70,
  0x3F, 0x83, 0xDC, 0x3E, 0xFF, 0xF7, 0xFF, 0x3F, 0xE0, 0x1F, 0x87, 0xFE,
  0xFF, 0xEF, 0x9F, 0xF0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE,
  0x3F, 0x80, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x87, 0xFE, 0xFF, 0xEF, 0x9F, 0xF0,
  0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xC3, 0xDF, 0x1E, 0xFF, 0xF3,
  0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x1E, 0x79,
  0xE3, 0xCF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xE7, 0x8F, 0x3C,
  0x79, 0xF3, 0xC7, 0x9E, 0x3E, 0xF0, 0xF7, 0x87, 0xBC, 0x3E, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0x37, 0xFC, 0xFF,
  0xB3, 0xFE, 0xDF, 0xFB, 0xEF, 0xE7, 0xBF, 0xDE, 0xFF, 0x7B, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xC0, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFC, 0x7E,
  0xE7, 0xEE, 0x7E, 0xE7, 0xE7, 0x7E, 0x77, 0xE7, 0x7E, 0x3F, 0xE3, 0xFE,
  0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xF0, 0x3F, 0x87, 0xFE, 0xFF, 0xEF, 0x1F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF1, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x3F, 0x87, 0xFE, 0xFF, 0xEF, 0x1F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xE7,
  0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1,
  0xFF, 0x0F, 0x3C, 0x79, 0xE3, 0xC7, 0x9E, 0x3C, 0xF1, 0xF7, 0x87, 0xBC,
  0x3E, 0x1F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF1, 0xF7, 0x07, 0xF8, 0x01, 0xE0,
  0x0F, 0xC0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x3F,
  0xC1, 0xFF, 0x1F, 0x7F, 0xF9, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0xF0,
  0x3F, 0xC0, 0xFF, 0x07, 0x9C, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x0E,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x1D, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0xE3, 0x8F, 0xE7,
  0x1F, 0xCF, 0x3B, 0x9E, 0x77, 0x3C, 0xEE, 0x79, 0xDC, 0xF3, 0xBB, 0x67,
  0x76, 0xCE, 0xED, 0xB9, 0xD9, 0x73, 0xB3, 0xE7, 0x67, 0xC6, 0xCF, 0x8F,
  0x9F, 0x1F, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF1, 0xF0, 0xF0, 0x7D, 0xE1,
  0xE7, 0x8F, 0x0F, 0x3C, 0x3D, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xF7, 0x83, 0xCF, 0x1E,
  0x3C, 0x78, 0x7B, 0xC1, 0xEF, 0x03, 0xC0, 0xF8, 0x1E, 0xF0, 0x3D, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC7, 0x83, 0xCF, 0x07, 0x9C, 0x07, 0x78, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xF0, 0x1F, 0x83,
  0xF8, 0x3B, 0xC3, 0x9C, 0x79, 0xC7, 0x1E, 0xF0, 0xEE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0xF8, 0xF8, 0x01, 0x00, 0xFF, 0x0F, 0xFC, 0xFF,
  0xF7, 0x87, 0x80, 0x3C, 0x0F, 0xE7, 0xFF, 0x7F, 0xFF, 0x83, 0xFC, 0x1F,
  0xE0, 0xF7, 0xFF, 0xBF, 0xFC, 0xFD, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF1, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xEF, 0xFE, 0xFE, 0xE7, 0xC0,
  0x04, 0x03, 0xFC, 0x7F, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0xFF, 0x1F, 0xFF, 0xF7, 0xFE, 0x3F, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xF7, 0xEF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF,
  0xF7, 0xFF, 0x3E, 0xF0, 0x04, 0x03, 0xFC, 0x7F, 0xEF, 0x9E, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x0F, 0xFF, 0xE7,
  0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0x00, 0xF0, 0x07,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x08, 0x07,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF1, 0xFF, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x03, 0xF3,
  0xFE, 0x3F, 0xC3, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0x0F,
  0xFC, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x06, 0x00, 0x78,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x78, 0x0F,
  0x81, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xCF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xBF, 0xF7, 0xFC, 0xFF, 0x1F, 0x80, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x7F, 0xC3, 0xDE, 0x3C, 0xF1, 0xE7, 0x9E,
  0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x79, 0xE3, 0xCF, 0x9E, 0x3C, 0xF1, 0xF7,
  0x87, 0xBC, 0x3E, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xC0, 0x04, 0x23, 0xBD, 0xEF, 0xFF, 0xBD, 0xCE, 0xE7, 0x3F, 0x9C, 0xFE,
  0x73, 0xF9, 0xCF, 0xE7, 0x3F, 0x9C, 0xFE, 0x73, 0xF9, 0xCF, 0xE7, 0x3F,
  0x9C, 0xFE, 0x73, 0xC0, 0x01, 0x0E, 0xFC, 0xEF, 0xEF, 0xFF, 0xF1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xF0, 0x04, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE,
  0x3F, 0x80, 0x01, 0x0E, 0xFC, 0xEF, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xF7,
  0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x08, 0x07, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0x07, 0xBF, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x03, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xF7, 0x87, 0xBC,
  0x01, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0xF7, 0xFF,
  0xBF, 0xF8, 0x7F, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF9, 0xFF, 0xFE, 0x7F, 0xE3, 0xF8, 0xF0, 0x3F, 0xC1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0xF0, 0xE3, 0xC3, 0xCF, 0x0F, 0x38, 0x1D, 0xE0, 0x7F,
  0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xE3, 0x8E, 0xE7, 0x1D,
  0xCF, 0x3B, 0x9E, 0x77, 0x3C, 0xEE, 0x5B, 0x9D, 0xB7, 0x3B, 0x6E, 0x3E,
  0x5C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xC7, 0x87, 0x8F, 0x00, 0xF8,
  0x7D, 0xE3, 0xC3, 0xDF, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xDF, 0x1F, 0x3C, 0x78, 0x7B, 0xC1, 0xF0,
  0xF0, 0x3F, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x8F,
  0xF0, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F,
  0x80, 0xFC, 0x0F, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xFF, 0x07, 0xF0, 0xFF, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF0, 0x00,
  0x7E, 0x3F, 0xFC, 0xFF, 0xF3, 0xF9, 0xFE, 0xE3, 0xF8, 0x07, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 19, 16, 5, -19 },
  { 13, 10, 8, 16, 3, -19 },
  { 23, 14, 19, 16, 1, -19 },
  { 57, 13, 27, 16, 1, -23 },
  { 101, 16, 19, 16, 0, -19 },
  { 139, 14, 19, 16, 1, -19 },
  { 173, 4, 8, 16, 6, -19 },
  { 177, 9, 25, 16, 4, -22 },
  { 206, 9, 25, 16, 3, -22 },
  { 235, 14, 14, 16, 1, -16 },
  { 260, 13, 13, 16, 1, -15 },
  { 282, 6, 8, 16, 4, -4 },
  { 288, 8, 3, 16, 4, -10 },
  { 291, 5, 5, 16, 5, -5 },
  { 295, 13, 25, 16, 1, -22 },
  { 336, 12, 19, 16, 2, -19 },
  { 365, 13, 19, 16, 2, -19 },
  { 396, 13, 19, 16, 1, -19 },
  { 427, 13, 19, 16, 1, -19 },
  { 458, 13, 19, 16, 1, -19 },
  { 489, 12, 19, 16, 2, -19 },
  { 518, 13, 19, 16, 1, -19 },
  { 549, 13, 19, 16, 1, -19 },
  { 580, 13, 19, 16, 1, -19 },
  { 611, 13, 19, 16, 1, -19 },
  { 642, 5, 15, 16, 5, -15 },
  { 652, 7, 19, 16, 4, -15 },
  { 669, 12, 15, 16, 2, -16 },
  { 692, 12, 10, 16, 2, -14 },
  { 707, 12, 15, 16, 2, -16 },
  { 730, 10, 19, 16, 3, -19 },
  { 754, 14, 24, 16, 1, -19 },
  { 796, 14, 19, 16, 1, -19 },
  { 830, 13, 19, 16, 2, -19 },
  { 861, 12, 19, 16, 2, -19 },
  { 890, 12, 19, 16, 2, -19 },
  { 919, 12, 19, 16, 2, -19 },
  { 948, 12, 19, 16, 2, -19 },
  { 977, 12, 19, 16, 2, -19 },
  { 1006, 12, 19, 16, 2, -19 },
  { 1035, 12, 19, 16, 2, -19 },
  { 1064, 13, 19, 16, 1, -19 },
  { 1095, 13, 19, 16, 2, -19 },
  { 1126, 12, 19, 16, 2, -19 },
  { 1155, 14, 19, 16, 1, -19 },
  { 1189, 12, 19, 16, 2, -19 },
  { 1218, 12, 19, 16, 2, -19 },
  { 1247, 13, 19, 16, 2, -19 },
  { 1278, 12, 24, 16, 2, -19 },
  { 1314, 13, 19, 16, 2, -19 },
  { 1345, 13, 19, 16, 1, -19 },
  { 1376, 14, 19, 16, 1, -19 },
  { 1410, 12, 19, 16, 2, -19 },
  { 1439, 14, 19, 16, 1, -19 },
  { 1473, 15, 19, 16, 0, -19 },
  { 1509, 14, 19, 16, 1, -19 },
  { 1543, 15, 19, 16, 0, -19 },
  { 1579, 12, 19, 16, 2, -19 },
  { 1608, 8, 25, 16, 4, -22 },
  { 1633, 13, 25, 16, 1, -22 },
  { 1674, 8, 25, 16, 3, -22 },
  { 1699, 12, 10, 16, 2, -19 },
  { 1714, 12, 3, 16, 2, 1 },
  { 1719, 7, 3, 16, 4, -20 },
  { 1722, 13, 15, 16, 1, -15 },
  { 1747, 12, 19, 16, 2, -19 },
  { 1776, 12, 15, 16, 2, -15 },
  { 1799, 12, 19, 16, 2, -19 },
  { 1828, 12, 15, 16, 2, -15 },
  { 1851, 13, 19, 16, 1, -19 },
  { 1882, 12, 20, 16, 2, -15 },
  { 1912, 12, 19, 16, 2, -19 },
  { 1941, 13, 21, 16, 2, -21 },
  { 1976, 11, 26, 16, 2, -21 },
  { 2012, 13, 19, 16, 2, -19 },
  { 2043, 14, 19, 16, 1, -19 },
  { 2077, 14, 15, 16, 1, -15 },
  { 2104, 12, 15, 16, 2, -15 },
  { 2127, 12, 15, 16, 2, -15 },
  { 2150, 12, 20, 16, 2, -15 },
  { 2180, 12, 20, 16, 2, -15 },
  { 2210, 13, 15, 16, 2, -15 },
  { 2235, 13, 15, 16, 1, -15 },
  { 2260, 13, 18, 16, 1, -18 },
  { 2290, 12, 14, 16, 2, -14 },
  { 2311, 14, 14, 16, 1, -14 },
  { 2336, 15, 14, 16, 0, -14 },
  { 2363, 14, 14, 16, 1, -14 },
  { 2388, 14, 19, 16, 1, -14 },
  { 2422, 12, 14, 16, 2, -14 },
  { 2443, 12, 25, 16, 2, -22 },
  { 2481, 4, 25, 16, 6, -22 },
  { 2494, 12, 25, 16, 2, -22 },
  { 2532, 14, 6, 16, 1, -12 },
};

const GFXfont JetBrainsMono_ExtraBold26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_EXTRABOLD26PT7B_H_
