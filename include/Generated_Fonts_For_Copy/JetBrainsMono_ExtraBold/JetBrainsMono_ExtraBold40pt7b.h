#ifndef _JETBRAINSMONO_EXTRABOLD40PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0xFF, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0,
  0x3E, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC1, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF0, 0x7C, 0x03,
  0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE1, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xE6, 0x7E, 0xFC, 0x67, 0xFF, 0xC6,
  0x3F, 0xFC, 0x60, 0x0F, 0xE6, 0x00, 0x7F, 0x60, 0x07, 0xFE, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x67, 0xF0, 0x06, 0x3F, 0x00, 0x63, 0xFF, 0xC6, 0x3F,
  0xFC, 0x63, 0xFF, 0xE6, 0x7F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x07,
  0xC7, 0xFC, 0x03, 0xC3, 0xFF, 0x80, 0xF0, 0xF1, 0xE0, 0x78, 0x78, 0x78,
  0x3C, 0x1E, 0x1E, 0x1E, 0x07, 0x87, 0x87, 0x81, 0xE1, 0xE3, 0xC0, 0x78,
  0x79, 0xE0, 0x0F, 0x3E, 0xF8, 0x03, 0xFF, 0xBC, 0x00, 0x7F, 0xDE, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7D, 0xFC, 0x00, 0x1E, 0xFF, 0x80, 0x0F, 0x7F, 0xF0, 0x07,
  0x9E, 0x3C, 0x01, 0xE7, 0x87, 0x80, 0xF1, 0xE1, 0xE0, 0x78, 0x78, 0x78,
  0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x87, 0x81, 0xE3, 0xC3, 0xC0, 0x7F,
  0xF1, 0xF0, 0x0F, 0xF8, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F,
  0x81, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0xFD, 0xF3, 0xE7, 0xEF, 0xCF, 0xDF,
  0xBF, 0x1F, 0xFC, 0xFC, 0x3F, 0xF3, 0xF0, 0xFF, 0x8F, 0xC1, 0xFE, 0x3F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xFD, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFD, 0xF8, 0x3F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x03, 0xF0, 0x7F,
  0x87, 0xFC, 0x7F, 0xE3, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0x80, 0x07, 0x00, 0x3E,
  0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC,
  0xFF, 0xC7, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x40,
  0x78, 0x09, 0xE1, 0xE1, 0xE7, 0xC7, 0x8F, 0x9F, 0xCC, 0xFE, 0xFF, 0xB7,
  0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0x3C, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x80, 0xF0, 0x3C, 0x01, 0xC0, 0xE0, 0x02, 0x01, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xCF,
  0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x43, 0xFF,
  0xCF, 0x3F, 0xFD, 0xFB, 0xFF, 0xDF, 0xBF, 0xFD, 0xFB, 0xFF, 0xCF, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xC7,
  0xE0, 0xE0, 0xFC, 0x18, 0x1F, 0x82, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x7E, 0xFE, 0x0F, 0xDF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x7F, 0x07, 0xEF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xE7, 0xE0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF3, 0xE0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x07,
  0xEF, 0xE0, 0x7E, 0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0,
  0xFE, 0x3F, 0x9F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xF9, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xF0,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF9,
  0xFE, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x3F, 0xF7, 0xE1, 0xFE, 0xFC, 0x03, 0x8F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F,
  0x8F, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0xDF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xE7, 0xFE, 0x0F,
  0xCF, 0xF8, 0x7F, 0xBF, 0xE3, 0xFF, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F,
  0xF8, 0xF8, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8,
  0xF8, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFE, 0xFF, 0x83, 0xF3, 0xFE, 0x07, 0x80, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xF0,
  0x1F, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x3F, 0xCF, 0xFF,
  0xF1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xF8, 0x1F, 0xDF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x03,
  0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x7F, 0xBF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7E, 0x07, 0xF7,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x07,
  0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1,
  0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x7E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0x70, 0xEF, 0xF7, 0x0E, 0xFF, 0x79,
  0xFF, 0xF7, 0x9F, 0xFF, 0xB9, 0xDF, 0xFB, 0xDD, 0xFF, 0xBF, 0xDF, 0xFB,
  0xFD, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFB, 0xC3, 0xFF, 0xBE, 0x3F, 0xFB, 0xE3, 0xFF, 0x9E, 0x3F,
  0xFD, 0xF3, 0xFF, 0xDF, 0x3F, 0xFC, 0xF3, 0xFF, 0xCF, 0xBF, 0xFC, 0xFB,
  0xFF, 0xC7, 0x9F, 0xFC, 0x7D, 0xFF, 0xC7, 0xDF, 0xFC, 0x3D, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC1,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F,
  0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC,
  0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xF0, 0x00, 0x70, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7E, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xEF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xF8, 0x3C,
  0x1F, 0x78, 0x3C, 0x1E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E,
  0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E,
  0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x66, 0x3E, 0x7C, 0xE7, 0x3C, 0x3C, 0xE7,
  0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3E, 0xE7, 0x3C, 0x3E, 0xE7,
  0x7C, 0x3E, 0xE7, 0x7C, 0x3E, 0xE7, 0x7C, 0x3E, 0xC7, 0x7C, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x83,
  0xF8, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC,
  0x1F, 0x87, 0xE0, 0x7F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F,
  0x3F, 0x01, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x3F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x1F, 0x9F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x07, 0xC7, 0xE0, 0x7E, 0xFC,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF7, 0xF9, 0xFE,
  0xFC, 0x0F, 0xDF, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE1, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xEF, 0xBF, 0xFD, 0xF3,
  0xFF, 0x3E, 0x3F, 0xC7, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE7, 0xF0,
  0xFD, 0xFF, 0x1F, 0xFF, 0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF, 0xE1, 0xFD,
  0xF8, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0xFE, 0xFF, 0xFF, 0xDF, 0x7F, 0xFB, 0xEF, 0xFE, 0x7C, 0xFF, 0x8F,
  0x8F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x7F, 0x3F, 0x1F, 0xF7, 0xE7, 0xFF, 0xFD, 0xFF, 0xEF, 0xBF,
  0xFF, 0xF7, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xDF, 0x81, 0xFB, 0xF8, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0x7C, 0xFF,
  0xEF, 0x8F, 0xF9, 0xF0, 0xFE, 0x3E, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x07,
  0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0xBF, 0xFD, 0xF7,
  0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xDF,
  0x81, 0xFB, 0xFD, 0xFF, 0x7F, 0xFB, 0xE7, 0xFF, 0x7C, 0xFF, 0xEF, 0x8F,
  0xFB, 0xF0, 0x3C, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF3, 0xF8, 0xFD, 0xFF, 0x3F, 0xFF, 0xEF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFC,
  0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F,
  0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0xF3, 0xE7, 0xEF, 0x7E, 0x7E, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1,
  0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F,
  0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8,
  0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF,
  0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xFE, 0x3E, 0x7F, 0xCF,
  0xBF, 0xFB, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE,
  0x7E, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xE0,
  0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0xF8, 0xFE, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7D,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFE, 0x1F, 0xDF, 0xFF, 0xFB, 0xEF,
  0xFF, 0x7F, 0xFF, 0xCF, 0xDF, 0xF1, 0xF9, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE3, 0xE3, 0xFE, 0x7C, 0xFF, 0xEF, 0xBF, 0xFD, 0xF7, 0xFF,
  0xFE, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFB, 0xF0, 0x3F, 0x7F, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xEF, 0x9F, 0xFF,
  0xF1, 0xFF, 0x7E, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0xFC, 0xFF,
  0x0F, 0xDF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7F, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0xF8, 0x3C, 0x1F, 0x78, 0x3C, 0x1E, 0x7C, 0x3C, 0x1E, 0x7C, 0x7E,
  0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E,
  0x3E, 0x3C, 0x66, 0x3C, 0x3C, 0xE7, 0x3C, 0x3E, 0xE7, 0x7C, 0x3E, 0xE7,
  0x7C, 0x3E, 0xE7, 0x7C, 0x3E, 0xE7, 0x7C, 0x1E, 0xE7, 0x78, 0x1E, 0xE7,
  0x78, 0x1F, 0xC3, 0x78, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x7F, 0x03, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F, 0x0F,
  0xC0, 0xFC, 0x7F, 0x03, 0xFB, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFD, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFB, 0xF8, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 29, 24, 8, -29 },
  { 30, 16, 12, 24, 4, -29 },
  { 54, 22, 29, 24, 1, -29 },
  { 134, 20, 41, 24, 2, -35 },
  { 237, 26, 29, 24, -1, -29 },
  { 332, 22, 30, 24, 1, -30 },
  { 415, 6, 12, 24, 9, -29 },
  { 424, 13, 39, 24, 6, -34 },
  { 488, 13, 39, 24, 5, -34 },
  { 552, 22, 21, 24, 1, -24 },
  { 610, 20, 19, 24, 2, -23 },
  { 658, 10, 12, 24, 6, -6 },
  { 673, 12, 6, 24, 6, -16 },
  { 682, 8, 8, 24, 8, -8 },
  { 690, 20, 37, 24, 2, -33 },
  { 783, 20, 30, 24, 2, -30 },
  { 858, 19, 29, 24, 3, -29 },
  { 927, 20, 30, 24, 2, -30 },
  { 1002, 20, 29, 24, 2, -29 },
  { 1075, 19, 29, 24, 2, -29 },
  { 1144, 20, 29, 24, 2, -29 },
  { 1217, 20, 29, 24, 2, -29 },
  { 1290, 20, 29, 24, 2, -29 },
  { 1363, 20, 30, 24, 2, -30 },
  { 1438, 20, 30, 24, 2, -30 },
  { 1513, 8, 22, 24, 8, -22 },
  { 1535, 10, 28, 24, 6, -22 },
  { 1570, 18, 22, 24, 3, -24 },
  { 1620, 18, 16, 24, 3, -21 },
  { 1656, 18, 22, 24, 3, -24 },
  { 1706, 17, 29, 24, 4, -29 },
  { 1768, 22, 37, 24, 1, -30 },
  { 1870, 22, 29, 24, 1, -29 },
  { 1950, 19, 29, 24, 3, -29 },
  { 2019, 20, 30, 24, 2, -30 },
  { 2094, 19, 29, 24, 3, -29 },
  { 2163, 18, 29, 24, 3, -29 },
  { 2229, 19, 29, 24, 3, -29 },
  { 2298, 20, 30, 24, 2, -30 },
  { 2373, 18, 29, 24, 3, -29 },
  { 2439, 18, 29, 24, 3, -29 },
  { 2505, 20, 29, 24, 1, -29 },
  { 2578, 20, 29, 24, 3, -29 },
  { 2651, 18, 29, 24, 4, -29 },
  { 2717, 20, 29, 24, 2, -29 },
  { 2790, 20, 29, 24, 2, -29 },
  { 2863, 20, 30, 24, 2, -30 },
  { 2938, 20, 29, 24, 3, -29 },
  { 3011, 20, 37, 24, 2, -30 },
  { 3104, 20, 29, 24, 3, -29 },
  { 3177, 20, 30, 24, 2, -30 },
  { 3252, 20, 29, 24, 2, -29 },
  { 3325, 20, 29, 24, 2, -29 },
  { 3398, 22, 29, 24, 1, -29 },
  { 3478, 24, 29, 24, 0, -29 },
  { 3565, 22, 29, 24, 1, -29 },
  { 3645, 22, 29, 24, 1, -29 },
  { 3725, 18, 29, 24, 3, -29 },
  { 3791, 12, 37, 24, 7, -33 },
  { 3847, 20, 37, 24, 2, -33 },
  { 3940, 12, 37, 24, 5, -33 },
  { 3996, 20, 15, 24, 2, -29 },
  { 4034, 20, 6, 24, 2, 1 },
  { 4049, 11, 5, 24, 6, -31 },
  { 4056, 19, 22, 24, 2, -22 },
  { 4109, 19, 29, 24, 3, -29 },
  { 4178, 20, 22, 24, 2, -22 },
  { 4233, 19, 29, 24, 2, -29 },
  { 4302, 20, 22, 24, 2, -22 },
  { 4357, 20, 29, 24, 2, -29 },
  { 4430, 19, 29, 24, 2, -22 },
  { 4499, 18, 29, 24, 3, -29 },
  { 4565, 19, 32, 24, 3, -32 },
  { 4641, 16, 39, 24, 3, -32 },
  { 4719, 20, 29, 24, 3, -29 },
  { 4792, 22, 29, 24, 1, -29 },
  { 4872, 20, 22, 24, 2, -22 },
  { 4927, 18, 22, 24, 3, -22 },
  { 4977, 20, 22, 24, 2, -22 },
  { 5032, 19, 29, 24, 3, -22 },
  { 5101, 19, 29, 24, 2, -22 },
  { 5170, 20, 22, 24, 3, -22 },
  { 5225, 20, 22, 24, 2, -22 },
  { 5280, 20, 28, 24, 1, -28 },
  { 5350, 18, 22, 24, 3, -22 },
  { 5400, 22, 22, 24, 1, -22 },
  { 5461, 24, 22, 24, 0, -22 },
  { 5527, 22, 22, 24, 1, -22 },
  { 5588, 22, 29, 24, 1, -22 },
  { 5668, 18, 22, 24, 3, -22 },
  { 5718, 18, 37, 24, 3, -33 },
  { 5802, 6, 37, 24, 9, -33 },
  { 5830, 18, 37, 24, 3, -33 },
  { 5914, 20, 10, 24, 2, -19 },
};

const GFXfont JetBrainsMono_ExtraBold40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_EXTRABOLD40PT7B_H_
