#ifndef _JETBRAINSMONO_EXTRABOLD25PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x00, 0x1F, 0xFB,
  0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0x07, 0x38, 0x0C,
  0x70, 0x38, 0xE0, 0x71, 0xC7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x86, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0x71, 0x87, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x8E,
  0x38, 0x1C, 0x70, 0x38, 0xC0, 0x63, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x01, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0x5E, 0xF2, 0x7F, 0x90, 0x1E,
  0x80, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x5F, 0x02, 0x7F, 0x93,
  0xFE, 0xBE, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x7E, 0x0E, 0xFC, 0x1B, 0x9C, 0x67, 0x39, 0xCE, 0x77, 0x1C,
  0xEC, 0x1F, 0xB8, 0x1E, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1D, 0xE0, 0x77,
  0xE0, 0xDC, 0xE3, 0x39, 0xCE, 0x73, 0xB8, 0xE7, 0x60, 0xFD, 0xC0, 0xF0,
  0x02, 0x00, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x78, 0xE1, 0xE0, 0x43, 0x80,
  0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF3, 0xB9, 0xDE, 0xE7, 0xF3, 0x8F,
  0xCE, 0x1E, 0x3C, 0x78, 0xFF, 0xF1, 0xFF, 0xC3, 0xF3, 0xC0, 0xFF, 0xFF,
  0xF8, 0x01, 0x07, 0x1F, 0x3F, 0x7C, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x7C, 0x3F, 0x1F, 0x0F,
  0x01, 0x80, 0xE0, 0xF8, 0xFC, 0x3E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x3E, 0xFC, 0xF8, 0xE0,
  0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xCE, 0x6F, 0x27, 0xFF, 0xFC, 0xFF,
  0x80, 0xE0, 0x1D, 0xC1, 0xEF, 0x0E, 0x38, 0xF1, 0xE1, 0x04, 0x00, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3E, 0x78, 0xF1, 0xE7, 0x8F,
  0x1C, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0x8F, 0x78, 0x3B,
  0xC1, 0xFE, 0x0F, 0xF7, 0x7F, 0xBB, 0xFD, 0xDF, 0xE4, 0xFF, 0x07, 0xF8,
  0x3D, 0xC1, 0xCF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x1F, 0x03, 0xF0,
  0xFF, 0x0F, 0x70, 0xE7, 0x08, 0x70, 0x87, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xEF, 0x8F, 0x78, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0xF8, 0x3B, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0xFE,
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x03,
  0xCF, 0x78, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xEF, 0x0F, 0xFC, 0x7F, 0xF3, 0xC7, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0xF8, 0x39, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x7C, 0x7F,
  0xF7, 0xFF, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xE3, 0xEF, 0xFE,
  0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F,
  0x78, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x02, 0x00,
  0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0x8F, 0x38, 0x39, 0xC1, 0xCF, 0x1E, 0x3F,
  0xE0, 0xFE, 0x0F, 0xF8, 0xFB, 0xE7, 0x07, 0x78, 0x3F, 0xC1, 0xFF, 0x1F,
  0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x02, 0x00, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFB, 0xFF, 0x8F, 0xFC, 0x3D,
  0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x77, 0xFF, 0xF2, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x39, 0xF7, 0xDF,
  0x10, 0x00, 0x00, 0x00, 0x03, 0xDF, 0x79, 0xE7, 0x3C, 0xF3, 0x80, 0x00,
  0x20, 0x3C, 0x1F, 0x8F, 0xF7, 0xF1, 0xF8, 0x3C, 0x07, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x1E, 0x03,
  0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xC0, 0x78, 0x1F, 0x0F, 0xE7, 0xF3, 0xF8,
  0x7C, 0x0E, 0x01, 0x00, 0x00, 0xFE, 0x3F, 0xCF, 0xF8, 0x1F, 0x03, 0xC0,
  0xF0, 0x7D, 0xFE, 0x7F, 0x9F, 0xC7, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x78, 0x1E, 0x00, 0x02, 0x00, 0x7F, 0x87, 0xFF, 0x1E, 0x3E, 0xF0,
  0x3B, 0x80, 0xEE, 0x03, 0xF8, 0xF7, 0xE7, 0xFF, 0x9C, 0xFE, 0xF3, 0xFB,
  0xCF, 0xEF, 0x3F, 0xBC, 0xFE, 0x73, 0xF9, 0xFF, 0xE7, 0xDF, 0x86, 0x0E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x07, 0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xF7, 0x87, 0xBC, 0x38, 0xE1,
  0xC7, 0x1E, 0x3C, 0xFF, 0xE7, 0xFF, 0x3F, 0xFB, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xFE, 0x0E,
  0xE1, 0xEF, 0xFC, 0xFF, 0x0F, 0xFE, 0xE1, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xFF,
  0xE7, 0x8F, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC1, 0xEF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07,
  0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x02, 0x00, 0xFE, 0x0F,
  0xF8, 0xFF, 0xE7, 0x8F, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x9F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x07, 0xF8, 0x3D, 0xC1, 0xEF, 0x1E, 0x7F, 0xF1,
  0xFF, 0x07, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0x07, 0xB8, 0x3D, 0xE3, 0xEF, 0xFE, 0x3F, 0xF0, 0xFE, 0x00, 0xE0,
  0xFE, 0x1E, 0xE1, 0xEE, 0x1E, 0xE3, 0xCE, 0x3C, 0xE7, 0x8F, 0xF8, 0xFF,
  0x0F, 0xF8, 0xE7, 0x8E, 0x3C, 0xE3, 0xCE, 0x3E, 0xE1, 0xEE, 0x1E, 0xE0,
  0xFE, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0xDF, 0xF6, 0xDF, 0xB6, 0xFD, 0xB7, 0xEF, 0xBF, 0x39, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0, 0xF8,
  0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0x3F, 0xF9, 0xFE, 0xCF,
  0xF7, 0x7F, 0xBB, 0xFC, 0xDF, 0xE7, 0xFF, 0x3F, 0xF8, 0xDF, 0xC7, 0xFE,
  0x3F, 0xF0, 0xFF, 0x87, 0xC0, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7,
  0x8F, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3D, 0xC1, 0xCF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0,
  0xFF, 0x8F, 0xFE, 0xFF, 0xEE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0xFF, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0x8F, 0x78,
  0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3D, 0xC1, 0xCF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x1F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8E, 0x78,
  0xE3, 0xCE, 0x3C, 0xE1, 0xEE, 0x1E, 0xE1, 0xEE, 0x0F, 0x02, 0x00, 0xFE,
  0x1F, 0xF8, 0xFF, 0xE7, 0x0F, 0x78, 0x3F, 0xC0, 0x0F, 0x00, 0x7F, 0x81,
  0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0xC1, 0xFF, 0x1F, 0x7F,
  0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xB8, 0x39, 0xE3, 0xCF, 0xFE,
  0x3F, 0xE0, 0xFE, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xE0, 0xE7, 0x87,
  0x3C, 0x79, 0xE3, 0xC7, 0x1C, 0x38, 0xE1, 0xE7, 0x0F, 0x78, 0x3B, 0xC1,
  0xDC, 0x0E, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0xE3, 0x8F,
  0xC7, 0x1D, 0xCA, 0x73, 0x94, 0xE7, 0x29, 0xCE, 0xDB, 0x9D, 0xB7, 0x3B,
  0x6E, 0x76, 0xDC, 0xED, 0xB9, 0xDB, 0x73, 0xB6, 0xE7, 0x6D, 0x86, 0x8B,
  0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0xF0,
  0xF1, 0xE0, 0xF7, 0x81, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xEF, 0x03, 0xDE, 0x0F, 0x1E,
  0x1E, 0x3C, 0x78, 0x3D, 0xF0, 0x7C, 0xF8, 0x3E, 0xF0, 0x78, 0xE0, 0xE1,
  0xE3, 0xC3, 0xC7, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3C, 0x0F,
  0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0x3B, 0x81, 0xDC, 0x1E, 0xF0, 0xE3, 0x8F, 0x1E, 0x70, 0x77, 0x83,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xF0, 0xE1, 0xF0, 0x0F, 0x83,
  0xFE, 0x7F, 0xF7, 0x8F, 0x70, 0x70, 0x07, 0x3F, 0xF7, 0xFF, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0xFF, 0x7F, 0x73, 0xE7, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x9E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0E, 0xF1, 0xEF, 0xFE, 0xEF, 0xCE, 0xF8, 0x0F, 0x81,
  0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0x83, 0xDE, 0x3C, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x9F, 0x70, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0x71, 0xF7,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x1C, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0xC3, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x9F, 0x70,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x8F, 0x7F, 0xF3, 0xF7, 0x1F,
  0x70, 0x07, 0x00, 0xF1, 0xFF, 0x1F, 0xE1, 0xFC, 0x1E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x79, 0xDF, 0xBF, 0xFF, 0x8F, 0xF1, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x06,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0x7F, 0xDF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xEF, 0xFB, 0xFC, 0xF8,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x0F, 0xE1, 0xEE,
  0x3E, 0xE3, 0xCF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8E, 0x3C, 0xE3, 0xEE,
  0x1E, 0xE1, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xEE, 0x77,
  0xF7, 0xFF, 0xFF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7,
  0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9C, 0xE7, 0x9D, 0xFB,
  0xFF, 0xF8, 0xFF, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7,
  0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0x83, 0x9E, 0x3C, 0xFF,
  0xE3, 0xFE, 0x0F, 0xE0, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x9E, 0xF0, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xF1, 0xEF, 0xFE, 0xEF, 0xCE,
  0xFC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x73, 0xF7,
  0x7F, 0xF7, 0x9F, 0x70, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x0F,
  0x78, 0xF7, 0xFF, 0x3F, 0x71, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xE0, 0xF7, 0x00, 0x3E, 0x01, 0xFF, 0x83, 0xFE,
  0x01, 0xF8, 0x03, 0xFC, 0x1E, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0xC7, 0xFF, 0xF7, 0xFC, 0x7F, 0x00, 0xF0, 0x7F, 0x83,
  0xFC, 0x1E, 0xF0, 0xE7, 0x8F, 0x3C, 0x78, 0xE3, 0x87, 0xBC, 0x3D, 0xE0,
  0xEE, 0x07, 0x70, 0x3F, 0x80, 0xF8, 0x07, 0xC0, 0xE3, 0x8F, 0xC7, 0x1D,
  0xCE, 0x73, 0x94, 0xE7, 0x29, 0xCE, 0xDB, 0x9D, 0xB7, 0x3B, 0x6E, 0x76,
  0xDC, 0x6D, 0xB0, 0xF9, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x00, 0xF0,
  0x7B, 0xC7, 0x9F, 0x7C, 0x7B, 0xC1, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0xC0, 0xEE, 0x0F, 0x78, 0xF1, 0xE7, 0x8F, 0x78, 0x3C, 0xF0, 0x7F,
  0x83, 0xDE, 0x1E, 0xF1, 0xE7, 0x8F, 0x1E, 0x70, 0xF7, 0x87, 0xBC, 0x1D,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xF3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFE, 0x03, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x03, 0xF0, 0x7E,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x7F, 0x87, 0xF0,
  0xFE, 0x3F, 0xCF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0x80, 0x3C, 0x03, 0xF1, 0xFF, 0xCF, 0xCF, 0xFE, 0x3F,
  0xF1, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 9, 7, 15, 3, -18 },
  { 21, 15, 18, 15, 0, -18 },
  { 55, 13, 26, 15, 1, -22 },
  { 98, 15, 18, 15, 0, -18 },
  { 132, 14, 19, 15, 1, -19 },
  { 166, 3, 7, 15, 6, -18 },
  { 169, 8, 24, 15, 4, -21 },
  { 193, 8, 24, 15, 3, -21 },
  { 217, 13, 13, 15, 1, -15 },
  { 239, 13, 12, 15, 1, -14 },
  { 259, 7, 8, 15, 3, -4 },
  { 266, 9, 4, 15, 3, -10 },
  { 271, 5, 5, 15, 5, -5 },
  { 275, 13, 24, 15, 1, -21 },
  { 314, 13, 19, 15, 1, -19 },
  { 345, 12, 18, 15, 2, -18 },
  { 372, 13, 19, 15, 1, -19 },
  { 403, 13, 18, 15, 1, -18 },
  { 433, 12, 18, 15, 1, -18 },
  { 460, 13, 18, 15, 1, -18 },
  { 490, 13, 18, 15, 1, -18 },
  { 520, 13, 18, 15, 1, -18 },
  { 550, 13, 19, 15, 1, -19 },
  { 581, 13, 19, 15, 1, -19 },
  { 612, 5, 14, 15, 5, -14 },
  { 621, 6, 18, 15, 4, -14 },
  { 635, 11, 14, 15, 2, -15 },
  { 655, 11, 10, 15, 2, -13 },
  { 669, 11, 14, 15, 2, -15 },
  { 689, 10, 18, 15, 3, -18 },
  { 712, 14, 23, 15, 1, -19 },
  { 753, 13, 18, 15, 1, -18 },
  { 783, 12, 18, 15, 2, -18 },
  { 810, 13, 19, 15, 1, -19 },
  { 841, 12, 18, 15, 2, -18 },
  { 868, 11, 18, 15, 2, -18 },
  { 893, 12, 18, 15, 2, -18 },
  { 920, 13, 19, 15, 1, -19 },
  { 951, 11, 18, 15, 2, -18 },
  { 976, 11, 18, 15, 2, -18 },
  { 1001, 13, 18, 15, 0, -18 },
  { 1031, 12, 18, 15, 2, -18 },
  { 1058, 12, 18, 15, 2, -18 },
  { 1085, 13, 18, 15, 1, -18 },
  { 1115, 13, 18, 15, 1, -18 },
  { 1145, 13, 19, 15, 1, -19 },
  { 1176, 12, 18, 15, 2, -18 },
  { 1203, 13, 24, 15, 1, -19 },
  { 1242, 12, 18, 15, 2, -18 },
  { 1269, 13, 19, 15, 1, -19 },
  { 1300, 13, 18, 15, 1, -18 },
  { 1330, 13, 18, 15, 1, -18 },
  { 1360, 13, 18, 15, 1, -18 },
  { 1390, 15, 18, 15, 0, -18 },
  { 1424, 15, 18, 15, 0, -18 },
  { 1458, 15, 18, 15, 0, -18 },
  { 1492, 11, 18, 15, 2, -18 },
  { 1517, 8, 24, 15, 4, -21 },
  { 1541, 13, 24, 15, 1, -21 },
  { 1580, 8, 24, 15, 3, -21 },
  { 1604, 13, 10, 15, 1, -18 },
  { 1621, 13, 3, 15, 1, 1 },
  { 1626, 7, 4, 15, 4, -20 },
  { 1630, 12, 14, 15, 1, -14 },
  { 1651, 12, 18, 15, 2, -18 },
  { 1678, 13, 14, 15, 1, -14 },
  { 1701, 12, 18, 15, 1, -18 },
  { 1728, 13, 14, 15, 1, -14 },
  { 1751, 13, 18, 15, 1, -18 },
  { 1781, 12, 19, 15, 1, -14 },
  { 1810, 11, 18, 15, 2, -18 },
  { 1835, 12, 20, 15, 2, -20 },
  { 1865, 10, 25, 15, 2, -20 },
  { 1897, 12, 18, 15, 2, -18 },
  { 1924, 13, 18, 15, 1, -18 },
  { 1954, 13, 14, 15, 1, -14 },
  { 1977, 11, 14, 15, 2, -14 },
  { 1997, 13, 14, 15, 1, -14 },
  { 2020, 12, 19, 15, 2, -14 },
  { 2049, 12, 19, 15, 1, -14 },
  { 2078, 12, 14, 15, 2, -14 },
  { 2099, 13, 14, 15, 1, -14 },
  { 2122, 12, 18, 15, 1, -18 },
  { 2149, 11, 14, 15, 2, -14 },
  { 2169, 13, 14, 15, 1, -14 },
  { 2192, 15, 14, 15, 0, -14 },
  { 2219, 13, 14, 15, 1, -14 },
  { 2242, 13, 19, 15, 1, -14 },
  { 2273, 11, 14, 15, 2, -14 },
  { 2293, 11, 24, 15, 2, -21 },
  { 2326, 3, 24, 15, 6, -21 },
  { 2335, 11, 24, 15, 2, -21 },
  { 2368, 13, 6, 15, 1, -12 },
};

const GFXfont JetBrainsMono_ExtraBold25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_EXTRABOLD25PT7B_H_
