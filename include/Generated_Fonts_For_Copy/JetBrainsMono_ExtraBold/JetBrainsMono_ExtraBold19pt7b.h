#ifndef _JETBRAINSMONO_EXTRABOLD19PT7B_H_
#define _JETBRAINSMONO_EXTRABOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0x60, 0x2F, 0xC0, 0xEF, 0xDF, 0xBF, 0x3E, 0x7C,
  0xC0, 0x0C, 0xC3, 0x18, 0x63, 0x3F, 0xF7, 0xFE, 0x33, 0x06, 0x61, 0x8C,
  0x31, 0x9F, 0xFB, 0xFF, 0x19, 0x83, 0x30, 0xC6, 0x00, 0x08, 0x02, 0x00,
  0x80, 0xF8, 0x7F, 0xBF, 0xEE, 0xBB, 0xA0, 0xF8, 0x1F, 0xC3, 0xF8, 0x3E,
  0x0B, 0xBA, 0x7F, 0xB9, 0xFE, 0x3F, 0x02, 0x00, 0x80, 0x20, 0x78, 0x7F,
  0xC6, 0xCC, 0xCC, 0xD8, 0xCD, 0x87, 0xB0, 0x06, 0x00, 0xC0, 0x0F, 0xC1,
  0xB6, 0x32, 0x62, 0x26, 0x63, 0xEC, 0x3C, 0x3E, 0x1F, 0xC7, 0x71, 0x8E,
  0x70, 0x1C, 0x0F, 0x83, 0xE7, 0xDD, 0xB3, 0xEC, 0x73, 0x9C, 0xFF, 0x9F,
  0x70, 0xFF, 0xFE, 0xC0, 0x04, 0x73, 0xDE, 0x73, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x87, 0x0F, 0x1C, 0x30, 0xC3, 0x8F, 0x8E, 0x1C, 0x70, 0xC3,
  0x0C, 0x30, 0xC3, 0x1C, 0x73, 0xFE, 0xF3, 0x00, 0x1C, 0x07, 0x00, 0xC3,
  0x36, 0xFB, 0xDF, 0xE1, 0xC0, 0xDC, 0x77, 0x98, 0xC0, 0x1C, 0x0E, 0x07,
  0x1F, 0xFF, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x00, 0x7B, 0x9D, 0xCE, 0x60,
  0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x60,
  0x70, 0x00, 0x3E, 0x3F, 0xBD, 0xFC, 0x3E, 0x1F, 0x0F, 0xF7, 0xFB, 0xE1,
  0xF0, 0xF8, 0x7E, 0x77, 0xF9, 0xF0, 0x1E, 0x0F, 0x8F, 0xE3, 0xB8, 0xCE,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x7F, 0xDF, 0xF0,
  0x3E, 0x3F, 0xBF, 0xFC, 0x70, 0x38, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xBF, 0xDF, 0xE0, 0xE0, 0xE0, 0xF0, 0x7C,
  0x0F, 0x03, 0x81, 0xF8, 0xFC, 0x77, 0xF9, 0xF0, 0x07, 0x07, 0x83, 0x83,
  0x83, 0x83, 0xC1, 0xCF, 0xC7, 0xE3, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C,
  0x7F, 0xBF, 0xDF, 0xEC, 0x06, 0x07, 0x7B, 0xFF, 0xC7, 0x03, 0x81, 0xF8,
  0xFE, 0x77, 0xF9, 0xF8, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x06,
  0xF3, 0xFE, 0xE3, 0xB8, 0x7E, 0x1B, 0xCE, 0x7F, 0x8F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7E, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x83,
  0x81, 0xC0, 0x3E, 0x3F, 0xBC, 0xFC, 0x7E, 0x3B, 0xBC, 0xFC, 0xFE, 0xF3,
  0xF1, 0xF8, 0x7E, 0x77, 0xF9, 0xF8, 0x3E, 0x1F, 0xCF, 0x3B, 0x86, 0xE1,
  0xF8, 0x6F, 0xF9, 0xFE, 0x17, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x00,
  0x6F, 0xF6, 0x00, 0x00, 0xEF, 0xE0, 0x33, 0xDE, 0x60, 0x00, 0x00, 0x7B,
  0x9D, 0xCE, 0x60, 0x00, 0x80, 0xC1, 0xE7, 0xEF, 0xC7, 0x03, 0xE0, 0xFC,
  0x1F, 0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x70, 0x3E, 0x0F, 0xC0, 0xF8, 0x1C, 0x1E, 0x3E, 0xFC, 0x78, 0x30, 0x00,
  0xF8, 0xFE, 0xFE, 0x07, 0x07, 0x0F, 0x7E, 0x7C, 0x70, 0x70, 0x00, 0x20,
  0x70, 0x70, 0x1F, 0x87, 0xF9, 0xC3, 0xB0, 0x36, 0x07, 0xCF, 0xFB, 0xBF,
  0x63, 0xEC, 0x7D, 0x8F, 0xB9, 0xF7, 0xFE, 0x76, 0xC0, 0x1C, 0x01, 0xF8,
  0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xB8, 0x37, 0x0E, 0xE1,
  0xCC, 0x39, 0xC7, 0xF9, 0xFF, 0x38, 0xE7, 0x0F, 0xC1, 0xC0, 0xFE, 0x3F,
  0xEE, 0x7B, 0x8E, 0xE3, 0xB8, 0xEF, 0xE3, 0xFE, 0xE3, 0xB8, 0x7E, 0x1F,
  0x8E, 0xFF, 0xBF, 0x80, 0x3E, 0x3F, 0xFD, 0xFC, 0x7E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x7E, 0x77, 0xF9, 0xF8, 0xFE, 0x7F, 0xBF, 0xFC,
  0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFF, 0xFF, 0xF7, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3E, 0x3F, 0xFD, 0xFC, 0x7E, 0x07,
  0x03, 0x9F, 0xCF, 0xE7, 0xF0, 0xF8, 0x7E, 0x77, 0xF9, 0xF8, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1C, 0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x7E, 0x1D, 0xCF, 0x7F, 0x8F, 0xC0, 0xE1, 0xF8,
  0xEE, 0x3B, 0x9C, 0xE7, 0x3F, 0xCF, 0xE3, 0xF8, 0xE7, 0x39, 0xCE, 0x73,
  0x8E, 0xE3, 0xB8, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFF, 0x3F, 0xDF, 0xD7,
  0xF7, 0xFD, 0xDF, 0x77, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x70,
  0xF1, 0xF8, 0xFC, 0x7F, 0x3D, 0x9F, 0xCF, 0xF7, 0xDB, 0xED, 0xF7, 0xF9,
  0xFC, 0xFE, 0x7F, 0x1C, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0x77, 0xF9, 0xF0, 0xFE, 0x3F, 0xEF, 0xFB,
  0x87, 0xE1, 0xF8, 0x7F, 0xFB, 0xFE, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x00, 0x3E, 0x1F, 0xCF, 0x7B, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E,
  0xE3, 0xB8, 0xEE, 0x3B, 0xCE, 0x7F, 0x8F, 0x80, 0x70, 0x1C, 0x03, 0xC0,
  0xFE, 0x3F, 0xCF, 0xFB, 0x8E, 0xE1, 0xF8, 0xEF, 0xFB, 0xFC, 0xFE, 0x39,
  0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0xF0, 0x3E, 0x1F, 0xEF, 0x7B, 0x8E, 0xE0,
  0x3C, 0x07, 0xF0, 0xFE, 0x07, 0x80, 0xEE, 0x1F, 0xCE, 0x7F, 0x8F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0x77, 0xF9, 0xF0, 0xF0, 0xEE,
  0x1D, 0xC3, 0x38, 0xE3, 0x1C, 0x73, 0x8E, 0x61, 0xDC, 0x1B, 0x83, 0x70,
  0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0xE6, 0x7D, 0xCF, 0xB9, 0xB7, 0x36,
  0xE6, 0xD5, 0xDA, 0xBB, 0x5E, 0x6B, 0xCD, 0x79, 0xA7, 0x3C, 0xE7, 0x9C,
  0xF3, 0x80, 0x70, 0xEE, 0x38, 0xE7, 0x1D, 0xC1, 0xF8, 0x3E, 0x03, 0x80,
  0x78, 0x1F, 0x03, 0xF0, 0xEE, 0x1C, 0xE7, 0x1D, 0xE1, 0xC0, 0xE0, 0xEE,
  0x19, 0xC7, 0x1C, 0xE3, 0xB8, 0x37, 0x07, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xBF, 0xDF, 0xE0, 0xE0, 0x70,
  0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFF, 0xF0,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x1C,
  0x0F, 0x0F, 0x86, 0xE7, 0x73, 0x99, 0x8F, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE3, 0x8E, 0x1C, 0x3F, 0x9F, 0xFC, 0x70, 0x3B, 0xFF, 0xCF, 0xC7, 0xE3,
  0xFF, 0xDF, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0xCF, 0xF7, 0xFF, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFE, 0x7F, 0xFF, 0x78, 0x1C, 0x3F, 0x9F, 0xFC, 0x7E,
  0x07, 0x03, 0x81, 0xC3, 0xF3, 0xBF, 0xCF, 0xC0, 0x03, 0x81, 0xC0, 0xE3,
  0x77, 0xFF, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0x77, 0xF9, 0xFC,
  0x1C, 0x3F, 0x9F, 0xFC, 0x7E, 0x1F, 0xFF, 0x81, 0xC0, 0xE3, 0xBF, 0xCF,
  0x80, 0x0F, 0x8F, 0xC7, 0xE3, 0x81, 0xC7, 0xFF, 0xFE, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x18, 0x3F, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0x7F, 0xBF, 0xC0, 0xE0, 0x73, 0xF9, 0xF8, 0xE0, 0x70, 0x38,
  0x1C, 0xCF, 0xF7, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1C, 0x0C, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x1C, 0x38, 0x00,
  0x1F, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xF8,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE3, 0xB8, 0xEE, 0x73, 0xFC, 0xFE, 0x3F,
  0x8E, 0x73, 0x9E, 0xE3, 0xB8, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0xFE,
  0x0F, 0xC0, 0x19, 0x3E, 0xEC, 0xDF, 0x37, 0xCD, 0xF3, 0x7C, 0xDF, 0x37,
  0xCD, 0xF3, 0x7C, 0xDC, 0x06, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x1C, 0x3F, 0x9F, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xF3, 0xBF, 0xCF, 0x80, 0x06, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xF3, 0xFF, 0xFB, 0xDC, 0x0E, 0x07, 0x00, 0x18, 0x3F,
  0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xBF, 0xCF, 0xE0, 0x70,
  0x38, 0x1C, 0x0C, 0x6F, 0xBF, 0xFC, 0x7C, 0x3E, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x00, 0x1E, 0x3F, 0xBF, 0xFC, 0x0F, 0x03, 0xF8, 0x7E, 0x03,
  0xE3, 0xFF, 0xDF, 0xC0, 0x38, 0x1C, 0x0E, 0x1F, 0xFF, 0xF9, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x07, 0xE3, 0xF0, 0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xE7, 0x7F, 0x1F, 0x00, 0xE1, 0xF8, 0xEE, 0x39, 0xCE,
  0x73, 0x1D, 0xC3, 0x70, 0xF8, 0x3E, 0x07, 0x80, 0xE6, 0x7D, 0xCD, 0xB9,
  0xB5, 0x76, 0xAC, 0xD7, 0x9A, 0xF3, 0x5E, 0x79, 0xC7, 0x38, 0x71, 0xE7,
  0x70, 0x7E, 0x0F, 0x80, 0xE0, 0x3E, 0x07, 0xE1, 0xDC, 0x79, 0xDE, 0x3C,
  0xF0, 0xEE, 0x38, 0xE7, 0x1C, 0xC3, 0xB8, 0x3F, 0x07, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x7F, 0xBF, 0xC1, 0xC1, 0xC1, 0xE1,
  0xE1, 0xE1, 0xE0, 0xFF, 0xFF, 0xC0, 0x03, 0x83, 0xC3, 0xE1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0xFC, 0x7E, 0x3F, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F,
  0x0F, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7C,
  0x3E, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x78, 0x1F, 0x87, 0xC7, 0xE7, 0x03,
  0x80, 0xC0, 0x61, 0xF0, 0xF8, 0x78, 0x00, 0x79, 0xFE, 0x7D, 0xDF, 0x3E,
  0x07, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 7, 6, 11, 2, -14 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 10, 20, 11, 1, -17 },
  { 58, 12, 14, 11, 0, -14 },
  { 79, 10, 14, 11, 1, -14 },
  { 97, 3, 6, 11, 4, -14 },
  { 100, 6, 18, 11, 3, -16 },
  { 114, 6, 18, 11, 2, -16 },
  { 128, 10, 10, 11, 1, -12 },
  { 141, 9, 9, 11, 1, -11 },
  { 152, 5, 6, 11, 3, -3 },
  { 156, 6, 3, 11, 3, -8 },
  { 159, 4, 4, 11, 4, -4 },
  { 161, 9, 18, 11, 1, -16 },
  { 182, 9, 14, 11, 1, -14 },
  { 198, 10, 14, 11, 1, -14 },
  { 216, 9, 14, 11, 1, -14 },
  { 232, 9, 14, 11, 1, -14 },
  { 248, 9, 14, 11, 1, -14 },
  { 264, 9, 14, 11, 1, -14 },
  { 280, 10, 14, 11, 1, -14 },
  { 298, 9, 14, 11, 1, -14 },
  { 314, 9, 14, 11, 1, -14 },
  { 330, 10, 14, 11, 1, -14 },
  { 348, 4, 11, 11, 4, -11 },
  { 354, 5, 14, 11, 3, -11 },
  { 363, 9, 11, 11, 1, -12 },
  { 376, 8, 7, 11, 2, -10 },
  { 383, 9, 11, 11, 1, -12 },
  { 396, 8, 14, 11, 2, -14 },
  { 410, 11, 17, 11, 0, -14 },
  { 434, 11, 14, 11, 0, -14 },
  { 454, 10, 14, 11, 1, -14 },
  { 472, 9, 14, 11, 1, -14 },
  { 488, 9, 14, 11, 1, -14 },
  { 504, 8, 14, 11, 2, -14 },
  { 518, 9, 14, 11, 1, -14 },
  { 534, 9, 14, 11, 1, -14 },
  { 550, 9, 14, 11, 1, -14 },
  { 566, 8, 14, 11, 2, -14 },
  { 580, 10, 14, 11, 0, -14 },
  { 598, 10, 14, 11, 1, -14 },
  { 616, 8, 14, 11, 2, -14 },
  { 630, 10, 14, 11, 1, -14 },
  { 648, 9, 14, 11, 1, -14 },
  { 664, 9, 14, 11, 1, -14 },
  { 680, 10, 14, 11, 1, -14 },
  { 698, 10, 17, 11, 1, -14 },
  { 720, 10, 14, 11, 1, -14 },
  { 738, 10, 14, 11, 1, -14 },
  { 756, 10, 14, 11, 1, -14 },
  { 774, 9, 14, 11, 1, -14 },
  { 790, 11, 14, 11, 0, -14 },
  { 810, 11, 14, 11, 0, -14 },
  { 830, 11, 14, 11, 0, -14 },
  { 850, 11, 14, 11, 0, -14 },
  { 870, 9, 14, 11, 1, -14 },
  { 886, 6, 18, 11, 3, -16 },
  { 900, 9, 18, 11, 1, -16 },
  { 921, 6, 18, 11, 2, -16 },
  { 935, 9, 8, 11, 1, -14 },
  { 944, 9, 3, 11, 1, 0 },
  { 948, 5, 3, 11, 3, -15 },
  { 950, 9, 11, 11, 1, -11 },
  { 963, 9, 14, 11, 1, -14 },
  { 979, 9, 11, 11, 1, -11 },
  { 992, 9, 14, 11, 1, -14 },
  { 1008, 9, 11, 11, 1, -11 },
  { 1021, 9, 14, 11, 1, -14 },
  { 1037, 9, 14, 11, 1, -11 },
  { 1053, 9, 14, 11, 1, -14 },
  { 1069, 10, 15, 11, 1, -15 },
  { 1088, 7, 18, 11, 2, -15 },
  { 1104, 10, 14, 11, 1, -14 },
  { 1122, 11, 14, 11, 0, -14 },
  { 1142, 10, 11, 11, 1, -11 },
  { 1156, 9, 11, 11, 1, -11 },
  { 1169, 9, 11, 11, 1, -11 },
  { 1182, 9, 14, 11, 1, -11 },
  { 1198, 9, 14, 11, 1, -11 },
  { 1214, 9, 11, 11, 2, -11 },
  { 1227, 9, 11, 11, 1, -11 },
  { 1240, 9, 13, 11, 1, -13 },
  { 1255, 9, 10, 11, 1, -10 },
  { 1267, 10, 10, 11, 1, -10 },
  { 1280, 11, 10, 11, 0, -10 },
  { 1294, 11, 10, 11, 0, -10 },
  { 1308, 11, 13, 11, 0, -10 },
  { 1326, 9, 10, 11, 1, -10 },
  { 1338, 9, 18, 11, 1, -16 },
  { 1359, 3, 18, 11, 4, -16 },
  { 1366, 9, 18, 11, 1, -16 },
  { 1387, 10, 5, 11, 1, -9 },
};

const GFXfont JetBrainsMono_ExtraBold19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBold19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBold19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_EXTRABOLD19PT7B_H_
