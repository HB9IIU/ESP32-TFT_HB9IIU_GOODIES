#ifndef _NOTOSANS_SEMICONDENSED_LIGHT42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light42pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x00, 0x00, 0x6F, 0xFE, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x08,
  0x00, 0x60, 0x60, 0x01, 0x81, 0x81, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0,
  0xC0, 0x60, 0x03, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x20, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0xFF,
  0x01, 0xFF, 0xF1, 0xE4, 0x79, 0xC2, 0x04, 0xC1, 0x00, 0xE0, 0x80, 0x70,
  0x40, 0x38, 0x20, 0x1C, 0x10, 0x06, 0x08, 0x03, 0x84, 0x00, 0xF2, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x2F, 0x80, 0x11, 0xE0, 0x08,
  0x70, 0x04, 0x1C, 0x02, 0x06, 0x01, 0x03, 0x00, 0x81, 0x80, 0x41, 0xC0,
  0x20, 0xD8, 0x10, 0xEF, 0xEF, 0xE3, 0xFF, 0xC0, 0x0F, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x1C, 0x07, 0x70, 0x03, 0x01,
  0x83, 0x00, 0xE0, 0x30, 0x60, 0x18, 0x0E, 0x0E, 0x07, 0x01, 0x80, 0xC0,
  0xC0, 0x30, 0x18, 0x18, 0x06, 0x03, 0x06, 0x00, 0xC0, 0x60, 0xC0, 0x18,
  0x0C, 0x30, 0x03, 0x01, 0x86, 0x00, 0x60, 0x31, 0x80, 0x0C, 0x06, 0x31,
  0xF0, 0xC1, 0xCC, 0x77, 0x18, 0x31, 0x98, 0x33, 0x06, 0x63, 0x06, 0x3B,
  0x8C, 0x60, 0x63, 0xE3, 0x18, 0x0C, 0x00, 0x63, 0x01, 0x80, 0x18, 0x60,
  0x30, 0x03, 0x0C, 0x06, 0x00, 0xE1, 0x80, 0xC0, 0x18, 0x30, 0x18, 0x07,
  0x06, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x0C, 0x1C, 0x06, 0x01, 0x83,
  0x00, 0xC0, 0x38, 0x60, 0x30, 0x03, 0xB8, 0x0E, 0x00, 0x3E, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x70, 0x01, 0x80,
  0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x18, 0x18, 0x00, 0x38, 0x70, 0x00, 0x33, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x38, 0x70, 0x0C,
  0xE0, 0x70, 0x39, 0xC0, 0xE0, 0x67, 0x00, 0xE0, 0xCE, 0x00, 0xE3, 0x98,
  0x00, 0xE6, 0x30, 0x00, 0xFC, 0x60, 0x00, 0xF0, 0xE0, 0x00, 0xE1, 0xC0,
  0x03, 0xC1, 0xC0, 0x0F, 0xC3, 0xC0, 0x79, 0xC3, 0xFF, 0xC1, 0xC1, 0xFF,
  0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x38,
  0x30, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x0E, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC1, 0x81,
  0xF9, 0x9F, 0xFF, 0xFF, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0x60, 0x06, 0x60,
  0x0C, 0x30, 0x1C, 0x38, 0x38, 0x1C, 0x08, 0x08, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x33, 0x77, 0x76, 0x6E, 0xCC, 0xFF, 0xFF,
  0xF0, 0x6E, 0xFE, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x00, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00,
  0xC3, 0x00, 0x73, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x07, 0x60, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1B, 0x00, 0x1D, 0x80, 0x0E, 0xE0, 0x06, 0x70, 0x03, 0x18, 0x03, 0x8E,
  0x01, 0x83, 0x83, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0x83, 0xC3, 0xE3,
  0xB3, 0x9F, 0x8F, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0F, 0xF0, 0x1F, 0xFE, 0x1C, 0x07,
  0x8C, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8,
  0x3F, 0xFE, 0x3C, 0x07, 0x88, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xD8, 0x03, 0xCF, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x37, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xC7,
  0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x30, 0x70, 0x06, 0x07, 0x00, 0xE0,
  0x70, 0x0C, 0x07, 0x01, 0x80, 0x70, 0x18, 0x07, 0x03, 0x00, 0x70, 0x70,
  0x07, 0x06, 0x00, 0x70, 0xC0, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x7F, 0xFC, 0x7F, 0xFC, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x40, 0x3C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0xC0,
  0x3C, 0xFF, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x1C, 0x06, 0x7F, 0xC7, 0x7D, 0xF3, 0xF0,
  0x1D, 0xE0, 0x06, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x70, 0x01, 0x98, 0x01,
  0xCE, 0x01, 0xC3, 0x81, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x07, 0xF8, 0x0F, 0xFE, 0x0E, 0x03, 0x86, 0x00, 0xE7, 0x00, 0x33,
  0x00, 0x1D, 0x80, 0x0E, 0xC0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x8E, 0x01,
  0x83, 0x83, 0xC0, 0xF3, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x1E, 0xF0, 0x1C,
  0x1E, 0x1C, 0x07, 0x9C, 0x00, 0xCC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0xDC, 0x00, 0xC7, 0x01,
  0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFE, 0x0E, 0x07, 0x0E,
  0x01, 0xC6, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3B, 0x00, 0x1D, 0xC0,
  0x1E, 0xF0, 0x1B, 0x3E, 0x79, 0x8F, 0xF8, 0xC0, 0xF0, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x6F, 0xFE, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xE0, 0x18, 0xF3, 0xCE,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8E,
  0x38, 0xE3, 0x0C, 0x71, 0x86, 0x38, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xC3, 0xFF,
  0xCC, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x30, 0x01, 0x80, 0x31, 0x80,
  0x7F, 0xC1, 0x9C, 0x0F, 0x0E, 0x06, 0xC0, 0x60, 0x30, 0x36, 0x06, 0x03,
  0x81, 0xB0, 0x30, 0x1C, 0x0F, 0x83, 0x00, 0xE0, 0x78, 0x18, 0x06, 0x03,
  0xC0, 0xC0, 0x30, 0x1E, 0x06, 0x01, 0x80, 0xF0, 0x30, 0x0C, 0x07, 0x81,
  0x80, 0x60, 0x3C, 0x0C, 0x03, 0x03, 0x70, 0x70, 0x38, 0x19, 0x81, 0x83,
  0x61, 0xCC, 0x0F, 0x7B, 0xFC, 0x60, 0x3F, 0x8F, 0xC3, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x78, 0x07, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x38, 0x00, 0x60, 0x30, 0x01, 0xC0,
  0x60, 0x03, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0C,
  0x1C, 0x00, 0x18, 0x30, 0x00, 0x38, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x63,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0C, 0x01, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00,
  0x3B, 0x00, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x1C,
  0xC0, 0x0E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0x00, 0xF8, 0xC0, 0x07, 0x30,
  0x00, 0xEC, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x73, 0x00, 0x7C,
  0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0x80,
  0x60, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x02, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0xC0, 0x3E, 0x0C, 0x00, 0x78, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xC0,
  0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00,
  0x38, 0xC0, 0x0F, 0x0C, 0x03, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xF8, 0x1F, 0x00, 0x70, 0x78, 0x00, 0x20, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0xC0, 0x00,
  0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xC0,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xDF, 0xEF, 0xE3,
  0xC0, 0xC0, 0x03, 0xF0, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x38, 0xC0, 0x1C,
  0x30, 0x0E, 0x0C, 0x03, 0x03, 0x01, 0xC0, 0xC0, 0xE0, 0x30, 0x70, 0x0C,
  0x38, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x33, 0x80, 0x0D, 0xF0, 0x03, 0xEE,
  0x00, 0xF1, 0x80, 0x38, 0x70, 0x0C, 0x0E, 0x03, 0x03, 0x80, 0xC0, 0x70,
  0x30, 0x0E, 0x0C, 0x03, 0x83, 0x00, 0x70, 0xC0, 0x0E, 0x30, 0x03, 0x8C,
  0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x70, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1B, 0xD8, 0x00, 0x06, 0xF6, 0x00, 0x03, 0xBD, 0xC0, 0x00,
  0xCF, 0x30, 0x00, 0x33, 0xCC, 0x00, 0x1C, 0xF3, 0x80, 0x06, 0x3C, 0x60,
  0x01, 0x8F, 0x18, 0x00, 0xE3, 0xC7, 0x00, 0x30, 0xF0, 0xC0, 0x0C, 0x3C,
  0x38, 0x06, 0x0F, 0x06, 0x01, 0x83, 0xC1, 0x80, 0xE0, 0xF0, 0x70, 0x30,
  0x3C, 0x0C, 0x0C, 0x0F, 0x03, 0x07, 0x03, 0xC0, 0xE1, 0x80, 0xF0, 0x18,
  0x60, 0x3C, 0x06, 0x38, 0x0F, 0x01, 0xCC, 0x03, 0xC0, 0x33, 0x00, 0xF0,
  0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xF0, 0x03, 0x00, 0x30, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3D, 0xC0, 0x03, 0xCC, 0x00, 0x3C, 0xE0, 0x03,
  0xC6, 0x00, 0x3C, 0x70, 0x03, 0xC3, 0x80, 0x3C, 0x18, 0x03, 0xC1, 0xC0,
  0x3C, 0x0C, 0x03, 0xC0, 0xE0, 0x3C, 0x06, 0x03, 0xC0, 0x70, 0x3C, 0x03,
  0x83, 0xC0, 0x18, 0x3C, 0x01, 0xC3, 0xC0, 0x0C, 0x3C, 0x00, 0xE3, 0xC0,
  0x07, 0x3C, 0x00, 0x73, 0xC0, 0x03, 0xBC, 0x00, 0x1B, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x7C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0xFC, 0xFF, 0xF0, 0xFF,
  0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x07, 0x80,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0xFF, 0xE0, 0x3F, 0xFE, 0x0C, 0x07, 0xC3, 0x00,
  0x38, 0xC0, 0x07, 0x30, 0x01, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x06, 0x30, 0x03, 0x8C,
  0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x30, 0x38, 0x0C, 0x06, 0x03, 0x01,
  0xC0, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x0E,
  0x30, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x70,
  0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0x00, 0xCE, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xD8, 0x03, 0xCF,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0xC0, 0x07, 0x1E, 0x03, 0xC1, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x66, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x18, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x81, 0xC0, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0xE0,
  0x07, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xE1, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x00, 0x00, 0xDC,
  0x00, 0x03, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xB8,
  0x00, 0xF0, 0x00, 0xCC, 0x00, 0x78, 0x00, 0xE6, 0x00, 0x3E, 0x00, 0x73,
  0x00, 0x1B, 0x00, 0x31, 0xC0, 0x1D, 0x80, 0x18, 0x60, 0x0C, 0xC0, 0x1C,
  0x30, 0x06, 0x70, 0x0E, 0x18, 0x03, 0x18, 0x06, 0x0E, 0x03, 0x8C, 0x03,
  0x03, 0x01, 0x86, 0x03, 0x81, 0x80, 0xC3, 0x81, 0xC0, 0xC0, 0x60, 0xC0,
  0xC0, 0x70, 0x70, 0x60, 0x60, 0x18, 0x30, 0x30, 0x70, 0x0C, 0x18, 0x1C,
  0x38, 0x06, 0x0C, 0x06, 0x18, 0x03, 0x8E, 0x03, 0x0C, 0x00, 0xC6, 0x01,
  0x8E, 0x00, 0x63, 0x00, 0xE7, 0x00, 0x31, 0x80, 0x33, 0x00, 0x1D, 0xC0,
  0x19, 0x80, 0x0E, 0xC0, 0x0C, 0xC0, 0x03, 0x60, 0x06, 0xE0, 0x01, 0xB0,
  0x01, 0xE0, 0x00, 0xD8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x73, 0x00, 0x0E,
  0x38, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x01, 0x80, 0xE0, 0x38, 0x06, 0x07,
  0x00, 0x70, 0x60, 0x03, 0x0E, 0x00, 0x38, 0xC0, 0x01, 0x9C, 0x00, 0x1D,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x1D, 0x80, 0x01, 0x9C, 0x00, 0x30, 0xC0, 0x07, 0x0E, 0x00,
  0x60, 0x60, 0x0E, 0x07, 0x00, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0x80, 0x1C,
  0x38, 0x00, 0xC3, 0x00, 0x0E, 0x70, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00,
  0x76, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0x80,
  0x18, 0x1C, 0x03, 0x80, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x06,
  0x0E, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00, 0x39, 0x80, 0x01, 0xB8, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1F, 0xFF, 0xF8, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x19, 0x80, 0x06, 0x30,
  0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x0E, 0x01, 0x81, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x33, 0x80, 0x06,
  0xE0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE1, 0xC1, 0xC1,
  0xC1, 0xC1, 0x80, 0x01, 0xC0, 0x3F, 0xF0, 0xF0, 0xF1, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0F, 0xF8,
  0xFF, 0xF3, 0xC0, 0x6E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0xF7, 0x03, 0x6F, 0xFC, 0xCF, 0xF1, 0x80, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x7C, 0x0E, 0x7F, 0xC3,
  0xBC, 0x78, 0xF8, 0x07, 0x3C, 0x00, 0xCF, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x01, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x3B,
  0xC0, 0x0C, 0xF8, 0x07, 0x37, 0x03, 0x8C, 0xFF, 0xC3, 0x1F, 0xE0, 0x00,
  0xF0, 0x0F, 0xFC, 0x3E, 0x70, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x21, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x81, 0xF0, 0xC3, 0xFE, 0x63, 0xC3, 0xB3, 0x80, 0x79, 0x80,
  0x3D, 0xC0, 0x0E, 0xC0, 0x07, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0x73, 0x00, 0x79, 0xE0, 0x6C, 0x7F,
  0xE6, 0x0F, 0xE3, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC3,
  0x00, 0x73, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x30,
  0x7F, 0xF8, 0x1F, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFE, 0x3F,
  0xF8, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x03, 0xE0, 0x07, 0xFC, 0xC7, 0xCF, 0x67, 0x00, 0xF3, 0x00, 0x3B, 0x80,
  0x1D, 0x80, 0x0E, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x01,
  0xB0, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0xF3, 0xC0, 0xD8, 0xFF, 0xCC, 0x1F,
  0xC6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x3A, 0x00, 0x39, 0xC0, 0x38, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xF0, 0xE7, 0xFC, 0xEE, 0x3E, 0xF8,
  0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0x5F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x02, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0xFE, 0xF8, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x02, 0xE0, 0x0C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x70,
  0xE0, 0xE0, 0xE1, 0xC0, 0xE1, 0x80, 0xE3, 0x80, 0xE7, 0x00, 0xEF, 0x00,
  0xEF, 0x00, 0xFB, 0x80, 0xF1, 0xC0, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0x70,
  0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x18, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x1E, 0x0C, 0x7F, 0x87, 0xF8, 0xCE, 0x3C, 0xF3, 0xCD, 0x81,
  0xD8, 0x0E, 0xF0, 0x0F, 0x00, 0x6F, 0x00, 0xF0, 0x06, 0xE0, 0x06, 0x00,
  0x6E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0,
  0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60,
  0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E,
  0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06,
  0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x70, 0x01, 0xE0, 0xC7,
  0xFC, 0xCE, 0x3E, 0xD8, 0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x01, 0xE0, 0x03, 0xFF, 0x01,
  0xE1, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x19, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xDC, 0x00, 0x67,
  0x00, 0x38, 0xE0, 0x0C, 0x1C, 0x0F, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x01,
  0xF0, 0x31, 0xFF, 0x0C, 0xF1, 0xE3, 0x60, 0x1C, 0xF0, 0x03, 0x3C, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x06, 0xE0,
  0x01, 0xBC, 0x00, 0xEF, 0x00, 0x33, 0xE0, 0x1C, 0xFC, 0x0E, 0x3B, 0xFF,
  0x8E, 0x3F, 0x83, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0xC7, 0x8F, 0x67, 0x00, 0xF3, 0x00,
  0x7B, 0x80, 0x1D, 0x80, 0x0E, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x01, 0xDC, 0x00, 0xE6, 0x00, 0xF3, 0xC0, 0xD8, 0xFF,
  0xCC, 0x3F, 0xC6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xF8, 0xFF, 0x3F, 0xEE, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xC0, 0xFF,
  0xE7, 0x87, 0xB8, 0x02, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x80, 0x3B, 0xFF, 0xC7,
  0xFE, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x3F, 0xFF,
  0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x7F, 0x87, 0xF0, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x0F, 0x70, 0x1B, 0x3F, 0xF3, 0x1F,
  0xE3, 0xE0, 0x01, 0xD8, 0x00, 0xE6, 0x00, 0x39, 0xC0, 0x0C, 0x30, 0x07,
  0x0C, 0x01, 0xC3, 0x80, 0x60, 0x60, 0x38, 0x18, 0x0E, 0x07, 0x03, 0x00,
  0xC0, 0xC0, 0x30, 0x70, 0x0E, 0x18, 0x01, 0x86, 0x00, 0x63, 0x80, 0x1C,
  0xC0, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x76, 0x00, 0xF0, 0x06, 0x70, 0x0F,
  0x00, 0x63, 0x00, 0xF8, 0x0E, 0x30, 0x0D, 0x80, 0xC3, 0x01, 0xD8, 0x0C,
  0x38, 0x19, 0x80, 0xC1, 0x81, 0x9C, 0x1C, 0x18, 0x38, 0xC1, 0x81, 0x83,
  0x0C, 0x18, 0x1C, 0x30, 0xC1, 0x80, 0xC3, 0x06, 0x38, 0x0C, 0x70, 0x63,
  0x00, 0xC6, 0x06, 0x30, 0x0E, 0x60, 0x73, 0x00, 0x6E, 0x03, 0x70, 0x06,
  0xC0, 0x36, 0x00, 0x6C, 0x03, 0x60, 0x06, 0xC0, 0x3E, 0x00, 0x3C, 0x01,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x38, 0x03,
  0x0E, 0x03, 0x83, 0x01, 0x81, 0xC1, 0xC0, 0x61, 0xC0, 0x38, 0xC0, 0x0E,
  0xE0, 0x03, 0x60, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x3B, 0x80, 0x38, 0xC0, 0x18, 0x70, 0x1C, 0x18, 0x0C, 0x0E, 0x0E, 0x03,
  0x8E, 0x00, 0xC6, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x01, 0xD8, 0x00, 0x67,
  0x00, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x0E, 0x01, 0xC1, 0x80, 0x60, 0x60,
  0x18, 0x1C, 0x0E, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x70, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x73, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x1F, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x0F,
  0xC0, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0xE0, 0x1F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x3F, 0x00, 0xF0, 0x3C, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x7C, 0x0F, 0x80, 0x80,
  0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x3C, 0x1F, 0xFE, 0x01, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Light42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 30, 10, 3, -30 },
  { 16, 9, 11, 15, 3, -30 },
  { 29, 22, 30, 24, 1, -30 },
  { 112, 17, 34, 22, 2, -32 },
  { 185, 27, 30, 31, 2, -30 },
  { 287, 23, 30, 26, 2, -30 },
  { 374, 2, 11, 8, 3, -30 },
  { 377, 8, 37, 12, 2, -30 },
  { 414, 9, 37, 12, 1, -30 },
  { 456, 16, 16, 20, 2, -32 },
  { 488, 18, 20, 22, 2, -25 },
  { 533, 4, 10, 9, 2, -5 },
  { 538, 10, 2, 13, 1, -12 },
  { 541, 4, 4, 10, 3, -4 },
  { 543, 13, 30, 15, 1, -30 },
  { 592, 17, 30, 22, 2, -30 },
  { 656, 9, 30, 22, 4, -30 },
  { 690, 17, 30, 22, 2, -30 },
  { 754, 17, 30, 22, 2, -30 },
  { 818, 20, 30, 22, 1, -30 },
  { 893, 16, 30, 22, 3, -30 },
  { 953, 17, 30, 22, 2, -30 },
  { 1017, 17, 30, 22, 2, -30 },
  { 1081, 17, 30, 22, 2, -30 },
  { 1145, 17, 30, 22, 2, -30 },
  { 1209, 4, 23, 10, 3, -23 },
  { 1221, 6, 28, 10, 1, -23 },
  { 1242, 18, 19, 22, 2, -25 },
  { 1285, 18, 11, 22, 2, -20 },
  { 1310, 18, 19, 22, 2, -25 },
  { 1353, 14, 30, 16, 1, -30 },
  { 1406, 29, 34, 33, 2, -30 },
  { 1530, 23, 30, 23, 0, -30 },
  { 1617, 18, 30, 24, 4, -30 },
  { 1685, 20, 30, 23, 2, -30 },
  { 1760, 20, 30, 27, 4, -30 },
  { 1835, 14, 30, 21, 4, -30 },
  { 1888, 14, 30, 19, 4, -30 },
  { 1941, 23, 30, 27, 2, -30 },
  { 2028, 19, 30, 27, 4, -30 },
  { 2100, 8, 30, 12, 2, -30 },
  { 2130, 9, 38, 10, -3, -30 },
  { 2173, 18, 30, 22, 4, -30 },
  { 2241, 14, 30, 19, 4, -30 },
  { 2294, 26, 30, 34, 4, -30 },
  { 2392, 20, 30, 28, 4, -30 },
  { 2467, 24, 30, 29, 2, -30 },
  { 2557, 16, 30, 22, 4, -30 },
  { 2617, 24, 37, 29, 2, -30 },
  { 2728, 18, 30, 23, 4, -30 },
  { 2796, 17, 30, 21, 2, -30 },
  { 2860, 19, 30, 20, 0, -30 },
  { 2932, 19, 30, 27, 4, -30 },
  { 3004, 22, 30, 22, 0, -30 },
  { 3087, 33, 30, 34, 1, -30 },
  { 3211, 20, 30, 20, 0, -30 },
  { 3286, 20, 30, 20, 0, -30 },
  { 3361, 18, 30, 21, 1, -30 },
  { 3429, 9, 37, 13, 3, -30 },
  { 3471, 13, 30, 15, 1, -30 },
  { 3520, 9, 37, 13, 1, -30 },
  { 3562, 19, 17, 22, 1, -30 },
  { 3603, 18, 2, 17, 0, 4 },
  { 3608, 7, 7, 11, 2, -32 },
  { 3615, 15, 23, 20, 2, -23 },
  { 3659, 18, 32, 23, 3, -32 },
  { 3731, 15, 23, 18, 2, -23 },
  { 3775, 17, 32, 23, 2, -32 },
  { 3843, 17, 23, 21, 2, -23 },
  { 3892, 14, 32, 12, 0, -32 },
  { 3948, 17, 33, 23, 2, -23 },
  { 4019, 16, 32, 23, 3, -32 },
  { 4083, 3, 31, 9, 3, -31 },
  { 4095, 8, 41, 9, -2, -31 },
  { 4136, 16, 32, 19, 3, -32 },
  { 4200, 3, 32, 9, 3, -32 },
  { 4212, 28, 23, 34, 3, -23 },
  { 4293, 16, 23, 23, 3, -23 },
  { 4339, 18, 23, 22, 2, -23 },
  { 4391, 18, 33, 23, 3, -23 },
  { 4466, 17, 33, 23, 2, -23 },
  { 4537, 11, 23, 15, 3, -23 },
  { 4569, 14, 23, 17, 2, -23 },
  { 4610, 11, 28, 13, 1, -28 },
  { 4649, 16, 22, 23, 3, -22 },
  { 4693, 18, 22, 18, 0, -22 },
  { 4743, 28, 22, 28, 0, -22 },
  { 4820, 17, 22, 19, 1, -22 },
  { 4867, 18, 32, 18, 0, -22 },
  { 4939, 14, 22, 17, 1, -22 },
  { 4978, 12, 37, 15, 1, -30 },
  { 5034, 2, 42, 20, 9, -32 },
  { 5045, 12, 37, 15, 2, -30 },
  { 5101, 18, 4, 22, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Light42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT42PT7B_H_
