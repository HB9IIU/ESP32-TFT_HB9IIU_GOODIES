#ifndef _NOTOSANS_SEMICONDENSED_LIGHT11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x28, 0xA7, 0xCA, 0x4B, 0xF5, 0x14, 0x6D, 0xCC, 0x25,
  0x5E, 0x40, 0xC9, 0x52, 0xC5, 0xEE, 0xA5, 0x52, 0xA6, 0x62, 0x4A, 0x10,
  0xAA, 0x69, 0x3B, 0xE0, 0x29, 0x49, 0x22, 0x44, 0x89, 0x12, 0x4A, 0x50,
  0x4F, 0x4A, 0x21, 0x3E, 0x42, 0x00, 0x60, 0xE0, 0x80, 0x12, 0x22, 0x44,
  0x48, 0x69, 0x99, 0x99, 0x9E, 0x75, 0x55, 0xE1, 0x11, 0x24, 0x8F, 0xF0,
  0x42, 0x60, 0x84, 0x3E, 0x10, 0x8A, 0x94, 0xFC, 0x21, 0xF8, 0x8E, 0x11,
  0x1E, 0x78, 0x8E, 0x99, 0x9E, 0xF8, 0x42, 0x21, 0x10, 0x8C, 0xE9, 0x96,
  0xA9, 0x9F, 0xE9, 0x99, 0xF1, 0x1E, 0x84, 0x40, 0x18, 0x1B, 0x38, 0x20,
  0x80, 0xF8, 0x3E, 0xE0, 0x86, 0xC8, 0x00, 0xE1, 0x12, 0x44, 0x04, 0x3D,
  0x86, 0x6D, 0x5C, 0xB9, 0x6D, 0x40, 0x78, 0x20, 0xC3, 0x12, 0x79, 0x28,
  0x61, 0xF4, 0x63, 0xE9, 0x46, 0x3E, 0x7C, 0x21, 0x08, 0x42, 0x0F, 0xF4,
  0x63, 0x18, 0xC6, 0x3E, 0xF8, 0x8F, 0x88, 0x8F, 0xF8, 0x88, 0xF8, 0x88,
  0x7C, 0x21, 0x09, 0xC6, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xE9, 0x24,
  0x97, 0x24, 0x92, 0x49, 0x38, 0x8C, 0xA9, 0x8A, 0x52, 0x51, 0x88, 0x88,
  0x88, 0x8F, 0x83, 0x0F, 0x1E, 0x5A, 0xB5, 0x6C, 0xC9, 0x8C, 0x73, 0x5A,
  0xCE, 0x31, 0x72, 0x28, 0x61, 0x86, 0x18, 0x5E, 0xE9, 0x99, 0xE8, 0x88,
  0x72, 0x28, 0x61, 0x86, 0x18, 0x5E, 0x10, 0x20, 0xE4, 0xA5, 0x2E, 0x52,
  0x51, 0xF8, 0x8C, 0x21, 0x1E, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x8C, 0x63,
  0x18, 0xC6, 0x2E, 0x86, 0x24, 0x92, 0x50, 0xC3, 0x08, 0x88, 0xC4, 0x55,
  0x4A, 0xA5, 0x52, 0xA8, 0x88, 0x44, 0x8A, 0x54, 0x42, 0x29, 0x31, 0x8C,
  0x54, 0xA2, 0x10, 0x84, 0x78, 0x44, 0x42, 0x21, 0x1F, 0xEA, 0xAA, 0xB0,
  0x88, 0x44, 0x22, 0x21, 0xE4, 0x92, 0x49, 0x3C, 0x21, 0x94, 0x98, 0x80,
  0xF8, 0xC0, 0x71, 0x35, 0x97, 0x88, 0xF9, 0x99, 0x9F, 0x72, 0x49, 0xC0,
  0x11, 0xF9, 0x99, 0x9F, 0x69, 0xF8, 0x8F, 0x74, 0xE4, 0x44, 0x44, 0xF9,
  0x99, 0x9F, 0x11, 0xE0, 0x88, 0xF9, 0x99, 0x99, 0xBF, 0x45, 0x55, 0x58,
  0x88, 0x9A, 0xCC, 0xA9, 0xFF, 0xEF, 0x26, 0x4C, 0x99, 0x32, 0x40, 0xF9,
  0x99, 0x99, 0x69, 0x99, 0x9E, 0xF9, 0x99, 0x9F, 0x88, 0x80, 0xF9, 0x99,
  0x9F, 0x11, 0x10, 0xF2, 0x49, 0x00, 0x78, 0x43, 0x1F, 0x5D, 0x24, 0x98,
  0x99, 0x99, 0x9F, 0x8C, 0x94, 0xA6, 0x10, 0x93, 0x25, 0x6B, 0x56, 0xC8,
  0x80, 0x8A, 0x88, 0x45, 0x44, 0x8C, 0x94, 0xA6, 0x10, 0x88, 0x80, 0x71,
  0x24, 0x4F, 0x34, 0x44, 0xC4, 0x44, 0x43, 0xFF, 0xE0, 0xC4, 0x22, 0x32,
  0x22, 0x4C, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Light11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 6, 8, 6, 0, -8 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 7, 8, 8, 1, -8 },
  { 21, 6, 8, 7, 1, -8 },
  { 27, 1, 3, 2, 1, -8 },
  { 28, 3, 10, 3, 0, -8 },
  { 32, 3, 10, 3, 0, -8 },
  { 36, 4, 4, 5, 1, -8 },
  { 38, 5, 5, 6, 0, -6 },
  { 42, 2, 2, 2, 0, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 1, 1, 3, 1, -1 },
  { 45, 4, 8, 4, 0, -8 },
  { 49, 4, 8, 6, 1, -8 },
  { 53, 2, 8, 6, 1, -8 },
  { 55, 4, 8, 6, 1, -8 },
  { 59, 5, 8, 6, 0, -8 },
  { 64, 5, 8, 6, 0, -8 },
  { 69, 4, 8, 6, 1, -8 },
  { 73, 4, 8, 6, 1, -8 },
  { 77, 5, 8, 6, 0, -8 },
  { 82, 4, 8, 6, 1, -8 },
  { 86, 4, 8, 6, 1, -8 },
  { 90, 1, 6, 3, 1, -6 },
  { 91, 2, 7, 3, 0, -6 },
  { 93, 5, 5, 6, 0, -6 },
  { 97, 5, 3, 6, 0, -5 },
  { 99, 5, 5, 6, 0, -6 },
  { 103, 4, 8, 4, 0, -8 },
  { 107, 7, 9, 9, 1, -8 },
  { 115, 6, 8, 6, 0, -8 },
  { 121, 5, 8, 6, 1, -8 },
  { 126, 5, 8, 6, 1, -8 },
  { 131, 5, 8, 7, 1, -8 },
  { 136, 4, 8, 5, 1, -8 },
  { 140, 4, 8, 5, 1, -8 },
  { 144, 5, 8, 7, 1, -8 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 3, 8, 3, 0, -8 },
  { 157, 3, 10, 3, -1, -8 },
  { 161, 5, 8, 6, 1, -8 },
  { 166, 4, 8, 5, 1, -8 },
  { 170, 7, 8, 9, 1, -8 },
  { 177, 5, 8, 7, 1, -8 },
  { 182, 6, 8, 7, 1, -8 },
  { 188, 4, 8, 6, 1, -8 },
  { 192, 6, 10, 7, 1, -8 },
  { 200, 5, 8, 6, 1, -8 },
  { 205, 4, 8, 5, 1, -8 },
  { 209, 5, 8, 5, 0, -8 },
  { 214, 5, 8, 7, 1, -8 },
  { 219, 6, 8, 6, 0, -8 },
  { 225, 9, 8, 9, 0, -8 },
  { 234, 5, 8, 5, 0, -8 },
  { 239, 5, 8, 5, 0, -8 },
  { 244, 5, 8, 5, 0, -8 },
  { 249, 2, 10, 3, 1, -8 },
  { 252, 4, 8, 4, 0, -8 },
  { 256, 3, 10, 3, 0, -8 },
  { 260, 5, 5, 6, 0, -8 },
  { 264, 5, 1, 5, 0, 1 },
  { 265, 2, 1, 3, 0, -8 },
  { 266, 4, 6, 5, 0, -6 },
  { 269, 4, 8, 6, 1, -8 },
  { 273, 3, 6, 5, 1, -6 },
  { 276, 4, 8, 6, 1, -8 },
  { 280, 4, 6, 5, 1, -6 },
  { 283, 4, 8, 3, 0, -8 },
  { 287, 4, 9, 6, 1, -6 },
  { 292, 4, 8, 6, 1, -8 },
  { 296, 1, 8, 2, 1, -8 },
  { 297, 2, 11, 2, 0, -8 },
  { 300, 4, 8, 5, 1, -8 },
  { 304, 1, 8, 2, 1, -8 },
  { 305, 7, 6, 9, 1, -6 },
  { 311, 4, 6, 6, 1, -6 },
  { 314, 4, 6, 6, 1, -6 },
  { 317, 4, 9, 6, 1, -6 },
  { 322, 4, 9, 6, 1, -6 },
  { 327, 3, 6, 4, 1, -6 },
  { 330, 4, 6, 5, 0, -6 },
  { 333, 3, 7, 3, 0, -7 },
  { 336, 4, 6, 6, 1, -6 },
  { 339, 5, 6, 5, 0, -6 },
  { 343, 7, 6, 7, 0, -6 },
  { 349, 5, 6, 5, 0, -6 },
  { 353, 5, 9, 5, 0, -6 },
  { 359, 4, 6, 4, 0, -6 },
  { 362, 4, 10, 4, 0, -8 },
  { 367, 1, 11, 5, 2, -8 },
  { 369, 4, 10, 4, 0, -8 },
  { 374, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Light11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT11PT7B_H_
