#ifndef _NOTOSANS_SEMICONDENSED_LIGHT21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE6, 0xCE, 0x52, 0x94, 0x80, 0x04, 0x40, 0x84, 0x08, 0x80,
  0x88, 0x7F, 0xF0, 0x88, 0x08, 0x81, 0x08, 0x11, 0x0F, 0xFE, 0x11, 0x01,
  0x10, 0x11, 0x02, 0x10, 0x22, 0x00, 0x08, 0x08, 0x7F, 0xC8, 0x88, 0x88,
  0xC8, 0x68, 0x1C, 0x0B, 0x09, 0x09, 0x09, 0x89, 0xFE, 0x08, 0x08, 0x70,
  0x21, 0x21, 0x08, 0x84, 0x22, 0x20, 0x88, 0x82, 0x24, 0x08, 0x97, 0x12,
  0x92, 0x72, 0x88, 0x12, 0x20, 0x48, 0xC2, 0x22, 0x08, 0x88, 0x41, 0x21,
  0x07, 0x00, 0x3E, 0x02, 0x20, 0x63, 0x06, 0x20, 0x22, 0x03, 0x60, 0x18,
  0x03, 0x80, 0x44, 0x2C, 0x66, 0x83, 0x48, 0x1C, 0x80, 0x84, 0x34, 0x3E,
  0x30, 0xF5, 0x40, 0x12, 0x64, 0x4C, 0x88, 0x88, 0x88, 0x8C, 0x44, 0x23,
  0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x32, 0x26, 0x48, 0x18, 0x08, 0x08,
  0xEF, 0x18, 0x1C, 0x24, 0x42, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x5E, 0x80, 0xF8, 0xC0, 0x02, 0x08, 0x10,
  0x20, 0x81, 0x06, 0x08, 0x10, 0x60, 0x81, 0x04, 0x08, 0x30, 0x00, 0x3E,
  0x31, 0x10, 0x58, 0x28, 0x14, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x58,
  0x24, 0x13, 0x10, 0xF8, 0x19, 0xF7, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x60, 0x7E, 0x61, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x06, 0x06, 0x06, 0x03, 0xFE, 0x7E, 0x83, 0x01, 0x01, 0x01,
  0x03, 0x06, 0x3C, 0x03, 0x01, 0x01, 0x01, 0x01, 0x83, 0xFE, 0x01, 0x00,
  0xC0, 0x70, 0x14, 0x09, 0x06, 0x41, 0x10, 0x84, 0x21, 0x10, 0x4F, 0xFC,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0xF8, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x14, 0x1B, 0xF0, 0x1F, 0x18,
  0x18, 0x08, 0x04, 0x06, 0x02, 0xF9, 0x82, 0xC1, 0xC0, 0x60, 0x38, 0x34,
  0x13, 0x18, 0xF8, 0xFF, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08,
  0x0C, 0x04, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x3E, 0x21, 0x90, 0x58,
  0x24, 0x13, 0x18, 0xF0, 0x78, 0x63, 0x60, 0xA0, 0x70, 0x18, 0x1A, 0x08,
  0xF8, 0x3C, 0x21, 0x30, 0x50, 0x28, 0x14, 0x0E, 0x06, 0x87, 0x7D, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x31, 0xF0, 0xC0, 0x60, 0x50, 0x00, 0x16, 0xA0,
  0x01, 0x83, 0x06, 0x0C, 0x08, 0x03, 0x00, 0x60, 0x0E, 0x01, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x18, 0x38,
  0x60, 0xC0, 0x80, 0x00, 0x7D, 0x0C, 0x08, 0x10, 0x20, 0xC1, 0x04, 0x10,
  0x20, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x07, 0xC0, 0x30, 0x60, 0xC0, 0x23,
  0x00, 0x24, 0x3C, 0x48, 0x88, 0xA3, 0x11, 0x44, 0x21, 0x88, 0x47, 0x10,
  0x8A, 0x21, 0x14, 0x25, 0x64, 0x31, 0x08, 0x00, 0x08, 0x00, 0x08, 0x10,
  0x0F, 0xC0, 0x04, 0x00, 0xC0, 0x28, 0x05, 0x00, 0x90, 0x22, 0x04, 0x40,
  0x84, 0x20, 0x87, 0xF0, 0x81, 0x20, 0x24, 0x04, 0x80, 0x60, 0x08, 0xFE,
  0x41, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x19, 0xFC, 0x81, 0x40, 0xE0, 0x30,
  0x18, 0x1C, 0x1B, 0xF8, 0x0F, 0xCC, 0x16, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x0C, 0x01, 0xFC, 0xFC,
  0x20, 0xC8, 0x1A, 0x02, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x02, 0x81, 0xA0, 0xCF, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x7F, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x7F, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x00, 0x0F, 0xE6,
  0x04, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x1F, 0xC0, 0x38, 0x05,
  0x00, 0xA0, 0x16, 0x02, 0x60, 0x43, 0xF8, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0xF0, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0C, 0xFC, 0x81, 0xC1,
  0xA1, 0x90, 0x88, 0x84, 0x82, 0xC1, 0xE0, 0xD8, 0x46, 0x21, 0x10, 0xC8,
  0x24, 0x0A, 0x06, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x3F, 0x80, 0xC0, 0x1E, 0x00, 0xF8, 0x0B, 0x40, 0x5A,
  0x02, 0xD8, 0x26, 0x41, 0x32, 0x09, 0x88, 0x8C, 0x44, 0x62, 0x63, 0x0A,
  0x18, 0x50, 0xC3, 0x06, 0x08, 0x20, 0xC0, 0x70, 0x1E, 0x06, 0x81, 0x90,
  0x64, 0x18, 0x86, 0x31, 0x84, 0x61, 0x98, 0x26, 0x05, 0x81, 0x60, 0x38,
  0x0C, 0x1F, 0x83, 0x04, 0x60, 0x24, 0x02, 0x40, 0x3C, 0x01, 0xC0, 0x18,
  0x01, 0xC0, 0x1C, 0x01, 0x40, 0x34, 0x02, 0x60, 0x23, 0x04, 0x1F, 0x80,
  0xFC, 0x86, 0x83, 0x81, 0x81, 0x81, 0x83, 0x86, 0xF8, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1F, 0x83, 0x04, 0x60, 0x24, 0x02, 0x40, 0x3C, 0x01,
  0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x34, 0x02, 0x60, 0x23, 0x04,
  0x1F, 0x80, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0xFC, 0x43, 0x20, 0x50,
  0x28, 0x14, 0x0A, 0x09, 0xFC, 0xF8, 0x42, 0x21, 0x10, 0x48, 0x34, 0x0A,
  0x06, 0x3F, 0x41, 0xC0, 0x80, 0xC0, 0x40, 0x70, 0x1C, 0x06, 0x01, 0x01,
  0x01, 0x01, 0x83, 0xFE, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0xC0, 0x90, 0x63, 0xF0, 0x80, 0x78, 0x09, 0x01, 0x20, 0x66,
  0x08, 0x41, 0x08, 0x21, 0x88, 0x11, 0x02, 0x20, 0x68, 0x05, 0x00, 0xA0,
  0x1C, 0x01, 0x00, 0xC0, 0x80, 0xA0, 0x60, 0xD0, 0x50, 0x48, 0x28, 0x26,
  0x14, 0x11, 0x0B, 0x18, 0x88, 0x88, 0x44, 0x44, 0x32, 0x22, 0x09, 0x1B,
  0x05, 0x05, 0x02, 0x82, 0x81, 0xC1, 0x40, 0x60, 0xE0, 0x20, 0x20, 0xC0,
  0xD8, 0x22, 0x10, 0xC4, 0x12, 0x06, 0x80, 0xC0, 0x30, 0x0E, 0x04, 0x81,
  0x30, 0x84, 0x61, 0x90, 0x2C, 0x0C, 0xC0, 0xD0, 0x24, 0x18, 0x84, 0x23,
  0x04, 0x81, 0x20, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0xFF, 0x00, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x30, 0x10, 0x18,
  0x08, 0x08, 0x04, 0x04, 0x03, 0xFE, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x8F, 0xC0, 0x81, 0x01, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10,
  0x20, 0x20, 0x40, 0x80, 0x80, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x1F, 0x08, 0x0A, 0x05, 0x04, 0xC2, 0x22, 0x19, 0x05, 0x03, 0x80,
  0x80, 0xFF, 0x80, 0xC4, 0x30, 0x7E, 0x02, 0x02, 0x03, 0x0F, 0x73, 0xC3,
  0x83, 0x83, 0xC7, 0x79, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBE, 0xC3, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x3E, 0xC1, 0x06, 0x08,
  0x10, 0x20, 0x60, 0x40, 0xC0, 0xF8, 0x00, 0x80, 0x40, 0x20, 0x10, 0x09,
  0xF5, 0x06, 0x83, 0xC1, 0xC0, 0x60, 0x30, 0x18, 0x1A, 0x0D, 0x0A, 0x79,
  0x3E, 0x43, 0x41, 0x81, 0x81, 0xFF, 0x80, 0xC0, 0x40, 0x61, 0x3F, 0x1E,
  0x60, 0x81, 0x02, 0x1F, 0x88, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x3E, 0xA0, 0xD0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x03, 0x41, 0xA1,
  0x4F, 0x20, 0x10, 0x18, 0x09, 0x0C, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xBE, 0xC2, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xCF,
  0xFE, 0x11, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3E, 0x81,
  0x02, 0x04, 0x08, 0x10, 0xE3, 0x4C, 0x91, 0x43, 0x44, 0x88, 0x91, 0xA1,
  0x41, 0xFF, 0xFF, 0xBC, 0xF6, 0x38, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1,
  0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x82, 0xBE, 0xC2, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x3E, 0x20, 0x90, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x81, 0x41, 0xB0, 0x8F, 0x80, 0xBE, 0xC3, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x3E, 0xA1, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x41, 0xA1,
  0x4F, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xBE, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x20, 0x7F, 0x02, 0x04, 0x06, 0x03, 0x01, 0x01, 0x03, 0x0F, 0xF0,
  0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x87, 0x79, 0x81, 0xA0,
  0x90, 0x48, 0x62, 0x21, 0x10, 0x98, 0x28, 0x14, 0x0E, 0x02, 0x00, 0xC3,
  0x0D, 0x0C, 0x24, 0x30, 0x91, 0xA2, 0x64, 0x88, 0x92, 0x42, 0x4D, 0x0A,
  0x14, 0x18, 0x50, 0x61, 0x81, 0x82, 0x00, 0x41, 0x91, 0x8C, 0x82, 0x80,
  0xC0, 0x60, 0x50, 0x2C, 0x22, 0x30, 0xB0, 0x60, 0xC1, 0xA0, 0x90, 0x4C,
  0x62, 0x21, 0x10, 0xD8, 0x28, 0x14, 0x0A, 0x02, 0x01, 0x01, 0x80, 0x80,
  0xC1, 0xC0, 0xFE, 0x08, 0x20, 0x41, 0x06, 0x08, 0x30, 0x41, 0x03, 0xF8,
  0x1C, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x63, 0x02, 0x08, 0x20, 0x82, 0x08,
  0x30, 0x70, 0xFF, 0xFF, 0xF8, 0xC0, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x18,
  0x73, 0x08, 0x20, 0x82, 0x08, 0x23, 0x80, 0x20, 0x6C, 0x61, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 15, 5, 2, -15 },
  { 3, 5, 5, 7, 1, -15 },
  { 7, 12, 15, 12, 0, -15 },
  { 30, 8, 17, 11, 1, -16 },
  { 47, 14, 15, 16, 1, -15 },
  { 74, 12, 15, 13, 1, -15 },
  { 97, 2, 5, 4, 1, -15 },
  { 99, 4, 18, 6, 1, -15 },
  { 108, 4, 18, 6, 1, -15 },
  { 117, 8, 8, 10, 1, -16 },
  { 125, 9, 10, 11, 1, -12 },
  { 137, 2, 5, 5, 1, -2 },
  { 139, 5, 1, 6, 1, -6 },
  { 140, 1, 2, 5, 2, -2 },
  { 141, 7, 15, 7, 0, -15 },
  { 155, 9, 15, 11, 1, -15 },
  { 172, 5, 15, 11, 2, -15 },
  { 182, 9, 15, 11, 1, -15 },
  { 199, 8, 15, 11, 1, -15 },
  { 214, 10, 15, 11, 0, -15 },
  { 233, 9, 15, 11, 1, -15 },
  { 250, 9, 15, 11, 1, -15 },
  { 267, 9, 15, 11, 1, -15 },
  { 284, 9, 15, 11, 1, -15 },
  { 301, 9, 15, 11, 1, -15 },
  { 318, 1, 11, 5, 2, -11 },
  { 320, 2, 14, 5, 1, -11 },
  { 324, 9, 9, 11, 1, -12 },
  { 335, 9, 5, 11, 1, -10 },
  { 341, 9, 9, 11, 1, -12 },
  { 352, 7, 15, 8, 0, -15 },
  { 366, 15, 17, 17, 1, -15 },
  { 398, 11, 15, 11, 0, -15 },
  { 419, 9, 15, 12, 2, -15 },
  { 436, 10, 15, 12, 1, -15 },
  { 455, 10, 15, 13, 2, -15 },
  { 474, 7, 15, 10, 2, -15 },
  { 488, 7, 15, 10, 2, -15 },
  { 502, 11, 15, 14, 1, -15 },
  { 523, 10, 15, 14, 2, -15 },
  { 542, 4, 15, 6, 1, -15 },
  { 550, 5, 19, 5, -2, -15 },
  { 562, 9, 15, 11, 2, -15 },
  { 579, 7, 15, 10, 2, -15 },
  { 593, 13, 15, 17, 2, -15 },
  { 618, 10, 15, 14, 2, -15 },
  { 637, 12, 15, 14, 1, -15 },
  { 660, 8, 15, 11, 2, -15 },
  { 675, 12, 19, 14, 1, -15 },
  { 704, 9, 15, 11, 2, -15 },
  { 721, 8, 15, 10, 1, -15 },
  { 736, 10, 15, 10, 0, -15 },
  { 755, 10, 15, 13, 2, -15 },
  { 774, 11, 15, 11, 0, -15 },
  { 795, 17, 15, 17, 0, -15 },
  { 827, 10, 15, 10, 0, -15 },
  { 846, 10, 15, 10, 0, -15 },
  { 865, 9, 15, 10, 1, -15 },
  { 882, 4, 18, 7, 2, -15 },
  { 891, 7, 15, 7, 0, -15 },
  { 905, 4, 18, 7, 1, -15 },
  { 914, 9, 9, 11, 1, -15 },
  { 925, 9, 1, 9, 0, 2 },
  { 927, 4, 3, 5, 1, -16 },
  { 929, 8, 11, 10, 1, -11 },
  { 940, 8, 16, 11, 2, -16 },
  { 956, 7, 11, 9, 1, -11 },
  { 966, 9, 16, 11, 1, -16 },
  { 984, 8, 11, 10, 1, -11 },
  { 995, 7, 16, 6, 0, -16 },
  { 1009, 9, 16, 11, 1, -11 },
  { 1027, 8, 16, 11, 2, -16 },
  { 1043, 1, 15, 5, 2, -15 },
  { 1045, 4, 20, 5, -1, -15 },
  { 1055, 7, 16, 9, 2, -16 },
  { 1069, 1, 16, 5, 2, -16 },
  { 1071, 13, 11, 17, 2, -11 },
  { 1089, 8, 11, 11, 2, -11 },
  { 1100, 9, 11, 11, 1, -11 },
  { 1113, 8, 16, 11, 2, -11 },
  { 1129, 9, 16, 11, 1, -11 },
  { 1147, 5, 11, 7, 2, -11 },
  { 1154, 7, 11, 9, 1, -11 },
  { 1164, 6, 14, 6, 0, -14 },
  { 1175, 8, 11, 11, 2, -11 },
  { 1186, 9, 11, 9, 0, -11 },
  { 1199, 14, 11, 14, 0, -11 },
  { 1219, 9, 11, 9, 0, -11 },
  { 1232, 9, 16, 9, 0, -11 },
  { 1250, 7, 11, 8, 1, -11 },
  { 1260, 6, 18, 8, 1, -15 },
  { 1274, 1, 21, 10, 5, -16 },
  { 1277, 6, 18, 8, 1, -15 },
  { 1291, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Light21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT21PT7B_H_
