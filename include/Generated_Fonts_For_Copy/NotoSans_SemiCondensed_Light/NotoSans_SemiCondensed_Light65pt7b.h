#ifndef _NOTOSANS_SEMICONDENSED_LIGHT65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x77, 0xFF, 0xFF, 0xFC, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xF7, 0x01, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0x0C, 0x07, 0x0F, 0x03,
  0x00, 0x47, 0x80, 0xC0, 0x01, 0xE0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x3C,
  0x03, 0x00, 0x0F, 0x00, 0xC0, 0x03, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00,
  0x1C, 0x03, 0x00, 0x07, 0x80, 0xC0, 0x01, 0xF0, 0x30, 0x00, 0x3E, 0x0C,
  0x00, 0x07, 0xC3, 0x00, 0x00, 0xFC, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0C, 0xFE, 0x00, 0x03, 0x0F, 0xC0, 0x00, 0xC0, 0xF8, 0x00, 0x30,
  0x1E, 0x00, 0x0C, 0x03, 0xC0, 0x03, 0x00, 0xF0, 0x00, 0xC0, 0x1C, 0x00,
  0x30, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x3C,
  0x00, 0x30, 0x0F, 0x00, 0x0C, 0x07, 0xA0, 0x03, 0x03, 0xE7, 0x00, 0xC1,
  0xF1, 0xFF, 0x37, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x40, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x38, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x01, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC0, 0x0E, 0x1E, 0x0F, 0xE0, 0x70, 0x07, 0x87, 0x07, 0xFC,
  0x1C, 0x01, 0xC1, 0xC3, 0xC7, 0x87, 0x00, 0x70, 0xE1, 0xE0, 0xF0, 0xE0,
  0x3C, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x38, 0x03, 0x87, 0x07, 0x87,
  0x0E, 0x00, 0xE1, 0xFF, 0xC3, 0x83, 0x80, 0x38, 0x3F, 0xE0, 0xE1, 0xE0,
  0x0E, 0x03, 0xF0, 0x70, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x70,
  0x00, 0x0F, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x07, 0x00, 0x01,
  0xE0, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x00, 0x3C, 0x07,
  0x00, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x70, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0x0F, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x03, 0xC0, 0x03, 0xC3,
  0xE0, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x80,
  0x38, 0x78, 0x00, 0x7C, 0x07, 0x87, 0x00, 0x03, 0xE0, 0x78, 0xF0, 0x00,
  0x1F, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0x00, 0x07, 0x9E, 0x0F,
  0x00, 0x00, 0x3D, 0xE0, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x1F,
  0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x78, 0x00,
  0x03, 0xFC, 0x07, 0xC0, 0x00, 0x7D, 0xE0, 0x3E, 0x00, 0x0F, 0x8F, 0x01,
  0xF8, 0x03, 0xF0, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x7F, 0xFF, 0x80,
  0x3E, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x00, 0xF8, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0xF8, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0x00, 0x38, 0x01, 0x70, 0x1C, 0x07,
  0xFF, 0x0E, 0x1F, 0xFF, 0xF7, 0x7F, 0xE3, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x04, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8E, 0x3C,
  0x78, 0xF1, 0xC3, 0x8F, 0x1C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x77, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x3E, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xDC, 0x3E, 0x71,
  0xF1, 0xDF, 0x07, 0xF8, 0x1F, 0xC0, 0x76, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xE0, 0xFE, 0x07,
  0xE0, 0x03, 0xE0, 0x70, 0x00, 0x3C, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFE,
  0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC6, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xEC, 0x00, 0x01, 0xF3, 0xE0, 0x01, 0xF8,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x0F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x1F, 0x8F, 0x00, 0x1F, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xF0, 0x18, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x01, 0xF8, 0x03, 0xC3, 0xFF, 0xC0, 0xE1, 0xFF, 0xF8, 0x38, 0xFC, 0x7F,
  0x0E, 0x78, 0x03, 0xE3, 0xB8, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xF0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07,
  0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0xBF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xF0, 0x03, 0xC0,
  0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xF7, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xDE, 0x00, 0x01,
  0xF9, 0xE0, 0x00, 0x7F, 0x3E, 0x00, 0x1D, 0xC3, 0xF0, 0x0F, 0x38, 0x3F,
  0xFF, 0xC7, 0x03, 0xFF, 0xF0, 0xE0, 0x1F, 0xF8, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x01,
  0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x77, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xFE, 0x60,
  0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFC, 0x0F, 0xC7, 0x00, 0x1F, 0x20, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC3, 0xC0,
  0x01, 0xFF, 0xC0, 0x1E, 0x38, 0x00, 0x7F, 0xFE, 0x00, 0xE7, 0x80, 0x0F,
  0xC3, 0xE0, 0x0E, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0xE7, 0x00, 0x3C, 0x00,
  0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0xE0, 0x07,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xE0,
  0x1E, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x1E,
  0x00, 0x1E, 0x00, 0x7E, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x1E, 0x00,
  0x1C, 0x00, 0x7E, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0xE0, 0x0E, 0x00, 0x1C,
  0x00, 0xEE, 0x00, 0xE0, 0x03, 0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0x3E, 0x01,
  0xEE, 0x00, 0xF0, 0x07, 0xE0, 0x1C, 0xE0, 0x07, 0x80, 0xE6, 0x03, 0xCF,
  0x00, 0x7C, 0x1E, 0x78, 0x78, 0x70, 0x03, 0xFF, 0xC3, 0xFF, 0x07, 0x00,
  0x1F, 0xF8, 0x1F, 0xE0, 0x78, 0x00, 0x7C, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x78, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x07,
  0xF0, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x1F, 0xE0, 0xF0,
  0x00, 0x1F, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xCF, 0x00,
  0x01, 0xF8, 0xF0, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x38, 0x0F,
  0xC0, 0x00, 0x20, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x7F, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x07, 0xF8, 0x0F, 0x00, 0x01, 0xF8, 0x1E,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0xFE, 0x03, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x00,
  0x40, 0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x00, 0xF0, 0x3F, 0x00,
  0x00, 0x3C, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0x7F, 0x00,
  0x00, 0xF7, 0xF8, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0xFE, 0x3C, 0x00, 0x0F,
  0xC1, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xEE, 0x00, 0x00, 0x00, 0x7F, 0xEE, 0x00, 0x00,
  0x00, 0x77, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0xE7, 0x00, 0x00, 0x00, 0xE7,
  0xE7, 0x80, 0x00, 0x00, 0xE7, 0xE7, 0x80, 0x00, 0x01, 0xE7, 0xE3, 0x80,
  0x00, 0x01, 0xC7, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0xE1,
  0xE0, 0x00, 0x07, 0x87, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0xE0, 0xF0, 0x00,
  0x0F, 0x07, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0xE0, 0x3C,
  0x00, 0x1C, 0x07, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0xE0, 0x01, 0xE3, 0x80,
  0x07, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0xE0,
  0x00, 0xF7, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xC0, 0x00,
  0x07, 0xF3, 0xC0, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x1F, 0xC7, 0x80, 0x00,
  0x3F, 0x8F, 0x00, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0xFE, 0x1F, 0x00, 0x01,
  0xFC, 0x1E, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x0F,
  0xE0, 0x3C, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x7F,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xF8,
  0x01, 0xE0, 0x07, 0xF0, 0x01, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x1F, 0xC0,
  0x03, 0xC0, 0x3F, 0x80, 0x03, 0xC0, 0x7F, 0x00, 0x07, 0x80, 0xFE, 0x00,
  0x07, 0x81, 0xFC, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x0F, 0x07, 0xF0, 0x00,
  0x1F, 0x0F, 0xE0, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x1E, 0x3F, 0x80, 0x00,
  0x3C, 0x7F, 0x00, 0x00, 0x3C, 0xFE, 0x00, 0x00, 0x79, 0xFC, 0x00, 0x00,
  0x79, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1E, 0x00, 0x3F, 0x8F, 0x00, 0x07,
  0xE7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xF7, 0x80, 0x01, 0xF3, 0xC0, 0x03, 0xF1, 0xE0, 0x0F, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC0, 0xF0,
  0x03, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1F, 0x80, 0x07, 0x0F, 0x80, 0x00, 0x43, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xCC, 0x00, 0x01, 0xF3, 0xE0, 0x03, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xDC,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x1C, 0x3C, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x01, 0xC0,
  0x07, 0x01, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x07, 0x87, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x3C, 0x00,
  0x01, 0xC7, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x77,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFC, 0x07, 0xE0, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xDC, 0x7F, 0x00, 0x39,
  0xF0, 0x00, 0x77, 0xC0, 0x00, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xDE, 0x00, 0x3B, 0xBE, 0x00,
  0xE7, 0x3F, 0xDF, 0xCE, 0x3F, 0xFF, 0x0C, 0x3F, 0xF8, 0x18, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x0F, 0xF8, 0x07, 0x87, 0xFF, 0xC0, 0xF1, 0xFF, 0xFC, 0x1E, 0x78,
  0x0F, 0xC3, 0xDC, 0x00, 0x7C, 0x7F, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x79,
  0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF3, 0xF0,
  0x00, 0x1E, 0x7F, 0x00, 0x07, 0x8F, 0xE0, 0x01, 0xF1, 0xCF, 0x00, 0x7C,
  0x38, 0xFF, 0xFF, 0x07, 0x0F, 0xFF, 0xC0, 0xE0, 0x7F, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0x80, 0xE0, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x06, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xF0,
  0x78, 0x0F, 0xFF, 0x8F, 0x03, 0xFF, 0xF9, 0xE0, 0xFC, 0x0F, 0xBC, 0x3E,
  0x00, 0x73, 0x8F, 0x80, 0x07, 0x71, 0xE0, 0x00, 0x7E, 0x78, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x8F,
  0x00, 0x03, 0x71, 0xF0, 0x00, 0xEE, 0x1F, 0x00, 0x79, 0xC1, 0xFE, 0xFE,
  0x38, 0x1F, 0xFF, 0x87, 0x00, 0xFF, 0xC0, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x81, 0xF0,
  0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x08, 0x1F, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xCE, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xC0, 0xE0, 0x3F, 0xFE, 0x1C, 0x0F, 0xFF, 0xE3, 0x83,
  0xF0, 0x3E, 0x70, 0xF8, 0x01, 0xEE, 0x3E, 0x00, 0x1D, 0xC7, 0x80, 0x01,
  0xF9, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x0D, 0xC7, 0xC0, 0x03, 0xF8, 0x7C, 0x01,
  0xEF, 0x07, 0xFB, 0xF9, 0xE0, 0x7F, 0xFE, 0x3C, 0x03, 0xFF, 0x07, 0x80,
  0x0E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x60, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0xFF, 0x81, 0xE1, 0xFF, 0xF0, 0xF1, 0xFF, 0xFC, 0x79,
  0xE0, 0x3F, 0x3D, 0xC0, 0x07, 0x9F, 0xC0, 0x01, 0xEF, 0xC0, 0x00, 0xF7,
  0xE0, 0x00, 0x3B, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0x80, 0xF7, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x30, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0,
  0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3E, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00,
  0xF3, 0xF0, 0x00, 0xF3, 0xF0, 0x00, 0xF7, 0x78, 0x00, 0xFF, 0x7C, 0x00,
  0xFE, 0x3C, 0x00, 0xFC, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x38, 0x7F, 0xF8, 0x0F, 0xFF, 0x0E,
  0x3F, 0xFF, 0x07, 0xFF, 0xF3, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0xE7, 0x00,
  0x7D, 0xE0, 0x0F, 0xBF, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0xE0, 0x3F, 0xE0, 0x70, 0x7F, 0xFC, 0x38,
  0x7F, 0xFF, 0x1C, 0x78, 0x0F, 0xCE, 0x70, 0x01, 0xE7, 0xF0, 0x00, 0x7B,
  0xF0, 0x00, 0x3D, 0xF8, 0x00, 0x0E, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x3F, 0xE0, 0x1C, 0x1F, 0xFF, 0x03, 0x87, 0xFF, 0xF0, 0x71,
  0xE0, 0x3F, 0x0E, 0x70, 0x01, 0xF1, 0xDC, 0x00, 0x1E, 0x3F, 0x00, 0x01,
  0xE7, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x03, 0xCF,
  0xC0, 0x00, 0x79, 0xFC, 0x00, 0x1E, 0x3D, 0xC0, 0x07, 0xC7, 0xBC, 0x01,
  0xF0, 0xF3, 0xFF, 0xFC, 0x1E, 0x3F, 0xFF, 0x03, 0xC1, 0xFF, 0x80, 0x78,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0xE0, 0x3F, 0xFE, 0x1C, 0x0F, 0xFF, 0xE3,
  0x83, 0xE0, 0x3E, 0x70, 0xF8, 0x01, 0xCE, 0x3E, 0x00, 0x1D, 0xC7, 0x80,
  0x01, 0xF9, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x0D, 0xC7, 0xC0, 0x03, 0x78, 0x7C,
  0x01, 0xEF, 0x07, 0xFB, 0xF9, 0xE0, 0x7F, 0xFE, 0x3C, 0x03, 0xFF, 0x07,
  0x80, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E,
  0x78, 0x07, 0xB8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x7C, 0x01, 0xE7, 0x80, 0x01, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xDC, 0x00, 0x3E, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x03, 0x80, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFB, 0xC0, 0x01,
  0xFD, 0xF0, 0x01, 0xDE, 0x7C, 0x01, 0xCF, 0x3F, 0xFF, 0xE7, 0x8F, 0xFF,
  0xC1, 0xC1, 0xFF, 0xC0, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x07,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x01, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x39, 0xC0,
  0x00, 0xFC, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0xC0, 0x01, 0xE7, 0x80, 0x07, 0xF8, 0x00, 0x70, 0xE0, 0x01, 0xCE, 0x00,
  0x3C, 0x3C, 0x00, 0x73, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0x87, 0x00, 0x78, 0x1E, 0x00,
  0xE1, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x0F, 0x01, 0xC0, 0xE0, 0x3C,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0xF0, 0x38, 0x07, 0x03, 0x80, 0x1C,
  0x0E, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0xE3,
  0xC0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x73, 0x80, 0x01, 0xDE,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x2F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFD,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x02, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 47, 15, 5, -46 },
  { 31, 15, 16, 23, 4, -46 },
  { 61, 34, 46, 37, 2, -46 },
  { 257, 26, 53, 33, 3, -49 },
  { 430, 42, 48, 48, 3, -47 },
  { 682, 36, 48, 40, 3, -47 },
  { 898, 4, 16, 13, 4, -46 },
  { 906, 13, 56, 18, 3, -46 },
  { 997, 13, 56, 18, 2, -46 },
  { 1088, 25, 24, 31, 3, -49 },
  { 1163, 27, 30, 33, 3, -38 },
  { 1265, 7, 15, 14, 3, -7 },
  { 1279, 15, 3, 20, 2, -19 },
  { 1285, 5, 7, 15, 5, -6 },
  { 1290, 21, 46, 23, 1, -46 },
  { 1411, 27, 48, 33, 3, -47 },
  { 1573, 14, 46, 33, 6, -46 },
  { 1654, 27, 47, 33, 3, -47 },
  { 1813, 26, 48, 33, 3, -47 },
  { 1969, 31, 47, 33, 1, -47 },
  { 2152, 26, 47, 33, 4, -46 },
  { 2305, 26, 48, 33, 4, -47 },
  { 2461, 27, 46, 33, 3, -46 },
  { 2617, 27, 48, 33, 3, -47 },
  { 2779, 27, 48, 33, 3, -47 },
  { 2941, 5, 36, 15, 5, -35 },
  { 2964, 8, 43, 15, 2, -35 },
  { 3007, 27, 29, 33, 3, -38 },
  { 3105, 27, 16, 33, 3, -31 },
  { 3159, 27, 29, 33, 3, -38 },
  { 3257, 21, 48, 24, 1, -47 },
  { 3383, 44, 52, 52, 4, -46 },
  { 3669, 35, 47, 35, 0, -47 },
  { 3875, 28, 46, 37, 6, -46 },
  { 4036, 30, 48, 36, 4, -47 },
  { 4216, 31, 46, 41, 6, -46 },
  { 4395, 22, 46, 32, 6, -46 },
  { 4522, 23, 46, 30, 6, -46 },
  { 4655, 34, 48, 43, 4, -47 },
  { 4859, 30, 46, 42, 6, -46 },
  { 5032, 13, 46, 19, 3, -46 },
  { 5107, 15, 58, 15, -5, -46 },
  { 5216, 28, 46, 34, 6, -46 },
  { 5377, 22, 46, 30, 6, -46 },
  { 5504, 40, 46, 52, 6, -46 },
  { 5734, 31, 46, 43, 6, -46 },
  { 5913, 36, 48, 44, 4, -47 },
  { 6129, 25, 46, 34, 6, -46 },
  { 6273, 36, 58, 44, 4, -47 },
  { 6534, 28, 46, 35, 6, -46 },
  { 6695, 26, 48, 32, 3, -47 },
  { 6851, 30, 46, 30, 0, -46 },
  { 7024, 31, 47, 42, 5, -46 },
  { 7207, 34, 46, 34, 0, -46 },
  { 7403, 51, 46, 53, 1, -46 },
  { 7697, 31, 46, 31, 0, -46 },
  { 7876, 30, 46, 30, 0, -46 },
  { 8049, 28, 46, 32, 2, -46 },
  { 8210, 14, 56, 21, 5, -46 },
  { 8308, 21, 46, 23, 1, -46 },
  { 8429, 13, 56, 21, 2, -46 },
  { 8520, 29, 27, 33, 2, -47 },
  { 8618, 27, 3, 27, 0, 6 },
  { 8629, 11, 11, 17, 3, -50 },
  { 8645, 23, 36, 31, 3, -35 },
  { 8749, 27, 50, 35, 5, -49 },
  { 8918, 23, 36, 27, 3, -35 },
  { 9022, 27, 50, 35, 3, -49 },
  { 9191, 26, 36, 32, 3, -35 },
  { 9308, 20, 50, 18, 1, -50 },
  { 9433, 27, 51, 35, 3, -35 },
  { 9606, 25, 49, 35, 5, -49 },
  { 9760, 5, 47, 14, 5, -47 },
  { 9790, 12, 63, 14, -2, -47 },
  { 9885, 24, 49, 29, 5, -49 },
  { 10032, 4, 49, 14, 5, -49 },
  { 10057, 42, 35, 52, 5, -35 },
  { 10241, 25, 35, 35, 5, -35 },
  { 10351, 28, 36, 34, 3, -35 },
  { 10477, 27, 50, 35, 5, -35 },
  { 10646, 27, 50, 35, 3, -35 },
  { 10815, 17, 35, 23, 5, -35 },
  { 10890, 21, 36, 27, 3, -35 },
  { 10985, 17, 44, 20, 1, -43 },
  { 11079, 25, 36, 35, 5, -35 },
  { 11192, 27, 35, 27, 0, -35 },
  { 11311, 42, 35, 44, 1, -35 },
  { 11495, 27, 35, 29, 1, -35 },
  { 11614, 27, 51, 28, 0, -35 },
  { 11787, 22, 35, 26, 2, -35 },
  { 11884, 19, 56, 23, 2, -46 },
  { 12017, 3, 66, 32, 14, -50 },
  { 12042, 19, 56, 23, 2, -46 },
  { 12175, 27, 7, 33, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_Light65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT65PT7B_H_
