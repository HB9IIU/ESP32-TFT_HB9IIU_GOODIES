#ifndef _NOTOSANS_SEMICONDENSED_LIGHT14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xB6, 0xD0, 0x12, 0x14, 0x14, 0x7F, 0x24, 0x24, 0xFE,
  0x28, 0x28, 0x48, 0x23, 0xAB, 0x4A, 0x30, 0xE5, 0x2D, 0x5C, 0x40, 0xE2,
  0x52, 0x29, 0x15, 0x0A, 0xB7, 0xA4, 0x52, 0x49, 0x24, 0xB1, 0x80, 0x71,
  0x11, 0x22, 0x82, 0x1A, 0x64, 0xC6, 0x85, 0xF4, 0xF0, 0x5A, 0xAA, 0xA9,
  0xC8, 0x92, 0x49, 0x25, 0x60, 0x21, 0x3E, 0x45, 0x68, 0x20, 0x82, 0x3F,
  0x20, 0x80, 0xF0, 0xF0, 0x80, 0x08, 0x84, 0x42, 0x11, 0x08, 0x44, 0x00,
  0x74, 0x63, 0x18, 0xC6, 0x31, 0x8B, 0x80, 0x2E, 0x92, 0x49, 0x24, 0xF0,
  0x42, 0x10, 0x88, 0x88, 0x87, 0xC0, 0xF0, 0x42, 0x17, 0x04, 0x21, 0x0F,
  0x80, 0x0C, 0x18, 0x51, 0x22, 0x48, 0xA1, 0x7F, 0x04, 0x08, 0xFC, 0x21,
  0x0F, 0x04, 0x21, 0x0F, 0x80, 0x39, 0x08, 0x20, 0xFA, 0x28, 0x61, 0x89,
  0xE0, 0xF8, 0x42, 0x21, 0x08, 0x84, 0x42, 0x00, 0x7C, 0x63, 0x17, 0x2E,
  0x31, 0x8B, 0xC0, 0x74, 0x63, 0x18, 0xFC, 0x21, 0x0F, 0x80, 0xC1, 0x50,
  0x05, 0x60, 0x0C, 0xCC, 0x30, 0x30, 0x30, 0xFC, 0x00, 0x3F, 0x81, 0x81,
  0x87, 0x62, 0x00, 0xF0, 0x42, 0x11, 0x10, 0x80, 0x03, 0x00, 0x3E, 0x20,
  0xA0, 0x33, 0xDA, 0x2D, 0x16, 0x8B, 0x2D, 0x89, 0x20, 0x0F, 0x80, 0x10,
  0x18, 0x28, 0x28, 0x24, 0x44, 0x7C, 0x42, 0x82, 0x83, 0xFA, 0x18, 0x61,
  0xFA, 0x18, 0x61, 0x87, 0xE0, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x40,
  0xF0, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0xF0, 0xFC, 0x21,
  0x0F, 0xC2, 0x10, 0x87, 0xC0, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x00,
  0x3E, 0x82, 0x04, 0x08, 0x11, 0xE0, 0xC1, 0x42, 0x7C, 0x83, 0x06, 0x0C,
  0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x04, 0xD5, 0x55, 0x70, 0x24, 0x92, 0x49,
  0x24, 0x9C, 0x86, 0x29, 0x28, 0xA3, 0x89, 0x22, 0x8A, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x87, 0xC0, 0xC0, 0xE0, 0xF0, 0x74, 0x5A, 0x2C, 0x96,
  0x53, 0x29, 0x88, 0xC4, 0x40, 0x83, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC3,
  0x87, 0x04, 0x3C, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C,
  0xFA, 0x18, 0x61, 0x8B, 0xC8, 0x20, 0x82, 0x00, 0x3C, 0x42, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x42, 0x3C, 0x08, 0x06, 0xFA, 0x18, 0x61, 0x8B,
  0xC9, 0x22, 0x8A, 0x10, 0x7C, 0x21, 0x06, 0x08, 0x21, 0x0F, 0x80, 0xFC,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x84, 0xF8, 0x83, 0x05, 0x0A, 0x24, 0x44, 0x8A, 0x14, 0x18,
  0x20, 0x84, 0x30, 0xC5, 0x18, 0xA5, 0x24, 0xA4, 0x92, 0x8A, 0x51, 0x8C,
  0x30, 0x82, 0x10, 0xC6, 0x88, 0xA1, 0x41, 0x02, 0x0A, 0x24, 0x45, 0x0C,
  0x86, 0x89, 0x21, 0x42, 0x82, 0x04, 0x08, 0x10, 0x20, 0x7C, 0x10, 0x82,
  0x10, 0x42, 0x10, 0x43, 0xF0, 0xF2, 0x49, 0x24, 0x92, 0x70, 0x82, 0x10,
  0x82, 0x10, 0x82, 0x10, 0x40, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x10, 0x50,
  0xA2, 0x24, 0x50, 0x40, 0xFC, 0xA4, 0x64, 0x82, 0x3E, 0xC6, 0x3F, 0x82,
  0x08, 0x2C, 0xCA, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x3A, 0x21, 0x08, 0x42,
  0x0E, 0x08, 0x42, 0x7C, 0xC6, 0x31, 0x8C, 0x5E, 0x36, 0x63, 0x1F, 0x42,
  0x0F, 0x3A, 0x11, 0xE4, 0x21, 0x08, 0x42, 0x10, 0x36, 0x63, 0x18, 0xC6,
  0x2F, 0x08, 0x7E, 0x84, 0x21, 0x6C, 0xC6, 0x31, 0x8C, 0x62, 0x9F, 0xC0,
  0x20, 0x12, 0x49, 0x24, 0x9E, 0x84, 0x21, 0x19, 0x52, 0x9C, 0x94, 0xA2,
  0xFF, 0xE0, 0x33, 0x66, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x36,
  0x63, 0x18, 0xC6, 0x31, 0x33, 0x28, 0x61, 0x86, 0x18, 0x9E, 0x33, 0x28,
  0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x00, 0x36, 0x63, 0x18, 0xC6, 0x2F,
  0x08, 0x42, 0x3C, 0x88, 0x88, 0x88, 0x69, 0x8C, 0x21, 0x1F, 0x4F, 0x44,
  0x44, 0x44, 0x70, 0x8C, 0x63, 0x18, 0xC5, 0xE0, 0x85, 0x24, 0x92, 0x30,
  0xC3, 0x00, 0x88, 0xA6, 0x55, 0x2A, 0xA5, 0x31, 0x18, 0x88, 0xCC, 0xA3,
  0x0C, 0x31, 0x2C, 0x40, 0x85, 0x24, 0x92, 0x30, 0xC3, 0x08, 0x23, 0x00,
  0x78, 0x84, 0x42, 0x23, 0xE0, 0x12, 0x22, 0x22, 0xC2, 0x22, 0x23, 0xFF,
  0xFC, 0x84, 0x44, 0x44, 0x34, 0x44, 0x4C, 0xC6, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Light14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 3, 4, 5, 1, -10 },
  { 5, 8, 10, 8, 0, -10 },
  { 15, 5, 12, 7, 1, -11 },
  { 23, 9, 10, 10, 1, -10 },
  { 35, 7, 10, 9, 1, -10 },
  { 44, 1, 4, 3, 1, -10 },
  { 45, 2, 12, 4, 1, -10 },
  { 48, 3, 12, 4, 0, -10 },
  { 53, 5, 6, 7, 1, -11 },
  { 57, 6, 6, 7, 1, -8 },
  { 62, 1, 4, 3, 1, -2 },
  { 63, 4, 1, 4, 0, -4 },
  { 64, 1, 1, 3, 1, -1 },
  { 65, 5, 10, 5, 0, -10 },
  { 72, 5, 10, 7, 1, -10 },
  { 79, 3, 10, 7, 1, -10 },
  { 83, 5, 10, 7, 1, -10 },
  { 90, 5, 10, 7, 1, -10 },
  { 97, 7, 10, 7, 0, -10 },
  { 106, 5, 10, 7, 1, -10 },
  { 113, 6, 10, 7, 1, -10 },
  { 121, 5, 10, 7, 1, -10 },
  { 128, 5, 10, 7, 1, -10 },
  { 135, 5, 10, 7, 1, -10 },
  { 142, 1, 8, 3, 1, -8 },
  { 143, 2, 10, 3, 0, -8 },
  { 146, 6, 6, 7, 1, -8 },
  { 151, 6, 4, 7, 1, -7 },
  { 154, 6, 6, 7, 1, -8 },
  { 159, 5, 10, 5, 0, -10 },
  { 166, 9, 11, 11, 1, -10 },
  { 179, 8, 10, 8, 0, -10 },
  { 189, 6, 10, 8, 1, -10 },
  { 197, 6, 10, 8, 1, -10 },
  { 205, 7, 10, 9, 1, -10 },
  { 214, 5, 10, 7, 1, -10 },
  { 221, 5, 10, 6, 1, -10 },
  { 228, 7, 10, 9, 1, -10 },
  { 237, 7, 10, 9, 1, -10 },
  { 246, 2, 10, 4, 1, -10 },
  { 249, 3, 13, 3, -1, -10 },
  { 254, 6, 10, 7, 1, -10 },
  { 262, 5, 10, 6, 1, -10 },
  { 269, 9, 10, 11, 1, -10 },
  { 281, 7, 10, 9, 1, -10 },
  { 290, 8, 10, 10, 1, -10 },
  { 300, 6, 10, 7, 1, -10 },
  { 308, 8, 12, 10, 1, -10 },
  { 320, 6, 10, 8, 1, -10 },
  { 328, 5, 10, 7, 1, -10 },
  { 335, 6, 10, 7, 0, -10 },
  { 343, 7, 10, 9, 1, -10 },
  { 352, 7, 10, 7, 0, -10 },
  { 361, 11, 10, 11, 0, -10 },
  { 375, 7, 10, 7, 0, -10 },
  { 384, 7, 10, 7, 0, -10 },
  { 393, 6, 10, 7, 0, -10 },
  { 401, 3, 12, 4, 1, -10 },
  { 406, 5, 10, 5, 0, -10 },
  { 413, 3, 12, 4, 0, -10 },
  { 418, 7, 6, 7, 0, -10 },
  { 424, 6, 1, 6, 0, 1 },
  { 425, 2, 3, 4, 1, -11 },
  { 426, 5, 8, 7, 1, -8 },
  { 431, 6, 11, 8, 1, -11 },
  { 440, 5, 8, 6, 1, -8 },
  { 445, 5, 11, 8, 1, -11 },
  { 452, 5, 8, 7, 1, -8 },
  { 457, 5, 11, 4, 0, -11 },
  { 464, 5, 11, 8, 1, -8 },
  { 471, 5, 11, 8, 1, -11 },
  { 478, 1, 10, 3, 1, -10 },
  { 480, 3, 13, 3, -1, -10 },
  { 485, 5, 11, 6, 1, -11 },
  { 492, 1, 11, 3, 1, -11 },
  { 494, 9, 8, 11, 1, -8 },
  { 503, 5, 8, 8, 1, -8 },
  { 508, 6, 8, 7, 1, -8 },
  { 514, 6, 11, 8, 1, -8 },
  { 523, 5, 11, 8, 1, -8 },
  { 530, 4, 8, 5, 1, -8 },
  { 534, 4, 8, 6, 1, -8 },
  { 538, 4, 9, 4, 0, -9 },
  { 543, 5, 7, 8, 1, -7 },
  { 548, 6, 7, 6, 0, -7 },
  { 554, 9, 7, 9, 0, -7 },
  { 562, 6, 7, 6, 0, -7 },
  { 568, 6, 10, 6, 0, -7 },
  { 576, 5, 7, 6, 0, -7 },
  { 581, 4, 12, 5, 0, -10 },
  { 587, 1, 14, 7, 3, -11 },
  { 589, 4, 12, 5, 1, -10 },
  { 595, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Light14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT14PT7B_H_
