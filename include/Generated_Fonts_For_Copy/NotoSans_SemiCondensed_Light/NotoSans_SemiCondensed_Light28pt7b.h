#ifndef _NOTOSANS_SEMICONDENSED_LIGHT28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF5, 0x55, 0x54, 0x0F, 0xCF, 0x38, 0xE3, 0x86, 0x18, 0x40,
  0x06, 0x10, 0x10, 0xC0, 0x43, 0x01, 0x08, 0x0C, 0x20, 0x30, 0x87, 0xFF,
  0xC2, 0x18, 0x08, 0x60, 0x21, 0x01, 0x84, 0x06, 0x10, 0x10, 0x43, 0xFF,
  0xE1, 0x0C, 0x04, 0x20, 0x30, 0x80, 0xC2, 0x02, 0x08, 0x08, 0x60, 0x06,
  0x00, 0x60, 0x1F, 0xC7, 0x66, 0x66, 0x04, 0x60, 0xC6, 0x04, 0x60, 0x66,
  0x03, 0xE0, 0x1E, 0x00, 0x78, 0x06, 0xE0, 0x66, 0x06, 0x30, 0x63, 0x06,
  0x20, 0x66, 0x77, 0xC7, 0xF8, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x06,
  0x19, 0x81, 0x04, 0x20, 0xC1, 0x08, 0x20, 0xC3, 0x18, 0x30, 0xC4, 0x0C,
  0x33, 0x03, 0x0C, 0x80, 0x42, 0x67, 0x90, 0x92, 0x36, 0x6C, 0x8C, 0xF2,
  0x61, 0x01, 0x98, 0x40, 0x44, 0x10, 0x11, 0x04, 0x08, 0x61, 0x02, 0x18,
  0x41, 0x82, 0x30, 0x40, 0xCC, 0x30, 0x1E, 0x0F, 0x80, 0x18, 0xC0, 0x30,
  0x40, 0x30, 0x40, 0x30, 0x40, 0x30, 0xC0, 0x10, 0xC0, 0x19, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x3B, 0x00, 0x61, 0x86, 0x61, 0x86, 0xC0, 0xC4, 0xC0,
  0x6C, 0xC0, 0x38, 0xC0, 0x18, 0x60, 0x3C, 0x70, 0xE6, 0x1F, 0x87, 0xFA,
  0xA8, 0x0C, 0x61, 0x0C, 0x21, 0x86, 0x10, 0x43, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0x41, 0x06, 0x18, 0x20, 0xC1, 0x83, 0xC1, 0x82, 0x0C, 0x30, 0x41,
  0x86, 0x08, 0x20, 0x83, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x84, 0x30, 0x86,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x22, 0x1F, 0xFE, 0x0C, 0x02, 0x80, 0xC8,
  0x11, 0x86, 0x18, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF,
  0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x6D,
  0xA5, 0xA0, 0xFC, 0xF0, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x18,
  0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x18, 0x00, 0x1F, 0x83, 0x8C, 0x30, 0x66, 0x06, 0x60, 0x24, 0x03,
  0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x34, 0x03,
  0x40, 0x36, 0x02, 0x60, 0x63, 0x06, 0x38, 0xC1, 0xF8, 0x06, 0x1C, 0xDB,
  0x3C, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x3F, 0x87, 0x1C, 0x40, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0F, 0xFF, 0x3F, 0x8E, 0x0C,
  0x40, 0x60, 0x06, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x01, 0x81, 0xE0,
  0x03, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0xC0, 0xC7, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x50, 0x07, 0x80, 0x6C, 0x02,
  0x60, 0x33, 0x01, 0x18, 0x10, 0xC1, 0x86, 0x08, 0x30, 0xC1, 0x8C, 0x0C,
  0x40, 0x63, 0xFF, 0xE0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x7F, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF,
  0x08, 0x70, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x1B, 0x0E, 0x7F, 0x80, 0x0F, 0xC3, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x9F, 0x94, 0x1B, 0x01, 0x60, 0x38, 0x07, 0x00, 0xE0,
  0x1E, 0x03, 0xC0, 0x6C, 0x19, 0xC7, 0x0F, 0x80, 0xFF, 0xF0, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x1F, 0x83, 0x0C, 0x60, 0x66, 0x02, 0x60, 0x26, 0x02, 0x60,
  0x63, 0x0C, 0x1D, 0x80, 0x70, 0x19, 0x83, 0x0E, 0x60, 0x64, 0x03, 0xC0,
  0x3C, 0x03, 0x40, 0x36, 0x02, 0x30, 0xE1, 0xF8, 0x1F, 0x83, 0x1C, 0x60,
  0x44, 0x06, 0xC0, 0x2C, 0x02, 0xC0, 0x3C, 0x03, 0x40, 0x36, 0x07, 0x70,
  0xF3, 0xFB, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x03,
  0x87, 0xE0, 0xF4, 0x00, 0x00, 0x3C, 0x6C, 0x80, 0x00, 0x00, 0x06, 0xDA,
  0x5A, 0x00, 0x00, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x00, 0xFE, 0x63, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x06, 0x06,
  0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0xF8, 0x01, 0xE1, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x08,
  0x80, 0x01, 0xB0, 0x7E, 0x16, 0x18, 0x42, 0x86, 0x08, 0x70, 0x81, 0x0E,
  0x10, 0x21, 0xC2, 0x0C, 0x38, 0x41, 0x87, 0x08, 0x30, 0xA1, 0x86, 0x14,
  0x1B, 0x64, 0xC1, 0xC7, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x40, 0x1F, 0xF8, 0x00, 0x20, 0x00, 0x01, 0x80, 0x07, 0x00, 0x0A,
  0x00, 0x16, 0x00, 0x6C, 0x00, 0x88, 0x01, 0x18, 0x06, 0x30, 0x08, 0x20,
  0x10, 0x60, 0x60, 0xC0, 0x80, 0x81, 0xFF, 0x86, 0x03, 0x0C, 0x02, 0x10,
  0x06, 0x60, 0x0C, 0xC0, 0x0B, 0x00, 0x1E, 0x00, 0x30, 0xFF, 0x10, 0xFA,
  0x03, 0x40, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x81, 0x9F, 0xC2, 0x07,
  0x40, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x0F, 0x7F,
  0x80, 0x0F, 0xF8, 0xE1, 0x8C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x07, 0x04, 0x1F, 0xE0, 0xFF, 0x04,
  0x3E, 0x20, 0x39, 0x00, 0x68, 0x03, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x50, 0x06,
  0x80, 0x64, 0x07, 0x21, 0xF1, 0xFC, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x1F, 0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x00, 0x07, 0xF8, 0x70, 0x73, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x0F,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x60, 0x04, 0xC0,
  0x11, 0xC0, 0xC3, 0xFE, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x3F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30, 0xE6, 0xF0, 0x80,
  0x68, 0x0C, 0x80, 0x88, 0x18, 0x83, 0x08, 0x60, 0x8C, 0x09, 0x80, 0x98,
  0x0B, 0x80, 0xEC, 0x0C, 0xC0, 0x86, 0x08, 0x30, 0x83, 0x08, 0x18, 0x80,
  0x88, 0x0C, 0x80, 0x68, 0x07, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x1F, 0xF0, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF4, 0x00,
  0xFB, 0x00, 0x5D, 0x80, 0x2E, 0x40, 0x37, 0x30, 0x13, 0x98, 0x09, 0xC4,
  0x0C, 0xE3, 0x04, 0x71, 0x86, 0x38, 0x43, 0x1C, 0x31, 0x0E, 0x09, 0x87,
  0x04, 0xC3, 0x83, 0x41, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0x40, 0x3B, 0x01, 0xCC, 0x0E, 0x60, 0x71, 0x83,
  0x8C, 0x1C, 0x30, 0xE0, 0x87, 0x06, 0x38, 0x19, 0xC0, 0xCE, 0x03, 0x70,
  0x0B, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x30, 0x0F, 0xE0, 0x70, 0x70,
  0xC0, 0x63, 0x00, 0x6C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xA0, 0x02, 0x60, 0x0C, 0x60, 0x30, 0x60, 0xC0, 0x7F, 0x00, 0xFE, 0x21,
  0xE8, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x6F, 0xF3,
  0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0F,
  0xE0, 0x30, 0x70, 0xC0, 0x63, 0x00, 0x6C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xA0, 0x03, 0x60, 0x0C, 0x60, 0x30, 0x60, 0xE0, 0x7F,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0xFE, 0x08,
  0xF8, 0x80, 0xC8, 0x0C, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0xC8,
  0x18, 0xFF, 0x08, 0x60, 0x82, 0x08, 0x30, 0x81, 0x88, 0x18, 0x80, 0xC8,
  0x0C, 0x80, 0x68, 0x07, 0x1F, 0xE7, 0x0D, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0F, 0x87, 0x7F, 0xC0, 0xFF, 0xF8, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x02, 0x60, 0x19, 0x80,
  0x63, 0x87, 0x07, 0xF8, 0xC0, 0x07, 0x00, 0x34, 0x00, 0xD8, 0x02, 0x60,
  0x18, 0x80, 0x63, 0x01, 0x0C, 0x0C, 0x10, 0x30, 0x60, 0x81, 0x86, 0x02,
  0x18, 0x0C, 0x40, 0x31, 0x00, 0x4C, 0x01, 0xB0, 0x06, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0xC0, 0x10, 0x06, 0x80, 0x70, 0x09, 0x80, 0xE0, 0x33,
  0x01, 0x40, 0x62, 0x02, 0x80, 0x84, 0x0D, 0x81, 0x0C, 0x1B, 0x06, 0x18,
  0x22, 0x0C, 0x10, 0xC4, 0x10, 0x21, 0x8C, 0x20, 0x63, 0x18, 0xC0, 0xC4,
  0x11, 0x80, 0x98, 0x22, 0x01, 0x30, 0x64, 0x03, 0x60, 0xD8, 0x06, 0x80,
  0xB0, 0x05, 0x01, 0x40, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x1B, 0x00, 0x8C, 0x0C, 0x20, 0xC1, 0x86, 0x04, 0x60, 0x32,
  0x00, 0xB0, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x0B, 0x00, 0xC8, 0x04, 0x60,
  0x61, 0x02, 0x0C, 0x30, 0x33, 0x01, 0x98, 0x07, 0x80, 0x30, 0xC0, 0x1A,
  0x00, 0x98, 0x0C, 0x40, 0x43, 0x06, 0x08, 0x30, 0x63, 0x01, 0x18, 0x0C,
  0x80, 0x6C, 0x01, 0xC0, 0x0E, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xC0, 0x30, 0x18, 0x04, 0x03,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08,
  0x06, 0x01, 0x00, 0x80, 0x60, 0x10, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF,
  0x06, 0x00, 0x38, 0x03, 0x40, 0x13, 0x01, 0x88, 0x08, 0x60, 0xC1, 0x04,
  0x0C, 0x60, 0x22, 0x01, 0xB0, 0x0D, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xE3,
  0x0C, 0x30, 0x1F, 0x8C, 0x70, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x3C, 0xFD,
  0x60, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xD8, 0x53, 0xE4, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0x8D, 0x1C, 0xE0, 0x6C, 0x06,
  0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x06,
  0xE0, 0x6F, 0x0C, 0xDF, 0x80, 0x0F, 0xCE, 0x13, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x0E, 0x11, 0xFC,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x1F, 0xB3, 0x8F,
  0x20, 0x76, 0x03, 0x40, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03,
  0x40, 0x36, 0x03, 0x60, 0x73, 0x0D, 0x1F, 0x90, 0x0F, 0x87, 0x18, 0x81,
  0xB0, 0x34, 0x02, 0x80, 0x5F, 0xFF, 0xFF, 0xC0, 0x08, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x70, 0xC7, 0xF0, 0x0F, 0x8C, 0x06, 0x02, 0x01, 0x00, 0x83,
  0xF8, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x1F, 0x93, 0x8F, 0x20, 0x76, 0x03, 0x40,
  0x34, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x40, 0x36, 0x03, 0x60,
  0x73, 0x0F, 0x1F, 0xB0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x24, 0x06, 0x7F,
  0xC0, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33, 0xE7,
  0x86, 0xE0, 0x58, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x1F, 0xB8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x0F, 0x06, 0xC3, 0x31, 0x8C, 0x43, 0x30, 0xD8, 0x3F, 0x0E, 0x43,
  0x18, 0xC3, 0x30, 0xCC, 0x1B, 0x02, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xDF, 0x0F, 0xBC, 0x6C, 0x7E, 0x0E, 0x0F, 0x03, 0x01, 0xC0,
  0x40, 0x70, 0x10, 0x1C, 0x04, 0x07, 0x01, 0x01, 0xC0, 0x40, 0x70, 0x10,
  0x1C, 0x04, 0x07, 0x01, 0x01, 0xC0, 0x40, 0x70, 0x10, 0x1C, 0x04, 0x04,
  0xCF, 0x9A, 0x1B, 0x81, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0x0F, 0x83, 0x8E,
  0x20, 0x66, 0x03, 0x40, 0x34, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x01,
  0x40, 0x36, 0x03, 0x20, 0x23, 0x8E, 0x1F, 0x80, 0xCF, 0x8D, 0x1C, 0xE0,
  0x6C, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x2C, 0x06, 0xE0, 0x6F, 0x0C, 0xDF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x1F, 0x93, 0x8F, 0x60, 0x76, 0x03, 0x40,
  0x34, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x40, 0x36, 0x03, 0x60,
  0x73, 0x0F, 0x1F, 0xB0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0xCF, 0xD9, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x98, 0x6C, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x78, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0xB0, 0x6F, 0xF0,
  0x10, 0x10, 0x30, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x18, 0x1F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0E,
  0xC3, 0xCF, 0x98, 0xC0, 0x34, 0x02, 0x40, 0x66, 0x06, 0x20, 0x42, 0x0C,
  0x30, 0xC3, 0x08, 0x11, 0x81, 0x98, 0x19, 0x00, 0xB0, 0x0F, 0x00, 0xE0,
  0x06, 0x00, 0xC0, 0x40, 0x50, 0x38, 0x16, 0x0A, 0x0D, 0x82, 0x83, 0x61,
  0xB0, 0x88, 0x6C, 0x23, 0x11, 0x18, 0xC4, 0x46, 0x13, 0x19, 0x04, 0x86,
  0x41, 0xA0, 0xB0, 0x78, 0x2C, 0x0E, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0xC0, 0x68, 0x19, 0x86, 0x18, 0xC1, 0x30, 0x34, 0x03, 0x80, 0x60, 0x0E,
  0x03, 0x40, 0xCC, 0x10, 0xC6, 0x09, 0x81, 0xB0, 0x18, 0xC0, 0x34, 0x02,
  0x60, 0x66, 0x06, 0x20, 0x43, 0x0C, 0x30, 0xC1, 0x08, 0x19, 0x81, 0x98,
  0x09, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0xF0, 0x0E, 0x00, 0x7F, 0x80, 0xC0, 0x40, 0x60, 0x60,
  0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0xFE, 0x07,
  0x0E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0xF0, 0xE0,
  0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x0F, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0xF0, 0x7E, 0x1C, 0x7F, 0x80, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 20, 7, 2, -20 },
  { 6, 6, 7, 10, 2, -20 },
  { 12, 14, 20, 16, 1, -20 },
  { 47, 12, 23, 14, 1, -21 },
  { 82, 18, 20, 21, 1, -20 },
  { 127, 16, 20, 17, 1, -20 },
  { 167, 2, 7, 5, 2, -20 },
  { 169, 6, 24, 8, 1, -20 },
  { 187, 6, 24, 8, 1, -20 },
  { 205, 11, 10, 14, 1, -21 },
  { 219, 12, 13, 14, 1, -16 },
  { 239, 3, 7, 6, 1, -3 },
  { 242, 6, 1, 8, 1, -8 },
  { 243, 2, 2, 6, 2, -2 },
  { 244, 9, 20, 10, 0, -20 },
  { 267, 12, 20, 14, 1, -20 },
  { 297, 7, 20, 14, 2, -20 },
  { 315, 12, 20, 14, 1, -20 },
  { 345, 12, 20, 14, 1, -20 },
  { 375, 13, 20, 14, 1, -20 },
  { 408, 11, 20, 14, 2, -20 },
  { 436, 11, 20, 14, 2, -20 },
  { 464, 12, 20, 14, 1, -20 },
  { 494, 12, 20, 14, 1, -20 },
  { 524, 12, 20, 14, 1, -20 },
  { 554, 2, 15, 6, 2, -15 },
  { 558, 3, 19, 6, 1, -15 },
  { 566, 12, 12, 14, 1, -16 },
  { 584, 12, 7, 14, 1, -13 },
  { 595, 12, 12, 14, 1, -16 },
  { 613, 9, 20, 11, 1, -20 },
  { 636, 19, 23, 22, 2, -20 },
  { 691, 15, 20, 15, 0, -20 },
  { 729, 11, 20, 16, 3, -20 },
  { 757, 13, 20, 15, 2, -20 },
  { 790, 13, 20, 18, 3, -20 },
  { 823, 9, 20, 14, 3, -20 },
  { 846, 9, 20, 13, 3, -20 },
  { 869, 14, 20, 18, 2, -20 },
  { 904, 13, 20, 18, 3, -20 },
  { 937, 6, 20, 8, 1, -20 },
  { 952, 6, 25, 7, -2, -20 },
  { 971, 12, 20, 15, 3, -20 },
  { 1001, 9, 20, 13, 3, -20 },
  { 1024, 17, 20, 22, 3, -20 },
  { 1067, 13, 20, 18, 3, -20 },
  { 1100, 15, 20, 19, 2, -20 },
  { 1138, 10, 20, 15, 3, -20 },
  { 1163, 15, 25, 19, 2, -20 },
  { 1210, 12, 20, 15, 3, -20 },
  { 1240, 11, 20, 14, 1, -20 },
  { 1268, 13, 20, 13, 0, -20 },
  { 1301, 14, 20, 18, 2, -20 },
  { 1336, 14, 20, 14, 0, -20 },
  { 1371, 23, 20, 23, 0, -20 },
  { 1429, 13, 20, 13, 0, -20 },
  { 1462, 13, 20, 13, 0, -20 },
  { 1495, 12, 20, 14, 1, -20 },
  { 1525, 6, 24, 9, 2, -20 },
  { 1543, 9, 20, 10, 0, -20 },
  { 1566, 6, 24, 9, 1, -20 },
  { 1584, 13, 12, 14, 1, -20 },
  { 1604, 12, 2, 12, 0, 2 },
  { 1607, 5, 4, 7, 1, -21 },
  { 1610, 10, 15, 14, 1, -15 },
  { 1629, 12, 21, 15, 2, -21 },
  { 1661, 10, 15, 12, 1, -15 },
  { 1680, 12, 21, 15, 1, -21 },
  { 1712, 11, 15, 14, 1, -15 },
  { 1733, 9, 21, 8, 0, -21 },
  { 1757, 12, 22, 15, 1, -15 },
  { 1790, 11, 21, 15, 2, -21 },
  { 1819, 2, 20, 6, 2, -20 },
  { 1824, 5, 27, 6, -1, -20 },
  { 1841, 10, 21, 12, 2, -21 },
  { 1868, 2, 21, 6, 2, -21 },
  { 1874, 18, 15, 22, 2, -15 },
  { 1908, 11, 15, 15, 2, -15 },
  { 1929, 12, 15, 15, 1, -15 },
  { 1952, 12, 22, 15, 2, -15 },
  { 1985, 12, 22, 15, 1, -15 },
  { 2018, 8, 15, 10, 2, -15 },
  { 2033, 10, 15, 12, 1, -15 },
  { 2052, 8, 18, 8, 0, -18 },
  { 2070, 11, 15, 15, 2, -15 },
  { 2091, 12, 15, 12, 0, -15 },
  { 2114, 18, 15, 19, 0, -15 },
  { 2148, 11, 15, 12, 1, -15 },
  { 2169, 12, 22, 12, 0, -15 },
  { 2202, 9, 15, 11, 1, -15 },
  { 2219, 8, 24, 10, 1, -20 },
  { 2243, 2, 28, 14, 6, -21 },
  { 2250, 8, 24, 10, 1, -20 },
  { 2274, 12, 3, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Light28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT28PT7B_H_
