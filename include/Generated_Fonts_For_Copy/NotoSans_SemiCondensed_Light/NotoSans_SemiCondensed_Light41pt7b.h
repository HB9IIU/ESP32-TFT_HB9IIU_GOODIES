#ifndef _NOTOSANS_SEMICONDENSED_LIGHT41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light41pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x00, 0x06, 0xEF, 0xE0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07,
  0x82, 0xC1, 0x60, 0x80, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x03, 0x01, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x83, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x40, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x60, 0x60, 0x02,
  0x03, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x10, 0x18, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xFE, 0x79, 0x86, 0x61, 0x80, 0xE1,
  0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xE1, 0x80, 0x61, 0x80, 0x79,
  0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0x9E, 0x01,
  0x87, 0x01, 0x83, 0x01, 0x83, 0x01, 0x83, 0x01, 0x83, 0x01, 0x83, 0x01,
  0x87, 0x81, 0x8E, 0xFD, 0xFC, 0xFF, 0xF8, 0x07, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x06, 0x07, 0x18, 0x03,
  0x01, 0x83, 0x00, 0xC0, 0x60, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C,
  0x0C, 0x03, 0x01, 0x83, 0x00, 0xC0, 0x61, 0x80, 0x30, 0x18, 0x60, 0x0C,
  0x06, 0x38, 0x03, 0x01, 0x8C, 0x00, 0xC0, 0xC3, 0x1E, 0x30, 0x31, 0x8F,
  0xC6, 0x0C, 0x66, 0x19, 0x83, 0x31, 0x86, 0x71, 0x8C, 0xC0, 0xCF, 0xC6,
  0x30, 0x30, 0xE1, 0x8C, 0x0C, 0x00, 0xC3, 0x03, 0x00, 0x30, 0xC0, 0xC0,
  0x18, 0x30, 0x30, 0x06, 0x0C, 0x0C, 0x03, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x01, 0x86, 0x03, 0x00,
  0x7F, 0x81, 0xC0, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x38,
  0xF0, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0xC0, 0x06, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x30, 0x60,
  0x00, 0x71, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0xE0, 0x1C, 0x60, 0xE0, 0x31, 0xC0, 0xE0, 0x67,
  0x00, 0xE1, 0xCE, 0x00, 0xE3, 0x18, 0x00, 0xC6, 0x30, 0x01, 0xD8, 0x60,
  0x01, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0xC1, 0xC0, 0x1D, 0xC3, 0xC0,
  0x71, 0x83, 0xFF, 0xC3, 0x81, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xF0, 0x07,
  0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60,
  0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x0E, 0x07, 0xE0, 0x18,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x38, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xE1, 0x86, 0xFD, 0xBF, 0x3F, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x06, 0x60,
  0x0E, 0x70, 0x1C, 0x30, 0x18, 0x38, 0x38, 0x1C, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x37, 0x77, 0x66, 0x6C, 0xCC, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0xFC, 0x07, 0xDF, 0x03, 0x01, 0x83, 0x80, 0x63, 0x80, 0x31,
  0xC0, 0x1C, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3B, 0x00, 0x19, 0x80, 0x0C,
  0xC0, 0x06, 0x70, 0x07, 0x18, 0x03, 0x0E, 0x03, 0x83, 0x83, 0x80, 0xFF,
  0x80, 0x3F, 0x80, 0x03, 0x83, 0xC7, 0x67, 0x37, 0x3F, 0x1F, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0x1F, 0x1E, 0x03, 0x84, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0F, 0xFC, 0x1F, 0x1F, 0x1C, 0x01,
  0xC4, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x3F, 0x80,
  0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x98, 0x03, 0xCF, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x39,
  0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x03, 0x03,
  0x00, 0x60, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x06,
  0x0E, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x3F, 0xFE, 0x1F, 0xFF, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0xF8, 0x07, 0xFF, 0x81, 0xC3, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x30, 0x07, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x01,
  0xF0, 0x81, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x3F, 0x87, 0x7F,
  0xE3, 0xB0, 0x39, 0xF0, 0x0E, 0xF0, 0x03, 0x70, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x07, 0x70, 0x03,
  0x98, 0x01, 0x8E, 0x01, 0xC3, 0x81, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC7, 0x00, 0x73,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x38, 0x03, 0x8C, 0x01,
  0x87, 0x01, 0xC1, 0xE3, 0xC0, 0x3F, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x1C,
  0x3C, 0x1C, 0x07, 0x1C, 0x01, 0xCC, 0x00, 0x6E, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0x9C, 0x01, 0xCF, 0x01,
  0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xC0, 0x07, 0xF8, 0x0F, 0x9E, 0x07,
  0x03, 0x87, 0x00, 0xE3, 0x00, 0x33, 0x80, 0x1D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1D, 0x80,
  0x1E, 0xE0, 0x1F, 0x38, 0x3B, 0x8F, 0xF9, 0x81, 0xF0, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x0F, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xB0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x39, 0xCE, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xCE, 0x73, 0x98, 0xCE, 0x63, 0x38, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x06, 0x03, 0xFF,
  0x3E, 0x7D, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x06, 0x30, 0x0F, 0xF0, 0x67, 0x01, 0xFF, 0x03, 0x60, 0x30, 0x30,
  0x36, 0x06, 0x03, 0x03, 0x60, 0xE0, 0x30, 0x3C, 0x0C, 0x03, 0x03, 0xC0,
  0xC0, 0x30, 0x3C, 0x0C, 0x03, 0x03, 0xC0, 0xC0, 0x30, 0x3C, 0x0C, 0x03,
  0x03, 0xC0, 0xC0, 0x70, 0x3C, 0x0C, 0x07, 0x03, 0xC0, 0xC0, 0x70, 0x66,
  0x0E, 0x0D, 0x06, 0x60, 0x73, 0x98, 0xC6, 0x03, 0xF0, 0xF8, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xE0, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x1C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0x00,
  0x38, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x80, 0x07, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x31, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x1C, 0xFF, 0xF0, 0x7F, 0xFE, 0x30, 0x07, 0x98, 0x00, 0xEC, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x01, 0xD8, 0x01, 0xCC, 0x07, 0xC7, 0xFF, 0x03, 0xFF, 0xF1, 0x80, 0x1C,
  0xC0, 0x07, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x03, 0xB0, 0x07, 0x9F,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFC, 0x0F, 0xCF, 0x83,
  0x80, 0x10, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x10, 0x3F,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x1E, 0x0C,
  0x00, 0x70, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x0E,
  0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0,
  0x01, 0xCC, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00, 0xF0, 0xC0, 0x3E, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0xB0, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xBF, 0xFE,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0x9F, 0xC1, 0xE0, 0x06, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x37,
  0x00, 0x00, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x30, 0xE0,
  0x00, 0xC1, 0xE0, 0x07, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0xFF, 0x3C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x83, 0xBF, 0xDF, 0xC2, 0x00, 0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00,
  0xE3, 0x00, 0x70, 0xC0, 0x38, 0x30, 0x0C, 0x0C, 0x07, 0x03, 0x03, 0x80,
  0xC1, 0xC0, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xCE, 0x00, 0x37,
  0xC0, 0x0F, 0xF0, 0x03, 0xCE, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x0C, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x30, 0x0E, 0x0C, 0x01, 0x83, 0x00, 0x70,
  0xC0, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x0E, 0xC0, 0x03, 0xC0,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFD, 0x80, 0x00, 0xDE, 0xC0, 0x00, 0x6F, 0x70, 0x00,
  0x77, 0x98, 0x00, 0x33, 0xCC, 0x00, 0x19, 0xE7, 0x00, 0x18, 0xF1, 0x80,
  0x0C, 0x78, 0xC0, 0x06, 0x3C, 0x70, 0x06, 0x1E, 0x18, 0x03, 0x0F, 0x0C,
  0x03, 0x87, 0x83, 0x01, 0x83, 0xC1, 0x80, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0,
  0x30, 0x60, 0x78, 0x18, 0x30, 0x3C, 0x0E, 0x30, 0x1E, 0x03, 0x18, 0x0F,
  0x01, 0x8C, 0x07, 0x80, 0xEC, 0x03, 0xC0, 0x36, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x18, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3D, 0x80, 0x07, 0xB8, 0x00,
  0xF3, 0x00, 0x1E, 0x70, 0x03, 0xC6, 0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x01,
  0xE0, 0xC0, 0x3C, 0x1C, 0x07, 0x81, 0x80, 0xF0, 0x38, 0x1E, 0x03, 0x83,
  0xC0, 0x70, 0x78, 0x07, 0x0F, 0x00, 0x61, 0xE0, 0x0E, 0x3C, 0x00, 0xC7,
  0x80, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xE7, 0xE0, 0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x3C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xF0, 0xFF, 0xC0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x0F, 0x00, 0xF0, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x0F, 0x18, 0x01, 0xCC, 0x00,
  0x66, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0E, 0xC0, 0x07, 0x60, 0x03, 0xB0,
  0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x01, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0,
  0xC0, 0xC0, 0x60, 0x70, 0x30, 0x1C, 0x18, 0x0E, 0x0C, 0x03, 0x86, 0x00,
  0xC3, 0x00, 0x71, 0x80, 0x18, 0xC0, 0x0E, 0x60, 0x03, 0x30, 0x01, 0xD8,
  0x00, 0x6C, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xFE, 0x3F, 0x7F, 0x38, 0x02,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0xC0, 0x1E,
  0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00,
  0x06, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x1C, 0x03, 0xC0, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xE0, 0x00,
  0xE3, 0x00, 0x07, 0x18, 0x00, 0x30, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x18,
  0x00, 0xC0, 0xE0, 0x06, 0x07, 0x00, 0x70, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x07, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x07, 0x07, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x07, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00,
  0x07, 0x30, 0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0xE0, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x60,
  0x06, 0xC0, 0x0E, 0x60, 0x06, 0xC0, 0x0E, 0x70, 0x06, 0xE0, 0x0C, 0x30,
  0x06, 0x60, 0x0C, 0x30, 0x0E, 0x60, 0x1C, 0x30, 0x0C, 0x60, 0x1C, 0x38,
  0x0C, 0x70, 0x18, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x1C, 0x30, 0x38, 0x18,
  0x18, 0x30, 0x38, 0x1C, 0x18, 0x38, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x0C,
  0x38, 0x18, 0x70, 0x0C, 0x30, 0x18, 0x70, 0x0E, 0x30, 0x1C, 0x60, 0x06,
  0x30, 0x0C, 0x60, 0x06, 0x70, 0x0C, 0xE0, 0x06, 0x60, 0x0C, 0xE0, 0x07,
  0x60, 0x06, 0xC0, 0x03, 0x60, 0x06, 0xC0, 0x03, 0xE0, 0x06, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xC0,
  0x18, 0x0C, 0x03, 0x00, 0xE0, 0x70, 0x06, 0x06, 0x00, 0x70, 0xE0, 0x03,
  0x0C, 0x00, 0x39, 0xC0, 0x01, 0x98, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x19, 0x80,
  0x03, 0x1C, 0x00, 0x70, 0xC0, 0x06, 0x06, 0x00, 0xE0, 0x70, 0x0C, 0x03,
  0x01, 0xC0, 0x38, 0x18, 0x01, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xC6, 0x00,
  0x0E, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0xC0, 0x07, 0x18,
  0x00, 0xC3, 0x80, 0x38, 0x30, 0x07, 0x07, 0x00, 0xC0, 0x60, 0x38, 0x0E,
  0x06, 0x00, 0xC1, 0xC0, 0x18, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x07,
  0x70, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC3, 0x00, 0x30, 0x60,
  0x0E, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x18,
  0x60, 0x03, 0x1C, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0xF0, 0x7F,
  0xF0, 0xC0, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x01, 0xFC, 0x3F, 0xF9, 0xF0, 0x77, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x5F, 0x01, 0xB7, 0xFE,
  0x67, 0xF8, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x71, 0xFC,
  0x3B, 0xFF, 0x1F, 0x81, 0xCD, 0x80, 0x77, 0x80, 0x3B, 0x80, 0x0D, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xBC, 0x01,
  0xDE, 0x00, 0xED, 0x80, 0xE6, 0x7F, 0xE3, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0xF1, 0xC0, 0x4E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x01, 0x1F, 0xFC, 0x1F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x83, 0xF8, 0xC7, 0xFE, 0x67,
  0x81, 0xB3, 0x80, 0x5B, 0x80, 0x3D, 0x80, 0x0E, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xF3,
  0x80, 0xD8, 0xFF, 0xCC, 0x3F, 0xC6, 0x07, 0xF0, 0x0F, 0xF8, 0x1C, 0x1C,
  0x38, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x02, 0x0F, 0xFE,
  0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xC1, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x01, 0xFF, 0x3F, 0xF8, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x07, 0xF1, 0x8F, 0xFC, 0xCF, 0x03, 0x67,
  0x00, 0xF7, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0x60, 0x03, 0xB8, 0x01, 0xCC, 0x01, 0x67, 0x01, 0xB1,
  0xFF, 0x98, 0x7F, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE4, 0x00, 0x73, 0xC0, 0xF1, 0xFF, 0xF0, 0x1F,
  0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xF8, 0xEF, 0xFC, 0xFC,
  0x1E, 0xD8, 0x06, 0xF0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xFF, 0xA0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x1C, 0x38, 0x20, 0x00, 0x00, 0x00, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xD3,
  0xBE, 0x78, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0x80, 0x67, 0x01,
  0xCE, 0x07, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0xC0, 0xE3, 0x81, 0xCE, 0x03,
  0xB8, 0x06, 0x78, 0x0D, 0xB8, 0x1E, 0x30, 0x38, 0x70, 0x70, 0x60, 0xE0,
  0xE1, 0xC0, 0xE3, 0x80, 0xC7, 0x01, 0xCE, 0x01, 0xDC, 0x01, 0xB8, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC7, 0xF0, 0x7F, 0x19, 0xFF, 0x1F, 0xF3, 0x60, 0x76, 0x07, 0x68,
  0x07, 0x80, 0x6F, 0x00, 0xF0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80,
  0x3F, 0x00, 0x70, 0x03, 0xE0, 0x0E, 0x00, 0x7C, 0x01, 0xC0, 0x0F, 0x80,
  0x38, 0x01, 0xF0, 0x07, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x00,
  0xF8, 0x03, 0x80, 0x1F, 0x00, 0x70, 0x03, 0xE0, 0x0E, 0x00, 0x7C, 0x01,
  0xC0, 0x0F, 0x80, 0x38, 0x01, 0xF0, 0x07, 0x00, 0x3E, 0x00, 0xE0, 0x07,
  0xC0, 0x1C, 0x00, 0xC0, 0xC3, 0xF8, 0xCF, 0xFC, 0xDC, 0x1E, 0xD0, 0x06,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0x07, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x18,
  0x00, 0xE6, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x03, 0x9C, 0x00, 0xC3, 0x00, 0x70, 0x70, 0x38, 0x1F, 0xFC, 0x01,
  0xFE, 0x00, 0xC3, 0xF8, 0x67, 0xFE, 0x33, 0x03, 0x9B, 0x00, 0xEF, 0x00,
  0x77, 0x00, 0x1B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0x78, 0x03, 0xB4, 0x01, 0xDF, 0x01, 0xCE, 0xFF, 0xC7, 0x3F,
  0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x07, 0xF1,
  0x8F, 0xFC, 0xCF, 0x03, 0x67, 0x00, 0xB7, 0x00, 0x7B, 0x00, 0x1D, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0x60, 0x03, 0xB8, 0x03,
  0xDC, 0x01, 0x67, 0x01, 0xB1, 0xFF, 0x98, 0x7F, 0x8C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xC3, 0xF9, 0xFF, 0x30, 0x6C, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x00, 0x1F, 0xF1, 0xFF, 0xDC, 0x05, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x7F, 0xFF, 0x3F,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x1F, 0xFF, 0xFC, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0xF0, 0xFC, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x60,
  0x0B, 0x70, 0x1B, 0x3F, 0xF3, 0x1F, 0xE3, 0xE0, 0x01, 0xB0, 0x01, 0xD8,
  0x00, 0xCE, 0x00, 0x67, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x18, 0x70, 0x1C,
  0x18, 0x0C, 0x0C, 0x06, 0x07, 0x07, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x71,
  0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x07, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x6C, 0x01, 0xC0,
  0x1D, 0x80, 0x3C, 0x03, 0x38, 0x07, 0x80, 0x63, 0x01, 0xB0, 0x0C, 0x60,
  0x37, 0x03, 0x8C, 0x06, 0x60, 0x61, 0xC0, 0xCC, 0x0C, 0x18, 0x31, 0x81,
  0x83, 0x06, 0x18, 0x70, 0x60, 0xC3, 0x0C, 0x0E, 0x38, 0x61, 0x80, 0xC6,
  0x0E, 0x30, 0x18, 0xC0, 0xCE, 0x03, 0x18, 0x19, 0x80, 0x77, 0x03, 0x30,
  0x06, 0xC0, 0x76, 0x00, 0xD8, 0x06, 0xC0, 0x1B, 0x00, 0xF0, 0x01, 0xC0,
  0x1E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x70,
  0x06, 0x30, 0x0E, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x0E, 0x30, 0x06,
  0x70, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x60, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x18, 0x18, 0x1C, 0x30, 0x0C, 0x70,
  0x0E, 0x60, 0x06, 0xE0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xEE,
  0x00, 0x63, 0x00, 0x71, 0x80, 0x30, 0xE0, 0x18, 0x30, 0x1C, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x07, 0x01, 0x83, 0x00, 0xE1, 0x80, 0x30, 0xC0, 0x18,
  0xC0, 0x0E, 0x60, 0x03, 0x30, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x03, 0xF0, 0x01, 0xE0,
  0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x3F, 0x03, 0x80, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x7C, 0x0F, 0x00, 0xFC, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x1F, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x0F, 0x83,
  0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x1F, 0x03, 0xC0, 0x40, 0x00, 0x1C,
  0x00, 0x3F, 0xC0, 0x78, 0xF8, 0xF0, 0x1F, 0xE8, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Light41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 29, 10, 3, -29 },
  { 16, 9, 10, 15, 3, -29 },
  { 28, 21, 29, 23, 1, -29 },
  { 105, 16, 33, 21, 2, -31 },
  { 171, 26, 30, 30, 2, -30 },
  { 269, 23, 30, 25, 2, -30 },
  { 356, 2, 10, 8, 3, -29 },
  { 359, 8, 35, 11, 2, -29 },
  { 394, 9, 35, 11, 1, -29 },
  { 434, 16, 15, 20, 2, -31 },
  { 464, 17, 19, 21, 2, -24 },
  { 505, 4, 10, 9, 2, -5 },
  { 510, 10, 2, 12, 1, -12 },
  { 513, 3, 4, 9, 3, -4 },
  { 515, 13, 29, 14, 1, -29 },
  { 563, 17, 30, 21, 2, -30 },
  { 627, 9, 29, 21, 4, -29 },
  { 660, 17, 30, 21, 2, -30 },
  { 724, 17, 30, 21, 2, -30 },
  { 788, 19, 29, 21, 1, -29 },
  { 857, 17, 29, 21, 2, -29 },
  { 919, 17, 30, 21, 2, -30 },
  { 983, 17, 29, 21, 2, -29 },
  { 1045, 17, 30, 21, 2, -30 },
  { 1109, 17, 30, 21, 2, -30 },
  { 1173, 3, 22, 9, 3, -22 },
  { 1182, 5, 27, 9, 1, -22 },
  { 1199, 17, 19, 21, 2, -24 },
  { 1240, 17, 11, 21, 2, -20 },
  { 1264, 17, 19, 21, 2, -24 },
  { 1305, 13, 30, 15, 1, -30 },
  { 1354, 28, 33, 33, 2, -29 },
  { 1470, 22, 29, 22, 0, -29 },
  { 1550, 17, 29, 23, 4, -29 },
  { 1612, 19, 30, 23, 2, -30 },
  { 1684, 20, 29, 26, 4, -29 },
  { 1757, 14, 29, 20, 4, -29 },
  { 1808, 14, 29, 19, 4, -29 },
  { 1859, 22, 30, 27, 2, -30 },
  { 1942, 19, 29, 26, 4, -29 },
  { 2011, 8, 29, 12, 2, -29 },
  { 2040, 9, 37, 10, -3, -29 },
  { 2082, 18, 29, 21, 4, -29 },
  { 2148, 14, 29, 19, 4, -29 },
  { 2199, 25, 29, 33, 4, -29 },
  { 2290, 19, 29, 27, 4, -29 },
  { 2359, 24, 30, 28, 2, -30 },
  { 2449, 16, 29, 22, 4, -29 },
  { 2507, 24, 37, 28, 2, -30 },
  { 2618, 17, 29, 22, 4, -29 },
  { 2680, 16, 30, 20, 2, -30 },
  { 2740, 19, 29, 19, 0, -29 },
  { 2809, 20, 29, 26, 3, -29 },
  { 2882, 21, 29, 21, 0, -29 },
  { 2959, 32, 29, 34, 1, -29 },
  { 3075, 20, 29, 20, 0, -29 },
  { 3148, 19, 29, 19, 0, -29 },
  { 3217, 18, 29, 20, 1, -29 },
  { 3283, 9, 36, 13, 3, -29 },
  { 3324, 13, 29, 14, 1, -29 },
  { 3372, 9, 36, 13, 1, -29 },
  { 3413, 19, 17, 21, 1, -29 },
  { 3454, 17, 2, 17, 0, 4 },
  { 3459, 7, 6, 11, 2, -31 },
  { 3465, 15, 22, 20, 2, -22 },
  { 3507, 17, 31, 22, 3, -31 },
  { 3573, 14, 22, 17, 2, -22 },
  { 3612, 17, 31, 22, 2, -31 },
  { 3678, 16, 22, 20, 2, -22 },
  { 3722, 13, 31, 12, 0, -31 },
  { 3773, 17, 32, 22, 2, -22 },
  { 3841, 16, 31, 22, 3, -31 },
  { 3903, 3, 30, 9, 3, -30 },
  { 3915, 7, 40, 9, -1, -30 },
  { 3950, 15, 31, 18, 3, -31 },
  { 4009, 3, 31, 9, 3, -31 },
  { 4021, 27, 22, 33, 3, -22 },
  { 4096, 16, 22, 22, 3, -22 },
  { 4140, 18, 22, 22, 2, -22 },
  { 4190, 17, 32, 22, 3, -22 },
  { 4258, 17, 32, 22, 2, -22 },
  { 4326, 11, 22, 14, 3, -22 },
  { 4357, 13, 22, 17, 2, -22 },
  { 4393, 10, 27, 12, 1, -27 },
  { 4427, 16, 22, 22, 3, -22 },
  { 4471, 17, 22, 17, 0, -22 },
  { 4518, 27, 22, 28, 0, -22 },
  { 4593, 16, 22, 18, 1, -22 },
  { 4637, 17, 32, 17, 0, -22 },
  { 4705, 14, 22, 16, 1, -22 },
  { 4744, 12, 36, 15, 1, -29 },
  { 4798, 2, 41, 20, 9, -31 },
  { 4809, 11, 36, 15, 2, -29 },
  { 4859, 17, 5, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Light41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT41PT7B_H_
