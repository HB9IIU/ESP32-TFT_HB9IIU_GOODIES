#ifndef _NOTOSANS_SEMICONDENSED_LIGHT44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light44pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x00, 0x06, 0xFF, 0x70, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xB0,
  0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x18, 0x00, 0x60, 0x60, 0x01, 0xC0,
  0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF8, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C,
  0x0C, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x01, 0x80,
  0xC0, 0x03, 0x03, 0x80, 0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x1F, 0xFF,
  0x8F, 0x30, 0xC7, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x38, 0x30, 0x0E,
  0x0C, 0x03, 0x83, 0x00, 0x60, 0xC0, 0x1C, 0x30, 0x03, 0xCC, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0x3C, 0x00, 0xC3,
  0x80, 0x30, 0x60, 0x0C, 0x1C, 0x03, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x70,
  0x0C, 0x18, 0x03, 0x0E, 0xE0, 0xC7, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x02, 0x03, 0xF8, 0x00, 0xC0, 0x31, 0xC0, 0x0C, 0x06, 0x0E, 0x01, 0x80,
  0x60, 0x60, 0x18, 0x06, 0x06, 0x03, 0x80, 0xE0, 0x60, 0x30, 0x0C, 0x06,
  0x07, 0x00, 0xC0, 0x70, 0x60, 0x0C, 0x07, 0x0E, 0x00, 0xC0, 0x70, 0xC0,
  0x0C, 0x07, 0x1C, 0x00, 0xC0, 0x61, 0x80, 0x0E, 0x06, 0x18, 0xF8, 0x60,
  0x63, 0x1F, 0xC6, 0x06, 0x33, 0x86, 0x60, 0xE6, 0x30, 0x73, 0x1C, 0x63,
  0x03, 0x1F, 0x8C, 0x60, 0x30, 0xF0, 0xC6, 0x03, 0x00, 0x18, 0x60, 0x30,
  0x01, 0x86, 0x03, 0x00, 0x30, 0x60, 0x30, 0x03, 0x06, 0x03, 0x00, 0x70,
  0x60, 0x30, 0x06, 0x06, 0x03, 0x00, 0xE0, 0x60, 0x30, 0x0C, 0x03, 0x03,
  0x01, 0xC0, 0x30, 0x70, 0x18, 0x03, 0x86, 0x03, 0x80, 0x1F, 0xE0, 0x30,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x1E, 0x00, 0x0C,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x70, 0x06, 0x38, 0x38, 0x0E, 0x70,
  0x1C, 0x0E, 0x60, 0x0E, 0x0C, 0xE0, 0x0E, 0x0C, 0xE0, 0x07, 0x1C, 0xE0,
  0x03, 0x98, 0xE0, 0x01, 0xF8, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x60,
  0x01, 0xF8, 0x70, 0x03, 0xF8, 0x3C, 0x0F, 0x1C, 0x1F, 0xFE, 0x0E, 0x0F,
  0xF8, 0x07, 0xFF, 0xED, 0xB6, 0xDB, 0x00, 0x03, 0x83, 0x03, 0x81, 0x81,
  0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30,
  0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x70, 0x1C, 0xF0, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07,
  0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x07, 0x06, 0x0F, 0xF2, 0x7E,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0xE3,
  0x80, 0x60, 0xE0, 0x70, 0x78, 0x10, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x39, 0xCC, 0xE7,
  0x31, 0x8C, 0xC6, 0x30, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xF3, 0xE0, 0x70,
  0x1C, 0x38, 0x07, 0x0C, 0x00, 0xE7, 0x00, 0x19, 0xC0, 0x06, 0x60, 0x01,
  0xD8, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07, 0x70, 0x01,
  0x9C, 0x00, 0x63, 0x00, 0x38, 0xE0, 0x0C, 0x18, 0x07, 0x07, 0x83, 0x80,
  0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xC1, 0xF0, 0xFC, 0x77, 0x39, 0xFC, 0x7E,
  0x1D, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xE0, 0x07, 0xFF, 0x03,
  0xE3, 0xE1, 0xC0, 0x3C, 0x20, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0x07,
  0xE3, 0xE3, 0xC0, 0x1C, 0x40, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x80, 0x07,
  0x38, 0x03, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00,
  0xCC, 0x00, 0x0E, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0,
  0x03, 0x06, 0x00, 0x30, 0x30, 0x03, 0x81, 0x80, 0x18, 0x0C, 0x01, 0xC0,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0x60, 0x06, 0x06,
  0x00, 0x30, 0x70, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x7F, 0xFE, 0x3F, 0xFF, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x07, 0xFF,
  0xC1, 0xC0, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xD0, 0x01, 0xCC, 0x03, 0xE7, 0xFF, 0xC1, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x3E, 0x10, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0xFF, 0x06, 0x7F, 0xF1, 0xB0,
  0x1E, 0xF8, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0x60, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x70, 0x00, 0xDC, 0x00, 0x33,
  0x00, 0x1C, 0xE0, 0x06, 0x1C, 0x03, 0x87, 0x81, 0xC0, 0xFF, 0xE0, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xF1, 0xF0, 0xE0, 0x1C, 0x30, 0x03, 0x9C, 0x00,
  0x67, 0x00, 0x19, 0xC0, 0x06, 0x70, 0x01, 0x9C, 0x00, 0x63, 0x00, 0x38,
  0xE0, 0x1C, 0x1C, 0x0E, 0x03, 0xC7, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x07,
  0xF8, 0x07, 0x87, 0x83, 0xC0, 0x70, 0xC0, 0x0E, 0x70, 0x01, 0xD8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1D,
  0x80, 0x07, 0x70, 0x03, 0x8F, 0x01, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xE0, 0x03, 0xFE, 0x01, 0xE3, 0xE0, 0xE0, 0x38, 0x70, 0x07, 0x1C, 0x00,
  0xE6, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x0F, 0x70,
  0x06, 0xCF, 0x07, 0x31, 0xFF, 0x9C, 0x1F, 0xC7, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x6F,
  0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0x33,
  0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73,
  0x39, 0xCE, 0x63, 0x39, 0x8C, 0x60, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x81, 0xFF,
  0xCF, 0x8F, 0x90, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0C,
  0x38, 0x01, 0xC0, 0x18, 0x60, 0x1F, 0xF8, 0x18, 0xC0, 0x78, 0x70, 0x33,
  0x01, 0xC0, 0x60, 0x66, 0x03, 0x01, 0xC0, 0xCC, 0x0E, 0x03, 0x81, 0x98,
  0x18, 0x07, 0x03, 0xF0, 0x30, 0x0E, 0x07, 0xE0, 0xE0, 0x18, 0x0F, 0x81,
  0xC0, 0x30, 0x1B, 0x03, 0x80, 0x60, 0x37, 0x07, 0x00, 0xC0, 0x6E, 0x06,
  0x01, 0x80, 0xCC, 0x0C, 0x07, 0x01, 0x98, 0x18, 0x0F, 0x06, 0x30, 0x18,
  0x36, 0x1C, 0x60, 0x3F, 0xC7, 0xF0, 0xE0, 0x1F, 0x07, 0xC0, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0xC3, 0x80, 0x01, 0x83, 0x80, 0x01, 0x81, 0x80,
  0x03, 0x81, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0,
  0x06, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38,
  0x38, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C,
  0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0x80, 0x3E, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x06, 0x70,
  0x01, 0xCE, 0x00, 0x71, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xE0,
  0x07, 0x9C, 0x00, 0x7B, 0x80, 0x07, 0x70, 0x00, 0x6E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x01, 0xCE, 0x01, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0x07, 0xF3, 0xF0, 0xF0, 0x02, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x02, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x38, 0x03, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0x38, 0x00, 0xF1, 0xC0, 0x0F, 0x0E, 0x03, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xE7, 0xF0,
  0x7C, 0x00, 0x61, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x71,
  0xE0, 0x00, 0xE1, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x30, 0xFF, 0x9F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC7, 0xFF, 0xFE, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x8F, 0x3F, 0x8F, 0xC0, 0xE0, 0x01, 0xFC, 0x00, 0x73, 0x80, 0x1C,
  0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x07, 0x03, 0x80,
  0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01,
  0xDE, 0x00, 0x3B, 0xE0, 0x07, 0xDC, 0x00, 0xF9, 0xC0, 0x1E, 0x38, 0x03,
  0x83, 0x80, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x07,
  0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x01, 0xCE,
  0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x38, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xEC, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x37, 0xB8,
  0x00, 0x06, 0xF3, 0x00, 0x01, 0xDE, 0x70, 0x00, 0x33, 0xCE, 0x00, 0x0E,
  0x78, 0xC0, 0x01, 0x8F, 0x1C, 0x00, 0x31, 0xE1, 0x80, 0x0E, 0x3C, 0x30,
  0x01, 0x87, 0x87, 0x00, 0x30, 0xF0, 0x60, 0x0E, 0x1E, 0x0C, 0x01, 0x83,
  0xC1, 0xC0, 0x30, 0x78, 0x18, 0x0E, 0x0F, 0x03, 0x01, 0x81, 0xE0, 0x70,
  0x30, 0x3C, 0x06, 0x0C, 0x07, 0x80, 0xE1, 0x80, 0xF0, 0x1C, 0x70, 0x1E,
  0x01, 0x8C, 0x03, 0xC0, 0x39, 0x80, 0x78, 0x03, 0x70, 0x0F, 0x00, 0x6C,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x18, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0x78, 0xC0, 0x03,
  0xC7, 0x00, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x83, 0x80, 0x3C, 0x0C,
  0x01, 0xE0, 0x70, 0x0F, 0x01, 0x80, 0x78, 0x0E, 0x03, 0xC0, 0x38, 0x1E,
  0x01, 0xC0, 0xF0, 0x07, 0x07, 0x80, 0x18, 0x3C, 0x00, 0xE1, 0xE0, 0x03,
  0x8F, 0x00, 0x1C, 0x78, 0x00, 0x73, 0xC0, 0x03, 0x9E, 0x00, 0x0E, 0xF0,
  0x00, 0x37, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x1E, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x07, 0x9C, 0x00, 0xEE, 0x00, 0x37,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x7C, 0xFF,
  0xF8, 0x7F, 0xF0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xE7, 0xE0, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0x80, 0x78, 0x70,
  0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x0C, 0xE0,
  0x01, 0x9C, 0x00, 0x33, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x31, 0xC0,
  0x0E, 0x38, 0x07, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1C, 0x0C, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00,
  0x70, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x0C, 0x70, 0x01, 0xCE, 0x00,
  0x19, 0xC0, 0x03, 0xB8, 0x00, 0x38, 0x01, 0xF8, 0x03, 0xFF, 0xC1, 0xFB,
  0xF8, 0xE0, 0x04, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x38,
  0x03, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xDC, 0x00, 0x06, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x9C, 0x00, 0x38, 0xF0,
  0x03, 0xC3, 0xC0, 0x3C, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xE0, 0x00,
  0x0E, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x70, 0x01, 0x80, 0x60, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x06,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0x80, 0x00, 0x63, 0x00, 0x00, 0xCE, 0x00, 0x01, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x1D, 0x80, 0x07, 0x80, 0x06, 0x60, 0x03, 0xE0,
  0x01, 0x9C, 0x00, 0xFC, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x38, 0xC0, 0x0C,
  0xC0, 0x0C, 0x30, 0x07, 0x38, 0x03, 0x0E, 0x01, 0xCE, 0x01, 0xC3, 0x80,
  0x61, 0x80, 0x70, 0x60, 0x18, 0x60, 0x18, 0x18, 0x0E, 0x1C, 0x06, 0x07,
  0x03, 0x87, 0x03, 0x81, 0xC0, 0xC0, 0xC0, 0xE0, 0x30, 0x30, 0x30, 0x30,
  0x0C, 0x1C, 0x0E, 0x0C, 0x03, 0x87, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x61,
  0xC0, 0x18, 0x60, 0x18, 0x60, 0x06, 0x38, 0x07, 0x18, 0x01, 0xCE, 0x01,
  0xCE, 0x00, 0x73, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x0C, 0xC0, 0x03, 0x30,
  0x03, 0xB0, 0x00, 0xDC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x06, 0x00, 0x38,
  0x38, 0x01, 0x80, 0xC0, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xE0,
  0x60, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x00, 0x01, 0xB8, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x06, 0xE0, 0x00, 0x73, 0x00, 0x03, 0x1C, 0x00, 0x38, 0x60, 0x03,
  0x83, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x70, 0x0C, 0x01, 0xC0, 0xE0, 0x0E,
  0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x07, 0x38, 0x00, 0x3B, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x18, 0x70, 0x01,
  0xC3, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x70, 0x06, 0x01, 0x80, 0x70, 0x0E,
  0x03, 0x00, 0x30, 0x38, 0x01, 0xC1, 0xC0, 0x06, 0x1C, 0x00, 0x38, 0xE0,
  0x00, 0xC6, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFC, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x00,
  0x20, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xD8, 0x00,
  0x19, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xE0, 0x03, 0x06, 0x00, 0x60, 0x70,
  0x06, 0x03, 0x00, 0xC0, 0x38, 0x0C, 0x01, 0x81, 0x80, 0x1C, 0x18, 0x00,
  0xC3, 0x00, 0x0E, 0x30, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x07, 0x01,
  0xE0, 0x1F, 0xFC, 0x3E, 0x3C, 0x10, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x7F, 0x0F, 0xFF, 0x3F,
  0x07, 0x78, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0B, 0x70, 0x3B, 0x7F, 0xF3, 0x1F, 0xC3, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x7C, 0x0C, 0xFF, 0xC3,
  0x78, 0xF8, 0xD8, 0x0F, 0x3C, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0E, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6E, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0x3C, 0x01, 0xCD, 0x80, 0xE3, 0x3F, 0xF0, 0x87,
  0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xFC, 0x3E, 0x78, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x43, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x7C, 0x30, 0xFF, 0xCC,
  0x7C, 0x7B, 0x3C, 0x06, 0xCE, 0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07, 0x60,
  0x01, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D,
  0xC0, 0x07, 0x70, 0x01, 0xCE, 0x00, 0xF1, 0xC0, 0x6C, 0x7F, 0xF3, 0x07,
  0xF8, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x70, 0x1C, 0x38,
  0x03, 0x0C, 0x00, 0xE7, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xB8, 0x00,
  0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x60, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0xE0, 0x1F, 0xC1,
  0xEE, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x01, 0xFF, 0xCF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x31, 0xF1, 0xEC, 0xF0,
  0x1B, 0x38, 0x03, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x77, 0x00, 0x1D, 0xC0,
  0x07, 0x38, 0x03, 0xC7, 0x01, 0xB0, 0xFF, 0xCC, 0x1F, 0xE3, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x80, 0x1C, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1, 0xF0, 0xCF, 0xFC, 0xDE, 0x3E, 0xD8,
  0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x6F, 0xE6, 0x00, 0x00, 0x06, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x03, 0x03, 0xC1,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0xFE, 0x7E, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x76, 0x01, 0xCC, 0x03, 0x18, 0x0E,
  0x30, 0x38, 0x60, 0xE0, 0xC3, 0x81, 0x86, 0x03, 0x1C, 0x06, 0x70, 0x0D,
  0xF0, 0x1F, 0x60, 0x3C, 0xE0, 0x70, 0xE0, 0xC1, 0xC1, 0x81, 0xC3, 0x01,
  0x86, 0x03, 0x8C, 0x03, 0x98, 0x07, 0x30, 0x07, 0x60, 0x07, 0xC0, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x1E,
  0x0C, 0xFF, 0x87, 0xFC, 0xDE, 0x78, 0xF3, 0xEF, 0x01, 0xD8, 0x0E, 0xE0,
  0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0E, 0x00, 0x7C, 0x00, 0x60,
  0x07, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x01, 0xE0, 0xC7,
  0xFC, 0xDE, 0x3E, 0xD8, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x01, 0xF0, 0x00,
  0xFF, 0xC0, 0x7C, 0x7C, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0x9C,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x60,
  0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x80, 0x38, 0x38,
  0x0E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF0, 0x31, 0xFF, 0x0D, 0xE3,
  0xE3, 0x60, 0x3C, 0xF0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x3B, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x1C, 0xF0, 0x07, 0x36, 0x03, 0x8C, 0xFF, 0xC3, 0x1F, 0xE0,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xF0, 0x03, 0xFE, 0x31, 0xF1, 0xEC, 0xF0, 0x1B, 0x38, 0x03, 0xDC, 0x00,
  0x77, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0x60,
  0x01, 0xD8, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x38, 0x02, 0xC7, 0x03,
  0xB1, 0xFF, 0xCC, 0x1F, 0xE3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x03, 0xF9, 0xFF, 0x7F, 0xEC, 0x0F, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x07, 0xE0, 0x3F, 0xF9, 0xF1, 0xF3, 0x80, 0x2E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xD8, 0x07, 0xBF, 0xFE, 0x3F, 0xF0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x3F, 0xFF, 0xFF, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07,
  0xF0, 0x7E, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xD8, 0x01, 0xEE, 0x01, 0xB7, 0x81, 0xD9, 0xFF,
  0xCC, 0x7F, 0x86, 0xE0, 0x01, 0xD8, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E,
  0x30, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x30, 0x60, 0x1C, 0x1C, 0x06, 0x07,
  0x01, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0E, 0x0C, 0x01, 0x87, 0x00, 0x61,
  0x80, 0x1C, 0x60, 0x03, 0x38, 0x00, 0xCC, 0x00, 0x3B, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x7E, 0x00,
  0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x66, 0x01, 0xF0, 0x06, 0x60, 0x1B, 0x80,
  0xE7, 0x01, 0x98, 0x0E, 0x70, 0x19, 0x80, 0xC3, 0x03, 0x98, 0x0C, 0x30,
  0x31, 0xC1, 0xC3, 0x83, 0x0C, 0x18, 0x38, 0x70, 0xC1, 0x81, 0x87, 0x0E,
  0x18, 0x18, 0x60, 0xE3, 0x81, 0xC6, 0x06, 0x30, 0x1C, 0xE0, 0x63, 0x00,
  0xCC, 0x07, 0x30, 0x0C, 0xC0, 0x37, 0x00, 0xCC, 0x03, 0x60, 0x0F, 0xC0,
  0x36, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x9C, 0x01, 0xC3, 0x80, 0x70, 0x60,
  0x38, 0x1C, 0x0C, 0x03, 0x87, 0x00, 0x63, 0x80, 0x1C, 0xC0, 0x03, 0x70,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xDC, 0x00,
  0x73, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x07, 0x03, 0x01, 0x80, 0xE0, 0xE0,
  0x1C, 0x70, 0x07, 0x1C, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x00, 0xEC, 0x00,
  0x39, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x70, 0x07, 0x06, 0x00,
  0xC0, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x38, 0x07, 0x07,
  0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x38,
  0x00, 0x77, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8,
  0x0F, 0xC0, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x3E, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x3E, 0x00, 0xF0, 0x1F, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0xF8, 0x0E, 0x00, 0x1E, 0x00, 0x2F,
  0xF8, 0x0F, 0x87, 0xC7, 0xC0, 0x3F, 0xE8, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Light44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 31, 10, 3, -31 },
  { 17, 10, 11, 16, 3, -31 },
  { 31, 23, 31, 25, 1, -31 },
  { 121, 18, 36, 23, 2, -33 },
  { 202, 28, 32, 33, 2, -32 },
  { 314, 24, 32, 27, 2, -32 },
  { 410, 3, 11, 8, 3, -31 },
  { 415, 9, 38, 12, 2, -31 },
  { 458, 9, 38, 12, 1, -31 },
  { 501, 17, 16, 21, 2, -33 },
  { 535, 19, 21, 23, 2, -26 },
  { 585, 5, 11, 10, 2, -5 },
  { 592, 10, 2, 13, 2, -13 },
  { 595, 4, 4, 10, 3, -4 },
  { 597, 14, 31, 15, 1, -31 },
  { 652, 18, 32, 23, 2, -32 },
  { 724, 10, 31, 23, 4, -31 },
  { 763, 18, 32, 23, 2, -32 },
  { 835, 18, 32, 23, 2, -32 },
  { 907, 21, 32, 23, 1, -32 },
  { 991, 17, 31, 23, 3, -31 },
  { 1057, 18, 32, 23, 2, -32 },
  { 1129, 18, 31, 23, 2, -31 },
  { 1199, 18, 32, 23, 2, -32 },
  { 1271, 18, 32, 23, 2, -32 },
  { 1343, 4, 24, 10, 3, -24 },
  { 1355, 5, 30, 10, 2, -24 },
  { 1374, 19, 20, 23, 2, -26 },
  { 1422, 19, 11, 23, 2, -21 },
  { 1449, 19, 20, 23, 2, -26 },
  { 1497, 14, 32, 17, 1, -32 },
  { 1553, 31, 35, 35, 2, -31 },
  { 1689, 24, 32, 24, 0, -32 },
  { 1785, 19, 31, 25, 4, -31 },
  { 1859, 20, 32, 24, 3, -32 },
  { 1939, 21, 31, 28, 4, -31 },
  { 2021, 15, 31, 22, 4, -31 },
  { 2080, 15, 31, 20, 4, -31 },
  { 2139, 23, 32, 29, 3, -32 },
  { 2231, 20, 31, 28, 4, -31 },
  { 2309, 9, 31, 13, 2, -31 },
  { 2344, 10, 39, 10, -3, -31 },
  { 2393, 19, 31, 23, 4, -31 },
  { 2467, 15, 31, 20, 4, -31 },
  { 2526, 27, 31, 35, 4, -31 },
  { 2631, 21, 31, 29, 4, -31 },
  { 2713, 24, 32, 30, 3, -32 },
  { 2809, 17, 31, 23, 4, -31 },
  { 2875, 24, 39, 30, 3, -32 },
  { 2992, 19, 31, 24, 4, -31 },
  { 3066, 18, 32, 22, 2, -32 },
  { 3138, 20, 31, 21, 0, -31 },
  { 3216, 21, 31, 28, 4, -31 },
  { 3298, 23, 31, 23, 0, -31 },
  { 3388, 34, 31, 36, 1, -31 },
  { 3520, 21, 31, 21, 0, -31 },
  { 3602, 21, 31, 21, 0, -31 },
  { 3684, 19, 31, 22, 1, -31 },
  { 3758, 9, 38, 14, 4, -31 },
  { 3801, 14, 31, 15, 1, -31 },
  { 3856, 9, 38, 14, 1, -31 },
  { 3899, 20, 19, 23, 1, -32 },
  { 3947, 18, 2, 18, 0, 4 },
  { 3952, 8, 7, 11, 2, -34 },
  { 3959, 16, 24, 21, 2, -24 },
  { 4007, 18, 33, 24, 4, -33 },
  { 4082, 15, 24, 19, 2, -24 },
  { 4127, 18, 33, 24, 2, -33 },
  { 4202, 18, 24, 22, 2, -24 },
  { 4256, 13, 34, 12, 1, -34 },
  { 4312, 18, 35, 24, 2, -24 },
  { 4391, 16, 33, 24, 4, -33 },
  { 4457, 4, 32, 10, 3, -32 },
  { 4473, 9, 43, 10, -2, -32 },
  { 4522, 15, 33, 20, 4, -33 },
  { 4584, 2, 33, 10, 4, -33 },
  { 4593, 28, 24, 35, 4, -24 },
  { 4677, 16, 24, 24, 4, -24 },
  { 4725, 19, 24, 23, 2, -24 },
  { 4782, 18, 34, 24, 4, -24 },
  { 4859, 18, 34, 24, 2, -24 },
  { 4936, 11, 24, 16, 4, -24 },
  { 4969, 15, 24, 18, 2, -24 },
  { 5014, 11, 29, 13, 1, -29 },
  { 5054, 17, 23, 24, 3, -23 },
  { 5103, 18, 23, 18, 0, -23 },
  { 5155, 28, 23, 30, 1, -23 },
  { 5236, 18, 23, 20, 1, -23 },
  { 5288, 19, 34, 19, 0, -23 },
  { 5369, 14, 23, 17, 2, -23 },
  { 5410, 13, 38, 16, 1, -31 },
  { 5472, 2, 45, 21, 10, -34 },
  { 5484, 12, 38, 16, 2, -31 },
  { 5541, 19, 5, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Light44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT44PT7B_H_
