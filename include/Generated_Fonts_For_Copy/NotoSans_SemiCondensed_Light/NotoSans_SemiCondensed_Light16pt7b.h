#ifndef _NOTOSANS_SEMICONDENSED_LIGHT16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light16pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x0C, 0x99, 0x99, 0x12, 0x09, 0x04, 0x8F, 0xF1, 0x21,
  0x10, 0x91, 0xFE, 0x24, 0x12, 0x09, 0x00, 0x21, 0xFA, 0x28, 0xA1, 0x81,
  0x89, 0x24, 0x9E, 0xCC, 0x20, 0x60, 0x24, 0x49, 0x22, 0x48, 0x94, 0x25,
  0x69, 0xA5, 0xA9, 0x12, 0x44, 0x92, 0x24, 0x86, 0x30, 0x24, 0x11, 0x09,
  0x04, 0x81, 0x81, 0x41, 0x12, 0x85, 0x43, 0x21, 0x8F, 0x30, 0xF0, 0x6A,
  0x49, 0x24, 0x92, 0x24, 0x40, 0x89, 0x22, 0x49, 0x29, 0x29, 0x00, 0x20,
  0x8D, 0xCC, 0x51, 0x20, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0xF0, 0xE0,
  0xC0, 0x08, 0x44, 0x21, 0x10, 0x88, 0x42, 0x20, 0x31, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x14, 0x5E, 0x35, 0x91, 0x11, 0x11, 0x11, 0x10, 0x33,
  0x20, 0x41, 0x04, 0x20, 0x84, 0x21, 0x08, 0x3F, 0x33, 0x20, 0x41, 0x04,
  0x67, 0x81, 0x04, 0x10, 0x7E, 0x04, 0x0C, 0x14, 0x14, 0x24, 0x44, 0x44,
  0xFF, 0x04, 0x04, 0x04, 0xFE, 0x08, 0x20, 0xF8, 0x10, 0x41, 0x04, 0x1F,
  0x80, 0x1D, 0x84, 0x20, 0x82, 0xEC, 0x61, 0x86, 0x14, 0x5E, 0xFC, 0x10,
  0x42, 0x08, 0x41, 0x04, 0x20, 0x84, 0x00, 0x31, 0x38, 0x61, 0xC5, 0xE7,
  0xA1, 0x86, 0x18, 0x5E, 0x31, 0x28, 0x61, 0x86, 0x1C, 0xCD, 0x04, 0x10,
  0xBC, 0xB0, 0x00, 0xC0, 0xB0, 0x02, 0xA8, 0x06, 0x31, 0x84, 0x06, 0x03,
  0x80, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x60, 0x20, 0x31, 0x8C, 0x20, 0x00,
  0x33, 0x20, 0x41, 0x08, 0x21, 0x08, 0x20, 0x00, 0x08, 0x3F, 0x88, 0x09,
  0x01, 0x47, 0x99, 0x13, 0x22, 0x64, 0x4C, 0x99, 0x9D, 0xD0, 0x01, 0x00,
  0x1F, 0x80, 0x08, 0x0A, 0x05, 0x04, 0x82, 0x41, 0x10, 0xF8, 0x84, 0x41,
  0x40, 0xA0, 0x60, 0xFD, 0x06, 0x0C, 0x18, 0x5F, 0xA0, 0xC1, 0x83, 0x07,
  0xF0, 0x0C, 0x65, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x01, 0xF0,
  0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x82, 0xFC, 0xFE,
  0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83,
  0xF8, 0x20, 0x82, 0x08, 0x00, 0x0E, 0x31, 0x40, 0x80, 0x80, 0x80, 0x87,
  0x81, 0x81, 0x41, 0x41, 0x3F, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x4B, 0x80, 0x24, 0x92, 0x49,
  0x24, 0x93, 0x80, 0x87, 0x0A, 0x24, 0x8A, 0x1A, 0x26, 0x44, 0x85, 0x0A,
  0x08, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC0, 0x68,
  0x3A, 0x0E, 0x83, 0x91, 0x64, 0x59, 0x26, 0x29, 0x8A, 0x63, 0x18, 0x44,
  0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x83, 0x83, 0x81, 0x1C,
  0x11, 0x10, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x90, 0x47,
  0xC0, 0xFD, 0x0E, 0x0C, 0x18, 0x5F, 0xA0, 0x40, 0x81, 0x02, 0x00, 0x1C,
  0x11, 0x10, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x90, 0x47,
  0xC0, 0x40, 0x10, 0x04, 0xFD, 0x06, 0x0C, 0x18, 0x5F, 0x22, 0x44, 0x85,
  0x0A, 0x08, 0x39, 0x18, 0x20, 0x81, 0x81, 0x81, 0x04, 0x10, 0x7E, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x81, 0x41, 0x42, 0x42,
  0x22, 0x24, 0x24, 0x24, 0x18, 0x18, 0x18, 0x82, 0x0A, 0x10, 0x91, 0x44,
  0x8A, 0x24, 0x51, 0x12, 0x50, 0xA2, 0x85, 0x14, 0x28, 0xA0, 0x82, 0x04,
  0x10, 0xC2, 0x44, 0x24, 0x28, 0x18, 0x18, 0x18, 0x24, 0x44, 0x42, 0x83,
  0x83, 0x42, 0x44, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC,
  0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x0F, 0xC0, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x8F, 0xC2, 0x10, 0x42, 0x10, 0x42, 0x10, 0x42, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x1F, 0x30, 0x61, 0x22, 0x48, 0x50, 0xC0, 0xFE,
  0x90, 0x72, 0x20, 0x41, 0x7E, 0x18, 0x63, 0xF4, 0x81, 0x02, 0x05, 0xCC,
  0x50, 0x60, 0xC1, 0x83, 0x07, 0x15, 0xE0, 0x3A, 0x21, 0x08, 0x42, 0x10,
  0x78, 0x04, 0x10, 0x4D, 0x4E, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x31, 0x28,
  0x61, 0xFE, 0x08, 0x20, 0x7C, 0x39, 0x09, 0xE2, 0x10, 0x84, 0x21, 0x08,
  0x40, 0x35, 0x38, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10, 0x61, 0x78, 0x82,
  0x08, 0x2E, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x61, 0xDF, 0xF0, 0x24, 0x12,
  0x49, 0x24, 0x92, 0x4E, 0x82, 0x08, 0x21, 0x8A, 0x4A, 0x28, 0xD2, 0x28,
  0xA1, 0xFF, 0xF0, 0xB9, 0x99, 0xCA, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61,
  0x0C, 0x21, 0x84, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x38,
  0x8A, 0x14, 0x18, 0x30, 0x61, 0x42, 0x78, 0xB9, 0x8B, 0x0C, 0x18, 0x30,
  0x60, 0xE2, 0xBD, 0x02, 0x04, 0x08, 0x00, 0x35, 0x38, 0x61, 0x86, 0x18,
  0x61, 0x7C, 0x10, 0x41, 0x04, 0xBC, 0xC8, 0x88, 0x88, 0x80, 0x74, 0x61,
  0x06, 0x0C, 0x21, 0xF0, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x30, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x7C, 0x83, 0x09, 0x12, 0x24, 0x85, 0x0A, 0x18,
  0x10, 0x84, 0x30, 0x89, 0x29, 0x25, 0x24, 0xA4, 0xA5, 0x0C, 0x61, 0x8C,
  0x31, 0x80, 0x82, 0x88, 0xA1, 0x41, 0x05, 0x0A, 0x22, 0xC6, 0x83, 0x09,
  0x12, 0x24, 0x85, 0x0A, 0x18, 0x10, 0x20, 0x81, 0x0C, 0x00, 0xF8, 0x44,
  0x42, 0x21, 0x10, 0xF8, 0x34, 0x44, 0x44, 0x84, 0x44, 0x44, 0x21, 0xFF,
  0xFF, 0xC4, 0x44, 0x42, 0x12, 0x44, 0x44, 0x48, 0x43, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_Light16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 9, 11, 9, 0, -11 },
  { 19, 6, 13, 8, 1, -12 },
  { 29, 10, 12, 12, 1, -12 },
  { 44, 9, 12, 10, 1, -12 },
  { 58, 1, 4, 3, 1, -11 },
  { 59, 3, 14, 4, 1, -11 },
  { 65, 3, 14, 4, 1, -11 },
  { 71, 6, 6, 8, 1, -12 },
  { 76, 6, 7, 8, 1, -9 },
  { 82, 1, 4, 3, 1, -2 },
  { 83, 3, 1, 5, 1, -5 },
  { 84, 2, 1, 4, 1, -1 },
  { 85, 5, 11, 6, 0, -11 },
  { 92, 6, 12, 8, 1, -12 },
  { 101, 4, 11, 8, 1, -11 },
  { 107, 6, 12, 8, 1, -12 },
  { 116, 6, 12, 8, 1, -12 },
  { 125, 8, 11, 8, 0, -11 },
  { 136, 6, 11, 8, 1, -11 },
  { 145, 6, 12, 8, 1, -12 },
  { 154, 6, 11, 8, 1, -11 },
  { 163, 6, 12, 8, 1, -12 },
  { 172, 6, 12, 8, 1, -12 },
  { 181, 2, 9, 4, 1, -9 },
  { 184, 2, 11, 4, 1, -9 },
  { 187, 7, 7, 8, 1, -9 },
  { 194, 6, 4, 8, 1, -8 },
  { 197, 7, 7, 8, 1, -9 },
  { 204, 6, 12, 6, 0, -12 },
  { 213, 11, 12, 13, 1, -11 },
  { 230, 9, 11, 9, 0, -11 },
  { 243, 7, 11, 9, 1, -11 },
  { 253, 7, 12, 9, 1, -12 },
  { 264, 8, 11, 10, 1, -11 },
  { 275, 6, 11, 8, 1, -11 },
  { 284, 6, 11, 7, 1, -11 },
  { 293, 8, 12, 10, 1, -12 },
  { 305, 8, 11, 10, 1, -11 },
  { 316, 3, 11, 5, 1, -11 },
  { 321, 3, 14, 4, -1, -11 },
  { 327, 7, 11, 8, 1, -11 },
  { 337, 6, 11, 7, 1, -11 },
  { 346, 10, 11, 13, 1, -11 },
  { 360, 8, 11, 11, 1, -11 },
  { 371, 9, 12, 11, 1, -12 },
  { 385, 7, 11, 8, 1, -11 },
  { 395, 9, 15, 11, 1, -12 },
  { 412, 7, 11, 9, 1, -11 },
  { 422, 6, 12, 8, 1, -12 },
  { 431, 7, 11, 7, 0, -11 },
  { 441, 8, 11, 10, 1, -11 },
  { 452, 8, 11, 8, 0, -11 },
  { 463, 13, 11, 13, 0, -11 },
  { 481, 8, 11, 8, 0, -11 },
  { 492, 8, 11, 8, 0, -11 },
  { 503, 6, 11, 8, 1, -11 },
  { 512, 4, 14, 5, 1, -11 },
  { 519, 5, 11, 6, 0, -11 },
  { 526, 4, 14, 5, 0, -11 },
  { 533, 7, 6, 8, 1, -11 },
  { 539, 7, 1, 7, 0, 1 },
  { 540, 2, 2, 4, 1, -12 },
  { 541, 6, 9, 8, 1, -9 },
  { 548, 7, 12, 9, 1, -12 },
  { 559, 5, 9, 7, 1, -9 },
  { 565, 6, 12, 9, 1, -12 },
  { 574, 6, 9, 8, 1, -9 },
  { 581, 5, 12, 5, 0, -12 },
  { 589, 6, 13, 9, 1, -9 },
  { 599, 6, 12, 9, 1, -12 },
  { 608, 1, 12, 3, 1, -12 },
  { 610, 3, 16, 3, -1, -12 },
  { 616, 6, 12, 7, 1, -12 },
  { 625, 1, 12, 3, 1, -12 },
  { 627, 11, 9, 13, 1, -9 },
  { 640, 6, 9, 9, 1, -9 },
  { 647, 7, 9, 8, 1, -9 },
  { 655, 7, 13, 9, 1, -9 },
  { 667, 6, 13, 9, 1, -9 },
  { 677, 4, 9, 6, 1, -9 },
  { 682, 5, 9, 7, 1, -9 },
  { 688, 4, 11, 5, 0, -11 },
  { 694, 6, 9, 9, 1, -9 },
  { 701, 7, 9, 7, 0, -9 },
  { 709, 11, 9, 11, 0, -9 },
  { 722, 7, 9, 7, 0, -9 },
  { 730, 7, 13, 7, 0, -9 },
  { 742, 5, 9, 6, 1, -9 },
  { 748, 4, 14, 6, 1, -11 },
  { 755, 1, 16, 8, 3, -12 },
  { 757, 4, 14, 6, 1, -11 },
  { 764, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Light16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT16PT7B_H_
