#ifndef _NOTOSANS_SEMICONDENSED_LIGHT36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light36pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x07, 0xFC, 0xE3,
  0xE3, 0xE3, 0x43, 0x43, 0x43, 0x43, 0x43, 0x43, 0x41, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x04, 0x08, 0x01, 0x81, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00,
  0xC1, 0x80, 0x10, 0x30, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x18, 0x30, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x02, 0x00, 0x60, 0x40, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF8, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x00, 0x30,
  0x20, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0xFC, 0x0F, 0xFE, 0x73, 0x1B, 0x8C, 0x0C, 0x30, 0x30,
  0xC0, 0xC3, 0x03, 0x0C, 0x0E, 0x30, 0x1C, 0xC0, 0x3F, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0x38, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C,
  0x0C, 0x30, 0x31, 0xF0, 0xCE, 0xFF, 0xF0, 0x7E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x3E, 0x00, 0xC0, 0xEE, 0x01, 0x81, 0x8C, 0x06, 0x06, 0x0C,
  0x0C, 0x0C, 0x18, 0x10, 0x18, 0x30, 0x60, 0x30, 0x60, 0x80, 0x60, 0xC3,
  0x00, 0xC1, 0x84, 0x01, 0x83, 0x18, 0x03, 0x06, 0x31, 0xC6, 0x0C, 0xCF,
  0xCC, 0x19, 0x98, 0xCC, 0x66, 0x61, 0x9F, 0xCC, 0xC1, 0x9E, 0x31, 0x03,
  0x00, 0x62, 0x06, 0x01, 0x84, 0x0C, 0x03, 0x08, 0x18, 0x0C, 0x10, 0x30,
  0x18, 0x20, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC1, 0x01, 0x01, 0x86, 0x06,
  0x01, 0x9C, 0x18, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x18, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x38, 0x03, 0x03,
  0x00, 0x18, 0x30, 0x01, 0xC6, 0x00, 0x0D, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x00, 0x31, 0xC0, 0xE6, 0x0E, 0x0C, 0xE0, 0x70, 0xCC,
  0x03, 0x0C, 0xC0, 0x19, 0x8C, 0x00, 0xD8, 0xC0, 0x0F, 0x0C, 0x00, 0x70,
  0xE0, 0x0F, 0x87, 0x01, 0xDC, 0x3F, 0xF0, 0xC1, 0xFE, 0x07, 0xFF, 0xA4,
  0x92, 0x48, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30, 0x61, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60,
  0xC0, 0xC1, 0x81, 0x83, 0x03, 0x03, 0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x03,
  0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0xC2, 0x0B, 0xEB, 0xF3, 0xFE, 0x01, 0xC0,
  0x0D, 0x80, 0x33, 0x01, 0x8C, 0x0E, 0x18, 0x30, 0x70, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x39, 0x8C, 0x66, 0x31, 0x88, 0xC0, 0xFF,
  0xFF, 0xC0, 0xDF, 0x00, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0xE0, 0xC1, 0x80, 0xC6,
  0x01, 0x8C, 0x01, 0xB8, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x1C, 0x06, 0x18,
  0x18, 0x1F, 0xF0, 0x1F, 0xC0, 0x03, 0x07, 0x0F, 0x1B, 0x73, 0xE3, 0x43,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F, 0xC1, 0xFF, 0x8E, 0x07,
  0x10, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xCE, 0x03, 0xA0, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x78, 0x1F, 0x80, 0x7F, 0x80, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xA0, 0x0E, 0xF9,
  0xF1, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0C,
  0x03, 0x06, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0,
  0x30, 0x60, 0x18, 0x60, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F,
  0xF8, 0xFF, 0xE2, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x20, 0x1F, 0xF8, 0x70, 0xF0, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xA0, 0x0E, 0xF9, 0xF1, 0xFF, 0x00, 0x01, 0xF8, 0x0F,
  0xF0, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x1F, 0x86, 0x7F, 0x8D, 0x83, 0x9E, 0x03, 0xB8,
  0x03, 0x60, 0x06, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x36, 0x00,
  0xCC, 0x01, 0x9C, 0x03, 0x1C, 0x0C, 0x1E, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0F,
  0xC0, 0x7F, 0xE0, 0xC0, 0xE3, 0x00, 0xC6, 0x00, 0xDC, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x18, 0x60, 0x70, 0xE1, 0xC0, 0x7F, 0x00, 0x78, 0x03,
  0xFC, 0x0E, 0x1C, 0x38, 0x0C, 0xE0, 0x0D, 0x80, 0x1B, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xB8, 0x03, 0x30, 0x0C, 0x3C, 0xF8, 0x3F, 0xC0,
  0x0F, 0xC0, 0xFF, 0x87, 0x07, 0x18, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1D, 0x80,
  0xF3, 0xDE, 0xC7, 0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x63, 0xC1, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xDF, 0x80, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x31, 0x9C, 0xC6, 0x31, 0x18, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00,
  0x40, 0x00, 0x3F, 0x1F, 0xFB, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x60, 0x18, 0x06, 0x60, 0x3F, 0x83, 0x30, 0x70, 0x41, 0x90, 0x30, 0x20,
  0x58, 0x30, 0x10, 0x3C, 0x18, 0x18, 0x1E, 0x0C, 0x0C, 0x0F, 0x04, 0x06,
  0x07, 0x86, 0x03, 0x03, 0xC1, 0x01, 0x81, 0x60, 0x80, 0xC1, 0xB0, 0x60,
  0xE0, 0xD8, 0x30, 0x58, 0xCC, 0x0F, 0xEF, 0xE3, 0x03, 0xE3, 0xC1, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x10, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00,
  0x46, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03,
  0x07, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x03, 0x00, 0x70, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0xFF,
  0xC0, 0xFF, 0xF0, 0xC0, 0x3C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0xF8, 0xFF,
  0xC0, 0xC0, 0xF8, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF,
  0xF8, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xC0, 0x43, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x01, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xFC, 0x0C, 0x07, 0xC3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00,
  0xCC, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x03, 0x30, 0x01,
  0xCC, 0x00, 0xE3, 0x00, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x7F, 0xFB, 0xFF, 0xD8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3C, 0x03, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x33,
  0x00, 0x06, 0x70, 0x00, 0xC7, 0x00, 0x18, 0x70, 0x03, 0x07, 0xEF, 0xE0,
  0x3F, 0xF8, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0xFF, 0xFC,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x79, 0xFC, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x07, 0x8E, 0xFC, 0x30, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C,
  0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xE0, 0xC1, 0xC0, 0xC3, 0x80,
  0xC3, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xDE, 0x00, 0xFF, 0x00, 0xF3, 0x80,
  0xE1, 0x80, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30,
  0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xBD, 0x80, 0x03, 0x7B, 0x00, 0x06, 0xF3, 0x00,
  0x19, 0xE6, 0x00, 0x33, 0xCC, 0x00, 0x67, 0x8C, 0x01, 0x8F, 0x18, 0x03,
  0x1E, 0x30, 0x06, 0x3C, 0x30, 0x18, 0x78, 0x60, 0x30, 0xF0, 0xC0, 0x41,
  0xE0, 0xC1, 0x83, 0xC1, 0x83, 0x07, 0x83, 0x0C, 0x0F, 0x03, 0x18, 0x1E,
  0x06, 0x30, 0x3C, 0x06, 0xC0, 0x78, 0x0D, 0x80, 0xF0, 0x1B, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x60, 0x0C, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x1E, 0xE0, 0x0F, 0x30, 0x07, 0x9C,
  0x03, 0xC6, 0x01, 0xE1, 0x80, 0xF0, 0xC0, 0x78, 0x30, 0x3C, 0x1C, 0x1E,
  0x06, 0x0F, 0x01, 0x87, 0x80, 0xC3, 0xC0, 0x31, 0xE0, 0x1C, 0xF0, 0x06,
  0x78, 0x03, 0x9C, 0x00, 0xCE, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1E, 0x03, 0x81,
  0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0x63, 0x00, 0x0E, 0x38,
  0x01, 0xC1, 0xC0, 0x38, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x03, 0xFF,
  0x8C, 0x07, 0xB0, 0x06, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3B, 0x03, 0xCF, 0xFE, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x1E, 0x03, 0x81, 0x80, 0x1C, 0x30, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0x63,
  0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0xFF, 0x80, 0xFF, 0xF0, 0xC0, 0x78, 0xC0, 0x18, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x18, 0xC0, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0,
  0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x07, 0x0F, 0xF0, 0xFF, 0xF7, 0x00,
  0x98, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xA0,
  0x0E, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x19,
  0xC0, 0x0C, 0x70, 0x1C, 0x1F, 0x7C, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0xFC,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0xE1, 0x80, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06,
  0x18, 0x00, 0xE3, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x6C, 0x00, 0xF0,
  0x06, 0x60, 0x0B, 0x00, 0x66, 0x01, 0xB0, 0x06, 0x60, 0x1B, 0x00, 0xC6,
  0x01, 0x98, 0x0C, 0x30, 0x19, 0x80, 0xC3, 0x03, 0x18, 0x0C, 0x30, 0x31,
  0x81, 0x83, 0x03, 0x0C, 0x18, 0x18, 0x30, 0xC1, 0x81, 0x86, 0x0C, 0x18,
  0x18, 0x60, 0xC3, 0x01, 0x86, 0x06, 0x30, 0x0C, 0x60, 0x63, 0x00, 0xCC,
  0x06, 0x30, 0x0C, 0xC0, 0x66, 0x00, 0xCC, 0x03, 0x60, 0x06, 0xC0, 0x36,
  0x00, 0x78, 0x03, 0x60, 0x07, 0x80, 0x34, 0x00, 0x78, 0x01, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x98, 0x01, 0x8C, 0x01,
  0xC3, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x60, 0x0C, 0x30, 0x06,
  0x30, 0x01, 0x98, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0x06, 0xE0, 0x07, 0x30, 0x03, 0x1C, 0x03, 0x06, 0x01, 0x83,
  0x81, 0x80, 0xC0, 0xC0, 0x30, 0xC0, 0x18, 0xE0, 0x06, 0x60, 0x03, 0x70,
  0x00, 0xC0, 0xC0, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xC6, 0x00, 0xC3, 0x00,
  0x61, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x38, 0x0C, 0x18, 0x06, 0x1C, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xFE,
  0xFF, 0xFC, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x3F, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0xFF, 0xFC, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0xFF, 0x01, 0x80, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F,
  0xE3, 0xC7, 0x90, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x0F, 0xF9, 0xF0, 0xDC, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x5B, 0x9E, 0xCF, 0xC6, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x80, 0xCF, 0xE1, 0xB8,
  0xE3, 0xC0, 0x67, 0x00, 0xEE, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xD8, 0x01, 0xB8,
  0x03, 0x70, 0x0C, 0xF0, 0x39, 0xB9, 0xE2, 0x3F, 0x80, 0x00, 0x80, 0xFF,
  0x1C, 0x33, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x1E, 0xF0, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x83, 0x1F, 0xE6, 0x78, 0xED, 0xC0, 0x5B,
  0x00, 0x76, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xD8, 0x03, 0xB0, 0x0F,
  0x70, 0x16, 0x79, 0xCC, 0x7F, 0x18, 0x01, 0x00, 0x3F, 0x83, 0xC7, 0x0C,
  0x0E, 0x60, 0x19, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x11, 0xE7, 0x83, 0xFE, 0x00, 0xC0, 0x7F, 0x0E, 0x20, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFC, 0xFF, 0xC0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x01,
  0x00, 0x3F, 0xCC, 0xF1, 0xDB, 0x80, 0xB6, 0x00, 0xEC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xB0, 0x07, 0x60, 0x1E, 0xE0, 0x2C, 0xF1, 0x98, 0xFE,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0D, 0x00, 0x39,
  0xC1, 0xE3, 0xFF, 0x80, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x40, 0xCF, 0xE3, 0x71, 0xCF,
  0x03, 0xB8, 0x06, 0xE0, 0x1B, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x1B, 0xEE, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x36, 0x03, 0x30, 0x31, 0x83, 0x0C,
  0x38, 0x63, 0x83, 0x18, 0x19, 0x80, 0xDC, 0x07, 0xB0, 0x39, 0xC1, 0xC6,
  0x0C, 0x18, 0x60, 0xE3, 0x03, 0x18, 0x1C, 0xC0, 0x66, 0x01, 0xB0, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x41, 0x9F, 0x87,
  0xF3, 0x63, 0x9C, 0x77, 0x81, 0xE0, 0x7E, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x06, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x07, 0x80, 0x30, 0x0F,
  0x00, 0x60, 0x1E, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x03, 0x00, 0xF0,
  0x06, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x07, 0x80, 0x30, 0x0F, 0x00,
  0x60, 0x1E, 0x00, 0xC0, 0x30, 0x01, 0x03, 0x3F, 0x8D, 0xC7, 0x3C, 0x0E,
  0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x01, 0x00, 0x1F, 0xC0, 0xF1, 0xE1, 0x80, 0xC6,
  0x00, 0xCC, 0x01, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xB0, 0x06, 0x60, 0x0C,
  0x60, 0x30, 0x7B, 0xC0, 0x7F, 0x00, 0x01, 0x01, 0x9F, 0xC3, 0x71, 0xC7,
  0x80, 0xCE, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xB0, 0x03, 0x70, 0x06,
  0xE0, 0x1D, 0xE0, 0x73, 0x7B, 0xC6, 0x7F, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x3F, 0xCC, 0xF1, 0xDB, 0x80, 0xB6, 0x01, 0xEC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0x60, 0x1E, 0xE0, 0x6C, 0xF3,
  0x98, 0xFE, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0xCF, 0xEE, 0x7C, 0x1C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x03, 0x00, 0xFF, 0x8E, 0x1C, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x34, 0x01, 0xBE,
  0x78, 0xFF, 0x80, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x07, 0xFF, 0xFE, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x72, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x6B, 0xCE, 0x4F,
  0xE2, 0xC0, 0x06, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x63, 0x01, 0x86, 0x03,
  0x0C, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x31, 0x80, 0x63, 0x00,
  0xC6, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x02, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x18, 0x03, 0x60, 0x1C, 0x06, 0x60, 0x3C, 0x06, 0x60, 0x3C,
  0x06, 0x30, 0x36, 0x06, 0x30, 0x26, 0x0C, 0x30, 0x66, 0x0C, 0x30, 0x62,
  0x0C, 0x18, 0x63, 0x0C, 0x18, 0xC3, 0x18, 0x18, 0xC3, 0x18, 0x18, 0xC1,
  0x18, 0x0C, 0x81, 0x98, 0x0D, 0x81, 0xB0, 0x0D, 0x81, 0xB0, 0x0D, 0x80,
  0xB0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0xE0, 0x1D,
  0x80, 0x63, 0x03, 0x0C, 0x1C, 0x18, 0x60, 0x33, 0x80, 0xCC, 0x01, 0xE0,
  0x07, 0x80, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x0C, 0xC0, 0x61, 0x83, 0x86,
  0x0C, 0x0C, 0x60, 0x19, 0x80, 0x6C, 0x00, 0xC0, 0xE0, 0x06, 0xC0, 0x1D,
  0x80, 0x33, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x0E, 0x06, 0x0C, 0x0C, 0x18,
  0x30, 0x10, 0x60, 0x30, 0xC0, 0x63, 0x00, 0x46, 0x00, 0xCC, 0x01, 0xB0,
  0x01, 0x60, 0x03, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x03, 0xE0, 0x03, 0x80,
  0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0xF0, 0x70, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0x83, 0xC0, 0xF0, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x3E, 0x06, 0x00, 0x18, 0x01, 0xFE, 0x07, 0x0F, 0xFC, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Light36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 26, 8, 3, -26 },
  { 11, 8, 10, 13, 2, -26 },
  { 21, 19, 26, 21, 1, -26 },
  { 83, 14, 29, 18, 2, -27 },
  { 134, 23, 26, 27, 2, -26 },
  { 209, 20, 26, 22, 2, -26 },
  { 274, 3, 10, 7, 2, -26 },
  { 278, 7, 32, 10, 2, -26 },
  { 306, 7, 32, 10, 1, -26 },
  { 334, 14, 13, 17, 2, -27 },
  { 357, 15, 17, 19, 2, -21 },
  { 389, 5, 9, 8, 1, -4 },
  { 395, 9, 2, 11, 1, -11 },
  { 398, 3, 3, 8, 3, -3 },
  { 400, 11, 26, 13, 1, -26 },
  { 436, 15, 26, 18, 2, -26 },
  { 485, 8, 26, 18, 3, -26 },
  { 511, 14, 26, 18, 2, -26 },
  { 557, 14, 26, 18, 2, -26 },
  { 603, 17, 26, 18, 1, -26 },
  { 659, 14, 26, 18, 2, -26 },
  { 705, 15, 26, 18, 2, -26 },
  { 754, 15, 26, 18, 2, -26 },
  { 803, 15, 26, 18, 2, -26 },
  { 852, 14, 26, 18, 2, -26 },
  { 898, 3, 19, 8, 3, -19 },
  { 906, 5, 24, 8, 1, -19 },
  { 921, 15, 16, 19, 2, -21 },
  { 951, 15, 9, 19, 2, -17 },
  { 968, 15, 16, 19, 2, -21 },
  { 998, 11, 26, 14, 1, -26 },
  { 1034, 25, 29, 29, 2, -26 },
  { 1125, 19, 26, 19, 0, -26 },
  { 1187, 16, 26, 20, 3, -26 },
  { 1239, 17, 26, 20, 2, -26 },
  { 1295, 18, 26, 23, 3, -26 },
  { 1354, 13, 26, 18, 3, -26 },
  { 1397, 13, 26, 16, 3, -26 },
  { 1440, 19, 26, 24, 2, -26 },
  { 1502, 17, 26, 23, 3, -26 },
  { 1558, 7, 26, 10, 2, -26 },
  { 1581, 8, 33, 8, -3, -26 },
  { 1614, 16, 26, 19, 3, -26 },
  { 1666, 13, 26, 16, 3, -26 },
  { 1709, 23, 26, 29, 3, -26 },
  { 1784, 17, 26, 24, 3, -26 },
  { 1840, 20, 26, 25, 2, -26 },
  { 1905, 14, 26, 19, 3, -26 },
  { 1951, 20, 32, 25, 2, -26 },
  { 2031, 16, 26, 19, 3, -26 },
  { 2083, 14, 26, 18, 2, -26 },
  { 2129, 17, 26, 17, 0, -26 },
  { 2185, 17, 26, 23, 3, -26 },
  { 2241, 19, 26, 19, 0, -26 },
  { 2303, 28, 26, 30, 1, -26 },
  { 2394, 17, 26, 17, 0, -26 },
  { 2450, 17, 26, 17, 0, -26 },
  { 2506, 15, 26, 18, 1, -26 },
  { 2555, 7, 32, 11, 3, -26 },
  { 2583, 11, 26, 13, 1, -26 },
  { 2619, 7, 32, 11, 1, -26 },
  { 2647, 16, 15, 19, 1, -26 },
  { 2677, 15, 2, 15, 0, 3 },
  { 2681, 7, 6, 9, 1, -28 },
  { 2687, 13, 19, 17, 2, -19 },
  { 2718, 15, 27, 20, 3, -27 },
  { 2769, 12, 20, 15, 2, -20 },
  { 2799, 15, 27, 20, 2, -27 },
  { 2850, 14, 20, 18, 2, -20 },
  { 2885, 12, 28, 10, 0, -28 },
  { 2927, 15, 29, 19, 2, -20 },
  { 2982, 14, 27, 19, 3, -27 },
  { 3030, 2, 26, 8, 3, -26 },
  { 3037, 6, 35, 8, -1, -26 },
  { 3064, 13, 27, 16, 3, -27 },
  { 3108, 2, 27, 8, 3, -27 },
  { 3115, 23, 20, 29, 3, -20 },
  { 3173, 14, 20, 19, 3, -20 },
  { 3208, 15, 20, 19, 2, -20 },
  { 3246, 15, 29, 20, 3, -20 },
  { 3301, 15, 29, 19, 2, -20 },
  { 3356, 9, 19, 13, 3, -19 },
  { 3378, 13, 20, 15, 1, -20 },
  { 3411, 9, 24, 11, 1, -24 },
  { 3438, 13, 19, 19, 3, -19 },
  { 3469, 15, 19, 15, 0, -19 },
  { 3505, 24, 19, 24, 0, -19 },
  { 3562, 14, 19, 16, 1, -19 },
  { 3596, 15, 28, 15, 0, -19 },
  { 3649, 12, 19, 14, 1, -19 },
  { 3678, 10, 32, 13, 1, -26 },
  { 3718, 2, 36, 18, 8, -27 },
  { 3727, 11, 32, 13, 1, -26 },
  { 3771, 15, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Light36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT36PT7B_H_
