#ifndef _NOTOSANS_SEMICONDENSED_LIGHT47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light47pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xE6, 0x60, 0x00, 0x00, 0xEE, 0xFE, 0xE0, 0xFC, 0x1F, 0x83, 0x70, 0x6E,
  0x0D, 0xC1, 0xB8, 0x37, 0x06, 0xE0, 0xCC, 0x19, 0x83, 0x30, 0x66, 0x0C,
  0x00, 0x70, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x07, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x80, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x1C, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xE0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x38, 0x0C,
  0x00, 0x1C, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0x8F, 0x18, 0xF3, 0xC3, 0x02, 0x70, 0x60, 0x0C, 0x0C, 0x01, 0x81,
  0x80, 0x70, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x1C, 0x18, 0x01, 0xC3,
  0x00, 0x3E, 0x60, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0xCF, 0x00, 0x18, 0xF0, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x0C,
  0x1C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0E, 0x00, 0xC1, 0xE0, 0x18,
  0x73, 0x83, 0x3C, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x03, 0x80,
  0x7F, 0x00, 0x0C, 0x03, 0x8E, 0x00, 0x70, 0x1C, 0x18, 0x01, 0x80, 0x60,
  0x70, 0x0E, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x03, 0x01, 0xC0, 0x38, 0x0C,
  0x06, 0x00, 0xE0, 0x30, 0x38, 0x03, 0x80, 0xC0, 0xC0, 0x0E, 0x03, 0x87,
  0x00, 0x38, 0x0C, 0x18, 0x00, 0xE0, 0x30, 0xE0, 0x03, 0x80, 0xC3, 0x02,
  0x06, 0x03, 0x0C, 0x7F, 0x18, 0x0C, 0x63, 0xDE, 0x60, 0x71, 0x8C, 0x19,
  0xC1, 0x8C, 0x70, 0x73, 0x8E, 0x31, 0x80, 0xC7, 0xF1, 0xC6, 0x03, 0x0F,
  0x86, 0x18, 0x0C, 0x00, 0x38, 0xE0, 0x30, 0x00, 0xC3, 0x80, 0xC0, 0x07,
  0x0E, 0x03, 0x00, 0x18, 0x38, 0x0C, 0x00, 0xE0, 0xE0, 0x30, 0x03, 0x03,
  0x80, 0xC0, 0x1C, 0x06, 0x03, 0x00, 0x60, 0x18, 0x0C, 0x03, 0x80, 0x60,
  0x70, 0x0C, 0x01, 0xC1, 0xC0, 0x70, 0x03, 0x0E, 0x01, 0x80, 0x0F, 0xF0,
  0x0E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0xE0,
  0x00, 0xE0, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xDC, 0x00, 0x01, 0xE3, 0x80, 0x38, 0xF0, 0x70, 0x0E, 0x38, 0x1E, 0x03,
  0x1C, 0x03, 0xC1, 0xC6, 0x00, 0x70, 0x73, 0x80, 0x0E, 0x18, 0xE0, 0x01,
  0xCE, 0x38, 0x00, 0x3B, 0x8E, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xE0, 0x60,
  0x00, 0x7C, 0x1C, 0x00, 0x3F, 0x07, 0x80, 0x1E, 0xE0, 0xF0, 0x1E, 0x1C,
  0x1F, 0xFF, 0x03, 0x81, 0xFF, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xED, 0xB6,
  0x01, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0C,
  0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80,
  0xE0, 0x70, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x0C, 0x0F, 0xF3, 0x1F, 0xFF, 0xFF, 0xC1, 0xFE, 0x00, 0x1E, 0x00, 0x06,
  0xC0, 0x03, 0x38, 0x01, 0xC6, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x1C, 0x07,
  0x03, 0x01, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x39, 0xCE,
  0x67, 0x39, 0xCC, 0xE6, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF7,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x01,
  0xE0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xC7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE3,
  0x00, 0x0C, 0x38, 0x01, 0xC1, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xF0, 0x70,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF1, 0xEE,
  0x79, 0xDE, 0x3F, 0x07, 0x40, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFC, 0xFC, 0x3C,
  0x03, 0xC2, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xF8, 0x7C, 0x78, 0x01, 0xC4, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xA0, 0x00, 0xF7, 0x80, 0x7C, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80,
  0x00, 0x76, 0x00, 0x01, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x71, 0x80, 0x01,
  0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x0E, 0x06,
  0x00, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x18, 0x06, 0x00, 0x60, 0x38, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00,
  0x18, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x70, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x20, 0x01, 0xC7, 0x00, 0xF8,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0x86,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC1, 0xF0, 0x31, 0xFF, 0x86, 0x7D, 0xF8, 0xDC, 0x07, 0x9E, 0x00, 0x7B,
  0xC0, 0x07, 0x70, 0x00, 0x6E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xB0, 0x00, 0x67,
  0x00, 0x1C, 0x60, 0x03, 0x8E, 0x00, 0xE0, 0xF0, 0x38, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0x0F, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC3, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C,
  0x1C, 0x03, 0x80, 0xE0, 0x70, 0x07, 0x9E, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x01, 0xC0, 0x78, 0x38, 0x01, 0xC7, 0x00,
  0x0E, 0x70, 0x00, 0xE6, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x67, 0x00, 0x0E, 0x38, 0x01, 0xC3,
  0xC0, 0x3C, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7C, 0x7C, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x73,
  0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xE7,
  0x00, 0x6C, 0xF0, 0x39, 0x8F, 0xFE, 0x30, 0x7F, 0x8E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x3B, 0xDE, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9C, 0xEE, 0x73,
  0x98, 0xCE, 0x63, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0xE3, 0xF3, 0xF2, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x07, 0xFC, 0x0E,
  0x60, 0x0F, 0xFC, 0x06, 0x60, 0x1C, 0x0C, 0x06, 0xE0, 0x38, 0x0C, 0x06,
  0xC0, 0x70, 0x0C, 0x07, 0xC0, 0x60, 0x0C, 0x07, 0xC0, 0x60, 0x0C, 0x07,
  0xC0, 0xE0, 0x0C, 0x03, 0xC0, 0xE0, 0x0C, 0x07, 0xC0, 0xE0, 0x0C, 0x07,
  0xC0, 0xC0, 0x0C, 0x07, 0xC0, 0xE0, 0x1C, 0x06, 0xC0, 0xE0, 0x1C, 0x06,
  0xC0, 0xE0, 0x1C, 0x06, 0xC0, 0x60, 0x3C, 0x0E, 0xC0, 0x70, 0x36, 0x0C,
  0xC0, 0x38, 0xE7, 0x38, 0xE0, 0x1F, 0xC3, 0xF8, 0x60, 0x0F, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0x60,
  0x18, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0xFF,
  0xA0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8E, 0x00, 0x7C, 0xE0, 0x01, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x07,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0xE0, 0x03, 0xCE, 0x00,
  0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x01, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0x9F, 0x81, 0xE0, 0x06, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x0E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x3C,
  0x38, 0x00, 0xF0, 0x70, 0x3F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xB8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0xF8, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1C,
  0x3C, 0x00, 0x0E, 0x0F, 0xC0, 0x1F, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0xFF,
  0xFF, 0xCF, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xFF,
  0xFF, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x1E, 0xFF, 0x3F, 0x83, 0x00, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0x38, 0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x03, 0x83,
  0x80, 0x38, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x1C,
  0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x1C,
  0xF0, 0x00, 0xEF, 0x80, 0x07, 0xEE, 0x00, 0x3E, 0x38, 0x01, 0xE1, 0xC0,
  0x0E, 0x07, 0x00, 0x70, 0x3C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0,
  0x1E, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x38,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x7E, 0xC0, 0x00, 0x1D,
  0xFB, 0x80, 0x00, 0x77, 0xEE, 0x00, 0x01, 0x9F, 0x98, 0x00, 0x0E, 0x7E,
  0x70, 0x00, 0x31, 0xF8, 0xC0, 0x00, 0xC7, 0xE3, 0x80, 0x07, 0x1F, 0x8E,
  0x00, 0x18, 0x7E, 0x18, 0x00, 0xE1, 0xF8, 0x70, 0x03, 0x87, 0xE1, 0xC0,
  0x0C, 0x1F, 0x83, 0x00, 0x70, 0x7E, 0x0E, 0x01, 0xC1, 0xF8, 0x38, 0x06,
  0x07, 0xE0, 0x60, 0x38, 0x1F, 0x81, 0xC0, 0xC0, 0x7E, 0x03, 0x03, 0x01,
  0xF8, 0x0C, 0x1C, 0x07, 0xE0, 0x38, 0x60, 0x1F, 0x80, 0x61, 0x80, 0x7E,
  0x01, 0xCE, 0x01, 0xF8, 0x07, 0x30, 0x07, 0xE0, 0x0D, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07,
  0x80, 0x1F, 0x80, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFB,
  0x80, 0x03, 0xF7, 0x00, 0x07, 0xE7, 0x00, 0x0F, 0xC7, 0x00, 0x1F, 0x8E,
  0x00, 0x3F, 0x0E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x1C, 0x01, 0xF8, 0x38,
  0x03, 0xF0, 0x38, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0x70,
  0x3F, 0x00, 0xE0, 0x7E, 0x00, 0xE0, 0xFC, 0x01, 0xC1, 0xF8, 0x01, 0xC3,
  0xF0, 0x01, 0xC7, 0xE0, 0x03, 0x8F, 0xC0, 0x03, 0x9F, 0x80, 0x07, 0x3F,
  0x00, 0x07, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0x60, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x01,
  0xC0, 0x1F, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x07, 0xCE, 0x00, 0x39, 0xC0,
  0x03, 0xB8, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x1C, 0xE0, 0x07, 0x9C, 0x03, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0x60, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0E, 0x00, 0xF8, 0xE0,
  0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x0F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0E, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0x7F, 0x1E, 0x00, 0x63,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0xA0, 0x00, 0xE7, 0x80, 0x7C, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0x70, 0x00, 0x39, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x07, 0xC0,
  0x78, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1C, 0x00,
  0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x03, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81,
  0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x00, 0x00, 0x76, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x0C, 0xC0, 0x01, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x80, 0x07,
  0x38, 0x00, 0x7C, 0x00, 0x39, 0xC0, 0x07, 0x60, 0x01, 0x8E, 0x00, 0x3B,
  0x00, 0x1C, 0x30, 0x01, 0x9C, 0x00, 0xE1, 0xC0, 0x0C, 0xE0, 0x07, 0x0E,
  0x00, 0xE3, 0x00, 0x30, 0x70, 0x07, 0x18, 0x03, 0x81, 0x80, 0x30, 0xE0,
  0x1C, 0x0E, 0x01, 0x87, 0x00, 0xE0, 0x70, 0x1C, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0xC0, 0x70, 0x0C, 0x06, 0x07, 0x03, 0x80, 0x70, 0x30, 0x38, 0x1C,
  0x03, 0x83, 0x80, 0xC0, 0xC0, 0x1C, 0x1C, 0x06, 0x0E, 0x00, 0x60, 0xC0,
  0x38, 0x70, 0x03, 0x86, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x06, 0x18, 0x00,
  0xE3, 0x80, 0x31, 0xC0, 0x03, 0x18, 0x01, 0xCE, 0x00, 0x1C, 0xC0, 0x0E,
  0x70, 0x00, 0xEE, 0x00, 0x33, 0x00, 0x07, 0x70, 0x01, 0xB8, 0x00, 0x1B,
  0x00, 0x0F, 0xC0, 0x00, 0xD8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x87,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0,
  0x70, 0x03, 0x01, 0x80, 0x0E, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x71, 0xC0,
  0x00, 0xC6, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xCE,
  0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x60, 0x70,
  0x01, 0xC3, 0x80, 0x03, 0x8C, 0x00, 0x0E, 0x70, 0x00, 0x1F, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x38, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xE0, 0x03, 0x03,
  0x00, 0x0E, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0x80, 0x00, 0xCE, 0x00,
  0x0E, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x38, 0x03, 0x80,
  0xC0, 0x18, 0x07, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xE0, 0xE0, 0x03, 0x06,
  0x00, 0x1C, 0x70, 0x00, 0x63, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0x80, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x0F, 0xFC, 0x1F, 0xFF, 0x06, 0x03, 0xC2, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x07, 0xE0, 0xFF, 0xF1, 0xFE, 0x19, 0xE0, 0x0D, 0xC0, 0x06, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7B, 0x80,
  0x6D, 0xE0, 0x76, 0x7F, 0xF3, 0x1F, 0xE1, 0x80, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x61, 0xFE,
  0x0C, 0xFF, 0xE1, 0xB8, 0x0E, 0x36, 0x00, 0xE7, 0x80, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x1B, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x80, 0x0E,
  0xD8, 0x03, 0x9B, 0x81, 0xE3, 0x3F, 0xF8, 0x61, 0xFE, 0x00, 0x01, 0xFF,
  0x83, 0xFF, 0x83, 0xC0, 0x43, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x04, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x3F, 0xC7, 0x0F, 0xFE,
  0x71, 0xE0, 0x77, 0x1C, 0x01, 0xF3, 0x80, 0x1F, 0x38, 0x00, 0xF7, 0x00,
  0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76,
  0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0x80, 0x0F,
  0x3C, 0x01, 0xF1, 0xE0, 0x77, 0x0F, 0xFE, 0x70, 0x7F, 0xC3, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x60, 0x03,
  0x9C, 0x00, 0x33, 0x80, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x83, 0xC0, 0x70, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xF8,
  0x0F, 0xF0, 0x78, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x03, 0xFC, 0x70, 0xFF, 0xE7, 0x1E, 0x07, 0x71, 0xC0, 0x1F, 0x38,
  0x00, 0xF3, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x07, 0x70, 0x00, 0x76,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0xF7, 0x00, 0x0F, 0x38, 0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x07, 0x70, 0xFF,
  0xE7, 0x07, 0xFC, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x20, 0x01, 0xC3,
  0x80, 0x78, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x0F, 0xF0, 0xCF, 0xFE,
  0x37, 0x03, 0xCD, 0x80, 0x3B, 0xC0, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x6E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x7F, 0xF6, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x03, 0x83, 0xC1,
  0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x83, 0xDF, 0xCF, 0xC0,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0xEC, 0x00, 0xE6, 0x00, 0xE3, 0x00, 0xE1, 0x80, 0xE0, 0xC0, 0x70,
  0x60, 0x70, 0x30, 0x70, 0x18, 0x70, 0x0C, 0x70, 0x06, 0x38, 0x03, 0x3C,
  0x01, 0xBF, 0x00, 0xF9, 0xC0, 0x78, 0xE0, 0x38, 0x38, 0x18, 0x0E, 0x0C,
  0x07, 0x06, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0x38, 0xC0, 0x0E, 0x60, 0x07,
  0x30, 0x01, 0xD8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xE3, 0x3F, 0xF0, 0xFF, 0xCD, 0xC1, 0xE7,
  0x07, 0xB6, 0x03, 0xB0, 0x0E, 0xF0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x7E, 0x00, 0x38, 0x01, 0xF8, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0C,
  0xC3, 0xFC, 0x33, 0xFF, 0x8D, 0xC0, 0xF3, 0x60, 0x0E, 0xF0, 0x03, 0xB8,
  0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0xFE, 0x00,
  0xFF, 0xF0, 0x1E, 0x03, 0xC1, 0xC0, 0x1C, 0x38, 0x00, 0xE3, 0x00, 0x0E,
  0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x73, 0x00, 0x0E, 0x38,
  0x00, 0xE1, 0xC0, 0x1C, 0x1E, 0x03, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00,
  0xC3, 0xFC, 0x18, 0xFF, 0xE3, 0x30, 0x1C, 0x6C, 0x01, 0xCF, 0x00, 0x1D,
  0xE0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0x78, 0x00, 0xEF,
  0x00, 0x3D, 0xB0, 0x07, 0x37, 0x03, 0xC6, 0x7F, 0xF0, 0xC3, 0xFC, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0xFC, 0x70, 0xFF, 0xE7, 0x1E, 0x07, 0x73, 0xC0, 0x1F,
  0x38, 0x01, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0x38, 0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x07, 0x70,
  0xFF, 0xE7, 0x07, 0xFC, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0xCE,
  0x0D, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xFC,
  0x3F, 0xFE, 0x78, 0x0E, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x80, 0x0E, 0xE0, 0x1C, 0xFF, 0xFC, 0x7F, 0xF0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xFF, 0x07, 0xF0, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x6D, 0xE0, 0x76,
  0x7F, 0xF3, 0x1F, 0xE1, 0x80, 0xE0, 0x00, 0x76, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x81, 0x80,
  0x38, 0x1C, 0x03, 0x81, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x06, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00,
  0x31, 0xC0, 0x03, 0x98, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x1F,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xB8, 0x01, 0xE0, 0x0E, 0x60,
  0x0F, 0xC0, 0x39, 0xC0, 0x37, 0x00, 0xE7, 0x00, 0xCC, 0x03, 0x0C, 0x07,
  0x30, 0x1C, 0x30, 0x1C, 0xE0, 0x70, 0xE0, 0x61, 0x81, 0xC3, 0x81, 0x86,
  0x06, 0x06, 0x0E, 0x1C, 0x38, 0x18, 0x30, 0x70, 0xE0, 0x70, 0xC0, 0xC3,
  0x81, 0xC7, 0x03, 0x0C, 0x03, 0x1C, 0x0E, 0x30, 0x0C, 0x60, 0x39, 0xC0,
  0x39, 0x80, 0x67, 0x00, 0xEE, 0x01, 0x98, 0x01, 0xB0, 0x07, 0x60, 0x06,
  0xC0, 0x1F, 0x80, 0x1B, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x38, 0xE0,
  0x0E, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x38,
  0xE0, 0x03, 0x38, 0x00, 0x77, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0xC0, 0x07, 0x1C, 0x00, 0xC3,
  0x80, 0x38, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x07, 0x1C, 0x00,
  0x63, 0x80, 0x0E, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x77, 0x00, 0x06, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC1,
  0x80, 0x18, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x70,
  0x06, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C,
  0x00, 0x39, 0xC0, 0x01, 0x9C, 0x00, 0x19, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x18, 0x07, 0xC0, 0xFE, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x3F, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x07, 0xC0, 0x3F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x7C,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0x17, 0xFE, 0x03,
  0xE1, 0xFC, 0xF8, 0x03, 0xFE, 0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Light47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 34, 11, 4, -34 },
  { 18, 11, 13, 17, 3, -34 },
  { 36, 25, 34, 27, 1, -34 },
  { 143, 19, 39, 24, 2, -36 },
  { 236, 30, 34, 35, 2, -34 },
  { 364, 26, 34, 29, 2, -34 },
  { 475, 3, 13, 9, 3, -34 },
  { 480, 9, 41, 13, 2, -34 },
  { 527, 9, 41, 13, 2, -34 },
  { 574, 18, 18, 23, 2, -36 },
  { 615, 20, 22, 24, 2, -28 },
  { 670, 5, 11, 10, 2, -5 },
  { 677, 11, 3, 14, 2, -14 },
  { 682, 4, 4, 11, 3, -4 },
  { 684, 15, 34, 16, 1, -34 },
  { 748, 20, 34, 24, 2, -34 },
  { 833, 11, 34, 24, 4, -34 },
  { 880, 19, 34, 24, 2, -34 },
  { 961, 19, 34, 24, 2, -34 },
  { 1042, 22, 34, 24, 1, -34 },
  { 1136, 19, 34, 24, 3, -34 },
  { 1217, 19, 35, 24, 3, -34 },
  { 1301, 20, 34, 24, 2, -34 },
  { 1386, 20, 34, 24, 2, -34 },
  { 1471, 19, 35, 24, 2, -34 },
  { 1555, 4, 25, 11, 3, -25 },
  { 1568, 5, 31, 11, 2, -25 },
  { 1588, 20, 22, 24, 2, -28 },
  { 1643, 20, 12, 24, 2, -23 },
  { 1673, 20, 22, 24, 2, -28 },
  { 1728, 15, 34, 18, 1, -34 },
  { 1792, 32, 38, 37, 3, -34 },
  { 1944, 25, 34, 25, 0, -34 },
  { 2051, 20, 34, 27, 4, -34 },
  { 2136, 22, 34, 26, 3, -34 },
  { 2230, 23, 34, 30, 4, -34 },
  { 2328, 17, 34, 23, 4, -34 },
  { 2401, 17, 34, 21, 4, -34 },
  { 2474, 25, 34, 31, 3, -34 },
  { 2581, 22, 34, 30, 4, -34 },
  { 2675, 9, 34, 14, 2, -34 },
  { 2714, 10, 43, 11, -3, -34 },
  { 2768, 21, 34, 25, 4, -34 },
  { 2858, 16, 34, 21, 4, -34 },
  { 2926, 30, 34, 38, 4, -34 },
  { 3054, 23, 34, 31, 4, -34 },
  { 3152, 26, 34, 32, 3, -34 },
  { 3263, 19, 34, 25, 4, -34 },
  { 3344, 26, 42, 32, 3, -34 },
  { 3481, 20, 34, 25, 4, -34 },
  { 3566, 19, 34, 23, 2, -34 },
  { 3647, 22, 34, 22, 0, -34 },
  { 3741, 22, 34, 30, 4, -34 },
  { 3835, 24, 34, 24, 0, -34 },
  { 3937, 37, 34, 39, 1, -34 },
  { 4095, 22, 34, 23, 0, -34 },
  { 4189, 22, 34, 22, 0, -34 },
  { 4283, 19, 34, 23, 2, -34 },
  { 4364, 10, 41, 15, 4, -34 },
  { 4416, 15, 34, 16, 1, -34 },
  { 4480, 10, 41, 15, 1, -34 },
  { 4532, 21, 20, 24, 2, -34 },
  { 4585, 20, 2, 20, 0, 4 },
  { 4590, 8, 8, 12, 2, -36 },
  { 4598, 17, 25, 23, 2, -25 },
  { 4652, 19, 36, 25, 4, -36 },
  { 4738, 17, 25, 20, 2, -25 },
  { 4792, 20, 36, 25, 2, -36 },
  { 4882, 19, 25, 23, 2, -25 },
  { 4942, 14, 36, 13, 1, -36 },
  { 5005, 20, 36, 25, 2, -25 },
  { 5095, 18, 36, 25, 4, -36 },
  { 5176, 4, 34, 10, 3, -34 },
  { 5193, 9, 45, 10, -2, -34 },
  { 5244, 17, 36, 21, 4, -36 },
  { 5321, 2, 36, 10, 4, -36 },
  { 5330, 30, 25, 38, 4, -25 },
  { 5424, 18, 25, 25, 4, -25 },
  { 5481, 20, 25, 25, 2, -25 },
  { 5544, 19, 36, 25, 4, -25 },
  { 5630, 20, 36, 25, 2, -25 },
  { 5720, 12, 25, 17, 4, -25 },
  { 5758, 16, 25, 20, 2, -25 },
  { 5808, 12, 31, 14, 1, -31 },
  { 5855, 17, 25, 25, 4, -25 },
  { 5909, 20, 25, 20, 0, -25 },
  { 5972, 30, 25, 32, 1, -25 },
  { 6066, 19, 25, 21, 1, -25 },
  { 6126, 20, 36, 20, 0, -25 },
  { 6216, 15, 25, 19, 2, -25 },
  { 6263, 13, 41, 17, 2, -34 },
  { 6330, 3, 47, 23, 10, -36 },
  { 6348, 13, 41, 17, 2, -34 },
  { 6415, 20, 5, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Light47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT47PT7B_H_
