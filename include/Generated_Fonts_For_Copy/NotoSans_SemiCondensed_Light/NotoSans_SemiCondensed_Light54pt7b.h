#ifndef _NOTOSANS_SEMICONDENSED_LIGHT54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light54pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0x00, 0x00, 0x00, 0x1D, 0xEF,
  0xFF, 0xC4, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x06, 0xE0, 0x6E, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x18,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38,
  0x06, 0x00, 0x01, 0xC0, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18,
  0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x0C,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0x8E, 0x0C, 0x70, 0x70, 0x07, 0x83, 0x80, 0x38,
  0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0,
  0x1C, 0x0E, 0x00, 0x70, 0x70, 0x03, 0xC3, 0x80, 0x0F, 0x9C, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x73, 0xE0, 0x03, 0x87, 0x80, 0x1C, 0x1E, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38,
  0x03, 0x83, 0xC0, 0x1C, 0x1D, 0xC0, 0xE3, 0xCF, 0xF7, 0xFC, 0x7F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x07, 0xF8, 0x00,
  0x38, 0x03, 0x8F, 0x00, 0x0E, 0x01, 0xC1, 0xC0, 0x07, 0x00, 0x60, 0x38,
  0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x60, 0x1C, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x30, 0x07, 0x03, 0x80, 0x0C,
  0x01, 0xC0, 0xE0, 0x03, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x1C, 0x1C, 0x00,
  0x30, 0x07, 0x06, 0x00, 0x0C, 0x01, 0xC3, 0x80, 0x03, 0x00, 0x60, 0xC0,
  0xE0, 0xE0, 0x18, 0x70, 0xFE, 0x38, 0x0E, 0x18, 0x7F, 0xCE, 0x03, 0x8E,
  0x38, 0x39, 0x80, 0xE3, 0x0C, 0x0E, 0x70, 0x71, 0xC7, 0x01, 0x8E, 0x3C,
  0x71, 0xC0, 0x71, 0xFE, 0x38, 0x60, 0x1C, 0x3E, 0x0E, 0x18, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0xC0, 0x01, 0xC3, 0x80, 0x30, 0x00, 0xE0, 0xE0, 0x0C,
  0x00, 0x38, 0x38, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x07, 0x03, 0x80,
  0x30, 0x01, 0x80, 0xE0, 0x0C, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x30, 0x06,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x06, 0x00, 0x70, 0x18, 0x03, 0x80,
  0x0C, 0x0E, 0x00, 0xC0, 0x03, 0x87, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x18,
  0x00, 0x0F, 0xE0, 0x08, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x73, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x38, 0xF0, 0x38, 0x01, 0xCF, 0x01, 0xE0, 0x1C, 0x70, 0x07,
  0x80, 0xE7, 0x00, 0x1E, 0x07, 0x38, 0x00, 0x78, 0x71, 0xC0, 0x01, 0xE3,
  0x8E, 0x00, 0x07, 0x3C, 0x70, 0x00, 0x1D, 0xC3, 0x80, 0x00, 0xFC, 0x1C,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xFC, 0x1C, 0x00,
  0x1E, 0xF0, 0xF8, 0x01, 0xE3, 0x83, 0xF0, 0x7E, 0x1E, 0x0F, 0xFF, 0xC0,
  0x78, 0x1F, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x6D, 0x80, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x60, 0x1E, 0x06, 0x07, 0xFE, 0x67,
  0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x19,
  0x80, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x1C,
  0x03, 0x80, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE3,
  0x9C, 0x71, 0xC6, 0x38, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF,
  0xF2, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0x80, 0xF0, 0x1C,
  0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00,
  0x03, 0x9C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC1, 0xC0, 0x0E,
  0x07, 0x80, 0x78, 0x0F, 0x8F, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x70, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0x71, 0xE7, 0x3C, 0x77, 0x87,
  0xF0, 0x74, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0x00, 0xF0, 0x70, 0x01,
  0xE1, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x7C, 0x70, 0x00,
  0x70, 0x80, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xB0,
  0x00, 0x3C, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x14,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0xF8, 0xFC,
  0x0F, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x1F, 0x80, 0xE1, 0xFF, 0x83, 0x9F, 0xFF, 0x8E,
  0xF0, 0x1F, 0x3B, 0x00, 0x1C, 0xF8, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x80,
  0x3C, 0x0F, 0x83, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0x80, 0x78, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x07,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x1E, 0x78, 0x00, 0x70, 0xE0, 0x03, 0xC1, 0xC0, 0x1E, 0x07, 0xC0,
  0xF0, 0x07, 0x8F, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0x9F, 0x80, 0x7C, 0x1F, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0x3C, 0x70,
  0x00, 0x7B, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0x3F, 0x03, 0xE0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF8, 0x0F, 0x80, 0xF0, 0x38, 0x01, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF7, 0x00, 0x07, 0xDE,
  0x00, 0x36, 0x3C, 0x01, 0xF8, 0xFC, 0x1E, 0xE1, 0xFF, 0xF3, 0x81, 0xFF,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x20, 0x3F,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x77, 0xBF, 0xEF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x67, 0xBF, 0xEF, 0x10, 0x1C, 0x78, 0xF9, 0xE3, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xC3, 0x86, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xE1,
  0x80, 0x3C, 0x40, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x70, 0x00, 0xFC, 0x00, 0xE3, 0x80, 0x1F, 0xFC, 0x07, 0x38,
  0x03, 0xF7, 0xE0, 0x19, 0xC0, 0x3C, 0x07, 0x00, 0xCE, 0x01, 0xC0, 0x38,
  0x07, 0x60, 0x1C, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x0E, 0x01, 0xF8, 0x0E,
  0x00, 0x70, 0x0F, 0xC0, 0x70, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x1C, 0x03,
  0xF0, 0x1C, 0x00, 0xE0, 0x1F, 0x80, 0xE0, 0x07, 0x00, 0xFC, 0x07, 0x00,
  0x38, 0x07, 0xE0, 0x38, 0x01, 0xC0, 0x3F, 0x01, 0xC0, 0x0E, 0x01, 0xB8,
  0x0E, 0x00, 0xF0, 0x0D, 0xC0, 0x70, 0x07, 0x80, 0xEE, 0x01, 0xC0, 0x6C,
  0x06, 0x70, 0x0E, 0x03, 0x70, 0x71, 0x80, 0x3C, 0x71, 0xCF, 0x0E, 0x00,
  0xFF, 0x0F, 0xF0, 0x70, 0x03, 0xF0, 0x1F, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xE0, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x00, 0x3F, 0x8E, 0x00, 0x0F, 0x9C,
  0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xE1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0E, 0x00, 0x3F, 0x1C, 0x00, 0x1F,
  0x38, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0x80,
  0x01, 0xE7, 0x00, 0x0F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x7E, 0x00, 0x70, 0x7C, 0x00, 0x08, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x3F, 0xC1, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x3F, 0xC0, 0xE0, 0x00, 0xF8, 0x38,
  0x00, 0x1F, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x83, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xB8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x3C,
  0x00, 0x02, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xFF,
  0xFF, 0xFD, 0xFF, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xE8, 0x3E, 0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7B, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x3C,
  0x38, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x1E, 0x03,
  0x80, 0x78, 0x07, 0x01, 0xE0, 0x0E, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xF0, 0x00, 0xE3, 0xC0, 0x01, 0xCF, 0x80, 0x03, 0x9F,
  0x00, 0x07, 0x7F, 0x00, 0x0F, 0xCE, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xF0,
  0x70, 0x00, 0xF0, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0xCE, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1D, 0xFF, 0x00, 0x00, 0x07, 0x7E, 0xE0,
  0x00, 0x01, 0xDF, 0xB8, 0x00, 0x00, 0xEF, 0xEE, 0x00, 0x00, 0x3B, 0xF9,
  0xC0, 0x00, 0x0E, 0xFE, 0x70, 0x00, 0x07, 0x3F, 0x9C, 0x00, 0x01, 0xCF,
  0xE3, 0x80, 0x00, 0x63, 0xF8, 0xE0, 0x00, 0x38, 0xFE, 0x18, 0x00, 0x0E,
  0x3F, 0x87, 0x00, 0x03, 0x0F, 0xE1, 0xC0, 0x01, 0xC3, 0xF8, 0x38, 0x00,
  0x70, 0xFE, 0x0E, 0x00, 0x38, 0x3F, 0x83, 0x80, 0x0E, 0x0F, 0xE0, 0x70,
  0x03, 0x83, 0xF8, 0x1C, 0x01, 0xC0, 0xFE, 0x07, 0x00, 0x70, 0x3F, 0x80,
  0xE0, 0x1C, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0xF8, 0x0E, 0x03, 0x80, 0xFE,
  0x01, 0xC0, 0xC0, 0x3F, 0x80, 0x70, 0x70, 0x0F, 0xE0, 0x0E, 0x1C, 0x03,
  0xF8, 0x03, 0x86, 0x00, 0xFE, 0x00, 0xE3, 0x80, 0x3F, 0x80, 0x1C, 0xE0,
  0x0F, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x00,
  0x78, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xB8, 0x00, 0x07, 0xE7, 0x00, 0x01,
  0xF9, 0xE0, 0x00, 0x7E, 0x38, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xE1, 0xC0,
  0x01, 0xF8, 0x38, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0x81, 0xC0, 0x07, 0xE0,
  0x78, 0x01, 0xF8, 0x0E, 0x00, 0x7E, 0x03, 0xC0, 0x1F, 0x80, 0x70, 0x07,
  0xE0, 0x0E, 0x01, 0xF8, 0x03, 0xC0, 0x7E, 0x00, 0x70, 0x1F, 0x80, 0x1E,
  0x07, 0xE0, 0x03, 0x81, 0xF8, 0x00, 0xF0, 0x7E, 0x00, 0x1C, 0x1F, 0x80,
  0x03, 0x87, 0xE0, 0x00, 0xF1, 0xF8, 0x00, 0x1C, 0x7E, 0x00, 0x07, 0x9F,
  0x80, 0x00, 0xE7, 0xE0, 0x00, 0x3D, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xC0, 0x1F, 0x8E,
  0x00, 0x3E, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07,
  0xB8, 0x00, 0x79, 0xC0, 0x0F, 0x8E, 0x0F, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xBC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0x00,
  0x7E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x3C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0xF1, 0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x07, 0x00, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x3C, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xE0, 0x00,
  0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xFC, 0x7C, 0x00, 0xE7, 0x80, 0x01, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3D, 0x80, 0x07, 0xCF, 0xC0, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x07, 0x81, 0xFC,
  0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x50, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x38,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0xC0, 0x00, 0xE7,
  0x80, 0x03, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0xEC, 0x00, 0x0E, 0x38, 0x00,
  0x73, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x38,
  0x00, 0x70, 0x70, 0x01, 0xC6, 0x00, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x07, 0x00, 0x38, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x1C, 0x00, 0xE0, 0x38,
  0x03, 0x83, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x01, 0x80,
  0x70, 0x07, 0x03, 0x80, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x00,
  0x70, 0x38, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x03,
  0x87, 0x00, 0x07, 0x1C, 0x00, 0x61, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x03,
  0x38, 0x00, 0x33, 0x80, 0x00, 0xEC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0,
  0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x3C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0xC0,
  0x03, 0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00,
  0xF0, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x3C, 0x00,
  0x38, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03,
  0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80,
  0x01, 0xC3, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0C,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0x8F, 0xC0, 0xC0, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1F, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0x71, 0xF0, 0x07, 0x3C, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x1F, 0x70, 0x01, 0xF7, 0x80, 0x37, 0x3C, 0x0F, 0x71, 0xFF, 0xE3, 0x0F,
  0xF8, 0x30, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0xFF, 0x03, 0x8F, 0xFF, 0x0E, 0x7E, 0x7E, 0x3B, 0x80, 0x3C,
  0xEC, 0x00, 0x73, 0xE0, 0x01, 0xEF, 0x80, 0x03, 0xBC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xBE, 0x00, 0x1E, 0xFC, 0x00, 0x73, 0xB8, 0x03,
  0xCE, 0x78, 0x3E, 0x38, 0xFF, 0xF0, 0xE1, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0x7C, 0x7C, 0x01, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x10, 0xF8,
  0x1C, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xFE, 0x1C, 0x1F, 0xFC, 0x70, 0xFC,
  0xF9, 0xC7, 0x80, 0x77, 0x3C, 0x00, 0xFC, 0xE0, 0x01, 0xF7, 0x00, 0x03,
  0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x1F, 0x38,
  0x00, 0x7C, 0xF0, 0x03, 0x71, 0xF0, 0x39, 0xC3, 0xFF, 0xC7, 0x03, 0xFE,
  0x1C, 0x00, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xE3, 0xF0,
  0x3C, 0x03, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x79, 0xC0, 0x01, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x83, 0xE0, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0A, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0xF8, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xFE, 0x1C, 0x1F, 0xFC, 0x70, 0xFC, 0xF9, 0xC7,
  0x80, 0x77, 0x3C, 0x00, 0xFC, 0xE0, 0x01, 0xF7, 0x00, 0x03, 0xDC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x1F, 0x38, 0x00, 0x7C,
  0xF0, 0x03, 0x71, 0xF0, 0x39, 0xC3, 0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x00,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x79, 0x00, 0x03, 0xC7,
  0x80, 0x1E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x0F, 0xF0, 0x71, 0xFF, 0xE3,
  0x9F, 0xBF, 0x9D, 0xC0, 0x3C, 0xEC, 0x00, 0xF7, 0xC0, 0x03, 0xBE, 0x00,
  0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x38, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0xBF, 0xCF, 0xE3, 0xF0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0,
  0x03, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xE0, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x70, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00,
  0xE3, 0xC0, 0x0E, 0x7C, 0x00, 0xEF, 0xE0, 0x0F, 0xCF, 0x00, 0xF8, 0x70,
  0x0F, 0x87, 0x80, 0xF0, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00,
  0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x3C, 0xE0,
  0x01, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE1,
  0xFE, 0x01, 0xFE, 0x1C, 0x7F, 0xF0, 0x7F, 0xE3, 0x9F, 0x3E, 0x3E, 0x7E,
  0x77, 0x01, 0xE7, 0x01, 0xEF, 0xC0, 0x1D, 0x80, 0x1D, 0xF0, 0x01, 0xF0,
  0x03, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x07, 0xF0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0,
  0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01,
  0xF8, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00,
  0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8,
  0x00, 0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0E, 0xE0, 0xFF, 0x07, 0x1F, 0xFE, 0x39,
  0xF3, 0xF9, 0xDC, 0x03, 0xCE, 0xC0, 0x0F, 0x7C, 0x00, 0x3B, 0xE0, 0x01,
  0xDE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0x3F, 0x80, 0xF0, 0x07, 0x83, 0xC0,
  0x07, 0x07, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0xE0, 0xFF, 0x03, 0x8F, 0xFF, 0x0E, 0x7E, 0x7E, 0x39, 0x80,
  0x3C, 0xEC, 0x00, 0x73, 0xE0, 0x01, 0xEF, 0x80, 0x03, 0xBC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xBE, 0x00, 0x1E, 0xEC, 0x00, 0x73, 0xB8,
  0x03, 0xCE, 0x78, 0x3E, 0x38, 0xFF, 0xF0, 0xE1, 0xFF, 0x83, 0x80, 0x40,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x1C, 0x1F, 0xFC, 0x70, 0xFC, 0xF9, 0xC7, 0x80, 0x77, 0x3C, 0x00, 0xFD,
  0xE0, 0x01, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00,
  0x03, 0xDE, 0x00, 0x1F, 0x38, 0x00, 0xFC, 0xF0, 0x07, 0x71, 0xF0, 0x39,
  0xC3, 0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x00, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0xFF, 0x8F, 0xFE, 0x7F, 0xFB,
  0xC0, 0xEC, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x07,
  0xFF, 0xF3, 0xF1, 0xF9, 0xE0, 0x02, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xEF, 0x80, 0xFB, 0xFF, 0xFC,
  0x3F, 0xFC, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3E, 0x10, 0x7F, 0xC0, 0xFF, 0x00, 0x20, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0x70, 0x01, 0xBB, 0xC0, 0x1D, 0xCF, 0x83, 0xCE, 0x3F, 0xFC, 0x70,
  0xFF, 0xC3, 0x80, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x1C, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x78, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x70,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3C,
  0x00, 0x3B, 0x80, 0x07, 0xC0, 0x07, 0x78, 0x00, 0xF8, 0x00, 0xE7, 0x00,
  0x1F, 0x00, 0x3C, 0xE0, 0x07, 0x60, 0x07, 0x1C, 0x00, 0xEE, 0x00, 0xE1,
  0xC0, 0x19, 0xC0, 0x1C, 0x38, 0x07, 0x38, 0x03, 0x87, 0x00, 0xE3, 0x00,
  0xE0, 0xE0, 0x1C, 0x70, 0x1C, 0x0E, 0x07, 0x0E, 0x03, 0x81, 0xC0, 0xE1,
  0xC0, 0x60, 0x38, 0x1C, 0x1C, 0x1C, 0x07, 0x03, 0x83, 0x83, 0x80, 0x70,
  0xE0, 0x70, 0x70, 0x0E, 0x1C, 0x06, 0x0C, 0x01, 0xC3, 0x80, 0xE3, 0x80,
  0x38, 0xE0, 0x1C, 0x70, 0x03, 0x9C, 0x03, 0x8E, 0x00, 0x73, 0x80, 0x31,
  0x80, 0x0E, 0x70, 0x07, 0x70, 0x01, 0xCC, 0x00, 0xEE, 0x00, 0x1B, 0x80,
  0x1D, 0xC0, 0x03, 0xF0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x39, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x1E,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x80, 0x1C, 0x0E,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0x78, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0xC3,
  0x80, 0x07, 0x1C, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x3C, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x06, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x18, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF0, 0x1F,
  0xC0, 0x3F, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x02, 0x7F, 0xE0, 0x05, 0xFF,
  0xF0, 0x1F, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xD0, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 40, 13, 4, -39 },
  { 26, 12, 14, 19, 4, -39 },
  { 47, 29, 39, 31, 1, -39 },
  { 189, 21, 44, 28, 3, -41 },
  { 305, 34, 40, 40, 3, -39 },
  { 475, 29, 40, 33, 3, -39 },
  { 620, 3, 14, 10, 4, -39 },
  { 626, 11, 48, 15, 2, -39 },
  { 692, 11, 48, 15, 2, -39 },
  { 758, 20, 20, 26, 3, -41 },
  { 808, 23, 26, 28, 2, -32 },
  { 883, 6, 13, 12, 2, -6 },
  { 893, 12, 3, 16, 2, -16 },
  { 898, 4, 6, 12, 4, -5 },
  { 901, 17, 39, 19, 1, -39 },
  { 984, 22, 39, 28, 3, -39 },
  { 1092, 12, 39, 28, 5, -39 },
  { 1151, 22, 39, 28, 3, -39 },
  { 1259, 22, 40, 28, 2, -39 },
  { 1369, 26, 39, 28, 1, -39 },
  { 1496, 22, 40, 28, 3, -39 },
  { 1606, 22, 40, 28, 3, -39 },
  { 1716, 23, 39, 28, 2, -39 },
  { 1829, 22, 40, 28, 3, -39 },
  { 1939, 22, 40, 28, 3, -39 },
  { 2049, 5, 30, 12, 4, -29 },
  { 2068, 7, 36, 12, 2, -29 },
  { 2100, 23, 25, 28, 2, -32 },
  { 2172, 23, 14, 28, 2, -26 },
  { 2213, 23, 25, 28, 2, -32 },
  { 2285, 18, 40, 20, 1, -39 },
  { 2375, 37, 44, 43, 3, -39 },
  { 2579, 29, 39, 29, 0, -39 },
  { 2721, 23, 39, 31, 5, -39 },
  { 2834, 25, 40, 30, 3, -39 },
  { 2959, 26, 39, 34, 5, -39 },
  { 3086, 19, 39, 27, 5, -39 },
  { 3179, 19, 39, 25, 5, -39 },
  { 3272, 29, 40, 35, 3, -39 },
  { 3417, 25, 39, 35, 5, -39 },
  { 3539, 11, 39, 16, 2, -39 },
  { 3593, 12, 49, 13, -4, -39 },
  { 3667, 23, 39, 28, 5, -39 },
  { 3780, 19, 39, 25, 5, -39 },
  { 3873, 34, 39, 43, 5, -39 },
  { 4039, 26, 39, 36, 5, -39 },
  { 4166, 31, 40, 37, 3, -39 },
  { 4321, 21, 39, 28, 5, -39 },
  { 4424, 31, 48, 37, 3, -39 },
  { 4610, 23, 39, 29, 5, -39 },
  { 4723, 21, 40, 27, 3, -39 },
  { 4828, 25, 39, 25, 0, -39 },
  { 4950, 25, 40, 35, 5, -39 },
  { 5075, 28, 39, 28, 0, -39 },
  { 5212, 42, 39, 44, 1, -39 },
  { 5417, 26, 39, 26, 0, -39 },
  { 5544, 25, 39, 25, 0, -39 },
  { 5666, 23, 39, 26, 2, -39 },
  { 5779, 12, 48, 17, 4, -39 },
  { 5851, 17, 39, 19, 1, -39 },
  { 5934, 11, 48, 17, 2, -39 },
  { 6000, 24, 23, 28, 2, -39 },
  { 6069, 23, 2, 22, 0, 5 },
  { 6075, 10, 8, 14, 2, -41 },
  { 6085, 20, 30, 26, 2, -29 },
  { 6160, 22, 42, 29, 4, -41 },
  { 6276, 18, 30, 23, 3, -29 },
  { 6344, 22, 42, 29, 3, -41 },
  { 6460, 21, 30, 27, 3, -29 },
  { 6539, 17, 41, 15, 1, -41 },
  { 6627, 22, 42, 29, 3, -29 },
  { 6743, 21, 41, 29, 4, -41 },
  { 6851, 4, 39, 12, 4, -39 },
  { 6871, 10, 52, 12, -2, -39 },
  { 6936, 20, 41, 24, 4, -41 },
  { 7039, 3, 41, 12, 4, -41 },
  { 7055, 35, 29, 43, 4, -29 },
  { 7182, 21, 29, 29, 4, -29 },
  { 7259, 23, 30, 29, 3, -29 },
  { 7346, 22, 42, 29, 4, -29 },
  { 7462, 22, 42, 29, 3, -29 },
  { 7578, 14, 29, 19, 4, -29 },
  { 7629, 18, 30, 22, 2, -29 },
  { 7697, 14, 37, 16, 1, -36 },
  { 7762, 21, 30, 29, 4, -29 },
  { 7841, 23, 29, 23, 0, -29 },
  { 7925, 35, 29, 36, 1, -29 },
  { 8052, 22, 29, 24, 1, -29 },
  { 8132, 23, 42, 23, 0, -29 },
  { 8253, 18, 29, 21, 2, -29 },
  { 8319, 15, 48, 19, 2, -39 },
  { 8409, 2, 54, 26, 12, -41 },
  { 8423, 15, 48, 19, 2, -39 },
  { 8513, 23, 6, 28, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Light54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT54PT7B_H_
