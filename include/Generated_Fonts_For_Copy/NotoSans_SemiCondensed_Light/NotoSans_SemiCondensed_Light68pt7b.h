#ifndef _NOTOSANS_SEMICONDENSED_LIGHT68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light68pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x30, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x78, 0xC0, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x0E, 0x78,
  0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xE3, 0x81, 0xE1,
  0xF0, 0x70, 0x04, 0x3C, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x38,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x1F, 0x07, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x1F,
  0xDC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x3F, 0x80, 0x00,
  0xE1, 0xF8, 0x00, 0x1C, 0x0F, 0x80, 0x03, 0x80, 0xF8, 0x00, 0x70, 0x0F,
  0x00, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x07,
  0x00, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x78,
  0x00, 0x70, 0x0F, 0x00, 0x0E, 0x03, 0xC8, 0x01, 0xC0, 0xF9, 0xF0, 0x38,
  0x7E, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x38, 0x00, 0x78, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x00, 0x3C, 0x1C, 0x07,
  0x80, 0x70, 0x03, 0xC3, 0xC1, 0xFE, 0x07, 0x00, 0x38, 0x38, 0x3F, 0xF8,
  0x70, 0x03, 0x83, 0x87, 0x87, 0x87, 0x80, 0x38, 0x78, 0xF0, 0x3C, 0x38,
  0x07, 0x87, 0x0E, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0xE0, 0x1E, 0x1E, 0x0F,
  0x0E, 0x1E, 0x00, 0xE1, 0xFF, 0xE1, 0xE1, 0xC0, 0x0E, 0x0F, 0xFC, 0x1C,
  0x1C, 0x00, 0xF0, 0x3F, 0x03, 0xC1, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x70, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x70,
  0x00, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x00,
  0x3C, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x3C,
  0x00, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x1F,
  0x00, 0xF0, 0x00, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0xC0,
  0x1E, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x78, 0x00, 0x1F, 0x03, 0xC1, 0xC0,
  0x00, 0x3E, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0xF0, 0x00, 0x03, 0xEF, 0x83, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0x00,
  0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x7E,
  0x01, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0x80,
  0x00, 0xFB, 0xE0, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x7F, 0x00, 0xFE, 0x0F,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0xBC, 0x00, 0x00, 0x00, 0xFB, 0xDE, 0xF7, 0xBD,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x40, 0x0E, 0x00, 0x4E, 0x01, 0xC0, 0x39,
  0xF8, 0x38, 0x7F, 0x7F, 0xE7, 0x7F, 0xE3, 0xFF, 0xFF, 0xFA, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x00, 0x3C, 0x00, 0x20, 0x02, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE3,
  0xC7, 0x1E, 0x3C, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xEF, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x7D, 0xC3, 0xF7, 0x8F, 0xCF, 0x3E, 0x1E, 0xF8, 0x3F, 0xE0, 0x7B,
  0x80, 0xF2, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0x80, 0x00, 0xF0, 0x10, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8,
  0x20, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC8, 0x00, 0x00,
  0x7C, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x40, 0x00,
  0x0F, 0x8C, 0x00, 0x03, 0xF1, 0xF0, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0x10,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xFE, 0x00, 0xF0, 0xFF, 0xF8, 0x0F,
  0x1F, 0xFF, 0xE0, 0xF3, 0xE0, 0x7F, 0x0F, 0x78, 0x00, 0xF8, 0xFE, 0x00,
  0x07, 0x8F, 0xC0, 0x00, 0x3C, 0xFC, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80,
  0x7C, 0x03, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x0F, 0x80, 0x0F, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC1, 0xF8,
  0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xE0, 0x00,
  0xF0, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x03,
  0xF3, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0xEF, 0x1F,
  0x80, 0x3C, 0xF0, 0xFF, 0xFF, 0x8F, 0x07, 0xFF, 0xF0, 0xF0, 0x1F, 0xFC,
  0x0E, 0x00, 0x2C, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFC, 0x02, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x33,
  0xEF, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFB,
  0xFF, 0xFF, 0xF8, 0xC0, 0x06, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0xF8, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0x87,
  0x00, 0x0F, 0x88, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x1F, 0xF0, 0x01, 0xE3, 0xC0, 0x01, 0xFF,
  0xF8, 0x03, 0x8E, 0x00, 0x1F, 0xFF, 0xE0, 0x0E, 0x78, 0x00, 0xF8, 0x07,
  0x80, 0x3D, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0xF7, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xDC, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x1F, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xF8, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x1F,
  0x80, 0x3C, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xF8,
  0x03, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x1F, 0x80,
  0x3C, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xF8, 0x03,
  0xC0, 0x03, 0xC0, 0x0E, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3B, 0x80, 0x1C,
  0x00, 0x7C, 0x00, 0xEE, 0x00, 0x78, 0x01, 0xB0, 0x07, 0xBC, 0x01, 0xE0,
  0x0E, 0xE0, 0x3C, 0xF0, 0x03, 0xC0, 0x73, 0xC0, 0xE1, 0xC0, 0x07, 0xEF,
  0xC7, 0xDF, 0x87, 0x00, 0x1F, 0xFE, 0x0F, 0xFC, 0x1E, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x38, 0x00, 0x04, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFA, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x03, 0xF8, 0x78, 0x00,
  0x07, 0xE3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x3F, 0x83,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0x80,
  0x07, 0xFC, 0x3C, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFC, 0x78,
  0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFE, 0x01, 0xFC, 0x00, 0x0E, 0x03, 0xF0,
  0x00, 0x02, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x02, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x07, 0xFC, 0x07, 0x80, 0x00, 0x7F, 0x03, 0xC0,
  0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x01, 0xFC, 0x0F,
  0x00, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x03, 0xC0, 0x1F, 0x80, 0x00, 0x0C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x01, 0xF8, 0x00,
  0x00, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x7D, 0x03, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC,
  0x00, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0,
  0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F,
  0x1F, 0x80, 0x00, 0x3C, 0xFE, 0x00, 0x00, 0xF7, 0xFC, 0x00, 0x03, 0xFC,
  0xF8, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xDF, 0xDC, 0x00, 0x00,
  0x00, 0xF7, 0xF7, 0x80, 0x00, 0x00, 0x39, 0xFD, 0xE0, 0x00, 0x00, 0x1E,
  0x7F, 0x3C, 0x00, 0x00, 0x07, 0x9F, 0xCF, 0x00, 0x00, 0x01, 0xC7, 0xF3,
  0xC0, 0x00, 0x00, 0xF1, 0xFC, 0x78, 0x00, 0x00, 0x3C, 0x7F, 0x1E, 0x00,
  0x00, 0x0E, 0x1F, 0xC3, 0x80, 0x00, 0x07, 0x87, 0xF0, 0xF0, 0x00, 0x01,
  0xE1, 0xFC, 0x3C, 0x00, 0x00, 0x70, 0x7F, 0x07, 0x00, 0x00, 0x3C, 0x1F,
  0xC1, 0xE0, 0x00, 0x0F, 0x07, 0xF0, 0x78, 0x00, 0x03, 0x81, 0xFC, 0x0E,
  0x00, 0x01, 0xE0, 0x7F, 0x03, 0xC0, 0x00, 0x70, 0x1F, 0xC0, 0xF0, 0x00,
  0x3C, 0x07, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xFC, 0x07, 0x80, 0x03, 0x80,
  0x7F, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0xF0,
  0x0F, 0x00, 0x1C, 0x01, 0xFC, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x78,
  0x01, 0xFC, 0x00, 0xF0, 0x1C, 0x00, 0x7F, 0x00, 0x3C, 0x07, 0x00, 0x1F,
  0xC0, 0x07, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0xE0, 0x01, 0xFC, 0x00,
  0x78, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0xC0, 0x03, 0xC7,
  0x00, 0x07, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF7,
  0x80, 0x00, 0x07, 0xFB, 0xE0, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x01, 0xFE,
  0x3C, 0x00, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x7F, 0x87, 0x80, 0x00, 0x3F,
  0xC3, 0xE0, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x07,
  0xF8, 0x1E, 0x00, 0x03, 0xFC, 0x07, 0x80, 0x01, 0xFE, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x3F, 0xC0, 0x1E, 0x00,
  0x1F, 0xE0, 0x07, 0x80, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0xF0,
  0x03, 0xFC, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x7F, 0x80, 0x03, 0xC0, 0x3F, 0xC0, 0x00, 0xF0, 0x1F, 0xE0, 0x00,
  0x7C, 0x0F, 0xF0, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x0F, 0x83, 0xFC, 0x00,
  0x03, 0xC1, 0xFE, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x78, 0x7F, 0x80,
  0x00, 0x1E, 0x3F, 0xC0, 0x00, 0x0F, 0x9F, 0xE0, 0x00, 0x03, 0xCF, 0xF0,
  0x00, 0x01, 0xF7, 0xF8, 0x00, 0x00, 0x7B, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x7E, 0x3C, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x7E, 0x1E,
  0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFF,
  0xE8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x1E, 0x00,
  0x0F, 0xC0, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xE1, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x01, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xCC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x3C, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x1C, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x1C,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x1C,
  0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFE,
  0x3F, 0x80, 0xF0, 0x03, 0xE0, 0x40, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE1, 0xFC, 0x00, 0xF3, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x3D, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x7C, 0x00, 0x77, 0xBF, 0x00, 0xF3, 0xCF,
  0xFF, 0xF1, 0xE3, 0xFF, 0xF0, 0x70, 0x7F, 0xF0, 0x38, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0xF0, 0x7F, 0xF8, 0x0F,
  0x0F, 0xFF, 0xE0, 0xF1, 0xFD, 0xFF, 0x0F, 0x3C, 0x01, 0xF8, 0xF7, 0x00,
  0x0F, 0x8F, 0x60, 0x00, 0x7C, 0xFE, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x1E,
  0xFC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0E, 0xF8, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x1E, 0xFC, 0x00,
  0x03, 0xEF, 0xE0, 0x00, 0x3C, 0xFE, 0x00, 0x07, 0xCF, 0x70, 0x00, 0xF8,
  0xF3, 0xC0, 0x3F, 0x0F, 0x1F, 0xFF, 0xE0, 0xF0, 0xFF, 0xFC, 0x0E, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFC, 0x00, 0xC3, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x1C, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x01,
  0xF8, 0x07, 0x01, 0xFF, 0xE0, 0xE0, 0x7F, 0xFE, 0x1C, 0x3F, 0xEF, 0xE3,
  0x87, 0xC0, 0x1E, 0x71, 0xF0, 0x00, 0xEE, 0x7C, 0x00, 0x0D, 0xCF, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xB8, 0xF8,
  0x00, 0x77, 0x1F, 0x80, 0x3C, 0xE1, 0xFF, 0xFF, 0x1C, 0x1F, 0xFF, 0xC3,
  0x80, 0xFF, 0xE0, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x83, 0xF0, 0x01, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xF8, 0x60, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x1C, 0x0F,
  0xFF, 0xC3, 0x87, 0xFD, 0xFE, 0x70, 0xF8, 0x03, 0xCE, 0x3E, 0x00, 0x1D,
  0xCF, 0x80, 0x01, 0xF9, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x37, 0x1F, 0x00, 0x1E, 0xE3, 0xF0, 0x07, 0x9C, 0x3F,
  0xFF, 0xE3, 0x83, 0xFF, 0xF8, 0x70, 0x1F, 0xFC, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF2, 0x00, 0x00, 0x3C, 0x30, 0x00,
  0x1F, 0x87, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x7F, 0xF8, 0x3C, 0x3F,
  0xFF, 0x8F, 0x1F, 0xDF, 0xF3, 0xCF, 0x00, 0x7C, 0xF7, 0x00, 0x0F, 0xBF,
  0x80, 0x01, 0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0x27, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80,
  0x00, 0x40, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x87, 0xCF, 0xFC,
  0xFF, 0x8F, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x3C,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF3, 0xF8, 0x00, 0x79, 0xFE,
  0x00, 0x3D, 0xCF, 0x00, 0x1F, 0xC3, 0xC0, 0x0F, 0xE1, 0xE0, 0x07, 0xE0,
  0x78, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78,
  0x01, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0xF1, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0x3F,
  0xBF, 0xC3, 0xFB, 0xFC, 0xF7, 0x80, 0x7C, 0x78, 0x07, 0xEF, 0x70, 0x01,
  0xEF, 0x00, 0x3E, 0xFE, 0x00, 0x1E, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x3C, 0x1F, 0xFE,
  0x0F, 0x0F, 0xFF, 0xE3, 0xC7, 0xF7, 0xFC, 0xF3, 0xC0, 0x1F, 0x3D, 0xC0,
  0x03, 0xEF, 0x60, 0x00, 0x7B, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x1C,
  0x1F, 0xFE, 0x03, 0x87, 0xFF, 0xF0, 0x71, 0xFD, 0xFF, 0x0E, 0x78, 0x03,
  0xF1, 0xDC, 0x00, 0x3E, 0x3B, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3C, 0xF8,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00,
  0x0F, 0xBF, 0x00, 0x01, 0xE7, 0x70, 0x00, 0x7C, 0xEF, 0x00, 0x1F, 0x1C,
  0xF0, 0x0F, 0xC3, 0x8F, 0xFF, 0xF0, 0x70, 0xFF, 0xFC, 0x0E, 0x0F, 0xFE,
  0x01, 0xC0, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x07, 0x01, 0xFF, 0xF8, 0x70, 0x7F, 0xDF, 0xC7, 0x0F, 0xC0, 0x1E,
  0x70, 0xF8, 0x00, 0x77, 0x1F, 0x00, 0x03, 0x71, 0xE0, 0x00, 0x3F, 0x3C,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x77, 0x0F,
  0x80, 0x0E, 0x70, 0xFC, 0x01, 0xE7, 0x07, 0xFF, 0xFC, 0x70, 0x3F, 0xFF,
  0x87, 0x00, 0xFF, 0xE0, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0x70, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7C, 0x07,
  0x78, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF1, 0xFF, 0x3F, 0xC3, 0xE0, 0x03, 0x8F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x79, 0xE0, 0x03, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0x78, 0x00, 0x0F, 0xDE, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xFC, 0xF0,
  0x00, 0xEF, 0x3F, 0x00, 0xF9, 0xC7, 0xFF, 0xFC, 0x70, 0xFF, 0xFC, 0x1C,
  0x0F, 0xFE, 0x07, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x70, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x0E,
  0x70, 0x00, 0x1F, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xF8, 0x00, 0x1E, 0x78,
  0x00, 0x1F, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xFC, 0x00, 0x1C, 0x38, 0x00,
  0x39, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x9C, 0x00, 0x3C, 0x3C, 0x00, 0x39,
  0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0x1C, 0x00, 0x79, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x81, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x07, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x38, 0x1E, 0x00, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x03,
  0xC1, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0x80,
  0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x01,
  0xEE, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x00, 0xEE,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFA, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 50, 16, 5, -49 },
  { 39, 16, 18, 24, 4, -49 },
  { 75, 35, 49, 39, 2, -49 },
  { 290, 27, 56, 35, 4, -52 },
  { 479, 44, 50, 50, 3, -49 },
  { 754, 38, 50, 42, 3, -49 },
  { 992, 5, 18, 13, 4, -49 },
  { 1004, 14, 60, 19, 3, -49 },
  { 1109, 14, 60, 19, 2, -49 },
  { 1214, 27, 26, 33, 3, -52 },
  { 1302, 29, 32, 35, 3, -40 },
  { 1418, 7, 17, 15, 3, -8 },
  { 1433, 16, 3, 21, 2, -20 },
  { 1439, 6, 7, 16, 5, -6 },
  { 1445, 22, 49, 24, 1, -49 },
  { 1580, 28, 50, 35, 3, -49 },
  { 1755, 15, 49, 35, 6, -49 },
  { 1847, 28, 49, 35, 3, -49 },
  { 2019, 28, 50, 35, 3, -49 },
  { 2194, 33, 49, 35, 1, -49 },
  { 2397, 27, 50, 35, 4, -49 },
  { 2566, 28, 50, 35, 4, -49 },
  { 2741, 28, 49, 35, 3, -49 },
  { 2913, 28, 50, 35, 3, -49 },
  { 3088, 28, 50, 35, 3, -49 },
  { 3263, 6, 38, 16, 5, -37 },
  { 3292, 9, 46, 16, 2, -37 },
  { 3344, 29, 31, 35, 3, -40 },
  { 3457, 29, 18, 35, 3, -33 },
  { 3523, 29, 31, 35, 3, -40 },
  { 3636, 23, 50, 26, 1, -49 },
  { 3780, 46, 54, 54, 4, -48 },
  { 4091, 36, 49, 37, 0, -49 },
  { 4312, 29, 49, 38, 6, -49 },
  { 4490, 32, 50, 38, 4, -49 },
  { 4690, 33, 49, 43, 6, -49 },
  { 4893, 24, 49, 34, 6, -49 },
  { 5040, 24, 49, 31, 6, -49 },
  { 5187, 36, 50, 44, 4, -49 },
  { 5412, 32, 49, 44, 6, -49 },
  { 5608, 14, 49, 20, 3, -49 },
  { 5694, 15, 61, 16, -5, -49 },
  { 5809, 30, 49, 36, 6, -49 },
  { 5993, 24, 49, 31, 6, -49 },
  { 6140, 42, 49, 55, 6, -49 },
  { 6398, 33, 49, 45, 6, -49 },
  { 6601, 38, 50, 46, 4, -49 },
  { 6839, 27, 49, 36, 6, -49 },
  { 7005, 38, 61, 46, 4, -49 },
  { 7295, 29, 49, 37, 6, -49 },
  { 7473, 27, 50, 34, 3, -49 },
  { 7642, 31, 49, 32, 0, -49 },
  { 7832, 32, 50, 44, 6, -49 },
  { 8032, 35, 49, 35, 0, -49 },
  { 8247, 54, 49, 56, 1, -49 },
  { 8578, 33, 49, 33, 0, -49 },
  { 8781, 32, 49, 32, 0, -49 },
  { 8977, 29, 49, 33, 2, -49 },
  { 9155, 14, 60, 22, 6, -49 },
  { 9260, 22, 49, 24, 1, -49 },
  { 9395, 14, 60, 22, 2, -49 },
  { 9500, 31, 28, 35, 2, -49 },
  { 9609, 28, 3, 28, 0, 6 },
  { 9620, 12, 11, 18, 3, -52 },
  { 9637, 25, 38, 33, 3, -37 },
  { 9756, 28, 53, 37, 5, -52 },
  { 9942, 23, 38, 29, 4, -37 },
  { 10052, 27, 53, 37, 4, -52 },
  { 10231, 26, 38, 34, 4, -37 },
  { 10355, 21, 52, 19, 1, -52 },
  { 10492, 27, 53, 37, 4, -37 },
  { 10671, 26, 52, 36, 5, -52 },
  { 10840, 5, 50, 15, 5, -50 },
  { 10872, 12, 66, 15, -2, -50 },
  { 10971, 25, 52, 30, 5, -52 },
  { 11134, 3, 52, 15, 6, -52 },
  { 11154, 44, 37, 55, 5, -37 },
  { 11358, 26, 37, 36, 5, -37 },
  { 11479, 28, 38, 36, 4, -37 },
  { 11612, 27, 53, 37, 6, -37 },
  { 11791, 28, 53, 37, 3, -37 },
  { 11977, 17, 37, 24, 6, -37 },
  { 12056, 23, 38, 28, 3, -37 },
  { 12166, 18, 46, 20, 1, -45 },
  { 12270, 26, 37, 36, 5, -36 },
  { 12391, 28, 36, 28, 0, -36 },
  { 12517, 44, 36, 46, 1, -36 },
  { 12715, 28, 36, 30, 1, -36 },
  { 12841, 29, 52, 29, 0, -36 },
  { 13030, 23, 36, 27, 2, -36 },
  { 13134, 20, 60, 24, 2, -49 },
  { 13284, 3, 69, 33, 15, -52 },
  { 13310, 19, 60, 24, 3, -49 },
  { 13453, 29, 8, 35, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_Light68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT68PT7B_H_
