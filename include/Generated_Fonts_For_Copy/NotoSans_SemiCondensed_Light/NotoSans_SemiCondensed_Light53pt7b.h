#ifndef _NOTOSANS_SEMICONDENSED_LIGHT53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76,
  0x66, 0x66, 0x66, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0x20, 0xF0, 0x77, 0x07,
  0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x76, 0x07, 0x60, 0x76, 0x07,
  0x60, 0x76, 0x07, 0x60, 0x36, 0x03, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x18, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x38,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x18, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF8, 0xF9,
  0x8F, 0x8F, 0x0C, 0x04, 0x70, 0x60, 0x07, 0x03, 0x00, 0x38, 0x18, 0x01,
  0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x70, 0x30, 0x03, 0x81, 0x80, 0x1E, 0x0C,
  0x00, 0x78, 0x60, 0x01, 0xE3, 0x00, 0x0F, 0xD8, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0C, 0xF8, 0x00, 0x61,
  0xE0, 0x03, 0x07, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x80,
  0x30, 0x1C, 0x01, 0x80, 0xE0, 0x0C, 0x07, 0x00, 0x60, 0x70, 0x03, 0x07,
  0xB0, 0x18, 0x79, 0xFC, 0xDF, 0x8F, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0xC0, 0x00, 0xE0, 0x0F, 0xF8, 0x00, 0x30, 0x07, 0x8F, 0x00, 0x1C,
  0x01, 0xC1, 0xC0, 0x06, 0x00, 0x60, 0x30, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0xC0, 0x0E, 0x03, 0x80, 0x70, 0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18,
  0x0E, 0x00, 0x30, 0x06, 0x03, 0x80, 0x0C, 0x01, 0x81, 0xC0, 0x03, 0x00,
  0x60, 0x70, 0x00, 0xC0, 0x18, 0x38, 0x00, 0x30, 0x06, 0x0E, 0x00, 0x0C,
  0x01, 0x87, 0x00, 0x03, 0x00, 0xE1, 0xC3, 0xF0, 0xE0, 0x38, 0x61, 0xFE,
  0x38, 0x0E, 0x38, 0xE3, 0xC6, 0x03, 0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x1C,
  0x0E, 0x38, 0xE1, 0x86, 0x03, 0x8F, 0xF8, 0xE3, 0x80, 0x61, 0xFC, 0x30,
  0xE0, 0x18, 0x00, 0x1C, 0x38, 0x06, 0x00, 0x06, 0x0E, 0x01, 0xC0, 0x03,
  0x83, 0x80, 0x70, 0x00, 0xC0, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x07, 0x00,
  0x1C, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x60, 0x03, 0x80, 0xE0, 0x18,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0x70, 0x06, 0x03, 0x80, 0x38, 0x01, 0x80,
  0xE0, 0x0E, 0x00, 0x70, 0x30, 0x07, 0x00, 0x0E, 0x1C, 0x01, 0xC0, 0x03,
  0xFE, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1C, 0x07, 0x80,
  0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x0E, 0x1E, 0x0F, 0x00, 0x71, 0xE0, 0x3C, 0x03, 0x8E, 0x00, 0xE0,
  0x1C, 0xE0, 0x03, 0x81, 0xC7, 0x00, 0x1E, 0x0E, 0x38, 0x00, 0x78, 0xF1,
  0xC0, 0x01, 0xE7, 0x0E, 0x00, 0x07, 0xF8, 0x70, 0x00, 0x1F, 0x83, 0x80,
  0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3F, 0x03, 0x80, 0x03,
  0xFC, 0x1E, 0x00, 0x7C, 0xF0, 0x7E, 0x0F, 0xC3, 0xC1, 0xFF, 0xF8, 0x0F,
  0x03, 0xFF, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x00, 0xF7, 0x77, 0x77, 0x76,
  0x66, 0x66, 0x66, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00, 0xC0, 0x6F,
  0x86, 0x1F, 0xFF, 0xB7, 0xF8, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0D, 0xC0, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xF0, 0xE0, 0x07,
  0x03, 0x80, 0x70, 0x1E, 0x07, 0x80, 0x70, 0x08, 0x02, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x73,
  0xCE, 0x38, 0xE3, 0x9C, 0x71, 0xC6, 0x38, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x6F, 0xFF, 0xF6, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xE3, 0xE0, 0x3C, 0x07, 0x83,
  0xC0, 0x1E, 0x1C, 0x00, 0x71, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x01, 0xCF, 0x00,
  0x0E, 0x38, 0x00, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x70, 0x1F, 0x1F, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x3C, 0x0F, 0x83, 0xF0, 0xF6,
  0x78, 0xDE, 0x1F, 0x83, 0xE0, 0x68, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x03, 0xF8, 0xFC, 0x1F, 0x00, 0x78, 0x30, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF,
  0x03, 0xF0, 0x7E, 0x3E, 0x00, 0x7C, 0x60, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xCC, 0x00, 0x1F, 0x3F, 0x01, 0xF8, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0x70, 0x30, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x7F, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x08, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x30,
  0x00, 0xF9, 0xF0, 0x1F, 0x8F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x02, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x7F, 0xC0, 0xE3, 0xFF, 0xC3,
  0xBC, 0x0F, 0x8E, 0xC0, 0x0F, 0x3E, 0x00, 0x1C, 0xF0, 0x00, 0x7B, 0xC0,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xC1, 0xE0,
  0x0E, 0x03, 0xE0, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x7C, 0x0F, 0x00, 0x78, 0x78, 0x00, 0xF1,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xF0, 0x07,
  0x81, 0xE0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0xDF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0x0F, 0x80, 0xF0, 0x0F, 0x83, 0x80,
  0x0E, 0x1C, 0x00, 0x1C, 0xF0, 0x00, 0x7B, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x80, 0x0F, 0x0F, 0x80,
  0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x7C, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF0,
  0xE0, 0x01, 0xC7, 0x80, 0x07, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0x67, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0xF3,
  0x80, 0x07, 0xCF, 0x00, 0x37, 0x1E, 0x03, 0xDC, 0x3F, 0xFE, 0x70, 0x7F,
  0xE1, 0xC0, 0x1E, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x04, 0x07,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x2F, 0xFF,
  0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF,
  0xF2, 0x08, 0xF3, 0xCF, 0x3C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3C, 0xF3, 0x8E, 0x39, 0xC7,
  0x1C, 0x61, 0x8E, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x1F, 0xF8, 0x3F, 0xFE, 0x3F, 0x1F, 0x8C, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x1F, 0xF8, 0x0E, 0x30, 0x03, 0xFF, 0xC0, 0x67, 0x00, 0x78,
  0x1C, 0x07, 0x70, 0x0E, 0x01, 0xC0, 0x76, 0x01, 0xC0, 0x1C, 0x07, 0xE0,
  0x1C, 0x01, 0x80, 0x3E, 0x03, 0x80, 0x18, 0x03, 0xE0, 0x38, 0x01, 0x80,
  0x3E, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x30, 0x01, 0x80, 0x3C, 0x03, 0x00,
  0x18, 0x03, 0xC0, 0x30, 0x03, 0x80, 0x7C, 0x03, 0x00, 0x38, 0x07, 0xC0,
  0x30, 0x03, 0x80, 0x7E, 0x03, 0x00, 0x38, 0x06, 0xE0, 0x38, 0x07, 0x80,
  0x6E, 0x03, 0x80, 0x78, 0x0E, 0xE0, 0x1C, 0x0E, 0xC1, 0xC6, 0x01, 0xE1,
  0xCE, 0x3C, 0x60, 0x0F, 0xF8, 0x7F, 0x87, 0x00, 0x3F, 0x03, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x38, 0x00,
  0xFC, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x3B, 0x80, 0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x07,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xE0, 0x01, 0xF3,
  0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xEE,
  0x00, 0x1F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x8F, 0xC0, 0x7C, 0x00, 0x60,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x40, 0x7F, 0x03, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x04,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1C, 0x00,
  0xFE, 0x0E, 0x00, 0x0F, 0x87, 0x00, 0x03, 0xE3, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x7C, 0x70, 0x00, 0x7C, 0x38,
  0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xB8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x01,
  0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x20, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70,
  0xF8, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x70, 0x1F, 0xC0, 0x7F, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x7C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0x83, 0xCF, 0xFC, 0xFF, 0x83, 0xC0, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x1E, 0x1C, 0x00,
  0x78, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x78, 0x00, 0x71, 0xE0, 0x00, 0xE7, 0x80, 0x01, 0xCF, 0x80, 0x03,
  0xBF, 0x00, 0x07, 0xEF, 0x00, 0x0F, 0x8F, 0x00, 0x1E, 0x0E, 0x00, 0x38,
  0x1E, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0xF0, 0x70, 0x00, 0xF0, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xE3, 0x80, 0x01,
  0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xDF, 0xB8, 0x00, 0x00, 0xEF, 0xDC, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00,
  0x73, 0xF3, 0x80, 0x00, 0x39, 0xF9, 0xC0, 0x00, 0x18, 0xFC, 0xE0, 0x00,
  0x1C, 0x7E, 0x38, 0x00, 0x0E, 0x3F, 0x1C, 0x00, 0x06, 0x1F, 0x8E, 0x00,
  0x07, 0x0F, 0xC3, 0x80, 0x03, 0x87, 0xE1, 0xC0, 0x03, 0x83, 0xF0, 0x70,
  0x01, 0xC1, 0xF8, 0x38, 0x00, 0xE0, 0xFC, 0x1C, 0x00, 0xE0, 0x7E, 0x07,
  0x00, 0x70, 0x3F, 0x03, 0x80, 0x30, 0x1F, 0x81, 0xC0, 0x38, 0x0F, 0xC0,
  0x70, 0x1C, 0x07, 0xE0, 0x38, 0x0C, 0x03, 0xF0, 0x1C, 0x0E, 0x01, 0xF8,
  0x07, 0x07, 0x00, 0xFC, 0x03, 0x87, 0x00, 0x7E, 0x01, 0xC3, 0x80, 0x3F,
  0x00, 0x71, 0xC0, 0x1F, 0x80, 0x39, 0xC0, 0x0F, 0xC0, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0x70, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0E, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3E, 0xE0, 0x00, 0x1F, 0xB8, 0x00, 0x0F, 0xDC,
  0x00, 0x07, 0xE7, 0x00, 0x03, 0xF3, 0xC0, 0x01, 0xF8, 0xE0, 0x00, 0xFC,
  0x78, 0x00, 0x7E, 0x1C, 0x00, 0x3F, 0x07, 0x00, 0x1F, 0x83, 0xC0, 0x0F,
  0xC0, 0xE0, 0x07, 0xE0, 0x78, 0x03, 0xF0, 0x1C, 0x01, 0xF8, 0x0F, 0x00,
  0xFC, 0x03, 0x80, 0x7E, 0x00, 0xE0, 0x3F, 0x00, 0x78, 0x1F, 0x80, 0x1C,
  0x0F, 0xC0, 0x0F, 0x07, 0xE0, 0x03, 0x83, 0xF0, 0x01, 0xE1, 0xF8, 0x00,
  0x70, 0xFC, 0x00, 0x1C, 0x7E, 0x00, 0x0F, 0x3F, 0x00, 0x03, 0x9F, 0x80,
  0x01, 0xEF, 0xC0, 0x00, 0x77, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xC0,
  0x0F, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x03, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xE7,
  0x00, 0x0F, 0x38, 0x00, 0xF1, 0xC0, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x57, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0x00, 0x3E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xE7,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x78, 0xE0, 0x01, 0xE1, 0xC0, 0x07, 0x83, 0x80, 0x3E, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x38, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x3C,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xE7, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0xDC, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x87,
  0xF3, 0xFC, 0x78, 0x00, 0xC7, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x20,
  0x00, 0xF9, 0xF8, 0x1F, 0x8F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x03,
  0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xEF, 0x00, 0x01,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x70, 0x00, 0x3E, 0x00,
  0x07, 0x9C, 0x00, 0x0D, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x70, 0x00, 0x70,
  0xE0, 0x01, 0xDC, 0x00, 0x1C, 0x38, 0x00, 0x77, 0x00, 0x0F, 0x0E, 0x00,
  0x1C, 0xE0, 0x03, 0x83, 0x80, 0x06, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x8E,
  0x00, 0x38, 0x1C, 0x00, 0xE3, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x70, 0x07,
  0x01, 0xC0, 0x0C, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x07, 0x00, 0x70, 0x0E,
  0x01, 0xC1, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x00, 0xE0, 0x18,
  0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0xE0,
  0x78, 0x01, 0xC0, 0xE0, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00,
  0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x30, 0x70, 0x00, 0xE1,
  0xC0, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00,
  0xE3, 0x80, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x00, 0x73, 0x80, 0x07, 0x70,
  0x00, 0x1C, 0xC0, 0x01, 0xDC, 0x00, 0x03, 0x70, 0x00, 0x77, 0x00, 0x00,
  0xFC, 0x00, 0x0D, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x9C, 0x00,
  0x03, 0x87, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x70, 0x01,
  0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x78,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03,
  0x9C, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE6,
  0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81,
  0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x18, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x81, 0xE0, 0x3C, 0x08, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF8, 0x07, 0x3C,
  0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0x70, 0x01, 0xF7, 0x80, 0x37,
  0x3C, 0x0E, 0x73, 0xFF, 0xC7, 0x0F, 0xF8, 0x70, 0x08, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0xE1, 0xFF, 0x83, 0x9F, 0xFF,
  0x0E, 0x70, 0x3E, 0x3B, 0x00, 0x3C, 0xF8, 0x00, 0x73, 0xE0, 0x01, 0xEF,
  0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x80, 0x07, 0x3E, 0x00,
  0x3C, 0xEC, 0x01, 0xE3, 0x9C, 0x0F, 0x8E, 0x3F, 0xFC, 0x38, 0x7F, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3E, 0x06,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x1C, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0xF0, 0x30, 0x7F, 0xE1, 0x87, 0xFF, 0x8C,
  0x7C, 0x0E, 0x67, 0x80, 0x1B, 0x38, 0x00, 0xFB, 0xC0, 0x03, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0x70, 0x01, 0xB3, 0xC0, 0x1D,
  0x8F, 0x81, 0xCC, 0x3F, 0xFC, 0x60, 0xFF, 0xC3, 0x00, 0x20, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x07, 0x83, 0xC0, 0x1C,
  0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0x07, 0xE0, 0x38, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x10, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xC1, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0xC3, 0xFF, 0xE6,
  0x3E, 0x07, 0x33, 0xC0, 0x0D, 0x9C, 0x00, 0x3D, 0xE0, 0x01, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0xD9, 0xE0, 0x0E,
  0xC7, 0xC0, 0xE6, 0x1F, 0xFE, 0x30, 0x3F, 0xE1, 0x80, 0x20, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x20, 0x00, 0x79, 0xE0, 0x0F, 0x8F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x17, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x07,
  0xC0, 0xE1, 0xFF, 0x8E, 0x7F, 0xFC, 0xEF, 0x03, 0xEE, 0xC0, 0x0E, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x6F,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x01, 0x80, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0xBF, 0xCF, 0xE1, 0xE0,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x01, 0xC7,
  0x00, 0x78, 0xE0, 0x1E, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x38, 0x0E,
  0x0F, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x07, 0x1C, 0x00, 0xE7, 0xC0, 0x1D,
  0xF8, 0x03, 0xB3, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0x01, 0xE0, 0x70, 0x38,
  0x0F, 0x07, 0x00, 0xE0, 0xE0, 0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x70,
  0x03, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0xB8, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x1C, 0x7F, 0xC0, 0x7F, 0xC3, 0x9F,
  0xFE, 0x3F, 0xFC, 0x77, 0x03, 0xC7, 0x03, 0xCE, 0xC0, 0x3D, 0x80, 0x3D,
  0xF0, 0x03, 0xF0, 0x03, 0xBC, 0x00, 0x7C, 0x00, 0x77, 0x80, 0x07, 0x80,
  0x0E, 0xF0, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0,
  0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80,
  0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01,
  0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7C, 0x0E,
  0x1F, 0xF8, 0xE7, 0xFF, 0xCE, 0x70, 0x3E, 0xEC, 0x00, 0xEF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF0,
  0xE0, 0x01, 0xC7, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00,
  0x03, 0x9E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0x70, 0x03, 0x81, 0xF0, 0x3E,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x03,
  0x87, 0xFE, 0x0E, 0x3F, 0xFC, 0x39, 0xC0, 0xF8, 0xEC, 0x00, 0xF3, 0xE0,
  0x01, 0xCF, 0x80, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xBE, 0x00, 0x1C, 0xFC, 0x00, 0xF3, 0xB8, 0x07, 0x8E, 0x70, 0x3E, 0x38,
  0xFF, 0xF0, 0xE1, 0xFF, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0xC3, 0xFF,
  0xC6, 0x3E, 0x07, 0x33, 0xC0, 0x0D, 0x9C, 0x00, 0x7D, 0xE0, 0x01, 0xEE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0xD9, 0xE0,
  0x0E, 0xC7, 0xC1, 0xE6, 0x1F, 0xFE, 0x70, 0x7F, 0xE3, 0x80, 0x20, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x7B, 0x87, 0xFE,
  0x3F, 0xF9, 0xC1, 0xEE, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xF0, 0x0E, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xB0, 0x01, 0xEF, 0x80, 0xF3,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x04, 0x1F, 0xF0, 0x3F, 0xC0, 0x10, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x1F, 0x78, 0x03,
  0x73, 0xE0, 0xF3, 0x1F, 0xFE, 0x30, 0xFF, 0x83, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00,
  0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0,
  0x70, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x0C, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x39, 0xC0, 0x0F, 0xC0, 0x0E, 0x70, 0x03, 0xF0,
  0x03, 0x9C, 0x00, 0xDC, 0x00, 0xC7, 0x00, 0x73, 0x00, 0x70, 0xE0, 0x1C,
  0xE0, 0x1C, 0x38, 0x07, 0x38, 0x07, 0x0E, 0x01, 0x8E, 0x01, 0x83, 0x80,
  0xE1, 0xC0, 0xE0, 0x70, 0x38, 0x70, 0x38, 0x1C, 0x0E, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x03, 0x01, 0xC1, 0xC0, 0xE1, 0xC0, 0x38, 0x70, 0x38, 0x70,
  0x0E, 0x18, 0x0E, 0x1C, 0x03, 0x8E, 0x01, 0x86, 0x00, 0xE3, 0x80, 0x73,
  0x80, 0x1C, 0xE0, 0x1C, 0xE0, 0x07, 0x30, 0x07, 0x38, 0x01, 0xDC, 0x00,
  0xCC, 0x00, 0x37, 0x00, 0x3F, 0x00, 0x0D, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x38,
  0x03, 0xC1, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0,
  0x03, 0x8F, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x38, 0x07, 0x01,
  0xC0, 0x78, 0x07, 0x03, 0x80, 0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x9C,
  0x00, 0x1F, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00,
  0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x03,
  0x80, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0,
  0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0xFE, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x05,
  0xFF, 0xE0, 0x1F, 0x83, 0xFD, 0xFC, 0x01, 0xFF, 0xD0, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 39, 12, 4, -38 },
  { 21, 12, 14, 19, 3, -38 },
  { 42, 28, 38, 30, 1, -38 },
  { 175, 21, 43, 27, 3, -40 },
  { 288, 34, 39, 39, 3, -38 },
  { 454, 29, 39, 32, 3, -38 },
  { 596, 4, 14, 10, 3, -38 },
  { 603, 11, 46, 15, 2, -38 },
  { 667, 10, 46, 15, 2, -38 },
  { 725, 21, 20, 26, 2, -40 },
  { 778, 23, 25, 27, 2, -31 },
  { 850, 6, 13, 12, 2, -6 },
  { 860, 12, 3, 16, 2, -16 },
  { 865, 4, 6, 12, 4, -5 },
  { 868, 17, 38, 18, 1, -38 },
  { 949, 21, 38, 27, 3, -38 },
  { 1049, 11, 38, 27, 5, -38 },
  { 1102, 22, 38, 27, 2, -38 },
  { 1207, 22, 39, 27, 2, -38 },
  { 1315, 25, 38, 27, 1, -38 },
  { 1434, 21, 39, 27, 3, -38 },
  { 1537, 22, 39, 27, 3, -38 },
  { 1645, 22, 38, 27, 2, -38 },
  { 1750, 22, 39, 27, 3, -38 },
  { 1858, 22, 39, 27, 2, -38 },
  { 1966, 4, 30, 12, 4, -29 },
  { 1981, 6, 36, 12, 2, -29 },
  { 2008, 23, 24, 27, 2, -31 },
  { 2077, 23, 13, 27, 2, -25 },
  { 2115, 23, 24, 27, 2, -31 },
  { 2184, 17, 39, 20, 1, -38 },
  { 2267, 36, 43, 42, 3, -38 },
  { 2461, 28, 38, 28, 0, -38 },
  { 2594, 22, 38, 30, 5, -38 },
  { 2699, 25, 39, 29, 3, -38 },
  { 2821, 25, 38, 33, 5, -38 },
  { 2940, 18, 38, 26, 5, -38 },
  { 3026, 18, 38, 24, 5, -38 },
  { 3112, 28, 39, 35, 3, -38 },
  { 3249, 24, 38, 34, 5, -38 },
  { 3363, 11, 38, 15, 2, -38 },
  { 3416, 12, 48, 12, -4, -38 },
  { 3488, 23, 38, 28, 5, -38 },
  { 3598, 18, 38, 24, 5, -38 },
  { 3684, 33, 38, 43, 5, -38 },
  { 3841, 25, 38, 35, 5, -38 },
  { 3960, 30, 39, 36, 3, -38 },
  { 4107, 21, 38, 28, 5, -38 },
  { 4207, 30, 47, 36, 3, -38 },
  { 4384, 23, 38, 29, 5, -38 },
  { 4494, 21, 39, 26, 3, -38 },
  { 4597, 24, 38, 25, 0, -38 },
  { 4711, 26, 39, 34, 4, -38 },
  { 4838, 27, 38, 27, 0, -38 },
  { 4967, 42, 38, 43, 1, -38 },
  { 5167, 25, 38, 26, 0, -38 },
  { 5286, 25, 38, 25, 0, -38 },
  { 5405, 22, 38, 26, 2, -38 },
  { 5510, 11, 46, 17, 4, -38 },
  { 5574, 17, 38, 18, 1, -38 },
  { 5655, 11, 46, 17, 1, -38 },
  { 5719, 24, 22, 27, 2, -38 },
  { 5785, 22, 2, 22, 0, 5 },
  { 5791, 10, 9, 14, 2, -41 },
  { 5803, 20, 30, 26, 2, -29 },
  { 5878, 22, 41, 29, 4, -40 },
  { 5991, 18, 30, 22, 3, -29 },
  { 6059, 21, 41, 29, 3, -40 },
  { 6167, 21, 30, 26, 3, -29 },
  { 6246, 16, 41, 15, 1, -41 },
  { 6328, 21, 42, 29, 3, -29 },
  { 6439, 20, 40, 28, 4, -40 },
  { 6539, 4, 39, 12, 4, -39 },
  { 6559, 10, 52, 12, -2, -39 },
  { 6624, 19, 40, 24, 4, -40 },
  { 6719, 3, 40, 11, 4, -40 },
  { 6734, 35, 29, 43, 4, -29 },
  { 6861, 20, 29, 28, 4, -29 },
  { 6934, 22, 30, 28, 3, -29 },
  { 7017, 22, 42, 29, 4, -29 },
  { 7133, 21, 42, 29, 3, -29 },
  { 7244, 14, 29, 19, 4, -29 },
  { 7295, 18, 30, 22, 2, -29 },
  { 7363, 14, 36, 16, 1, -35 },
  { 7426, 20, 29, 28, 4, -28 },
  { 7499, 22, 28, 22, 0, -28 },
  { 7576, 34, 28, 36, 1, -28 },
  { 7695, 21, 28, 24, 1, -28 },
  { 7769, 22, 41, 22, 0, -28 },
  { 7882, 17, 28, 21, 2, -28 },
  { 7942, 15, 46, 19, 2, -38 },
  { 8029, 2, 53, 26, 12, -40 },
  { 8043, 15, 46, 19, 2, -38 },
  { 8130, 23, 6, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Light53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT53PT7B_H_
