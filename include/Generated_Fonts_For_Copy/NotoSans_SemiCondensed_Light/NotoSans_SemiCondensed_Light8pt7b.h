#ifndef _NOTOSANS_SEMICONDENSED_LIGHT8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x55, 0xF5, 0xE6, 0x2C, 0xC2, 0x5E, 0x4A, 0xCA, 0x9D,
  0x35, 0x70, 0x62, 0x98, 0xD9, 0x7C, 0xC0, 0x5A, 0xA4, 0x95, 0x58, 0x5D,
  0x80, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x69, 0x99, 0x96,
  0xFC, 0xE1, 0x12, 0x4F, 0xE1, 0x26, 0x1E, 0x22, 0x6A, 0xF2, 0x68, 0xE1,
  0x1E, 0x68, 0xE9, 0x97, 0xF1, 0x22, 0x44, 0x69, 0x66, 0x9F, 0x69, 0x97,
  0x16, 0x10, 0x18, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0xC4, 0xA4, 0x80, 0x39,
  0x1B, 0xEB, 0xBD, 0x03, 0x00, 0x22, 0x67, 0x99, 0xD6, 0xFB, 0xC0, 0x34,
  0x88, 0x87, 0xE9, 0x99, 0x9E, 0xF2, 0x69, 0xC0, 0xF2, 0x69, 0x00, 0x3A,
  0x21, 0x38, 0xBC, 0xB6, 0xFB, 0x40, 0xD5, 0x70, 0x55, 0x5C, 0xBA, 0x6D,
  0x40, 0xAA, 0xB0, 0x8C, 0x67, 0xBE, 0xD4, 0x99, 0xDD, 0xB9, 0x74, 0x63,
  0x18, 0xB8, 0xD6, 0xE9, 0x00, 0x74, 0x63, 0x18, 0xB8, 0x60, 0xD6, 0xEB,
  0x40, 0x68, 0xC2, 0x1E, 0xF4, 0x44, 0x44, 0xB6, 0xDB, 0xC0, 0x99, 0x96,
  0x62, 0x96, 0x5B, 0x5B, 0x49, 0x20, 0x96, 0x64, 0x69, 0x9A, 0x64, 0x44,
  0xF2, 0x24, 0x4F, 0xFE, 0x91, 0x24, 0x40, 0xD5, 0x5C, 0x26, 0x59, 0xE0,
  0xC0, 0x6E, 0xF0, 0x9A, 0xDB, 0xC0, 0xF2, 0x30, 0x17, 0x99, 0x97, 0xFF,
  0x87, 0x79, 0x24, 0x80, 0xF9, 0x97, 0x16, 0x9A, 0xDB, 0x40, 0xBC, 0xBF,
  0x93, 0x4D, 0xC0, 0xFC, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0xF9, 0x97, 0xF6,
  0xF9, 0x00, 0xF9, 0x97, 0x11, 0xEA, 0xE8, 0xF0, 0xEA, 0xC0, 0xB6, 0xF0,
  0xB5, 0x20, 0xAD, 0x56, 0xA0, 0xA9, 0x50, 0xB5, 0x25, 0x00, 0xE9, 0x70,
  0x29, 0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Light8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 4, 6, 5, 0, -6 },
  { 6, 4, 6, 4, 0, -6 },
  { 9, 6, 6, 6, 0, -6 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 1, 2, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 2, 7, 2, 0, -6 },
  { 23, 3, 3, 4, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 1, 6, 4, 1, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 1, 4, 2, 0, -4 },
  { 62, 1, 5, 2, 0, -4 },
  { 63, 4, 4, 4, 0, -5 },
  { 65, 4, 2, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -5 },
  { 68, 3, 6, 3, 0, -6 },
  { 71, 6, 7, 6, 0, -6 },
  { 77, 4, 6, 4, 0, -6 },
  { 80, 3, 6, 5, 1, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 4, 6, 5, 1, -6 },
  { 89, 3, 6, 4, 1, -6 },
  { 92, 3, 6, 4, 1, -6 },
  { 95, 5, 6, 5, 0, -6 },
  { 99, 3, 6, 5, 1, -6 },
  { 102, 2, 6, 2, 0, -6 },
  { 104, 2, 7, 2, -1, -6 },
  { 106, 3, 6, 4, 1, -6 },
  { 109, 2, 6, 4, 1, -6 },
  { 111, 5, 6, 6, 1, -6 },
  { 115, 4, 6, 5, 1, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 3, 6, 4, 1, -6 },
  { 125, 5, 7, 5, 0, -6 },
  { 130, 3, 6, 4, 1, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 3, 6, 5, 1, -6 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 6, 6, 7, 0, -6 },
  { 150, 4, 6, 4, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 1, 7, 3, 1, -6 },
  { 160, 3, 6, 3, 0, -6 },
  { 163, 2, 7, 3, 0, -6 },
  { 165, 4, 4, 4, 0, -6 },
  { 167, 3, 1, 3, 0, 0 },
  { 168, 2, 1, 2, 0, -6 },
  { 169, 3, 4, 4, 0, -4 },
  { 171, 3, 6, 4, 1, -6 },
  { 174, 3, 4, 3, 0, -4 },
  { 176, 4, 6, 4, 0, -6 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 3, 6, 2, 0, -6 },
  { 184, 4, 6, 4, 0, -4 },
  { 187, 3, 6, 4, 1, -6 },
  { 190, 1, 6, 2, 0, -6 },
  { 191, 1, 8, 2, 0, -6 },
  { 192, 3, 6, 4, 1, -6 },
  { 195, 1, 6, 2, 0, -6 },
  { 196, 5, 4, 6, 1, -4 },
  { 199, 3, 4, 4, 1, -4 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 3, 6, 4, 1, -4 },
  { 206, 4, 6, 4, 0, -4 },
  { 209, 2, 4, 3, 1, -4 },
  { 210, 3, 4, 3, 0, -4 },
  { 212, 2, 5, 2, 0, -5 },
  { 214, 3, 4, 4, 1, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 5, 4, 5, 0, -4 },
  { 221, 3, 4, 4, 0, -4 },
  { 223, 3, 6, 3, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 3, 7, 3, 0, -6 },
  { 231, 1, 8, 4, 1, -6 },
  { 232, 3, 7, 3, 0, -6 },
  { 235, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Light8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT8PT7B_H_
