#ifndef _NOTOSANS_SEMICONDENSED_LIGHT56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light56pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x00, 0x00, 0xEF,
  0xFF, 0xEF, 0x20, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x03, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x03, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xFF, 0x8F, 0xCC, 0x7C, 0x7C, 0x30, 0x31, 0xC0, 0xC0, 0x0F, 0x03, 0x00,
  0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x38,
  0x0C, 0x00, 0xF0, 0x30, 0x01, 0xC0, 0xC0, 0x07, 0x83, 0x00, 0x0F, 0x8C,
  0x00, 0x1F, 0xB0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xCF, 0xC0, 0x03, 0x0F, 0x80, 0x0C, 0x1E, 0x00,
  0x30, 0x3C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x30,
  0x1C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x0E, 0x80, 0x30, 0x7B,
  0x80, 0xC7, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x3F, 0xF0,
  0x00, 0x70, 0x03, 0x87, 0x00, 0x06, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x07,
  0x03, 0x80, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0x0E, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x0C, 0x0E, 0x00, 0x0C,
  0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x0E, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x1C, 0x38, 0x08, 0x0E, 0x01, 0xC3, 0x87, 0xF0, 0xE0, 0x1C,
  0x30, 0xFF, 0x86, 0x01, 0xC7, 0x1C, 0x3C, 0x70, 0x38, 0x61, 0xC1, 0xC7,
  0x03, 0x8E, 0x38, 0x0E, 0x38, 0x70, 0xC3, 0x80, 0xE3, 0xFF, 0x1C, 0x30,
  0x0E, 0x0F, 0xE1, 0xC3, 0x00, 0x60, 0x20, 0x38, 0x70, 0x07, 0x00, 0x03,
  0x87, 0x00, 0x70, 0x00, 0x70, 0x70, 0x07, 0x00, 0x07, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0x70, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x70,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x03, 0x80, 0x30, 0x06, 0x00, 0x38,
  0x03, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xE0,
  0x06, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x01, 0xE3, 0xC0, 0x0C, 0x00, 0x0F,
  0xF8, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07,
  0xC7, 0x80, 0x0E, 0x1E, 0x07, 0x80, 0x1C, 0x78, 0x07, 0x80, 0x78, 0xE0,
  0x0F, 0x00, 0xE3, 0xC0, 0x0F, 0x01, 0xC7, 0x00, 0x0F, 0x03, 0x8E, 0x00,
  0x0F, 0x0E, 0x1C, 0x00, 0x0F, 0x1C, 0x38, 0x00, 0x0F, 0x70, 0x70, 0x00,
  0x0F, 0xE0, 0xE0, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0xFE, 0x07, 0x80, 0x03, 0xDE, 0x07, 0x80, 0x1F,
  0x1E, 0x0F, 0xE3, 0xFC, 0x1E, 0x0F, 0xFF, 0xE0, 0x3C, 0x07, 0xFF, 0x00,
  0x3E, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x10, 0x0E, 0x01, 0xF8, 0x70, 0x7F, 0xFB, 0xBF, 0xDF,
  0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x07, 0x70,
  0x00, 0x71, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x38, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xC0, 0x18, 0x02, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0x10, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7E, 0x3F, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xE0, 0x03, 0x81,
  0xC0, 0x0F, 0x03, 0xE0, 0x3C, 0x03, 0xF1, 0xF8, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x7F, 0x0F,
  0xF1, 0xE7, 0x3C, 0x77, 0x87, 0xF0, 0x74, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xF8, 0x1F, 0xC1, 0xF0, 0x78, 0x01, 0xE1, 0x80, 0x03, 0xC2, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFC, 0x3F, 0x87, 0xC0, 0x0F,
  0x8E, 0x00, 0x0F, 0x08, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE8, 0x00, 0x03, 0xDC, 0x00, 0x1F, 0x3F,
  0x81, 0xFC, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0F,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x77, 0xFE, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x80, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE4, 0x00, 0x07, 0x8E, 0x00, 0x1F,
  0x1F, 0x81, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x80,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x3E,
  0x01, 0xE3, 0xFF, 0x83, 0x8F, 0xFF, 0x87, 0x3C, 0x0F, 0x8E, 0xE0, 0x07,
  0x9F, 0x80, 0x07, 0xBE, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0xE0, 0x01, 0xE1, 0xE0, 0x07, 0x81, 0xE0,
  0x1E, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFC, 0x1F, 0x03, 0xE0, 0x0F, 0x07, 0x00,
  0x0F, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x00, 0x03, 0x87, 0x00, 0x07,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x8F, 0x80,
  0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03,
  0xE1, 0xF0, 0x0F, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0xF0, 0x00, 0x71, 0xC0,
  0x00, 0xF7, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x80, 0x03, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xE1, 0xF0, 0x3C, 0x01, 0xE0, 0xE0,
  0x03, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x7C, 0xE0, 0x03, 0xF3, 0xE0, 0x3D,
  0xC7, 0xFF, 0xE7, 0x07, 0xFE, 0x1C, 0x07, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x02, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xBF, 0xFF, 0xF8,
  0x80, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x38,
  0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0x87, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0xFC,
  0x60, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0xC0, 0x0E, 0x38,
  0x01, 0xFF, 0xE0, 0x18, 0xE0, 0x0F, 0xFF, 0x80, 0x77, 0x00, 0x78, 0x0E,
  0x01, 0xDC, 0x03, 0xC0, 0x38, 0x07, 0x70, 0x0E, 0x00, 0xE0, 0x0D, 0x80,
  0x70, 0x03, 0x80, 0x3E, 0x01, 0xC0, 0x0E, 0x00, 0xF8, 0x07, 0x00, 0x38,
  0x03, 0xE0, 0x38, 0x00, 0xE0, 0x0F, 0x80, 0xE0, 0x03, 0x80, 0x3E, 0x03,
  0x80, 0x0E, 0x00, 0xF8, 0x0E, 0x00, 0x38, 0x03, 0xE0, 0x38, 0x00, 0xE0,
  0x1F, 0x80, 0xE0, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x1E, 0x01, 0xF8, 0x06,
  0x00, 0x78, 0x06, 0xE0, 0x1C, 0x01, 0xE0, 0x3B, 0x80, 0x70, 0x0D, 0x80,
  0xE6, 0x00, 0xE0, 0x77, 0x07, 0x1C, 0x03, 0xFF, 0x8F, 0xF8, 0x70, 0x07,
  0xFC, 0x1F, 0xC1, 0xC0, 0x07, 0xC0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x08, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0xE0, 0x0F, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x1F, 0xF0, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x03, 0xF0, 0x01, 0x81, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x1F, 0xE1,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x70, 0x01, 0xFC,
  0x0E, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x7C, 0x38, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x0F, 0x1C, 0x00, 0x03, 0xE3, 0x80, 0x00, 0xF8, 0x70, 0x00, 0x3E,
  0x0E, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC1,
  0xFE, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x40, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0xE0, 0x00,
  0x07, 0x07, 0xC0, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x3F, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0,
  0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3,
  0xC0, 0x00, 0xE7, 0xE0, 0x00, 0xEF, 0xE0, 0x00, 0xEE, 0xF0, 0x00, 0xFC,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0,
  0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xDC, 0x00, 0x00, 0x1D, 0xFB, 0x80, 0x00,
  0x03, 0xBF, 0x70, 0x00, 0x00, 0x77, 0xE7, 0x00, 0x00, 0x1C, 0xFC, 0xE0,
  0x00, 0x03, 0x9F, 0x9E, 0x00, 0x00, 0xE3, 0xF1, 0xC0, 0x00, 0x1C, 0x7E,
  0x38, 0x00, 0x03, 0x8F, 0xC3, 0x80, 0x00, 0xE1, 0xF8, 0x70, 0x00, 0x1C,
  0x3F, 0x0E, 0x00, 0x03, 0x87, 0xE0, 0xE0, 0x00, 0xE0, 0xFC, 0x1C, 0x00,
  0x1C, 0x1F, 0x83, 0x80, 0x03, 0x83, 0xF0, 0x38, 0x00, 0xE0, 0x7E, 0x07,
  0x00, 0x1C, 0x0F, 0xC0, 0xF0, 0x07, 0x01, 0xF8, 0x0E, 0x00, 0xE0, 0x3F,
  0x01, 0xC0, 0x1C, 0x07, 0xE0, 0x3C, 0x07, 0x00, 0xFC, 0x03, 0x80, 0xE0,
  0x1F, 0x80, 0x70, 0x1C, 0x03, 0xF0, 0x07, 0x07, 0x00, 0x7E, 0x00, 0xE0,
  0xE0, 0x0F, 0xC0, 0x1C, 0x1C, 0x01, 0xF8, 0x01, 0xC7, 0x00, 0x3F, 0x00,
  0x38, 0xE0, 0x07, 0xE0, 0x07, 0x1C, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x1F,
  0x80, 0x0E, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x07,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFB, 0x80,
  0x00, 0x3F, 0x78, 0x00, 0x07, 0xE7, 0x80, 0x00, 0xFC, 0x70, 0x00, 0x1F,
  0x8F, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x7E, 0x1E, 0x00, 0x0F, 0xC1, 0xC0,
  0x01, 0xF8, 0x1C, 0x00, 0x3F, 0x03, 0xC0, 0x07, 0xE0, 0x38, 0x00, 0xFC,
  0x07, 0x80, 0x1F, 0x80, 0x70, 0x03, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0xF0,
  0x0F, 0xC0, 0x0E, 0x01, 0xF8, 0x01, 0xE0, 0x3F, 0x00, 0x1C, 0x07, 0xE0,
  0x03, 0xC0, 0xFC, 0x00, 0x38, 0x1F, 0x80, 0x07, 0x83, 0xF0, 0x00, 0x78,
  0x7E, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0xF1, 0xF8, 0x00, 0x0E, 0x3F, 0x00,
  0x01, 0xE7, 0xE0, 0x00, 0x1C, 0xFC, 0x00, 0x03, 0xDF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x38, 0x00, 0xF8, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x07,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0x78,
  0xE0, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xFF, 0x87, 0xF1, 0xFE, 0x3E, 0x00, 0x31, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF3, 0x00, 0x07, 0xCF, 0xE1, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1F, 0x00,
  0x3E, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xF0,
  0x00, 0x0E, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE7, 0x80, 0x01, 0xF8, 0x00,
  0x1E, 0x78, 0x00, 0x1F, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xB8, 0x00, 0x1C,
  0x38, 0x00, 0x39, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0x9C, 0x00, 0x3C, 0x3C,
  0x00, 0x39, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x70,
  0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x70, 0x0E,
  0x00, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x00,
  0x70, 0x1C, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x38, 0x1C, 0x00, 0x38,
  0x38, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0x38, 0x38,
  0x01, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x01,
  0xC3, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0xE7,
  0x80, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x00, 0x78, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x78,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x00,
  0x70, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x01,
  0xC0, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x78, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x3C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xF3, 0xF8,
  0x18, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x07, 0x3E, 0x00,
  0x39, 0xE0, 0x01, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0xFB, 0x80, 0x0F,
  0xDE, 0x00, 0xEE, 0x7C, 0x1E, 0x71, 0xFF, 0xE3, 0x87, 0xFE, 0x1C, 0x02,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x1F, 0xF0, 0x3C, 0x7F, 0xF8, 0x7B, 0xF3, 0xF8,
  0xF7, 0x00, 0xF9, 0xF8, 0x00, 0xF3, 0xF0, 0x00, 0xF7, 0xC0, 0x00, 0xEF,
  0x80, 0x01, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xEF, 0x80, 0x01,
  0xDF, 0x00, 0x07, 0xBB, 0x00, 0x1E, 0x77, 0x00, 0x7C, 0xE7, 0x83, 0xF1,
  0xC7, 0xFF, 0xC3, 0x83, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xDF, 0x87, 0x80, 0x21, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x87, 0xE0, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x0A, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x3F, 0xC1, 0xC1, 0xFF, 0xE3, 0x87, 0xF3, 0xE7, 0x1F, 0x00, 0xEE,
  0x78, 0x00, 0xDC, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x00, 0x01, 0xEE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07,
  0xCF, 0x00, 0x1B, 0x8F, 0x00, 0x77, 0x1F, 0x83, 0xCE, 0x1F, 0xFF, 0x1C,
  0x0F, 0xFC, 0x38, 0x01, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFC, 0xFC, 0x07, 0x80, 0x78, 0x1C, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x80,
  0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0x83, 0xF0, 0x7E, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0xFF, 0xE0, 0x78, 0x10, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x01,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x01, 0xFE, 0x0E, 0x0F, 0xFF, 0x1C, 0x3F, 0xBF,
  0x38, 0xF0, 0x07, 0x73, 0xC0, 0x07, 0xE7, 0x00, 0x07, 0xDE, 0x00, 0x0F,
  0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xBC, 0x00,
  0x1F, 0x38, 0x00, 0x3E, 0x78, 0x00, 0xDC, 0x78, 0x03, 0xB8, 0xFC, 0x1E,
  0x70, 0x7F, 0xF8, 0xE0, 0x7F, 0xE1, 0xC0, 0x08, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x18, 0x00, 0x7C, 0x3F,
  0x07, 0xF0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC3, 0xFE, 0x0F, 0x1F,
  0xFE, 0x3D, 0xF9, 0xFC, 0xF7, 0x00, 0xF3, 0xB0, 0x01, 0xEF, 0xC0, 0x03,
  0xBE, 0x00, 0x0E, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x6F, 0xFF, 0x70, 0x00, 0x00,
  0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x70, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x3A, 0x3E, 0xFF, 0x3F, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x38, 0x3C,
  0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xC0,
  0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xF8, 0x01, 0xEF,
  0xC0, 0x0E, 0xEF, 0x00, 0x7E, 0x38, 0x03, 0xE1, 0xE0, 0x1E, 0x07, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0x81, 0xE0, 0x0E, 0x0F, 0x00,
  0x78, 0x78, 0x01, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xE7,
  0x80, 0x07, 0xBC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0x1F, 0xFC, 0x1F, 0xFE, 0x39, 0xF3, 0xF1, 0xFB, 0xF9,
  0xDC, 0x03, 0xCE, 0x03, 0xCE, 0xC0, 0x0E, 0xC0, 0x0F, 0x7C, 0x00, 0x7E,
  0x00, 0x3B, 0xE0, 0x01, 0xE0, 0x01, 0xDE, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x00, 0x78, 0x00, 0x7F, 0x80, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x1C, 0x00,
  0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00,
  0x38, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x07,
  0xF0, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x1C,
  0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x03, 0xF8,
  0x00, 0x38, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x0E, 0x00,
  0x07, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x01, 0xFC, 0x00,
  0x1C, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x03,
  0xF8, 0x00, 0x38, 0x00, 0x1C, 0xE0, 0xFF, 0x83, 0x87, 0xFF, 0x8E, 0x3E,
  0x7F, 0x39, 0xC0, 0x3C, 0xEC, 0x00, 0x7B, 0xF0, 0x00, 0xEF, 0x80, 0x03,
  0xBE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x70, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x1F, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x1E, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x1E, 0x00,
  0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0xC1, 0xFF, 0x03, 0x0F, 0xFF, 0x0C, 0x7C, 0xFE, 0x33, 0x80, 0x7C,
  0xDC, 0x00, 0xF3, 0x60, 0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF8, 0x00, 0x7B, 0x60, 0x03,
  0xCE, 0xC0, 0x1F, 0x3B, 0xE1, 0xF8, 0xE7, 0xFF, 0xC3, 0x87, 0xFC, 0x0E,
  0x01, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x0E, 0x0F, 0xFF, 0x1C, 0x3F, 0x1F, 0x38, 0xF0, 0x07, 0x73,
  0xC0, 0x06, 0xE7, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xB8, 0x00, 0x0F, 0x70,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0xDC, 0x78, 0x03, 0xB8, 0xFC, 0x1E, 0x70, 0xFF, 0xF8, 0xE0,
  0x7F, 0xC1, 0xC0, 0x08, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0x80, 0xDC,
  0x03, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xFC, 0xFE, 0x3F, 0x1E, 0x00, 0x67, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3B, 0x00,
  0x0F, 0x7E, 0x07, 0xCF, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x78, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x08, 0x3F, 0xF0, 0x3F, 0xE0, 0x04, 0x00, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEE,
  0x00, 0x0F, 0x70, 0x00, 0x7B, 0xC0, 0x06, 0xCF, 0x00, 0x66, 0x7E, 0x1F,
  0x31, 0xFF, 0xF1, 0x87, 0xFE, 0x0C, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x07, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x38,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x07,
  0x80, 0x0E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0x79, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0xF0,
  0x00, 0xE7, 0x00, 0x1F, 0x80, 0x0E, 0x70, 0x01, 0xF8, 0x00, 0xE7, 0x00,
  0x1F, 0x80, 0x1E, 0x70, 0x01, 0x98, 0x01, 0xC3, 0x80, 0x39, 0xC0, 0x1C,
  0x38, 0x03, 0x9C, 0x01, 0xC3, 0x80, 0x39, 0xC0, 0x3C, 0x38, 0x07, 0x0C,
  0x03, 0x81, 0xC0, 0x70, 0xE0, 0x38, 0x1C, 0x07, 0x0E, 0x03, 0x81, 0xC0,
  0x60, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x70, 0x70,
  0x0E, 0x0E, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0x70, 0xF0, 0x0E, 0x1C, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x73,
  0x80, 0x18, 0xE0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x03, 0xB0, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xE0,
  0xE0, 0x03, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x70, 0x03,
  0x81, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x70, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0x38, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0x70, 0x07, 0x80, 0xF0,
  0x0E, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xE1, 0xC0, 0x01, 0xC7,
  0x80, 0x03, 0xDE, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE7, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x87, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xF0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0xFE, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFC,
  0x03, 0xF0, 0x3F, 0xDF, 0xC0, 0x0F, 0xFE, 0x80, 0x03, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Light56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 41, 13, 4, -40 },
  { 27, 12, 14, 20, 4, -40 },
  { 48, 30, 40, 32, 1, -40 },
  { 198, 22, 46, 29, 3, -43 },
  { 325, 36, 42, 42, 3, -41 },
  { 514, 31, 42, 34, 3, -41 },
  { 677, 3, 14, 11, 4, -40 },
  { 683, 12, 49, 16, 2, -40 },
  { 757, 11, 49, 16, 2, -40 },
  { 825, 21, 22, 27, 3, -43 },
  { 883, 24, 26, 29, 2, -33 },
  { 961, 7, 13, 12, 2, -6 },
  { 973, 13, 3, 17, 2, -17 },
  { 978, 5, 6, 13, 4, -5 },
  { 982, 18, 40, 19, 1, -40 },
  { 1072, 23, 42, 29, 3, -41 },
  { 1193, 12, 40, 29, 5, -40 },
  { 1253, 22, 41, 29, 3, -41 },
  { 1366, 23, 42, 29, 2, -41 },
  { 1487, 27, 40, 29, 1, -40 },
  { 1622, 23, 41, 29, 3, -40 },
  { 1740, 23, 42, 29, 3, -41 },
  { 1861, 23, 40, 29, 3, -40 },
  { 1976, 23, 42, 29, 3, -41 },
  { 2097, 22, 42, 29, 3, -41 },
  { 2213, 5, 31, 13, 4, -30 },
  { 2233, 7, 37, 13, 2, -30 },
  { 2266, 24, 26, 29, 2, -33 },
  { 2344, 23, 14, 29, 3, -27 },
  { 2385, 24, 26, 29, 2, -33 },
  { 2463, 18, 42, 21, 1, -41 },
  { 2558, 38, 45, 44, 3, -40 },
  { 2772, 30, 40, 30, 0, -40 },
  { 2922, 24, 40, 32, 5, -40 },
  { 3042, 26, 42, 31, 3, -41 },
  { 3179, 27, 40, 35, 5, -40 },
  { 3314, 20, 40, 28, 5, -40 },
  { 3414, 20, 40, 25, 5, -40 },
  { 3514, 30, 42, 37, 3, -41 },
  { 3672, 26, 40, 36, 5, -40 },
  { 3802, 11, 40, 16, 3, -40 },
  { 3857, 12, 50, 13, -4, -40 },
  { 3932, 24, 40, 29, 5, -40 },
  { 4052, 19, 40, 26, 5, -40 },
  { 4147, 35, 40, 45, 5, -40 },
  { 4322, 27, 40, 37, 5, -40 },
  { 4457, 32, 42, 38, 3, -41 },
  { 4625, 22, 40, 30, 5, -40 },
  { 4735, 32, 51, 38, 3, -41 },
  { 4939, 24, 40, 30, 5, -40 },
  { 5059, 22, 42, 28, 3, -41 },
  { 5175, 26, 40, 26, 0, -40 },
  { 5305, 26, 41, 36, 5, -40 },
  { 5439, 29, 40, 29, 0, -40 },
  { 5584, 44, 40, 46, 1, -40 },
  { 5804, 27, 40, 27, 0, -40 },
  { 5939, 26, 40, 26, 0, -40 },
  { 6069, 24, 40, 27, 2, -40 },
  { 6189, 11, 49, 18, 5, -40 },
  { 6257, 18, 40, 19, 1, -40 },
  { 6347, 11, 49, 18, 2, -40 },
  { 6415, 25, 23, 29, 2, -40 },
  { 6487, 23, 3, 23, 0, 5 },
  { 6496, 10, 9, 14, 2, -43 },
  { 6508, 21, 31, 27, 2, -30 },
  { 6590, 23, 44, 30, 4, -43 },
  { 6717, 19, 31, 24, 3, -30 },
  { 6791, 23, 44, 30, 3, -43 },
  { 6918, 22, 31, 28, 3, -30 },
  { 7004, 17, 43, 16, 1, -43 },
  { 7096, 23, 43, 30, 3, -30 },
  { 7220, 22, 43, 30, 4, -43 },
  { 7339, 4, 41, 12, 4, -41 },
  { 7360, 10, 54, 12, -2, -41 },
  { 7428, 21, 43, 25, 4, -43 },
  { 7541, 3, 43, 12, 5, -43 },
  { 7558, 37, 30, 45, 4, -30 },
  { 7697, 22, 30, 30, 4, -30 },
  { 7780, 24, 31, 30, 3, -30 },
  { 7873, 22, 43, 30, 5, -30 },
  { 7992, 23, 43, 30, 3, -30 },
  { 8116, 14, 30, 20, 5, -30 },
  { 8169, 19, 31, 23, 2, -30 },
  { 8243, 15, 38, 17, 1, -37 },
  { 8315, 21, 31, 30, 4, -30 },
  { 8397, 23, 30, 23, 0, -30 },
  { 8484, 36, 30, 38, 1, -30 },
  { 8619, 23, 30, 25, 1, -30 },
  { 8706, 24, 44, 24, 0, -30 },
  { 8838, 18, 30, 22, 2, -30 },
  { 8906, 16, 49, 20, 2, -40 },
  { 9004, 3, 57, 27, 12, -43 },
  { 9026, 16, 49, 20, 2, -40 },
  { 9124, 24, 6, 29, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Light56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT56PT7B_H_
