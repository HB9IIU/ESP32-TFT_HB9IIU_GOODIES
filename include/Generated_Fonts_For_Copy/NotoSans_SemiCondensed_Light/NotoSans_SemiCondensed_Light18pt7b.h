#ifndef _NOTOSANS_SEMICONDENSED_LIGHT18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light18pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x51, 0xC0, 0x99, 0x99, 0x90, 0x09, 0x02, 0x40, 0x90,
  0x44, 0x7F, 0xC4, 0x41, 0x20, 0x48, 0xFF, 0x88, 0x82, 0x20, 0x88, 0x24,
  0x00, 0x10, 0x21, 0xFC, 0x89, 0x12, 0x14, 0x1C, 0x14, 0x24, 0x48, 0x9F,
  0xC2, 0x04, 0x00, 0x70, 0x92, 0x12, 0x24, 0x44, 0x88, 0xA1, 0x15, 0xA5,
  0x4B, 0xA9, 0x09, 0x21, 0x24, 0x44, 0x88, 0x92, 0x0E, 0x38, 0x11, 0x04,
  0x41, 0x10, 0x24, 0x0E, 0x03, 0x01, 0x22, 0x84, 0xA0, 0xE8, 0x32, 0x0E,
  0x7C, 0xC0, 0xF8, 0x29, 0x29, 0x24, 0x92, 0x44, 0x91, 0x89, 0x22, 0x49,
  0x24, 0x94, 0x94, 0x10, 0x22, 0x4F, 0xF3, 0x05, 0x11, 0x00, 0x10, 0x20,
  0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x6A, 0xF0, 0x70, 0x04, 0x10, 0x82,
  0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x80, 0x38, 0x8A, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0A, 0x23, 0xC0, 0x35, 0x91, 0x11, 0x11, 0x11,
  0x11, 0x10, 0x79, 0x08, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x06,
  0x0F, 0xE0, 0x7D, 0x08, 0x08, 0x10, 0x61, 0x8E, 0x03, 0x02, 0x04, 0x08,
  0x3F, 0xC0, 0x02, 0x03, 0x02, 0x81, 0x41, 0x20, 0x90, 0x88, 0x84, 0x42,
  0x7F, 0xC0, 0x80, 0x40, 0x20, 0x7C, 0x81, 0x02, 0x08, 0x1F, 0x01, 0x01,
  0x02, 0x04, 0x0C, 0x3F, 0xC0, 0x1E, 0x41, 0x02, 0x08, 0x17, 0xB0, 0xC1,
  0x83, 0x06, 0x0A, 0x13, 0xC0, 0xFE, 0x04, 0x08, 0x20, 0x41, 0x82, 0x04,
  0x10, 0x20, 0xC1, 0x06, 0x00, 0x3C, 0x8E, 0x0C, 0x14, 0x65, 0x8E, 0x22,
  0x83, 0x06, 0x0C, 0x17, 0xC0, 0x78, 0x8A, 0x0C, 0x18, 0x30, 0x71, 0xBD,
  0x02, 0x04, 0x10, 0x27, 0x80, 0x70, 0x00, 0x70, 0x70, 0x00, 0xEA, 0x02,
  0x0C, 0x63, 0x08, 0x0C, 0x06, 0x03, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x81, 0x80, 0xC0, 0x60, 0x21, 0x8C, 0x60, 0x80, 0x7A, 0x10, 0x41, 0x04,
  0x21, 0x08, 0x20, 0x80, 0x08, 0x20, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x01,
  0x8F, 0x98, 0x89, 0x90, 0x99, 0x09, 0x90, 0x98, 0x99, 0x8E, 0xE4, 0x00,
  0x40, 0x03, 0x08, 0x0F, 0x00, 0x0C, 0x03, 0x01, 0x40, 0x48, 0x12, 0x04,
  0x82, 0x30, 0x84, 0x3F, 0x10, 0x44, 0x09, 0x02, 0x80, 0xC0, 0xF9, 0x0E,
  0x0C, 0x18, 0x30, 0xBF, 0x41, 0x83, 0x06, 0x0C, 0x3F, 0xC0, 0x1F, 0x21,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x1F, 0xF8,
  0x86, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0xF8,
  0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0xFC, 0xFE, 0x08,
  0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0x80, 0x1F, 0x88, 0x24, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x7E, 0x03, 0x80, 0xF0, 0x34, 0x0C, 0x83, 0x1F,
  0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xE9, 0x24, 0x92, 0x49, 0x2E, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x2E, 0x83, 0x0A, 0x24, 0xC9, 0x14, 0x38, 0x48, 0x99, 0x12,
  0x14, 0x28, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0xFC, 0x80, 0x78, 0x0F, 0x02, 0xE0, 0x5A, 0x0B, 0x42, 0x68, 0x4C, 0x89,
  0x92, 0x32, 0x46, 0x28, 0xC6, 0x18, 0x42, 0x81, 0xC1, 0xC1, 0xA1, 0xA1,
  0x91, 0x91, 0x89, 0x8D, 0x85, 0x83, 0x83, 0x81, 0x1F, 0x08, 0x64, 0x0B,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x14, 0x09, 0x86, 0x1F,
  0x00, 0xF9, 0x0A, 0x14, 0x18, 0x30, 0xA3, 0x78, 0x81, 0x02, 0x04, 0x08,
  0x00, 0x1F, 0x08, 0x64, 0x0B, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x70, 0x14, 0x09, 0x86, 0x1F, 0x00, 0x80, 0x10, 0x06, 0xF9, 0x0A, 0x1C,
  0x18, 0x30, 0xA6, 0x78, 0x89, 0x12, 0x14, 0x38, 0x20, 0x3F, 0x86, 0x04,
  0x08, 0x0C, 0x0E, 0x02, 0x02, 0x04, 0x08, 0x3F, 0xC0, 0xFF, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0x7C, 0x80,
  0xC0, 0x50, 0x68, 0x24, 0x11, 0x08, 0x88, 0x44, 0x12, 0x0A, 0x05, 0x01,
  0x80, 0x80, 0x81, 0x05, 0x04, 0x14, 0x30, 0x50, 0xA1, 0x42, 0x88, 0x92,
  0x22, 0x48, 0x89, 0x12, 0x24, 0x50, 0x61, 0x41, 0x85, 0x06, 0x0C, 0x18,
  0x20, 0xC1, 0x20, 0x88, 0x84, 0xC1, 0x40, 0xC0, 0x20, 0x28, 0x14, 0x11,
  0x18, 0x88, 0x28, 0x18, 0x81, 0x41, 0x42, 0x22, 0x24, 0x14, 0x18, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0xFE, 0x04, 0x10, 0x60, 0x82, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x0F, 0xE0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x18, 0x28, 0x24, 0x44,
  0x42, 0x82, 0x81, 0xFF, 0x88, 0x80, 0x39, 0x10, 0x41, 0x1D, 0x98, 0x61,
  0x85, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xA2, 0xC2, 0xC1, 0x81, 0x81,
  0xC1, 0xC3, 0xC2, 0xBC, 0x1D, 0x9C, 0x20, 0x82, 0x08, 0x20, 0x40, 0xF0,
  0x02, 0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x2F,
  0xC0, 0x38, 0x8A, 0x0C, 0x1F, 0xF0, 0x20, 0x40, 0x40, 0x7C, 0x1C, 0x82,
  0x08, 0xF8, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3A, 0x8E, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x42, 0xFC, 0x08, 0x10, 0x3F, 0x80, 0x81, 0x02,
  0x04, 0x09, 0xD4, 0xF0, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xC2,
  0xAA, 0xAA, 0x80, 0x30, 0x02, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xE0,
  0x81, 0x02, 0x04, 0x08, 0x70, 0xA2, 0x48, 0xB1, 0xA3, 0x24, 0x48, 0x50,
  0xC0, 0xFF, 0xFC, 0x98, 0xEA, 0x53, 0xC2, 0x1C, 0x21, 0x82, 0x18, 0x21,
  0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x9D, 0x4F, 0x0E, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x04, 0x38, 0x46, 0x82, 0x82, 0x81, 0x81, 0x83, 0x82, 0x42,
  0x3C, 0x9C, 0xA2, 0xC2, 0xC1, 0x81, 0x81, 0xC1, 0xC3, 0xC2, 0xBC, 0x80,
  0x80, 0x80, 0x80, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0xF4,
  0x08, 0x10, 0x20, 0x40, 0x9D, 0x31, 0x88, 0x42, 0x10, 0x84, 0x00, 0x7A,
  0x18, 0x20, 0x60, 0x60, 0xC1, 0x07, 0xE0, 0x21, 0x3E, 0xC6, 0x31, 0x8C,
  0x63, 0x08, 0x70, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0xF4,
  0x83, 0x82, 0x42, 0x44, 0x44, 0x24, 0x28, 0x28, 0x18, 0x10, 0x82, 0x1C,
  0x61, 0x46, 0x24, 0x52, 0x49, 0x22, 0x92, 0x29, 0x42, 0x8C, 0x30, 0xC1,
  0x0C, 0xC2, 0x42, 0x24, 0x24, 0x18, 0x18, 0x18, 0x24, 0x42, 0xC3, 0x83,
  0xC2, 0x42, 0x42, 0x64, 0x24, 0x24, 0x28, 0x18, 0x18, 0x10, 0x10, 0x20,
  0xE0, 0xF8, 0x20, 0x84, 0x30, 0x84, 0x10, 0x83, 0xF0, 0x19, 0x08, 0x42,
  0x11, 0x98, 0xC3, 0x08, 0x42, 0x10, 0x83, 0xFF, 0xFF, 0xC0, 0xC3, 0x08,
  0x42, 0x10, 0x87, 0x31, 0x08, 0x42, 0x11, 0x98, 0xF3, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_Light18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 4, 5, 6, 1, -13 },
  { 8, 10, 13, 10, 0, -13 },
  { 25, 7, 15, 9, 1, -14 },
  { 39, 11, 13, 13, 1, -13 },
  { 57, 10, 13, 11, 1, -13 },
  { 74, 1, 5, 3, 1, -13 },
  { 75, 3, 16, 5, 1, -13 },
  { 81, 3, 16, 5, 1, -13 },
  { 87, 7, 7, 9, 1, -14 },
  { 94, 7, 9, 9, 1, -11 },
  { 102, 2, 4, 4, 1, -2 },
  { 103, 4, 1, 5, 1, -5 },
  { 104, 2, 2, 4, 1, -2 },
  { 105, 6, 13, 6, 0, -13 },
  { 115, 7, 13, 9, 1, -13 },
  { 127, 4, 13, 9, 2, -13 },
  { 134, 7, 13, 9, 1, -13 },
  { 146, 7, 13, 9, 1, -13 },
  { 158, 9, 13, 9, 0, -13 },
  { 173, 7, 13, 9, 1, -13 },
  { 185, 7, 13, 9, 1, -13 },
  { 197, 7, 13, 9, 1, -13 },
  { 209, 7, 13, 9, 1, -13 },
  { 221, 7, 13, 9, 1, -13 },
  { 233, 2, 10, 4, 1, -10 },
  { 236, 2, 12, 4, 1, -10 },
  { 239, 7, 9, 9, 1, -11 },
  { 247, 7, 5, 9, 1, -9 },
  { 252, 7, 9, 9, 1, -11 },
  { 260, 6, 13, 7, 0, -13 },
  { 270, 12, 15, 14, 1, -13 },
  { 293, 10, 13, 10, 0, -13 },
  { 310, 7, 13, 10, 2, -13 },
  { 322, 8, 13, 10, 1, -13 },
  { 335, 8, 13, 11, 2, -13 },
  { 348, 6, 13, 9, 2, -13 },
  { 358, 6, 13, 8, 2, -13 },
  { 368, 10, 13, 12, 1, -13 },
  { 385, 8, 13, 12, 2, -13 },
  { 398, 3, 13, 5, 1, -13 },
  { 403, 4, 16, 4, -1, -13 },
  { 411, 7, 13, 9, 2, -13 },
  { 423, 6, 13, 8, 2, -13 },
  { 433, 11, 13, 14, 2, -13 },
  { 451, 8, 13, 12, 2, -13 },
  { 464, 10, 13, 12, 1, -13 },
  { 481, 7, 13, 9, 2, -13 },
  { 493, 10, 16, 12, 1, -13 },
  { 513, 7, 13, 10, 2, -13 },
  { 525, 7, 13, 9, 1, -13 },
  { 537, 8, 13, 8, 0, -13 },
  { 550, 8, 13, 12, 2, -13 },
  { 563, 9, 13, 9, 0, -13 },
  { 578, 14, 13, 15, 0, -13 },
  { 601, 9, 13, 9, 0, -13 },
  { 616, 8, 13, 8, 0, -13 },
  { 629, 7, 13, 9, 1, -13 },
  { 641, 4, 16, 6, 1, -13 },
  { 649, 6, 13, 6, 0, -13 },
  { 659, 4, 16, 6, 0, -13 },
  { 667, 8, 8, 9, 1, -13 },
  { 675, 8, 1, 7, 0, 2 },
  { 676, 3, 3, 5, 1, -14 },
  { 678, 6, 10, 9, 1, -10 },
  { 686, 8, 14, 10, 1, -14 },
  { 700, 6, 10, 8, 1, -10 },
  { 708, 7, 14, 10, 1, -14 },
  { 721, 7, 10, 9, 1, -10 },
  { 730, 6, 14, 5, 0, -14 },
  { 741, 7, 14, 10, 1, -10 },
  { 754, 7, 14, 10, 1, -14 },
  { 767, 2, 13, 4, 1, -13 },
  { 771, 4, 17, 4, -1, -13 },
  { 780, 7, 14, 8, 1, -14 },
  { 793, 1, 14, 4, 1, -14 },
  { 795, 12, 10, 14, 1, -10 },
  { 810, 7, 10, 10, 1, -10 },
  { 819, 8, 10, 10, 1, -10 },
  { 829, 8, 14, 10, 1, -10 },
  { 843, 7, 14, 10, 1, -10 },
  { 856, 5, 10, 6, 1, -10 },
  { 863, 6, 10, 7, 1, -10 },
  { 871, 5, 12, 5, 0, -12 },
  { 879, 7, 10, 10, 1, -10 },
  { 888, 8, 10, 8, 0, -10 },
  { 898, 12, 10, 12, 0, -10 },
  { 913, 8, 10, 8, 0, -10 },
  { 923, 8, 14, 8, 0, -10 },
  { 937, 6, 10, 7, 1, -10 },
  { 945, 5, 16, 6, 1, -13 },
  { 955, 1, 18, 9, 4, -14 },
  { 958, 5, 16, 6, 1, -13 },
  { 968, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Light18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT18PT7B_H_
