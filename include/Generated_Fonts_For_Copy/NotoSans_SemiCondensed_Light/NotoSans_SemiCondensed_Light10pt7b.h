#ifndef _NOTOSANS_SEMICONDENSED_LIGHT10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x29, 0x5C, 0xAF, 0xA9, 0x40, 0x4E, 0xCC, 0x65, 0x5E,
  0x40, 0xE5, 0x52, 0xB7, 0xD1, 0xA5, 0x4B, 0x80, 0x71, 0x45, 0x18, 0x96,
  0x27, 0x40, 0xC0, 0x5A, 0xA5, 0x40, 0xD5, 0x55, 0x80, 0x22, 0xF5, 0x21,
  0x3E, 0x42, 0x00, 0x60, 0xE0, 0x80, 0x24, 0xA5, 0x20, 0xE9, 0x99, 0x99,
  0xE0, 0x75, 0x54, 0x70, 0x84, 0x22, 0x23, 0xE0, 0xF0, 0x44, 0xE0, 0x87,
  0xC0, 0x11, 0x94, 0xA9, 0x3C, 0x40, 0xE8, 0xC2, 0x11, 0xE0, 0xE8, 0xE9,
  0x99, 0xE0, 0xF8, 0x84, 0x22, 0x11, 0x00, 0x74, 0x54, 0xE8, 0xC5, 0xC0,
  0x74, 0x62, 0xB2, 0x8B, 0x80, 0x88, 0x40, 0x60, 0x19, 0x30, 0x60, 0x80,
  0xF8, 0x3E, 0xC1, 0x06, 0xC8, 0x00, 0xE4, 0xA4, 0x10, 0x7A, 0x1B, 0xF3,
  0xCE, 0xF8, 0x1E, 0x21, 0x94, 0xA7, 0xC6, 0x20, 0xF9, 0x9E, 0x99, 0xF0,
  0x78, 0x88, 0x88, 0x70, 0xF4, 0x63, 0x18, 0xCB, 0x80, 0xF2, 0x79, 0x38,
  0xF2, 0x79, 0x20, 0x7C, 0x21, 0x38, 0xC5, 0xE0, 0x8C, 0x63, 0xF8, 0xC6,
  0x20, 0xD5, 0x5C, 0x55, 0x55, 0xC0, 0x9A, 0xCC, 0xAA, 0x90, 0x92, 0x49,
  0x38, 0x86, 0x3C, 0xF3, 0xB6, 0xDA, 0x40, 0x8C, 0x73, 0x5A, 0xCE, 0x20,
  0xF4, 0x63, 0x18, 0xC5, 0xC0, 0xE9, 0x9E, 0x88, 0x80, 0xF4, 0x63, 0x18,
  0xC5, 0xC2, 0x08, 0xE9, 0x9E, 0xA9, 0x90, 0x78, 0x42, 0x11, 0xF0, 0xF9,
  0x08, 0x42, 0x10, 0x80, 0x8C, 0x63, 0x18, 0xC7, 0xC0, 0x8C, 0x52, 0xA5,
  0x10, 0x80, 0x89, 0x99, 0x59, 0x56, 0x66, 0x26, 0x24, 0x9A, 0x98, 0x45,
  0x2A, 0x20, 0x8A, 0x94, 0x42, 0x10, 0x80, 0xF8, 0x88, 0x44, 0x23, 0xE0,
  0xEA, 0xAA, 0xC0, 0x89, 0x22, 0x48, 0xD5, 0x55, 0xC0, 0x22, 0x95, 0x10,
  0xF0, 0x90, 0x71, 0x79, 0x70, 0x88, 0xE9, 0x99, 0x9E, 0xF2, 0x4E, 0x11,
  0x5B, 0x99, 0x9F, 0xF7, 0x4E, 0x2B, 0xA4, 0x92, 0xF9, 0x99, 0xF1, 0xE0,
  0x88, 0xE9, 0x99, 0x99, 0xBE, 0xBF, 0x80, 0x92, 0x5D, 0xAD, 0xFF, 0xFE,
  0x59, 0x65, 0x94, 0xF9, 0x99, 0x90, 0xF9, 0x99, 0xE0, 0xF9, 0x99, 0xE8,
  0x80, 0xF9, 0x99, 0xF1, 0x10, 0xEA, 0x80, 0xFC, 0x21, 0xF0, 0x5D, 0x24,
  0x98, 0x99, 0x99, 0xF0, 0x99, 0x66, 0x20, 0x93, 0x69, 0xB3, 0x64, 0x80,
  0xD6, 0x25, 0x90, 0x99, 0x66, 0x24, 0xC0, 0x72, 0x44, 0xF0, 0x29, 0x2C,
  0x92, 0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Light10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 4, 1, -7 },
  { 3, 5, 7, 6, 0, -7 },
  { 8, 4, 9, 5, 1, -8 },
  { 13, 7, 7, 7, 0, -7 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 1, 2, 2, 0, -7 },
  { 27, 2, 9, 3, 0, -7 },
  { 30, 2, 9, 3, 0, -7 },
  { 33, 4, 4, 5, 0, -8 },
  { 35, 5, 5, 5, 0, -6 },
  { 39, 2, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 1, -1 },
  { 42, 3, 7, 3, 0, -7 },
  { 45, 4, 7, 5, 1, -7 },
  { 49, 2, 7, 5, 1, -7 },
  { 51, 5, 7, 5, 0, -7 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 4, 7, 5, 1, -7 },
  { 70, 4, 7, 5, 1, -7 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 5, 7, 5, 0, -7 },
  { 89, 1, 5, 2, 1, -5 },
  { 90, 2, 6, 2, 0, -5 },
  { 92, 5, 5, 5, 0, -6 },
  { 96, 5, 3, 5, 0, -5 },
  { 98, 5, 5, 5, 0, -6 },
  { 102, 3, 7, 4, 0, -7 },
  { 105, 6, 8, 8, 1, -7 },
  { 111, 5, 7, 5, 0, -7 },
  { 116, 4, 7, 6, 1, -7 },
  { 120, 4, 7, 6, 1, -7 },
  { 124, 5, 7, 6, 1, -7 },
  { 129, 3, 7, 5, 1, -7 },
  { 132, 3, 7, 5, 1, -7 },
  { 135, 5, 7, 7, 1, -7 },
  { 140, 5, 7, 6, 1, -7 },
  { 145, 2, 7, 3, 0, -7 },
  { 147, 2, 9, 2, -1, -7 },
  { 150, 4, 7, 5, 1, -7 },
  { 154, 3, 7, 5, 1, -7 },
  { 157, 6, 7, 8, 1, -7 },
  { 163, 5, 7, 7, 1, -7 },
  { 168, 5, 7, 7, 1, -7 },
  { 173, 4, 7, 5, 1, -7 },
  { 177, 5, 9, 7, 1, -7 },
  { 183, 4, 7, 5, 1, -7 },
  { 187, 4, 7, 5, 0, -7 },
  { 191, 5, 7, 5, 0, -7 },
  { 196, 5, 7, 6, 1, -7 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 8, 7, 8, 0, -7 },
  { 213, 5, 7, 5, 0, -7 },
  { 218, 5, 7, 5, 0, -7 },
  { 223, 5, 7, 5, 0, -7 },
  { 228, 2, 9, 3, 1, -7 },
  { 231, 3, 7, 3, 0, -7 },
  { 234, 2, 9, 3, 0, -7 },
  { 237, 5, 4, 5, 0, -7 },
  { 240, 4, 1, 4, 0, 1 },
  { 241, 2, 2, 3, 0, -8 },
  { 242, 4, 5, 5, 0, -5 },
  { 245, 4, 8, 5, 1, -8 },
  { 249, 3, 5, 4, 1, -5 },
  { 251, 4, 8, 5, 1, -8 },
  { 255, 3, 5, 5, 1, -5 },
  { 257, 3, 8, 3, 0, -8 },
  { 260, 4, 7, 5, 1, -5 },
  { 264, 4, 8, 5, 1, -8 },
  { 268, 1, 7, 2, 1, -7 },
  { 269, 1, 9, 2, 0, -7 },
  { 271, 3, 8, 4, 1, -8 },
  { 274, 1, 8, 2, 1, -8 },
  { 275, 6, 5, 8, 1, -5 },
  { 279, 4, 5, 5, 1, -5 },
  { 282, 4, 5, 5, 1, -5 },
  { 285, 4, 7, 5, 1, -5 },
  { 289, 4, 7, 5, 1, -5 },
  { 293, 2, 5, 4, 1, -5 },
  { 295, 4, 5, 4, 0, -5 },
  { 298, 3, 7, 3, 0, -7 },
  { 301, 4, 5, 5, 1, -5 },
  { 304, 4, 5, 4, 0, -5 },
  { 307, 7, 5, 7, 0, -5 },
  { 312, 4, 5, 4, 0, -5 },
  { 315, 4, 7, 4, 0, -5 },
  { 319, 4, 5, 4, 0, -5 },
  { 322, 3, 9, 4, 0, -7 },
  { 326, 1, 10, 5, 2, -8 },
  { 328, 3, 9, 4, 0, -7 },
  { 332, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Light10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT10PT7B_H_
