#ifndef _NOTOSANS_SEMICONDENSED_LIGHT71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light71pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7,
  0xFF, 0xFF, 0xF7, 0xCE, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1D, 0x80, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xF0, 0xE0, 0x78, 0x3E,
  0x0E, 0x00, 0x87, 0x80, 0xE0, 0x00, 0xF8, 0x0E, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00,
  0x1F, 0x8E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xE7, 0xF0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0xE0, 0x7C, 0x00,
  0x0E, 0x03, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0xE0,
  0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E,
  0x01, 0xE8, 0x00, 0xE0, 0x3C, 0xC0, 0x0E, 0x0F, 0xCF, 0xC0, 0xE3, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x00, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x1E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x80,
  0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x70, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x07,
  0x83, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x1E, 0x07, 0xE0, 0x70, 0x01, 0xC1,
  0xE0, 0xFF, 0xC3, 0xC0, 0x0E, 0x0F, 0x0F, 0xFF, 0x1E, 0x00, 0x70, 0x70,
  0xF8, 0x78, 0x70, 0x07, 0x87, 0x87, 0x81, 0xE3, 0xC0, 0x38, 0x38, 0x78,
  0x07, 0x1E, 0x03, 0xC3, 0xC3, 0x80, 0x3C, 0x78, 0x3C, 0x1C, 0x1C, 0x00,
  0xE1, 0xFF, 0xE1, 0xE1, 0xE0, 0x07, 0x07, 0xFE, 0x0E, 0x0F, 0x00, 0x3C,
  0x1F, 0xC0, 0xF0, 0x70, 0x01, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x00, 0x1E,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80,
  0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x70, 0x00, 0x3C, 0x03, 0x80,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x00, 0x03, 0xEF, 0xC0, 0x03,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C,
  0x0F, 0x81, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x3E, 0x00,
  0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x78,
  0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0xF0, 0x00, 0x01,
  0xF3, 0xC0, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x78, 0x00, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x00, 0xFF,
  0xC0, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x60, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x70, 0x0E, 0x7E, 0x07, 0x07, 0xE7, 0xFC,
  0x63, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x07,
  0xEF, 0x0F, 0x8F, 0x1F, 0x0F, 0x7E, 0x0F, 0xFC, 0x0F, 0x78, 0x0F, 0x20,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x1E,
  0x00, 0x03, 0xE0, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0x0F, 0xE0, 0x00, 0xFC, 0x3C, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x40, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1C,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x40, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0x80, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x03, 0xFF, 0x80, 0x78, 0x7F, 0xFF,
  0x03, 0xC7, 0xFF, 0xFC, 0x1E, 0x7C, 0x03, 0xF0, 0xF7, 0x80, 0x07, 0xC7,
  0xB8, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x79, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x0F,
  0x80, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x3C, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x1F, 0xC7, 0xC0, 0x01, 0xDE, 0x1F, 0x80, 0x3C, 0xF0, 0x7F,
  0xFF, 0xE7, 0x81, 0xFF, 0xFC, 0x3C, 0x07, 0xFF, 0xC1, 0xE0, 0x03, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x02, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x0F, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0x7C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3,
  0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0x83,
  0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x70, 0x00, 0xFC, 0x20, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0xFF, 0xC0,
  0x0E, 0x1E, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0x8E, 0x00, 0x1F, 0x00, 0x70,
  0x03, 0xCF, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE7, 0x80, 0x1E, 0x00, 0x1C,
  0x00, 0x73, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x39, 0xC0, 0x0F, 0x00, 0x07,
  0x00, 0x1D, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x0E, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x07, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x77, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x3B, 0x80, 0x1C, 0x00,
  0x0F, 0x00, 0x1D, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x0E, 0xE0, 0x07, 0x00,
  0x03, 0xC0, 0x07, 0x70, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xB8, 0x01, 0xE0,
  0x01, 0xF0, 0x03, 0x9C, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xCF, 0x00, 0x38,
  0x00, 0xFC, 0x01, 0xE7, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0xE3, 0xC0, 0x0F,
  0x80, 0x73, 0x80, 0xF0, 0xE0, 0x03, 0xE0, 0x79, 0xE0, 0xF0, 0x78, 0x00,
  0xFF, 0xF8, 0x7F, 0xF0, 0x3C, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x0E, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x01, 0xFE, 0x1F,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xFF,
  0x07, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x70, 0x0F, 0xC0, 0x00, 0x08, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x04,
  0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x3E,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x80, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0xFE,
  0x00, 0x00, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x7C,
  0x00, 0x07, 0xF8, 0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xE0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xDE, 0x00, 0x00, 0x00, 0x3D, 0xFE, 0xF0, 0x00, 0x00, 0x01, 0xEF,
  0xF7, 0x80, 0x00, 0x00, 0x0E, 0x7F, 0x9E, 0x00, 0x00, 0x00, 0xF3, 0xFC,
  0xF0, 0x00, 0x00, 0x07, 0x9F, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xFF, 0x1E,
  0x00, 0x00, 0x03, 0xC7, 0xF8, 0xF0, 0x00, 0x00, 0x1E, 0x3F, 0xC3, 0xC0,
  0x00, 0x00, 0xE1, 0xFE, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0x7F, 0x83, 0xC0, 0x00, 0x07, 0x83, 0xFC, 0x1E, 0x00, 0x00,
  0x3C, 0x1F, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xFF, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0xF0, 0x00, 0x07, 0x01,
  0xFE, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x7F,
  0x80, 0xF0, 0x00, 0x1C, 0x03, 0xFC, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x07, 0xF8, 0x03,
  0xC0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0x80, 0x1E, 0x00,
  0xE0, 0x03, 0xFC, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0xFF, 0x00, 0x1E, 0x03, 0x80, 0x07, 0xF8, 0x00, 0x78, 0x3C, 0x00,
  0x3F, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xFE, 0x00, 0x0E, 0x0E, 0x00, 0x0F,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0x0F,
  0xF7, 0xC0, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x00, 0xFF, 0x3E, 0x00, 0x00,
  0x3F, 0xC7, 0x80, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x03, 0xFC, 0x3E, 0x00,
  0x00, 0xFF, 0x07, 0x80, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x0F, 0xF0, 0x3C,
  0x00, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x3C, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0xFF,
  0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x0F, 0xF0, 0x03, 0xE0, 0x03,
  0xFC, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x03, 0xE0,
  0x0F, 0xF0, 0x00, 0x78, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x03,
  0xC0, 0x3F, 0xC0, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x1F, 0x03, 0xFC, 0x00,
  0x03, 0xC0, 0xFF, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x00, 0x1E, 0x0F, 0xF0,
  0x00, 0x07, 0xC3, 0xFC, 0x00, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0x1E, 0x1F,
  0xC0, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x00, 0xF1, 0xFC, 0x00, 0x00, 0x3E,
  0x7F, 0x00, 0x00, 0x07, 0x9F, 0xC0, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0x7F, 0x8F, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF8, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x07, 0xF8, 0x1F, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3F, 0x01, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0,
  0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFC, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x10, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x40, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01,
  0xF0, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0x00, 0xFC, 0x0E, 0x00, 0x1F, 0x02, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F, 0x1F, 0x80, 0x03, 0xCF, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x78, 0x00,
  0x1F, 0xDF, 0x00, 0x0E, 0xF3, 0xE0, 0x0F, 0x3C, 0xFF, 0xFF, 0x87, 0x1F,
  0xFF, 0xC1, 0xC1, 0xFF, 0xC0, 0x70, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xF0, 0x07, 0x87,
  0xFF, 0xE0, 0x3C, 0x7F, 0xFF, 0x81, 0xE7, 0xC0, 0x7E, 0x0F, 0x78, 0x00,
  0xF8, 0x7F, 0x00, 0x03, 0xE3, 0xB8, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x78, 0xEE, 0x00, 0x07, 0xC7, 0x38, 0x00, 0x7C, 0x39, 0xF0,
  0x0F, 0xC1, 0xC7, 0xFF, 0xFC, 0x0E, 0x1F, 0xFF, 0xC0, 0x70, 0x3F, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xF8, 0x1E, 0x0F, 0xC0, 0x02, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x0F,
  0xE0, 0x0F, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x7F, 0xE0, 0x78, 0x0F, 0xFF, 0xC3, 0xC1, 0xFF, 0xFF, 0x1E, 0x1F,
  0xC0, 0x7C, 0xF0, 0xF8, 0x00, 0xF7, 0x8F, 0x80, 0x03, 0xBC, 0xF8, 0x00,
  0x0F, 0xE7, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x03, 0x78,
  0xF8, 0x00, 0x7B, 0xC3, 0xF0, 0x07, 0x9E, 0x0F, 0xFF, 0xF8, 0xF0, 0x3F,
  0xFF, 0x87, 0x80, 0x7F, 0xF0, 0x1C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x07, 0xE0, 0x03,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0x06, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x78,
  0x0F, 0xFF, 0xC3, 0xC1, 0xFF, 0xFF, 0x1E, 0x1F, 0xC0, 0x7C, 0xF0, 0xF8,
  0x00, 0xF7, 0x8F, 0x80, 0x03, 0xFC, 0xF8, 0x00, 0x0F, 0xE7, 0x80, 0x00,
  0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0x78, 0xF8, 0x00, 0x7B, 0xC3,
  0xF0, 0x0F, 0x9E, 0x0F, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0x87, 0x80, 0x7F,
  0xF0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE1, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3F,
  0xF0, 0x1E, 0x1F, 0xFF, 0x83, 0xC7, 0xFF, 0xF8, 0x79, 0xF0, 0x1F, 0x8F,
  0x78, 0x00, 0xF9, 0xDC, 0x00, 0x0F, 0x3B, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x73, 0xEF, 0xBF, 0xF9, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x70,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF3, 0xBF, 0x8F, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x8F, 0x00, 0x0F, 0x87, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xE0,
  0x07, 0x80, 0xF0, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x1E,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01,
  0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x79, 0xFC, 0x00, 0x3D, 0xFE, 0x00,
  0x1D, 0xEF, 0x80, 0x0E, 0xE3, 0xE0, 0x07, 0xE0, 0xF0, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0x87, 0xFF, 0xE0,
  0x3F, 0xFF, 0x0E, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x39, 0xF0, 0x3F, 0x0F,
  0x81, 0xF8, 0xE7, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xB8, 0x00, 0x7B, 0xC0,
  0x03, 0xEF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x3F, 0xF0, 0x1C, 0x1F, 0xFF,
  0x83, 0x87, 0xFF, 0xF8, 0x71, 0xF0, 0x1F, 0x8E, 0x78, 0x00, 0xF9, 0xDC,
  0x00, 0x0F, 0x3B, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x3F, 0xF0, 0x07, 0x07, 0xFF,
  0xE0, 0x38, 0x7F, 0xFF, 0x81, 0xC7, 0xC0, 0x7E, 0x0E, 0x78, 0x00, 0xF8,
  0x73, 0x80, 0x03, 0xE3, 0xB8, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x78, 0xEE, 0x00, 0x07, 0xC7, 0xB8, 0x00, 0x7C, 0x3C, 0xF0, 0x0F,
  0xC1, 0xE7, 0xFF, 0xFC, 0x0F, 0x0F, 0xFF, 0xC0, 0x78, 0x3F, 0xFC, 0x03,
  0xC0, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x78, 0x0F, 0xFF, 0xC3, 0xC1, 0xFF, 0xFF,
  0x1E, 0x1F, 0xC0, 0x7C, 0xF1, 0xF8, 0x00, 0xF7, 0x8F, 0x80, 0x03, 0xBC,
  0xF8, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xC0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7F, 0x3E, 0x00,
  0x07, 0x78, 0xF8, 0x00, 0x7B, 0xC3, 0xF0, 0x0F, 0x9E, 0x0F, 0xFF, 0xF8,
  0xF0, 0x3F, 0xFF, 0x87, 0x80, 0x7F, 0xF0, 0x3C, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x3F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC7, 0xE7, 0x80, 0x39, 0xC0, 0x0E,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0x7C,
  0x3C, 0x00, 0x0C, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x80, 0x00, 0x3E, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x10, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x0E, 0xE7, 0xC0, 0x03, 0x9C, 0x7E, 0x01,
  0xF3, 0x8F, 0xFF, 0xFC, 0x70, 0xFF, 0xFE, 0x0E, 0x07, 0xFF, 0x81, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xC7, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x38, 0x00, 0x3C,
  0x3C, 0x00, 0x1C, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x87, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x0E, 0x00, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x01, 0xE0, 0x78, 0x07, 0x01, 0xE0, 0x07, 0x81, 0xE0,
  0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x78, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x71,
  0xE0, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x07, 0x9E,
  0x00, 0x07, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x3E,
  0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x39, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x04, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Light71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 52, 17, 5, -51 },
  { 40, 15, 19, 25, 5, -51 },
  { 76, 37, 51, 41, 2, -51 },
  { 312, 28, 58, 36, 4, -54 },
  { 515, 45, 52, 53, 4, -51 },
  { 808, 40, 52, 43, 3, -51 },
  { 1068, 4, 19, 14, 5, -51 },
  { 1078, 14, 62, 20, 3, -51 },
  { 1187, 15, 62, 20, 2, -51 },
  { 1304, 28, 27, 34, 3, -54 },
  { 1399, 30, 34, 37, 3, -42 },
  { 1527, 8, 17, 15, 3, -8 },
  { 1544, 17, 4, 21, 2, -21 },
  { 1553, 6, 7, 16, 5, -6 },
  { 1559, 23, 51, 25, 1, -51 },
  { 1706, 29, 52, 36, 4, -51 },
  { 1895, 16, 51, 36, 6, -51 },
  { 1997, 29, 51, 36, 3, -51 },
  { 2182, 29, 52, 36, 3, -51 },
  { 2371, 34, 51, 36, 1, -51 },
  { 2588, 29, 52, 36, 4, -51 },
  { 2777, 29, 52, 36, 4, -51 },
  { 2966, 30, 51, 36, 3, -51 },
  { 3158, 30, 52, 36, 3, -51 },
  { 3353, 29, 52, 36, 3, -51 },
  { 3542, 6, 39, 16, 5, -38 },
  { 3572, 9, 47, 16, 2, -38 },
  { 3625, 30, 33, 37, 3, -42 },
  { 3749, 30, 18, 37, 3, -34 },
  { 3817, 30, 33, 37, 3, -42 },
  { 3941, 24, 52, 27, 1, -51 },
  { 4097, 49, 58, 56, 4, -51 },
  { 4453, 38, 51, 38, 0, -51 },
  { 4696, 31, 51, 40, 6, -51 },
  { 4894, 33, 52, 39, 4, -51 },
  { 5109, 35, 51, 45, 6, -51 },
  { 5333, 25, 51, 35, 6, -51 },
  { 5493, 25, 51, 32, 6, -51 },
  { 5653, 38, 52, 46, 4, -51 },
  { 5900, 33, 51, 46, 6, -51 },
  { 6111, 14, 51, 21, 3, -51 },
  { 6201, 16, 64, 17, -5, -51 },
  { 6329, 31, 51, 37, 6, -51 },
  { 6527, 25, 51, 32, 6, -51 },
  { 6687, 45, 51, 57, 6, -51 },
  { 6974, 34, 51, 47, 6, -51 },
  { 7191, 40, 52, 48, 4, -51 },
  { 7451, 28, 51, 37, 6, -51 },
  { 7630, 40, 63, 48, 4, -51 },
  { 7945, 31, 51, 38, 6, -51 },
  { 8143, 29, 52, 35, 3, -51 },
  { 8332, 33, 51, 33, 0, -51 },
  { 8543, 34, 52, 46, 6, -51 },
  { 8764, 37, 51, 37, 0, -51 },
  { 9000, 56, 51, 58, 1, -51 },
  { 9357, 34, 51, 34, 0, -51 },
  { 9574, 33, 51, 33, 0, -51 },
  { 9785, 30, 51, 35, 2, -51 },
  { 9977, 14, 62, 23, 6, -51 },
  { 10086, 23, 51, 25, 1, -51 },
  { 10233, 15, 62, 23, 2, -51 },
  { 10350, 32, 30, 37, 2, -51 },
  { 10470, 30, 4, 30, 0, 6 },
  { 10485, 12, 11, 18, 3, -54 },
  { 10502, 26, 39, 34, 3, -38 },
  { 10629, 29, 55, 38, 6, -54 },
  { 10829, 24, 39, 30, 4, -38 },
  { 10946, 29, 55, 38, 4, -54 },
  { 11146, 28, 39, 35, 4, -38 },
  { 11283, 22, 54, 20, 1, -54 },
  { 11432, 29, 55, 38, 4, -38 },
  { 11632, 27, 54, 38, 6, -54 },
  { 11815, 6, 52, 15, 5, -52 },
  { 11854, 14, 69, 15, -3, -52 },
  { 11975, 25, 54, 32, 6, -54 },
  { 12144, 4, 54, 15, 6, -54 },
  { 12171, 46, 38, 57, 6, -38 },
  { 12390, 27, 38, 38, 6, -38 },
  { 12519, 30, 39, 38, 4, -38 },
  { 12666, 29, 55, 38, 6, -38 },
  { 12866, 29, 55, 38, 4, -38 },
  { 13066, 18, 38, 25, 6, -38 },
  { 13152, 24, 39, 30, 3, -38 },
  { 13269, 19, 48, 21, 1, -47 },
  { 13383, 27, 39, 38, 5, -38 },
  { 13515, 30, 38, 30, 0, -38 },
  { 13658, 46, 38, 48, 1, -38 },
  { 13877, 29, 38, 32, 1, -38 },
  { 14015, 30, 55, 30, 0, -38 },
  { 14222, 24, 38, 28, 2, -38 },
  { 14336, 21, 62, 25, 2, -51 },
  { 14499, 4, 71, 35, 15, -54 },
  { 14535, 20, 62, 25, 3, -51 },
  { 14690, 30, 8, 37, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_Light71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT71PT7B_H_
