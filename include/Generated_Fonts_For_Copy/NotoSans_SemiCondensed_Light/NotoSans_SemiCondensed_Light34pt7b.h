#ifndef _NOTOSANS_SEMICONDENSED_LIGHT34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x43, 0x43, 0x42, 0x42, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C,
  0x10, 0x02, 0x0C, 0x00, 0x83, 0x00, 0x60, 0xC1, 0xFF, 0xFF, 0x7F, 0xFF,
  0xC1, 0x82, 0x00, 0x41, 0x80, 0x10, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00,
  0xC1, 0x03, 0xFF, 0xFE, 0x08, 0x30, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x18, 0x20, 0x06, 0x08, 0x01, 0x06, 0x00, 0x41, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x7F, 0xE7, 0xA7, 0x71, 0x03, 0x08, 0x18, 0x40, 0xC2,
  0x06, 0x10, 0x30, 0x80, 0xE4, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x4E,
  0x02, 0x38, 0x10, 0xC0, 0x86, 0x04, 0x30, 0x21, 0x81, 0x0E, 0x09, 0xDF,
  0xFC, 0x3F, 0x80, 0x10, 0x00, 0x80, 0x04, 0x00, 0x18, 0x00, 0x01, 0xF8,
  0x06, 0x06, 0x20, 0x10, 0x30, 0xC0, 0xC0, 0xC3, 0x02, 0x02, 0x04, 0x18,
  0x08, 0x10, 0x40, 0x20, 0x63, 0x00, 0x81, 0x0C, 0x02, 0x04, 0x60, 0x08,
  0x11, 0x8E, 0x30, 0xCC, 0xFC, 0xC3, 0x32, 0x19, 0x89, 0x98, 0x67, 0xE6,
  0x60, 0x82, 0x31, 0x02, 0x00, 0xC4, 0x08, 0x02, 0x10, 0x30, 0x18, 0x40,
  0x80, 0x41, 0x02, 0x03, 0x06, 0x08, 0x08, 0x18, 0x60, 0x60, 0x61, 0x81,
  0x00, 0xCC, 0x0C, 0x01, 0xE0, 0x07, 0x00, 0x07, 0xF0, 0x01, 0x86, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x18,
  0x60, 0x06, 0x30, 0x00, 0xD8, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0E, 0xE0,
  0x07, 0x18, 0x1B, 0x83, 0x06, 0xC0, 0x61, 0xB0, 0x0C, 0xCC, 0x03, 0xB3,
  0x00, 0x78, 0xC0, 0x0E, 0x30, 0x07, 0x86, 0x03, 0xB1, 0xF7, 0xC6, 0x1F,
  0xC0, 0xC0, 0xFF, 0xD5, 0x40, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x0C, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x20, 0x40, 0xC1, 0x83, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC1, 0x81, 0x83,
  0x03, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x20, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0xC3, 0x0E, 0x00, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x08, 0x61, 0x79, 0x7D, 0xFF, 0x80, 0xC0, 0x0D, 0x00,
  0xCC, 0x06, 0x30, 0xE1, 0xC3, 0x04, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x33, 0x36, 0x66, 0x6C, 0xFF, 0xFF, 0x7D, 0x80, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0x7F, 0x03, 0x86, 0x1C, 0x0C, 0x60, 0x31,
  0x80, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0B, 0x00, 0x6C, 0x01,
  0xB0, 0x06, 0x60, 0x19, 0x80, 0xC3, 0x03, 0x0F, 0x78, 0x0F, 0xC0, 0x07,
  0x0F, 0x1B, 0x73, 0xE3, 0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07,
  0x01, 0xFE, 0x3C, 0x38, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0xFF, 0x87, 0x07, 0x90, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x78, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xBE, 0x3C, 0x7F, 0xE0,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x50, 0x00, 0xD0, 0x01, 0xB0, 0x01, 0x30,
  0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x30,
  0x30, 0x30, 0x20, 0x30, 0x60, 0x30, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x7F, 0xF1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x3C, 0x07, 0xFE, 0x10, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x3A, 0x01, 0xCF, 0x1E, 0x1F, 0xF0, 0x00, 0xE0, 0x1F, 0xC0, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x7C, 0x37, 0xFC, 0xF0, 0x3B, 0x80, 0x6C, 0x01, 0xB0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x19, 0x80, 0x63, 0x03, 0x07, 0x3C,
  0x0F, 0xC0, 0xFF, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x7F, 0x83,
  0x07, 0x18, 0x0E, 0x60, 0x1B, 0x00, 0x6C, 0x01, 0x90, 0x06, 0x60, 0x31,
  0xC0, 0xC3, 0x8E, 0x03, 0xE0, 0x0F, 0x80, 0x77, 0x87, 0x07, 0x18, 0x0E,
  0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x66, 0x03,
  0x9E, 0x3C, 0x1F, 0xC0, 0x06, 0x00, 0xFE, 0x1C, 0x38, 0xC0, 0x6C, 0x03,
  0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x03, 0xB8, 0x34, 0xFF, 0x61, 0xE3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x88, 0x78, 0x7F, 0x00, 0x7D, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xEC, 0x37, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33,
  0x36, 0x66, 0x4C, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x00, 0x40, 0x00, 0x0C, 0x1F, 0xF3, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x87, 0x80, 0x38, 0x01,
  0xC0, 0xE0, 0x01, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x01, 0x98, 0x02, 0x03,
  0x30, 0x3F, 0x83, 0x40, 0xC1, 0x07, 0x83, 0x02, 0x0F, 0x04, 0x04, 0x1E,
  0x18, 0x18, 0x1C, 0x30, 0x30, 0x30, 0x60, 0x60, 0xE0, 0xC0, 0xC1, 0xE1,
  0x81, 0x83, 0xC3, 0x03, 0x07, 0x82, 0x0E, 0x1B, 0x07, 0x36, 0x72, 0x07,
  0xC7, 0xC6, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x80, 0x0F, 0x9F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x06, 0x80, 0x01, 0x30, 0x00, 0xCC, 0x00,
  0x31, 0x00, 0x08, 0x60, 0x06, 0x18, 0x01, 0x82, 0x00, 0x40, 0xC0, 0x30,
  0x30, 0x0C, 0x0C, 0x02, 0x01, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x18, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x06, 0x60, 0x01, 0x98, 0x00, 0x6E,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE1, 0x83, 0xE3, 0x00, 0x66, 0x00, 0xEC,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x19, 0x80, 0x73, 0xFF,
  0xC7, 0xFF, 0x0C, 0x07, 0x98, 0x03, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x07, 0x3F, 0xFC, 0x7F,
  0xE0, 0x00, 0x60, 0x07, 0xFF, 0x0F, 0x06, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x9E, 0x03, 0xFE, 0xFF, 0xE0, 0xC3, 0xF0, 0xC0, 0x3C, 0xC0, 0x0C, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEF, 0xFE, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xF0, 0xF0, 0x38, 0x70, 0x02,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03,
  0x30, 0x00, 0xCE, 0x00, 0x31, 0xC0, 0x0C, 0x3F, 0x3F, 0x03, 0xFF, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x6F, 0xDF, 0x00, 0xC0, 0x0F, 0x80,
  0x33, 0x00, 0xC6, 0x03, 0x0C, 0x0E, 0x18, 0x18, 0x30, 0x60, 0x61, 0x80,
  0xC6, 0x01, 0x9C, 0x03, 0x70, 0x06, 0xF0, 0x0F, 0x60, 0x1C, 0x60, 0x30,
  0xE0, 0x60, 0xC0, 0xC0, 0xC1, 0x81, 0xC3, 0x01, 0x86, 0x01, 0x8C, 0x03,
  0x98, 0x03, 0x30, 0x03, 0x60, 0x07, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFD, 0x80, 0x05, 0xEC, 0x00, 0x6F, 0x60, 0x03,
  0x79, 0x80, 0x13, 0xCC, 0x01, 0x9E, 0x20, 0x0C, 0xF1, 0x80, 0xC7, 0x8C,
  0x06, 0x3C, 0x30, 0x31, 0xE1, 0x83, 0x0F, 0x0C, 0x18, 0x78, 0x30, 0xC3,
  0xC1, 0x8C, 0x1E, 0x0C, 0x60, 0xF0, 0x32, 0x07, 0x81, 0xB0, 0x3C, 0x05,
  0x81, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x06, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xD8, 0x03, 0xDC, 0x03, 0xCC, 0x03, 0xC6,
  0x03, 0xC6, 0x03, 0xC3, 0x03, 0xC3, 0x83, 0xC1, 0x83, 0xC1, 0xC3, 0xC0,
  0xC3, 0xC0, 0x63, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x3B, 0xC0, 0x19, 0xC0,
  0x0D, 0xC0, 0x0D, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x78, 0x3C, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0xE0, 0x01, 0x98,
  0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0x63, 0x00, 0x1C, 0x70,
  0x03, 0x07, 0x00, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC6, 0x1F,
  0x30, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0xEF, 0xFE, 0x7F, 0xC3, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0x80, 0x78, 0x3C, 0x0C, 0x01, 0xC3, 0x00, 0x18,
  0xE0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0x63,
  0x00, 0x1C, 0x70, 0x03, 0x07, 0x00, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0xFF, 0xC1, 0x87, 0xE3, 0x00, 0xC6, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xC6, 0x07,
  0x0F, 0xFC, 0x1F, 0xF0, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xE1, 0x80, 0xC3,
  0x01, 0xC6, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x30, 0x03, 0x60, 0x07, 0x03,
  0x00, 0xFF, 0xDE, 0x0C, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1E, 0x01,
  0xDF, 0x3C, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x70, 0x0C,
  0x3E, 0x78, 0x0F, 0xF0, 0xC0, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x06,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x06, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D,
  0x80, 0x01, 0x60, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x0C,
  0x00, 0xF0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x06, 0x60,
  0x16, 0x01, 0x98, 0x0C, 0x80, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C,
  0x30, 0x33, 0x03, 0x0C, 0x18, 0x40, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86,
  0x18, 0x18, 0x61, 0x86, 0x06, 0x30, 0x21, 0x81, 0x8C, 0x0C, 0x60, 0x63,
  0x03, 0x30, 0x0C, 0xC0, 0xCC, 0x03, 0x60, 0x13, 0x00, 0xD8, 0x06, 0xC0,
  0x36, 0x01, 0xA0, 0x05, 0x80, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x60, 0x07, 0x30, 0x06, 0x30, 0x0C, 0x18, 0x0C,
  0x18, 0x18, 0x0C, 0x18, 0x0E, 0x30, 0x06, 0x30, 0x03, 0x60, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30,
  0x0C, 0x30, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x70, 0x06,
  0x60, 0x06, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C,
  0x30, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60,
  0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0F, 0xE0, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0xFE, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0B, 0x00, 0x32, 0x00, 0x46, 0x01, 0x84, 0x03, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x60, 0x10, 0xC0, 0x33, 0x00, 0x26, 0x00, 0x78,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x06, 0x0C, 0x1F, 0xE1,
  0xC3, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x1F, 0x0F,
  0xF9, 0xC0, 0xDC, 0x06, 0xC0, 0x3E, 0x01, 0xE0, 0x1D, 0x80, 0xEC, 0x0F,
  0x71, 0xD9, 0xFC, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xCF, 0xC3, 0x63, 0xCE, 0x03, 0x38,
  0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x02, 0xC0, 0x1B, 0x00, 0x6E, 0x01, 0xA8, 0x0C, 0x9D, 0xE2,
  0x3F, 0x00, 0x0F, 0xE7, 0x8D, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x3C, 0x61, 0xFC, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x1F, 0xCC, 0xE3, 0xB7, 0x03, 0xD8, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x76, 0x01, 0xDC, 0x0F, 0x3C, 0xEC, 0x7F,
  0x30, 0x1F, 0xC1, 0xC7, 0x1C, 0x0C, 0xC0, 0x6C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x01, 0x3E, 0x70, 0x7F, 0x80, 0x03, 0xE1, 0xFC, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0x83, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x1F, 0xCC, 0xE1, 0xB7, 0x03,
  0xD8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x76, 0x01, 0xDC, 0x0B, 0x3C,
  0xEC, 0x7F, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x90,
  0x0C, 0x7D, 0xF0, 0xFF, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xCF, 0xC6, 0xC7, 0x38, 0x0D, 0xC0,
  0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0,
  0x5D, 0x80, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x08, 0x70,
  0xC0, 0x00, 0x00, 0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xBE, 0xF0, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x6C, 0x0C, 0xC1, 0x8C, 0x38, 0xC3, 0x0C, 0x60, 0xCC, 0x0D, 0xC0, 0xFC,
  0x0E, 0x60, 0xE6, 0x0C, 0x30, 0xC3, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0,
  0x6C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x9F, 0xC7, 0xF2,
  0xE7, 0xB8, 0xEA, 0x06, 0x81, 0xB0, 0x1C, 0x06, 0xC0, 0x30, 0x0F, 0x00,
  0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C,
  0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x30, 0x8F,
  0xC4, 0xC7, 0xA8, 0x0D, 0xC0, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x1F, 0xE0, 0xE1, 0xC7, 0x03, 0x98, 0x06,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x01, 0x9C, 0x0E, 0x3C, 0xF0, 0x3F,
  0x80, 0x8F, 0xC2, 0x63, 0xCA, 0x03, 0x38, 0x06, 0xC0, 0x1B, 0x00, 0x6C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0, 0x1B,
  0x00, 0x6E, 0x01, 0xBC, 0x0C, 0xDC, 0xE3, 0x3F, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x1F,
  0xCC, 0xE3, 0xB7, 0x03, 0xD8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x76,
  0x01, 0xDC, 0x0B, 0x3C, 0xEC, 0x7F, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x8F, 0xCE, 0xAC,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x1F, 0xE7, 0x06, 0x60, 0x06, 0x00,
  0x40, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x06, 0xF1, 0xE7, 0xF8, 0x30, 0x18, 0x0C,
  0x06, 0x0F, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x88, 0xFC, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x05, 0x71, 0xD3,
  0xF1, 0xC0, 0x0D, 0x80, 0x36, 0x01, 0x98, 0x06, 0x30, 0x18, 0xC0, 0xC3,
  0x03, 0x04, 0x0C, 0x18, 0x60, 0x61, 0x80, 0x86, 0x03, 0x30, 0x0C, 0xC0,
  0x13, 0x00, 0x68, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x38, 0x0D,
  0x80, 0xE0, 0x36, 0x02, 0x80, 0xD8, 0x0B, 0x03, 0x30, 0x6C, 0x18, 0xC1,
  0xB0, 0x63, 0x04, 0x41, 0x8C, 0x31, 0x84, 0x18, 0xC6, 0x30, 0x63, 0x18,
  0xC1, 0x98, 0x23, 0x06, 0x60, 0xC8, 0x0D, 0x83, 0x60, 0x34, 0x0D, 0x80,
  0xF0, 0x16, 0x03, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x1B, 0x01, 0x8C, 0x1C, 0x60, 0xC1, 0x8C, 0x0C, 0x60, 0x36, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0x60, 0x1B, 0x01, 0x8C, 0x1C, 0x30, 0xC1, 0x8C,
  0x06, 0x60, 0x3E, 0x00, 0xC0, 0xC0, 0x0D, 0x80, 0x36, 0x01, 0x98, 0x06,
  0x30, 0x18, 0xC0, 0xC3, 0x03, 0x06, 0x0C, 0x18, 0x20, 0x61, 0x80, 0xC6,
  0x03, 0x10, 0x04, 0xC0, 0x1B, 0x00, 0x68, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xC1, 0xE0, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0E, 0x0E, 0x01, 0xE0,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x1C, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x1E, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x1C, 0x1E, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0xE0, 0xF0, 0x00, 0x3C, 0x02, 0xFF, 0x07, 0x07, 0xFC, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 24, 8, 3, -24 },
  { 7, 8, 9, 12, 2, -24 },
  { 16, 18, 24, 19, 1, -24 },
  { 70, 13, 28, 17, 2, -26 },
  { 116, 22, 25, 25, 2, -25 },
  { 185, 18, 25, 21, 2, -25 },
  { 242, 2, 9, 7, 2, -24 },
  { 245, 7, 29, 9, 1, -24 },
  { 271, 7, 29, 9, 1, -24 },
  { 297, 13, 13, 16, 2, -26 },
  { 319, 15, 16, 17, 1, -20 },
  { 349, 4, 8, 7, 1, -4 },
  { 353, 8, 2, 10, 1, -10 },
  { 355, 3, 3, 8, 2, -3 },
  { 357, 10, 24, 12, 1, -24 },
  { 387, 14, 25, 17, 2, -25 },
  { 431, 8, 24, 17, 3, -24 },
  { 455, 13, 25, 17, 2, -25 },
  { 496, 14, 25, 17, 1, -25 },
  { 540, 16, 24, 17, 1, -24 },
  { 588, 14, 24, 17, 2, -24 },
  { 630, 14, 25, 17, 2, -25 },
  { 674, 14, 24, 17, 2, -24 },
  { 716, 14, 25, 17, 2, -25 },
  { 760, 13, 25, 17, 2, -25 },
  { 801, 3, 18, 8, 2, -18 },
  { 808, 4, 22, 8, 1, -18 },
  { 819, 15, 16, 17, 1, -20 },
  { 849, 14, 8, 17, 2, -16 },
  { 863, 15, 16, 17, 1, -20 },
  { 893, 11, 25, 13, 1, -25 },
  { 928, 23, 27, 27, 2, -24 },
  { 1006, 18, 24, 18, 0, -24 },
  { 1060, 15, 24, 19, 3, -24 },
  { 1105, 16, 25, 19, 2, -25 },
  { 1155, 16, 24, 21, 3, -24 },
  { 1203, 12, 24, 17, 3, -24 },
  { 1239, 12, 24, 15, 3, -24 },
  { 1275, 18, 25, 22, 2, -25 },
  { 1332, 16, 24, 22, 3, -24 },
  { 1380, 6, 24, 10, 2, -24 },
  { 1398, 7, 30, 8, -2, -24 },
  { 1425, 15, 24, 18, 3, -24 },
  { 1470, 12, 24, 16, 3, -24 },
  { 1506, 21, 24, 27, 3, -24 },
  { 1569, 16, 24, 22, 3, -24 },
  { 1617, 19, 25, 23, 2, -25 },
  { 1677, 13, 24, 18, 3, -24 },
  { 1716, 19, 31, 23, 2, -25 },
  { 1790, 15, 24, 18, 3, -24 },
  { 1835, 13, 25, 17, 2, -25 },
  { 1876, 16, 24, 16, 0, -24 },
  { 1924, 16, 24, 22, 3, -24 },
  { 1972, 18, 24, 18, 0, -24 },
  { 2026, 26, 24, 28, 1, -24 },
  { 2104, 16, 24, 16, 0, -24 },
  { 2152, 16, 24, 16, 0, -24 },
  { 2200, 15, 24, 17, 1, -24 },
  { 2245, 7, 29, 11, 3, -24 },
  { 2271, 10, 24, 12, 1, -24 },
  { 2301, 7, 29, 11, 1, -24 },
  { 2327, 15, 14, 18, 1, -24 },
  { 2354, 14, 2, 14, 0, 3 },
  { 2358, 6, 5, 9, 1, -26 },
  { 2362, 13, 18, 16, 1, -18 },
  { 2392, 14, 26, 18, 3, -26 },
  { 2438, 11, 18, 14, 2, -18 },
  { 2463, 14, 26, 18, 2, -26 },
  { 2509, 13, 18, 17, 2, -18 },
  { 2539, 11, 26, 10, 0, -26 },
  { 2575, 14, 26, 18, 2, -18 },
  { 2621, 13, 26, 18, 3, -26 },
  { 2664, 3, 25, 7, 2, -25 },
  { 2674, 6, 33, 7, -1, -25 },
  { 2699, 12, 26, 15, 3, -26 },
  { 2738, 2, 26, 7, 3, -26 },
  { 2745, 22, 18, 27, 3, -18 },
  { 2795, 13, 18, 18, 3, -18 },
  { 2825, 14, 18, 18, 2, -18 },
  { 2857, 14, 26, 18, 3, -18 },
  { 2903, 14, 26, 18, 2, -18 },
  { 2949, 9, 18, 12, 3, -18 },
  { 2970, 12, 18, 14, 1, -18 },
  { 2997, 9, 22, 10, 1, -22 },
  { 3022, 12, 18, 18, 3, -18 },
  { 3049, 14, 18, 14, 0, -18 },
  { 3081, 22, 18, 23, 0, -18 },
  { 3131, 13, 18, 15, 1, -18 },
  { 3161, 14, 26, 14, 0, -18 },
  { 3207, 11, 18, 13, 1, -18 },
  { 3232, 10, 29, 12, 1, -24 },
  { 3269, 2, 34, 17, 7, -26 },
  { 3278, 10, 29, 12, 1, -24 },
  { 3315, 15, 4, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Light34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT34PT7B_H_
