#ifndef _NOTOSANS_SEMICONDENSED_LIGHT38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x6C, 0x92, 0x49, 0x20, 0x00, 0xFF, 0x80,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x01, 0x81,
  0x80, 0x18, 0x10, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x03, 0x00, 0x10,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x20, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x02,
  0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x04, 0x0C, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xC0, 0x80,
  0x0C, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x00, 0x81, 0x80, 0x18, 0x18,
  0x01, 0x81, 0x00, 0x18, 0x30, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x7F, 0x83, 0xFF, 0xCE, 0x21, 0x98, 0x40, 0x60, 0x80, 0xC1, 0x01, 0x82,
  0x03, 0x04, 0x07, 0x08, 0x07, 0x10, 0x07, 0xA0, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x02, 0x78, 0x04, 0x30, 0x08, 0x30, 0x10, 0x60, 0x20, 0xC0,
  0x41, 0x80, 0x83, 0x81, 0x0D, 0xE2, 0x73, 0xFF, 0xC0, 0x7E, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x60, 0x63,
  0x00, 0x60, 0x61, 0x80, 0xC0, 0xC1, 0x80, 0xC0, 0xC0, 0x81, 0x80, 0xC0,
  0xC1, 0x80, 0xC0, 0xC3, 0x00, 0xC0, 0xC3, 0x00, 0xC0, 0xC6, 0x00, 0xC0,
  0xC6, 0x00, 0xC0, 0xC4, 0x30, 0xC0, 0x8C, 0xFC, 0xC1, 0x88, 0xC6, 0x61,
  0x99, 0x82, 0x73, 0x19, 0x83, 0x3F, 0x31, 0x83, 0x08, 0x31, 0x03, 0x00,
  0x63, 0x03, 0x00, 0x63, 0x03, 0x00, 0xC3, 0x03, 0x00, 0xC1, 0x03, 0x01,
  0x81, 0x03, 0x01, 0x81, 0x83, 0x03, 0x01, 0x83, 0x03, 0x01, 0x86, 0x06,
  0x00, 0xEE, 0x06, 0x00, 0x7C, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x9C,
  0x00, 0x30, 0x30, 0x03, 0x81, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x03, 0x1C, 0x00, 0x1D, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0x38, 0x06, 0x70,
  0xE0, 0x73, 0x03, 0x83, 0x30, 0x0E, 0x19, 0x80, 0x39, 0xCC, 0x00, 0xCC,
  0x60, 0x03, 0xE3, 0x00, 0x1E, 0x18, 0x00, 0x70, 0xE0, 0x07, 0xC3, 0x80,
  0xE7, 0x0F, 0xFE, 0x1C, 0x3F, 0xC0, 0x70, 0xFF, 0xFF, 0xE0, 0x06, 0x18,
  0x60, 0xC3, 0x06, 0x1C, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x70, 0x60, 0xC1, 0xC1, 0x83, 0x83,
  0x07, 0x06, 0x06, 0xE0, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06,
  0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x70, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0x8C, 0x3F, 0xFF,
  0xC7, 0xF8, 0x03, 0x80, 0x1B, 0x00, 0xCC, 0x07, 0x18, 0x18, 0x70, 0xC0,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x39, 0xCC, 0x63, 0x31, 0x8C, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0x1E, 0xF8, 0x38,
  0x18, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x06, 0x60,
  0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x18, 0x1F, 0xF0, 0x0F,
  0xE0, 0x03, 0x83, 0xC3, 0xE3, 0xB7, 0x1F, 0x0D, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x01, 0x00, 0x3F, 0xC1,
  0xF3, 0xC7, 0x01, 0xC4, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x00, 0x7F, 0xE1, 0xF3, 0xE7, 0x00, 0xE8, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0D,
  0x00, 0x3B, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x30,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x06,
  0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x38, 0x03, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFC, 0x7F, 0xF8, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xFF, 0x87, 0xDF, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x0E, 0xC0, 0x39, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x30,
  0x03, 0xFC, 0x07, 0x8C, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC3, 0xE0, 0xCF, 0xF8,
  0xDC, 0x1C, 0xD0, 0x0C, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0E,
  0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x01, 0x00, 0x0F, 0xF0, 0x3C, 0x78, 0x70, 0x1C, 0x60, 0x0C, 0x60, 0x0E,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x30, 0x1C, 0x1C, 0x38,
  0x0E, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x1C, 0x78, 0x30, 0x1C, 0x60, 0x0E,
  0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06,
  0x60, 0x0E, 0x70, 0x1C, 0x3E, 0xF8, 0x0F, 0xF0, 0x01, 0x00, 0x3F, 0xC0,
  0xFB, 0xC3, 0x81, 0xC6, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xD8, 0x07,
  0x9C, 0x1B, 0x1F, 0xE6, 0x0F, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE1, 0xDF, 0x83, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x39, 0xCE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C,
  0xC0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x04, 0x07, 0xFC, 0xFB, 0xE8, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x38, 0x03, 0xC0, 0x18, 0x00, 0x38, 0x0C, 0x00,
  0x07, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x08, 0x06, 0x60,
  0x3F, 0xE0, 0x98, 0x1C, 0x18, 0x36, 0x0E, 0x04, 0x0F, 0x03, 0x01, 0x03,
  0xC1, 0x80, 0xC0, 0xF0, 0x60, 0x30, 0x3C, 0x18, 0x0C, 0x0F, 0x06, 0x03,
  0x03, 0xC1, 0x80, 0xC0, 0xF0, 0x60, 0x30, 0x3C, 0x18, 0x0C, 0x0B, 0x07,
  0x07, 0x06, 0xC0, 0xC3, 0x63, 0x98, 0x1F, 0x8F, 0xC6, 0x01, 0xC1, 0xC1,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x40, 0x07, 0xC1, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80,
  0x00, 0xD8, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xE0, 0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x18,
  0x01, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0E, 0x30, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0xF0,
  0x7F, 0xFE, 0x38, 0x07, 0x9C, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0x80,
  0x0D, 0xC0, 0x06, 0xE0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x9C, 0x07, 0x8F,
  0xFF, 0x07, 0xFF, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0xE0, 0x03, 0x70, 0x01,
  0xB8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1B, 0x80, 0x0D, 0xC0,
  0x0E, 0xE0, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xE0, 0x7E, 0xFC, 0x38, 0x02, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x10, 0x7F, 0xF8, 0x07, 0xFE, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0x80, 0x78, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0,
  0x03, 0x38, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x07, 0x38, 0x00, 0xC7, 0x00, 0x78, 0xE0, 0x3E, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xFF, 0xFB, 0xFF, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0xB8, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFE, 0x03, 0xF7, 0xF0,
  0xF0, 0x02, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x03, 0x30,
  0x00, 0x33, 0x80, 0x03, 0x1C, 0x00, 0x30, 0xF0, 0x03, 0x07, 0xFF, 0xF0,
  0x1F, 0xFC, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0C, 0xFE, 0xF8, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0xFB, 0xF8, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x0C, 0x0E, 0xFE, 0x7C, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0x38, 0x03,
  0x1C, 0x03, 0x8E, 0x03, 0x87, 0x03, 0x83, 0x81, 0x81, 0xC1, 0x80, 0xE1,
  0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xC0, 0x0E, 0xF0, 0x07, 0xD8, 0x03,
  0xCE, 0x01, 0xC3, 0x80, 0xE0, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x06,
  0x0E, 0x03, 0x87, 0x00, 0xC3, 0x80, 0x31, 0xC0, 0x1C, 0xE0, 0x06, 0x70,
  0x03, 0xB8, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xD8, 0x00, 0x0F, 0xD8, 0x00, 0x1B, 0xCC, 0x00, 0x1B, 0xCC, 0x00,
  0x3B, 0xEC, 0x00, 0x33, 0xE6, 0x00, 0x33, 0xE6, 0x00, 0x63, 0xE6, 0x00,
  0x63, 0xE3, 0x00, 0x63, 0xE3, 0x00, 0xC3, 0xE3, 0x80, 0xC3, 0xE1, 0x80,
  0xC3, 0xE1, 0x81, 0x83, 0xE0, 0xC1, 0x83, 0xE0, 0xC1, 0x83, 0xE0, 0xC3,
  0x03, 0xE0, 0x63, 0x03, 0xE0, 0x67, 0x03, 0xE0, 0x66, 0x03, 0xE0, 0x36,
  0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x18,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xEC, 0x00, 0x7D, 0xC0,
  0x0F, 0x98, 0x01, 0xF3, 0x80, 0x3E, 0x30, 0x07, 0xE7, 0x00, 0xFC, 0x60,
  0x1F, 0x86, 0x03, 0xF0, 0xE0, 0x7E, 0x0C, 0x0F, 0xC1, 0xC1, 0xF8, 0x18,
  0x3F, 0x01, 0x87, 0xE0, 0x38, 0xFC, 0x03, 0x1F, 0x80, 0x73, 0xF0, 0x06,
  0x3E, 0x00, 0xE7, 0xC0, 0x0C, 0xF8, 0x00, 0xDF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00,
  0x7C, 0xF8, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x00,
  0x03, 0x1C, 0x00, 0x0E, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x01,
  0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x19, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0xE1, 0xFF, 0xF3, 0x80, 0xF7, 0x00, 0x6E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xDC,
  0x0F, 0x3F, 0xFC, 0x7F, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0xF8, 0x03, 0x80,
  0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0E,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19,
  0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xFF, 0xE0, 0x7F, 0xFC, 0x38, 0x0F, 0x1C, 0x01, 0xCE, 0x00, 0x67, 0x00,
  0x33, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0x38, 0x03, 0x9C,
  0x01, 0x8E, 0x01, 0xC7, 0xFF, 0x83, 0xFF, 0x81, 0xC1, 0x80, 0xE0, 0x60,
  0x70, 0x38, 0x38, 0x0C, 0x1C, 0x07, 0x0E, 0x01, 0x87, 0x00, 0xE3, 0x80,
  0x31, 0xC0, 0x1C, 0xE0, 0x06, 0x70, 0x03, 0xB8, 0x00, 0xE0, 0x01, 0x80,
  0x1F, 0xF8, 0xFF, 0xF3, 0x80, 0x26, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0D, 0x00, 0x7B, 0xFF,
  0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xD8, 0x00, 0x76, 0x00, 0x19, 0xC0, 0x0E, 0x38, 0x07, 0x07, 0xFF, 0x80,
  0x7F, 0xC0, 0xC0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00, 0x0C,
  0x70, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x80, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x38, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xE0,
  0x60, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x1C, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x07,
  0x00, 0x1F, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0x70, 0x01, 0x98, 0x01, 0x60,
  0x0E, 0x60, 0x0D, 0x80, 0x31, 0x80, 0x36, 0x00, 0xC6, 0x00, 0xD8, 0x03,
  0x1C, 0x03, 0x30, 0x1C, 0x30, 0x18, 0xC0, 0x60, 0xC0, 0x63, 0x01, 0x83,
  0x01, 0x8C, 0x06, 0x0E, 0x0E, 0x18, 0x38, 0x18, 0x30, 0x60, 0xC0, 0x60,
  0xC1, 0x83, 0x01, 0x83, 0x06, 0x0C, 0x07, 0x1C, 0x0C, 0x70, 0x0C, 0x60,
  0x31, 0x80, 0x31, 0x80, 0xC6, 0x00, 0xC6, 0x03, 0x18, 0x03, 0xB8, 0x06,
  0xE0, 0x06, 0xC0, 0x1B, 0x00, 0x1B, 0x00, 0x6C, 0x00, 0x6C, 0x01, 0xB0,
  0x01, 0xB0, 0x02, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xCC, 0x00, 0xE3, 0x80, 0x30, 0x60,
  0x1C, 0x1C, 0x06, 0x03, 0x03, 0x80, 0x60, 0xC0, 0x18, 0x70, 0x03, 0x18,
  0x00, 0xCC, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x01, 0xC6, 0x00, 0x61, 0xC0, 0x38,
  0x30, 0x0C, 0x0E, 0x06, 0x01, 0x81, 0x80, 0x70, 0xC0, 0x0C, 0x70, 0x03,
  0x98, 0x00, 0x6E, 0x00, 0x1C, 0xE0, 0x01, 0xD8, 0x00, 0x67, 0x00, 0x38,
  0xC0, 0x0C, 0x30, 0x07, 0x06, 0x01, 0x81, 0x80, 0xE0, 0x30, 0x30, 0x0C,
  0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x70, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x31, 0x80,
  0x18, 0x60, 0x18, 0x30, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x33, 0x00, 0x19, 0x80, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x01, 0x01, 0xFF, 0x1E, 0x1C, 0x40,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xC7, 0xFE,
  0xF0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF8,
  0x1A, 0xF7, 0x93, 0xF8, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x80, 0xCF,
  0xF0, 0xDC, 0x38, 0xD0, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xC0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x06, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xF0, 0x0C, 0xD0, 0x1C, 0xDF,
  0xF8, 0xC7, 0xF0, 0x00, 0xC0, 0x7F, 0xC7, 0x8E, 0x70, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0x87, 0x0F, 0xE7, 0x1C, 0x37,
  0x38, 0x1B, 0x70, 0x0F, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x38, 0x1B, 0x3E, 0xF3, 0x0F, 0xE3,
  0x01, 0x80, 0x1F, 0xE0, 0x79, 0xE1, 0x80, 0xC7, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x10,
  0xFB, 0xE0, 0xFF, 0x80, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFC, 0xFF, 0xC0, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0x00, 0x0F, 0xE3, 0x3C, 0x33, 0x30, 0x1B, 0x70, 0x0F, 0x60, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0B,
  0x38, 0x1F, 0x1E, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x60, 0x1C, 0x7F, 0xF8, 0x1F, 0xE0,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC1, 0xC3, 0x3F, 0xCD, 0xC7, 0xB4, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0C, 0x5F, 0xA0, 0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x60, 0x04, 0x1C, 0x38, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x77, 0xCF, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0xEC, 0x07, 0x30, 0x18, 0xC0, 0xC3, 0x06, 0x0C,
  0x38, 0x31, 0xC0, 0xC6, 0x03, 0x38, 0x0D, 0xE0, 0x3C, 0xC0, 0xE3, 0x83,
  0x06, 0x0C, 0x1C, 0x30, 0x30, 0xC0, 0x63, 0x01, 0xCC, 0x03, 0x30, 0x0E,
  0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x00,
  0x20, 0x67, 0xF0, 0xFF, 0x37, 0x1C, 0xE3, 0x9E, 0x07, 0xC0, 0xEE, 0x01,
  0xC0, 0x37, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x0F, 0x80, 0x30, 0x07, 0xC0,
  0x18, 0x03, 0xE0, 0x0C, 0x01, 0xF0, 0x06, 0x00, 0xF8, 0x03, 0x00, 0x7C,
  0x01, 0x80, 0x3E, 0x00, 0xC0, 0x1F, 0x00, 0x60, 0x0F, 0x80, 0x30, 0x07,
  0xC0, 0x18, 0x03, 0xE0, 0x0C, 0x01, 0xF0, 0x06, 0x00, 0xF8, 0x03, 0x00,
  0x7C, 0x01, 0x80, 0x38, 0x01, 0xC3, 0x3F, 0xCD, 0xE7, 0xB4, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0C, 0x01, 0x80, 0x0F, 0xF0, 0x1C, 0x38, 0x38,
  0x0C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60,
  0x07, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0x01,
  0xC0, 0xC7, 0xF0, 0xDC, 0x38, 0xD0, 0x1C, 0xF0, 0x0E, 0xE0, 0x06, 0xE0,
  0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xF0, 0x0C, 0xD8,
  0x1C, 0xDF, 0xF8, 0xC7, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x0F, 0xE3, 0x3C, 0x73, 0x30, 0x1B, 0x70, 0x0F, 0x60, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0B, 0x30,
  0x1F, 0x3E, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01,
  0xB3, 0xFD, 0xEF, 0x60, 0xF0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x02, 0x03, 0xFF, 0x70, 0xFE, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x7F, 0xFE, 0xFF, 0x80, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x3F, 0xFF, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x7B, 0x0F, 0xC0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xE0, 0x1D,
  0x80, 0xF7, 0xFE, 0xC7, 0xF1, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0xE0, 0x0C, 0x01,
  0xB0, 0x0E, 0x01, 0xD8, 0x07, 0x80, 0xCE, 0x03, 0xC0, 0x63, 0x03, 0x60,
  0x31, 0x81, 0x98, 0x38, 0xC0, 0xCC, 0x18, 0x70, 0x66, 0x0C, 0x18, 0x63,
  0x06, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x63, 0x01, 0x98, 0x31, 0x80, 0xCC,
  0x0C, 0xC0, 0x66, 0x06, 0x60, 0x33, 0x03, 0x60, 0x0F, 0x01, 0xB0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0xE0, 0x38, 0xC0, 0x61, 0xC1, 0xC1, 0x83, 0x01, 0x8C, 0x03,
  0x38, 0x03, 0x60, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x36, 0x00, 0xEC,
  0x01, 0x8C, 0x06, 0x1C, 0x0C, 0x18, 0x30, 0x18, 0xE0, 0x39, 0x80, 0x36,
  0x00, 0x70, 0xE0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0C,
  0x30, 0x0C, 0x38, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30,
  0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x7C,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x03, 0xC0, 0xE0, 0x0F, 0x00, 0x30, 0x06,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x78, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x07,
  0xC0, 0xF0, 0x00, 0x7F, 0x01, 0xE7, 0xC7, 0x80, 0xFE, 0x00, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_Light38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 27, 9, 3, -27 },
  { 12, 8, 10, 13, 3, -27 },
  { 22, 20, 27, 22, 1, -27 },
  { 90, 15, 31, 20, 2, -29 },
  { 149, 24, 28, 28, 2, -28 },
  { 233, 21, 28, 23, 2, -28 },
  { 307, 2, 10, 7, 3, -27 },
  { 310, 7, 33, 11, 2, -27 },
  { 339, 8, 33, 11, 1, -27 },
  { 372, 14, 14, 18, 2, -29 },
  { 397, 16, 18, 20, 2, -22 },
  { 433, 5, 9, 8, 1, -4 },
  { 439, 9, 2, 11, 1, -11 },
  { 442, 3, 3, 9, 3, -3 },
  { 444, 12, 27, 13, 1, -27 },
  { 485, 16, 28, 20, 2, -28 },
  { 541, 9, 27, 20, 3, -27 },
  { 572, 15, 28, 20, 2, -28 },
  { 625, 15, 28, 20, 2, -28 },
  { 678, 18, 27, 20, 1, -27 },
  { 739, 15, 27, 20, 2, -27 },
  { 790, 16, 28, 20, 2, -28 },
  { 846, 16, 27, 20, 2, -27 },
  { 900, 16, 28, 20, 2, -28 },
  { 956, 15, 28, 20, 2, -28 },
  { 1009, 3, 20, 9, 3, -20 },
  { 1017, 5, 25, 9, 1, -20 },
  { 1033, 16, 17, 20, 2, -22 },
  { 1067, 16, 9, 20, 2, -18 },
  { 1085, 16, 17, 20, 2, -22 },
  { 1119, 12, 28, 14, 1, -28 },
  { 1161, 26, 31, 30, 2, -27 },
  { 1262, 20, 27, 20, 0, -27 },
  { 1330, 17, 27, 22, 3, -27 },
  { 1388, 18, 28, 21, 2, -28 },
  { 1451, 19, 27, 24, 3, -27 },
  { 1516, 14, 27, 19, 3, -27 },
  { 1564, 14, 27, 17, 3, -27 },
  { 1612, 20, 28, 25, 2, -28 },
  { 1682, 18, 27, 25, 3, -27 },
  { 1743, 7, 27, 11, 2, -27 },
  { 1767, 9, 34, 9, -3, -27 },
  { 1806, 17, 27, 20, 3, -27 },
  { 1864, 14, 27, 17, 3, -27 },
  { 1912, 24, 27, 31, 3, -27 },
  { 1993, 19, 27, 25, 3, -27 },
  { 2058, 22, 28, 26, 2, -28 },
  { 2135, 15, 27, 20, 3, -27 },
  { 2186, 22, 34, 26, 2, -28 },
  { 2280, 17, 27, 20, 3, -27 },
  { 2338, 15, 28, 19, 2, -28 },
  { 2391, 17, 27, 18, 0, -27 },
  { 2449, 18, 27, 24, 3, -27 },
  { 2510, 20, 27, 20, 0, -27 },
  { 2578, 30, 27, 31, 1, -27 },
  { 2680, 18, 27, 18, 0, -27 },
  { 2741, 18, 27, 18, 0, -27 },
  { 2802, 16, 27, 19, 1, -27 },
  { 2856, 8, 33, 12, 3, -27 },
  { 2889, 12, 27, 13, 1, -27 },
  { 2930, 8, 33, 12, 1, -27 },
  { 2963, 17, 16, 20, 1, -27 },
  { 2997, 16, 2, 16, 0, 3 },
  { 3001, 6, 6, 10, 2, -29 },
  { 3006, 13, 21, 18, 2, -21 },
  { 3041, 16, 29, 21, 3, -29 },
  { 3099, 13, 21, 16, 2, -21 },
  { 3134, 16, 29, 21, 2, -29 },
  { 3192, 15, 21, 19, 2, -21 },
  { 3232, 12, 29, 11, 0, -29 },
  { 3276, 16, 30, 21, 2, -21 },
  { 3336, 14, 29, 20, 3, -29 },
  { 3387, 3, 28, 8, 3, -28 },
  { 3398, 7, 37, 8, -1, -28 },
  { 3431, 14, 29, 17, 3, -29 },
  { 3482, 2, 29, 8, 3, -29 },
  { 3490, 25, 21, 30, 3, -21 },
  { 3556, 14, 21, 20, 3, -21 },
  { 3593, 16, 21, 20, 2, -21 },
  { 3635, 16, 30, 21, 3, -21 },
  { 3695, 16, 30, 21, 2, -21 },
  { 3755, 10, 21, 13, 3, -21 },
  { 3782, 12, 21, 16, 2, -21 },
  { 3814, 10, 25, 11, 1, -25 },
  { 3846, 14, 20, 20, 3, -20 },
  { 3881, 16, 20, 16, 0, -20 },
  { 3921, 25, 20, 26, 0, -20 },
  { 3984, 15, 20, 17, 1, -20 },
  { 4022, 16, 29, 16, 0, -20 },
  { 4080, 13, 20, 15, 1, -20 },
  { 4113, 11, 33, 14, 1, -27 },
  { 4159, 2, 38, 19, 8, -29 },
  { 4169, 11, 33, 14, 1, -27 },
  { 4215, 16, 4, 20, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Light38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT38PT7B_H_
