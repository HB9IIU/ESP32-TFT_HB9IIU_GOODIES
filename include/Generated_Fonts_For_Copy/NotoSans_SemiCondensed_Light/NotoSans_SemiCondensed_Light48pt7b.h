#ifndef _NOTOSANS_SEMICONDENSED_LIGHT48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light48pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66,
  0x66, 0x60, 0x00, 0x00, 0xEF, 0xFE, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3B, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x07, 0x00,
  0x06, 0x03, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF0, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x01,
  0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x70,
  0x18, 0x00, 0x30, 0x0C, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7D, 0xBF,
  0x1C, 0x30, 0x27, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00,
  0x60, 0x60, 0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x3C, 0x30, 0x03, 0xC6, 0x00,
  0x3E, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x01, 0x8F, 0x00, 0x30, 0xF0, 0x06, 0x0E, 0x00, 0xC0, 0xC0, 0x18, 0x1C,
  0x03, 0x03, 0x80, 0x60, 0x70, 0x0C, 0x0C, 0x01, 0x83, 0xA0, 0x30, 0xE7,
  0x06, 0x7C, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0x00, 0xE3, 0x80, 0x0C, 0x01, 0x83, 0x80, 0x38, 0x07, 0x03,
  0x00, 0x60, 0x0C, 0x06, 0x01, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0x30, 0x1C,
  0x0E, 0x00, 0xE0, 0x38, 0x18, 0x01, 0xC0, 0x70, 0x30, 0x03, 0x80, 0xE0,
  0xE0, 0x07, 0x01, 0xC1, 0x80, 0x0E, 0x03, 0x87, 0x00, 0x0C, 0x07, 0x0C,
  0x00, 0x18, 0x0E, 0x38, 0x78, 0x30, 0x18, 0x63, 0xFC, 0x60, 0x31, 0xCE,
  0x18, 0xE0, 0xE3, 0x18, 0x38, 0xC1, 0x8E, 0x30, 0x31, 0xE7, 0x18, 0xE0,
  0x71, 0xFC, 0x71, 0x80, 0xE0, 0xE0, 0xC3, 0x00, 0xC0, 0x03, 0x86, 0x01,
  0x80, 0x06, 0x0C, 0x03, 0x00, 0x1C, 0x18, 0x06, 0x00, 0x30, 0x30, 0x0C,
  0x00, 0xE0, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x81, 0xC0, 0x18, 0x07, 0x03, 0x00, 0x70, 0x06, 0x06, 0x00,
  0xC0, 0x0E, 0x1C, 0x03, 0x80, 0x0F, 0xF0, 0x0E, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0,
  0x0C, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3D, 0xE0, 0x01, 0x0F, 0x1E, 0x00, 0xC3, 0x81, 0xC0, 0x38, 0xF0, 0x1C,
  0x07, 0x1C, 0x01, 0xC0, 0xE3, 0x00, 0x1C, 0x18, 0xE0, 0x01, 0xC7, 0x1C,
  0x00, 0x3C, 0xC3, 0x80, 0x03, 0xF8, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x3F, 0x81, 0xC0, 0x0F, 0x78, 0x3E,
  0x07, 0xC7, 0x83, 0xFF, 0xE0, 0x78, 0x1F, 0xF8, 0x07, 0x80, 0xFF, 0xFF,
  0xFB, 0x6D, 0xB0, 0x03, 0xC0, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83,
  0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x80, 0xC0, 0x9E, 0x18,
  0x7F, 0xFA, 0xFF, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x06, 0xC0, 0x00, 0xDC,
  0x00, 0x31, 0x80, 0x0E, 0x38, 0x03, 0x83, 0x80, 0xF0, 0x38, 0x1C, 0x07,
  0x00, 0x80, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x39, 0xCE,
  0x77, 0x39, 0xCC, 0x67, 0x30, 0xFF, 0xFF, 0xFC, 0x77, 0xBE, 0xE0, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0xE0,
  0x78, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x06, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x76,
  0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x63, 0x00,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x0F,
  0x07, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x7C, 0x1F, 0x87,
  0xF1, 0xEE, 0x71, 0xFC, 0x3B, 0x07, 0x40, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x3F,
  0xFF, 0x07, 0xC0, 0x78, 0x30, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0x80, 0x78, 0x60, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE8, 0x00, 0x3C, 0xF0, 0x0F, 0x8F, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x0E,
  0x00, 0x18, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x70, 0x03, 0x80, 0xE0,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC7,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x20, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x20, 0x01, 0xE7, 0x00, 0xF8, 0xFF, 0xFE, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0xFF,
  0x06, 0x3F, 0xF8, 0xCE, 0x07, 0x9B, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xB0, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01,
  0x8E, 0x00, 0x71, 0xE0, 0x1C, 0x1E, 0x07, 0x81, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xE0, 0x3C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0x67, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x80, 0x0E, 0x3C, 0x01,
  0xC1, 0xE0, 0x38, 0x0F, 0x0F, 0x00, 0x7D, 0xE0, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x07, 0x9E, 0x00, 0xE0, 0x78, 0x1C, 0x03, 0xC3, 0x80, 0x1E, 0x70,
  0x00, 0xE7, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xE3, 0x80, 0x1E,
  0x3E, 0x03, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x01, 0xC0, 0x78, 0x38, 0x03, 0x87, 0x00, 0x1C, 0x70,
  0x00, 0xC6, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x0F,
  0x70, 0x00, 0xF7, 0x80, 0x1F, 0x3C, 0x03, 0x71, 0xF0, 0xF7, 0x0F, 0xFC,
  0x70, 0x3F, 0x86, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x20, 0x3E, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x20, 0x00, 0x73, 0xBE, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xCF, 0xFB, 0x80, 0x38, 0xE7, 0xCE, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0x8E, 0x31, 0xC7, 0x1C, 0x63, 0x8C, 0x30, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0x7F,
  0xF0, 0xFF, 0xFC, 0x60, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x78, 0x03,
  0x1C, 0x01, 0xFF, 0x81, 0xCC, 0x03, 0xE3, 0xC0, 0x66, 0x01, 0xC0, 0xE0,
  0x37, 0x01, 0xC0, 0x70, 0x1B, 0x81, 0xC0, 0x38, 0x0D, 0x80, 0xE0, 0x1C,
  0x06, 0xC0, 0x60, 0x0E, 0x03, 0x60, 0x70, 0x07, 0x01, 0xF0, 0x38, 0x03,
  0x80, 0xD8, 0x1C, 0x01, 0xC0, 0x6C, 0x0E, 0x00, 0xE0, 0x36, 0x07, 0x00,
  0x60, 0x1B, 0x03, 0x80, 0x30, 0x0D, 0x80, 0xC0, 0x3C, 0x0E, 0xC0, 0x70,
  0x1E, 0x06, 0x60, 0x38, 0x1B, 0x07, 0x38, 0x0F, 0x38, 0xEF, 0x0C, 0x03,
  0xFC, 0x7F, 0x06, 0x00, 0x78, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xE0, 0x01, 0xC0, 0x30,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x70, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x01, 0xF1, 0xC0, 0x03, 0xCE, 0x00, 0x0E,
  0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xE3,
  0x80, 0x3E, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0x00, 0x7E, 0x38, 0x00,
  0x79, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x07, 0x9C, 0x03, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xF0, 0x06, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x18,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xE0, 0x1F, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0,
  0xE0, 0x03, 0xE0, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFE, 0xFF, 0xFF,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x7C, 0x00, 0xE0, 0xF8, 0x00, 0x10, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x78, 0x00, 0x0E, 0x1F, 0x00, 0x07, 0x07, 0xE0, 0x0F, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0xFF, 0xDF, 0xE0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0xFF, 0x9F, 0xE0, 0xF0,
  0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x38, 0x00, 0x79, 0xC0, 0x07, 0x8E,
  0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x71,
  0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xF0, 0x00, 0xEF, 0xC0, 0x07, 0xEF, 0x00,
  0x3E, 0x38, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1,
  0xC0, 0x07, 0x0E, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00,
  0x1E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1B, 0xFC,
  0x00, 0x00, 0xEF, 0xB0, 0x00, 0x03, 0xBE, 0xE0, 0x00, 0x0C, 0xF9, 0x80,
  0x00, 0x77, 0xE7, 0x00, 0x01, 0xDF, 0x9C, 0x00, 0x06, 0x7E, 0x30, 0x00,
  0x39, 0xF8, 0xE0, 0x00, 0xE7, 0xE3, 0x80, 0x03, 0x1F, 0x86, 0x00, 0x1C,
  0x7E, 0x1C, 0x00, 0x61, 0xF8, 0x70, 0x01, 0x87, 0xE0, 0xC0, 0x0E, 0x1F,
  0x83, 0x80, 0x30, 0x7E, 0x0E, 0x01, 0xC1, 0xF8, 0x18, 0x07, 0x07, 0xE0,
  0x70, 0x18, 0x1F, 0x80, 0xC0, 0xE0, 0x7E, 0x03, 0x83, 0x81, 0xF8, 0x0E,
  0x0C, 0x07, 0xE0, 0x18, 0x70, 0x1F, 0x80, 0x71, 0x80, 0x7E, 0x01, 0xC6,
  0x01, 0xF8, 0x03, 0x38, 0x07, 0xE0, 0x0E, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F,
  0x80, 0x0E, 0x00, 0x70, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7D, 0xC0, 0x00, 0xFB, 0x80, 0x01,
  0xF3, 0x80, 0x03, 0xE7, 0x80, 0x07, 0xC7, 0x00, 0x0F, 0x87, 0x00, 0x1F,
  0x0E, 0x00, 0x3E, 0x0E, 0x00, 0x7C, 0x1C, 0x00, 0xF8, 0x1C, 0x01, 0xF0,
  0x1C, 0x03, 0xE0, 0x38, 0x07, 0xC0, 0x38, 0x0F, 0x80, 0x70, 0x1F, 0x00,
  0x70, 0x3E, 0x00, 0xE0, 0x7C, 0x00, 0xE0, 0xF8, 0x00, 0xE1, 0xF0, 0x01,
  0xC3, 0xE0, 0x01, 0xC7, 0xC0, 0x03, 0x8F, 0x80, 0x03, 0x9F, 0x00, 0x07,
  0xBE, 0x00, 0x07, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x07,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x80, 0x7E,
  0x70, 0x01, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x07, 0x9C, 0x1F, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x38, 0x07, 0xE1,
  0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0xF0, 0xE0, 0x1F,
  0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80,
  0x03, 0x9C, 0x00, 0x1E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0x00, 0x63, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x74,
  0x00, 0x1E, 0xF0, 0x0F, 0x9F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x33, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x0F, 0x00,
  0x1E, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xE0, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0x70, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x60, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x18,
  0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x01, 0x87,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x80, 0x03, 0x9C,
  0x00, 0x3E, 0x00, 0x0E, 0x70, 0x00, 0xD8, 0x00, 0x31, 0xC0, 0x03, 0x60,
  0x01, 0xC7, 0x00, 0x0D, 0xC0, 0x07, 0x0C, 0x00, 0x77, 0x00, 0x1C, 0x38,
  0x01, 0xCC, 0x00, 0x60, 0xE0, 0x06, 0x30, 0x03, 0x83, 0x80, 0x18, 0xE0,
  0x0E, 0x06, 0x00, 0xE3, 0x80, 0x38, 0x1C, 0x03, 0x86, 0x00, 0xC0, 0x70,
  0x0C, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x70, 0x1C, 0x03, 0x01, 0xC1, 0xC0,
  0x70, 0x0E, 0x07, 0x03, 0x01, 0x80, 0x38, 0x18, 0x0E, 0x0E, 0x00, 0xE0,
  0xE0, 0x38, 0x38, 0x01, 0x83, 0x80, 0xE0, 0xE0, 0x07, 0x0E, 0x01, 0x83,
  0x00, 0x1C, 0x30, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x00, 0xC7,
  0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0xC6, 0x00, 0x0E, 0x60, 0x03, 0xB8,
  0x00, 0x39, 0x80, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x3B, 0x80, 0x01, 0xB8,
  0x00, 0x6C, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0C, 0x00, 0x06,
  0x38, 0x00, 0x0E, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70,
  0x00, 0x0C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x60, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x01,
  0xC0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0x1C, 0x06,
  0x00, 0x18, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0xC0, 0x00,
  0xC6, 0x00, 0x0E, 0x38, 0x00, 0x60, 0xC0, 0x07, 0x07, 0x00, 0x30, 0x18,
  0x03, 0x80, 0xE0, 0x18, 0x03, 0x01, 0xC0, 0x1C, 0x0C, 0x00, 0x60, 0xE0,
  0x03, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x73, 0x00, 0x01, 0xB8, 0x00, 0x0F,
  0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xF1, 0xF0, 0x40,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xE0, 0x73,
  0xC0, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF7, 0x00, 0xFD, 0xE0, 0x77, 0x3F, 0xF9,
  0xC7, 0xFC, 0x70, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE1, 0xF8, 0x0E, 0x7F, 0xE0, 0xCF, 0x9F, 0x0D,
  0xC0, 0x38, 0xD8, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xD8,
  0x03, 0x8C, 0xE0, 0x78, 0xCF, 0xFF, 0x0C, 0x3F, 0xC0, 0x01, 0xFC, 0x07,
  0xFF, 0x1F, 0xDE, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x03, 0x0F, 0xFF, 0x07,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x01, 0xF8, 0x70, 0x7F, 0xE7, 0x0F, 0x8F, 0x31, 0xE0, 0x3B,
  0x3C, 0x01, 0xB3, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xF3, 0x80, 0x0F, 0x3C, 0x01, 0xB1,
  0xE0, 0x33, 0x0F, 0xFE, 0x30, 0x3F, 0xC3, 0x03, 0xF8, 0x03, 0xFF, 0x01,
  0xF1, 0xE0, 0xF0, 0x1C, 0x38, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x04, 0x78,
  0x06, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x30, 0x7F, 0xE3, 0x0F, 0x8F, 0x31,
  0xE0, 0x1B, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0xF3, 0x80, 0x0B, 0x1C,
  0x01, 0xB1, 0xE0, 0x77, 0x0F, 0xFE, 0x70, 0x3F, 0xC7, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE2, 0x00, 0x1E, 0x38, 0x03, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x1F, 0x83, 0x9F, 0xF8, 0xEF, 0x9F, 0x37, 0x01, 0xED, 0x80,
  0x3B, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0x7F, 0xF7, 0x00, 0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xEF, 0xE7, 0xE0, 0x40, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x01, 0xFC, 0x00,
  0xEE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x70,
  0x70, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x70, 0x06, 0x38, 0x03, 0x3E, 0x01,
  0xBF, 0x00, 0xF9, 0xC0, 0x78, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x70, 0x03, 0xB8,
  0x01, 0xDC, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xF8, 0x07, 0xE1, 0x8F, 0xF8,
  0x3F, 0xE3, 0x3C, 0xF8, 0xF3, 0xE6, 0xC0, 0x7B, 0x01, 0xED, 0x00, 0x7C,
  0x01, 0xDE, 0x00, 0x78, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0,
  0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00,
  0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F,
  0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0,
  0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1C, 0xC1,
  0xF8, 0x31, 0xFF, 0x8C, 0xF1, 0xF3, 0x70, 0x1E, 0xD8, 0x03, 0xBC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xE3, 0xE0, 0x3C, 0x03, 0x83, 0xC0, 0x0E, 0x1C,
  0x00, 0x30, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x33, 0x80, 0x01,
  0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0x80,
  0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C,
  0xE0, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0x70, 0x07, 0x81, 0xE0,
  0x78, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xC1, 0xF8, 0x0C, 0x7F, 0xE0,
  0xCF, 0x9F, 0x0D, 0xC0, 0x38, 0xD8, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0,
  0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x01, 0xCF,
  0x00, 0x1C, 0xD8, 0x03, 0x8C, 0xE0, 0x78, 0xE7, 0xFF, 0x0E, 0x3F, 0xC0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x30, 0x7F, 0xE3, 0x0F, 0x8F, 0x31,
  0xE0, 0x3B, 0x3C, 0x01, 0xB3, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xF3, 0x80, 0x0B, 0x3C,
  0x01, 0xB1, 0xE0, 0x77, 0x0F, 0xFE, 0x70, 0x7F, 0xC7, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0xC1, 0xFC, 0x7F, 0xCF, 0xFD, 0xC0, 0xD8, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x3E, 0x3E, 0x70, 0x02,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC, 0x7F, 0xF0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF7, 0x00, 0x7D,
  0xE0, 0x77, 0x3F, 0xF8, 0xC7, 0xFC, 0x30, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x70, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x18, 0x01, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xC0,
  0x30, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x06, 0x06, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x30, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0x98, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xC0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1B, 0x80, 0x1E, 0x00, 0x77,
  0x00, 0x3E, 0x00, 0xE6, 0x00, 0x7C, 0x01, 0xCE, 0x01, 0xD8, 0x03, 0x1C,
  0x03, 0xB0, 0x0E, 0x38, 0x06, 0x70, 0x1C, 0x30, 0x0C, 0xE0, 0x38, 0x70,
  0x38, 0xC0, 0x60, 0xE0, 0x71, 0x81, 0xC1, 0xC0, 0xC3, 0x83, 0x81, 0x83,
  0x87, 0x07, 0x03, 0x87, 0x06, 0x0C, 0x07, 0x0C, 0x0E, 0x38, 0x0E, 0x18,
  0x1C, 0x70, 0x0C, 0x70, 0x18, 0xE0, 0x1C, 0xE0, 0x31, 0x80, 0x39, 0x80,
  0x73, 0x00, 0x37, 0x00, 0xEE, 0x00, 0x6E, 0x00, 0xDC, 0x00, 0xD8, 0x01,
  0xB0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x01, 0xC1, 0xC0, 0x78, 0x38, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x70,
  0x07, 0x1C, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1D, 0xC0, 0x03, 0x98, 0x00, 0xE3, 0x80,
  0x18, 0x38, 0x07, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x0E, 0x00, 0xE3,
  0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0x76, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01,
  0xC1, 0x80, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x0C, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x00, 0x60, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x03,
  0x0E, 0x00, 0x38, 0xE0, 0x03, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0xDC, 0x00,
  0x1D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x0F, 0xC0, 0xF0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x81, 0xF8, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0x07, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0x80, 0x7C, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x1F, 0x80, 0xF8, 0x04, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE8, 0x01, 0xFE, 0x00, 0x01, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 34, 11, 4, -34 },
  { 18, 11, 12, 17, 3, -34 },
  { 35, 25, 34, 27, 1, -34 },
  { 142, 19, 39, 25, 3, -36 },
  { 235, 31, 35, 36, 2, -35 },
  { 371, 27, 35, 29, 2, -35 },
  { 490, 3, 12, 9, 3, -34 },
  { 495, 10, 42, 13, 2, -34 },
  { 548, 9, 42, 13, 2, -34 },
  { 596, 19, 18, 23, 2, -36 },
  { 639, 20, 22, 25, 2, -28 },
  { 694, 5, 11, 10, 2, -5 },
  { 701, 11, 2, 15, 2, -14 },
  { 704, 5, 4, 11, 3, -4 },
  { 707, 15, 34, 17, 1, -34 },
  { 771, 20, 35, 25, 2, -35 },
  { 859, 11, 34, 25, 4, -34 },
  { 906, 20, 35, 25, 2, -35 },
  { 994, 20, 35, 25, 2, -35 },
  { 1082, 23, 34, 25, 1, -34 },
  { 1180, 19, 34, 25, 3, -34 },
  { 1261, 19, 36, 25, 3, -35 },
  { 1347, 20, 34, 25, 2, -34 },
  { 1432, 20, 35, 25, 2, -35 },
  { 1520, 20, 36, 25, 2, -35 },
  { 1610, 5, 26, 11, 3, -26 },
  { 1627, 6, 32, 11, 2, -26 },
  { 1651, 21, 22, 25, 2, -28 },
  { 1709, 20, 12, 25, 2, -23 },
  { 1739, 21, 22, 25, 2, -28 },
  { 1797, 16, 35, 18, 1, -35 },
  { 1867, 33, 38, 38, 3, -34 },
  { 2024, 26, 34, 26, 0, -34 },
  { 2135, 21, 34, 27, 4, -34 },
  { 2225, 22, 35, 27, 3, -35 },
  { 2322, 24, 34, 30, 4, -34 },
  { 2424, 17, 34, 24, 4, -34 },
  { 2497, 17, 34, 22, 4, -34 },
  { 2570, 25, 35, 31, 3, -35 },
  { 2680, 23, 34, 31, 4, -34 },
  { 2778, 10, 34, 14, 2, -34 },
  { 2821, 11, 43, 11, -4, -34 },
  { 2881, 21, 34, 25, 4, -34 },
  { 2971, 17, 34, 22, 4, -34 },
  { 3044, 30, 34, 39, 4, -34 },
  { 3172, 23, 34, 32, 4, -34 },
  { 3270, 27, 35, 33, 3, -35 },
  { 3389, 19, 34, 25, 4, -34 },
  { 3470, 27, 43, 33, 3, -35 },
  { 3616, 21, 34, 26, 4, -34 },
  { 3706, 19, 35, 24, 2, -35 },
  { 3790, 22, 34, 22, 0, -34 },
  { 3884, 23, 34, 31, 4, -34 },
  { 3982, 25, 34, 25, 0, -34 },
  { 4089, 38, 34, 39, 1, -34 },
  { 4251, 23, 34, 23, 0, -34 },
  { 4349, 23, 34, 23, 0, -34 },
  { 4447, 20, 34, 24, 2, -34 },
  { 4532, 10, 42, 15, 4, -34 },
  { 4585, 15, 34, 17, 1, -34 },
  { 4649, 10, 42, 15, 1, -34 },
  { 4702, 21, 20, 25, 2, -34 },
  { 4755, 20, 2, 20, 0, 4 },
  { 4760, 8, 8, 12, 2, -37 },
  { 4768, 18, 26, 23, 2, -26 },
  { 4827, 20, 36, 26, 4, -36 },
  { 4917, 16, 26, 20, 3, -26 },
  { 4969, 20, 36, 26, 2, -36 },
  { 5059, 18, 26, 24, 3, -26 },
  { 5118, 15, 37, 13, 1, -37 },
  { 5188, 20, 38, 26, 2, -26 },
  { 5283, 18, 36, 26, 4, -36 },
  { 5364, 4, 35, 10, 3, -35 },
  { 5382, 9, 47, 10, -2, -35 },
  { 5435, 17, 36, 21, 4, -36 },
  { 5512, 3, 36, 10, 4, -36 },
  { 5526, 31, 26, 39, 4, -26 },
  { 5627, 18, 26, 26, 4, -26 },
  { 5686, 21, 26, 25, 2, -26 },
  { 5755, 20, 37, 26, 4, -26 },
  { 5848, 20, 37, 26, 2, -26 },
  { 5941, 12, 26, 17, 4, -26 },
  { 5980, 16, 26, 20, 2, -26 },
  { 6032, 12, 32, 14, 1, -32 },
  { 6080, 18, 26, 26, 4, -26 },
  { 6139, 20, 26, 20, 0, -26 },
  { 6204, 31, 26, 32, 1, -26 },
  { 6305, 19, 26, 21, 1, -26 },
  { 6367, 20, 38, 20, 0, -26 },
  { 6462, 15, 26, 19, 2, -26 },
  { 6511, 13, 42, 17, 2, -34 },
  { 6580, 3, 49, 23, 10, -37 },
  { 6599, 13, 42, 17, 2, -34 },
  { 6668, 21, 6, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Light48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT48PT7B_H_
