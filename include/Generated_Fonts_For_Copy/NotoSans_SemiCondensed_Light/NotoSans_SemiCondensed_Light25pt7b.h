#ifndef _NOTOSANS_SEMICONDENSED_LIGHT25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x0C,
  0x60, 0x62, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x23, 0xFF, 0xE3, 0x10,
  0x10, 0x80, 0x84, 0x04, 0x21, 0xFF, 0xE1, 0x18, 0x18, 0x80, 0x84, 0x04,
  0x20, 0x21, 0x01, 0x08, 0x00, 0x04, 0x01, 0x03, 0xFD, 0x92, 0x44, 0x31,
  0x0C, 0x41, 0x10, 0x64, 0x07, 0x00, 0x70, 0x16, 0x04, 0xC1, 0x10, 0x44,
  0x13, 0xC5, 0x9F, 0xC0, 0x40, 0x10, 0x38, 0x08, 0x44, 0x18, 0x44, 0x10,
  0xC6, 0x30, 0x86, 0x20, 0x86, 0x60, 0x86, 0x40, 0xC6, 0xCE, 0x44, 0x92,
  0x45, 0xA1, 0x39, 0x21, 0x03, 0x21, 0x02, 0x21, 0x02, 0x21, 0x04, 0x21,
  0x04, 0x21, 0x08, 0x33, 0x18, 0x1E, 0x1F, 0x00, 0xC6, 0x02, 0x08, 0x08,
  0x20, 0x20, 0x80, 0xC6, 0x01, 0x30, 0x07, 0x80, 0x1C, 0x00, 0xD8, 0x06,
  0x30, 0x90, 0x46, 0xC0, 0x9B, 0x03, 0xCC, 0x06, 0x10, 0x1C, 0x61, 0xD8,
  0xFC, 0x30, 0xFE, 0x18, 0x8C, 0x46, 0x21, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x08, 0x43, 0x08, 0x61, 0x0C, 0xC2, 0x18, 0x43, 0x08, 0x42, 0x18, 0xC6,
  0x31, 0x8C, 0x62, 0x11, 0x88, 0xC4, 0x60, 0x0C, 0x03, 0x00, 0xC3, 0x13,
  0x7F, 0x83, 0x01, 0xE0, 0xCC, 0x21, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x6D, 0x2D, 0x00, 0xFC, 0xF0, 0x01, 0x03, 0x03, 0x02, 0x06, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0xC0, 0x1F,
  0x06, 0x31, 0x82, 0x20, 0x64, 0x04, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0x78,
  0x0F, 0x01, 0x60, 0x2C, 0x04, 0x80, 0x90, 0x33, 0x04, 0x31, 0x83, 0xE0,
  0x0C, 0x73, 0xF3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0x3F, 0x38, 0x64, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x3F,
  0xF0, 0x3F, 0x38, 0x68, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x3E,
  0x01, 0xE0, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x03, 0x81, 0xBF, 0xC0,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x02, 0xC0, 0x4C, 0x0C, 0xC0, 0x8C,
  0x10, 0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x7F, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x78,
  0xEF, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x83, 0x7F, 0x00,
  0x0F, 0x83, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x78, 0xF1,
  0x9C, 0x1B, 0x01, 0x60, 0x34, 0x06, 0x80, 0xD0, 0x13, 0x06, 0x30, 0x83,
  0xE0, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0x1F, 0x06, 0x31, 0x83, 0x20, 0x24, 0x04, 0x81, 0x98, 0x21,
  0xD8, 0x0E, 0x07, 0x61, 0x82, 0x20, 0x6C, 0x05, 0x80, 0xF0, 0x12, 0x02,
  0x60, 0xC7, 0xE0, 0x1F, 0x1C, 0x64, 0x0B, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x40, 0xD8, 0x53, 0xE4, 0x01, 0x00, 0x40, 0x30, 0x08, 0x06, 0x03,
  0x1F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x01, 0xB4, 0xB4,
  0x00, 0x20, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0x40, 0x00, 0xFC, 0x86, 0x02, 0x03, 0x03,
  0x03, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x30, 0x01, 0xF0, 0x01, 0xC7, 0x01, 0x80, 0x20, 0xC0, 0x04, 0x20, 0x01,
  0x98, 0x3E, 0x24, 0x31, 0x09, 0x08, 0x42, 0xC6, 0x10, 0xB1, 0x04, 0x3C,
  0x41, 0x0B, 0x10, 0x42, 0xC4, 0x10, 0x91, 0x8A, 0x64, 0x3C, 0xF1, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x1F, 0xE0, 0x03, 0x00,
  0x18, 0x01, 0x40, 0x0B, 0x00, 0x48, 0x06, 0x40, 0x23, 0x01, 0x08, 0x18,
  0x40, 0x83, 0x07, 0xF8, 0x7F, 0xC2, 0x03, 0x10, 0x19, 0x80, 0x48, 0x03,
  0xC0, 0x1E, 0x00, 0x40, 0xFF, 0x18, 0x73, 0x03, 0x60, 0x2C, 0x05, 0x80,
  0xB0, 0x16, 0x04, 0xFE, 0x18, 0x73, 0x01, 0x60, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x02, 0xC1, 0xDF, 0xE0, 0x07, 0xE1, 0xC3, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x1C, 0x10, 0xFF, 0xFE, 0x0C, 0x78, 0xC0,
  0xCC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x0C, 0xC7, 0x8F, 0xE0, 0xFF,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xF0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x07, 0xF0, 0x30, 0x61, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x03, 0xF4, 0x00,
  0xD0, 0x03, 0x40, 0x0D, 0x80, 0x32, 0x00, 0xCC, 0x03, 0x1C, 0x0C, 0x1F,
  0xE0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x27, 0xC0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0B, 0xE6, 0x00, 0xC0, 0x78,
  0x1B, 0x06, 0x61, 0x8C, 0x21, 0x8C, 0x33, 0x06, 0xC0, 0xF8, 0x1D, 0x83,
  0x10, 0x63, 0x0C, 0x31, 0x82, 0x30, 0x66, 0x06, 0xC0, 0xD8, 0x0C, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xC0, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xD0, 0x0B, 0xD0, 0x0B, 0xD8, 0x1B, 0xC8, 0x13,
  0xC8, 0x13, 0xCC, 0x33, 0xC4, 0x23, 0xC4, 0x23, 0xC6, 0x63, 0xC2, 0x43,
  0xC3, 0x43, 0xC3, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC0, 0x1E, 0x01, 0xE0,
  0x1F, 0x01, 0xD0, 0x1D, 0x81, 0xCC, 0x1C, 0x41, 0xC6, 0x1C, 0x21, 0xC3,
  0x1C, 0x11, 0xC1, 0x9C, 0x0D, 0xC0, 0x5C, 0x07, 0xC0, 0x3C, 0x03, 0x0F,
  0xE0, 0x38, 0xE0, 0xC0, 0x61, 0x00, 0x46, 0x00, 0xC8, 0x00, 0x90, 0x01,
  0x60, 0x02, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x24, 0x00, 0x4C,
  0x01, 0x98, 0x03, 0x18, 0x0C, 0x18, 0x30, 0x1F, 0xC0, 0xFE, 0x31, 0xEC,
  0x0B, 0x03, 0xC0, 0xF0, 0x1C, 0x0F, 0x03, 0xC1, 0xBF, 0xCF, 0x83, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x07, 0xE0, 0x38, 0xE0,
  0xC0, 0x61, 0x00, 0x46, 0x00, 0xC8, 0x00, 0x90, 0x01, 0x60, 0x02, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x12, 0x00, 0x24, 0x00, 0x4C, 0x01, 0x88, 0x03,
  0x18, 0x0C, 0x18, 0x30, 0x1F, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0xFC, 0x18, 0xF3, 0x03, 0x60, 0x6C, 0x05, 0x80, 0xB0, 0x36,
  0x06, 0xC1, 0x9F, 0xC3, 0x18, 0x61, 0x0C, 0x31, 0x83, 0x30, 0x66, 0x06,
  0xC0, 0x58, 0x0C, 0x1F, 0x9C, 0x34, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x10, 0x04, 0x03, 0xC1,
  0xBF, 0xC0, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x02, 0x70, 0xE1, 0xF8, 0xC0, 0x1E, 0x00, 0x90,
  0x04, 0xC0, 0x66, 0x03, 0x10, 0x10, 0x81, 0x86, 0x0C, 0x10, 0x40, 0x86,
  0x06, 0x30, 0x11, 0x00, 0x88, 0x06, 0xC0, 0x14, 0x00, 0xA0, 0x07, 0x00,
  0x10, 0x00, 0xC0, 0x60, 0x14, 0x06, 0x03, 0x40, 0x70, 0x36, 0x07, 0x02,
  0x60, 0xD0, 0x22, 0x09, 0x06, 0x20, 0x98, 0x63, 0x09, 0x84, 0x31, 0x88,
  0x41, 0x10, 0x8C, 0x11, 0x0C, 0xC1, 0x90, 0xC8, 0x1B, 0x04, 0x80, 0xA0,
  0x58, 0x0A, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x03, 0x00, 0x40, 0x30, 0x40,
  0x36, 0x06, 0x20, 0x43, 0x0C, 0x10, 0x81, 0x98, 0x0D, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0F, 0x00, 0x90, 0x19, 0x81, 0x0C, 0x30, 0x46, 0x06, 0x40,
  0x2C, 0x03, 0xC0, 0x34, 0x02, 0x60, 0x62, 0x04, 0x30, 0xC1, 0x08, 0x11,
  0x81, 0x90, 0x0B, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x3F, 0xF0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x7C, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x30,
  0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x03, 0x01,
  0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0xFC, 0x04, 0x01, 0xC0, 0x28, 0x0D, 0x81, 0x10, 0x63, 0x08, 0x23,
  0x06, 0x40, 0x58, 0x0C, 0xFF, 0xC0, 0xC6, 0x31, 0x04, 0x3F, 0x90, 0x60,
  0x10, 0x08, 0x04, 0x3E, 0x71, 0x40, 0xE0, 0x70, 0x38, 0x3C, 0x2B, 0xE4,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x21, 0x0B, 0xF2, 0x86, 0xC0, 0xF0,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x03, 0xC0, 0xA8, 0x69, 0xF0,
  0x04, 0x0F, 0xCC, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x0C, 0x03, 0x08, 0xFC, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x08,
  0xCF, 0xDB, 0x07, 0x60, 0x68, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1A, 0x03, 0x60, 0xE6, 0x3C, 0x7D, 0x80, 0x04, 0x0F, 0xC2, 0x09, 0x03,
  0x40, 0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x30, 0x47,
  0xE0, 0x0F, 0x18, 0x10, 0x30, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x04, 0x07, 0xED, 0x83,
  0xB0, 0x34, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x01, 0xB0,
  0x73, 0x1E, 0x3E, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x19, 0x86, 0x1F, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x22, 0xFD, 0x43, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0xF0, 0x2A,
  0xAA, 0xAA, 0xA0, 0x18, 0xC0, 0x00, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0xDC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x0D, 0x04, 0x84, 0x46, 0x26, 0x16, 0x0B, 0x86, 0x62, 0x11, 0x0C,
  0x83, 0x40, 0xA0, 0x60, 0xFF, 0xFF, 0xE0, 0x0C, 0x08, 0xBF, 0x3E, 0xA1,
  0x43, 0xC1, 0x81, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x04,
  0x5F, 0xA8, 0x78, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x04, 0x07, 0xF1, 0x83, 0x30, 0x24, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x01, 0x30, 0x23, 0x08, 0x3E, 0x00, 0x04,
  0x27, 0xCA, 0x1B, 0x03, 0xC0, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C,
  0x0F, 0x02, 0xA1, 0xA7, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x04, 0x07, 0xED, 0x83, 0xB0, 0x74, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0D, 0x01, 0xB0, 0x72, 0x1E, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x7A, 0x86, 0x0C, 0x18, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x00, 0x0C, 0x7F, 0xC0, 0xC0, 0xC0, 0x40, 0x70,
  0x1C, 0x07, 0x01, 0x01, 0x01, 0x83, 0xFE, 0x20, 0x40, 0x87, 0xF2, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x0F, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x68, 0x77, 0xE8,
  0xC0, 0x50, 0x34, 0x0D, 0x82, 0x21, 0x88, 0x43, 0x10, 0x4C, 0x12, 0x06,
  0x80, 0xA0, 0x30, 0x0C, 0x00, 0xC1, 0x81, 0x41, 0xC1, 0x41, 0x43, 0x61,
  0x43, 0x23, 0x62, 0x22, 0x22, 0x22, 0x26, 0x36, 0x26, 0x16, 0x34, 0x14,
  0x14, 0x14, 0x1C, 0x1C, 0x18, 0x08, 0x18, 0x60, 0xC4, 0x10, 0xC6, 0x0C,
  0x80, 0xA0, 0x1C, 0x03, 0x80, 0x50, 0x1B, 0x02, 0x20, 0xC2, 0x30, 0x6C,
  0x06, 0xC0, 0x68, 0x19, 0x83, 0x30, 0x42, 0x18, 0x63, 0x0C, 0x40, 0x88,
  0x13, 0x03, 0x40, 0x28, 0x07, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x06, 0x03, 0x80, 0x00, 0xFF, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30,
  0x20, 0x60, 0x40, 0xC0, 0xFF, 0x06, 0x38, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x63, 0x87, 0x03, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x30, 0x38, 0x71, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x83, 0x18, 0x00, 0x78, 0x30, 0xFC, 0x06, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 18, 6, 2, -18 },
  { 6, 5, 7, 9, 2, -18 },
  { 11, 13, 18, 14, 1, -18 },
  { 41, 10, 20, 13, 1, -19 },
  { 66, 16, 18, 19, 1, -18 },
  { 102, 14, 18, 15, 1, -18 },
  { 134, 1, 7, 5, 2, -18 },
  { 135, 5, 22, 7, 1, -18 },
  { 149, 5, 22, 7, 1, -18 },
  { 163, 10, 9, 12, 1, -19 },
  { 175, 11, 12, 13, 1, -15 },
  { 192, 3, 6, 5, 1, -3 },
  { 195, 6, 1, 8, 1, -7 },
  { 196, 2, 2, 6, 2, -2 },
  { 197, 8, 18, 9, 0, -18 },
  { 215, 11, 18, 13, 1, -18 },
  { 240, 6, 18, 13, 2, -18 },
  { 254, 10, 18, 13, 1, -18 },
  { 277, 10, 18, 13, 1, -18 },
  { 300, 12, 18, 13, 0, -18 },
  { 327, 9, 18, 13, 2, -18 },
  { 348, 11, 18, 13, 1, -18 },
  { 373, 11, 18, 13, 1, -18 },
  { 398, 11, 18, 13, 1, -18 },
  { 423, 10, 18, 13, 1, -18 },
  { 446, 2, 13, 6, 2, -13 },
  { 450, 3, 16, 6, 1, -13 },
  { 456, 11, 12, 13, 1, -15 },
  { 473, 11, 6, 13, 1, -12 },
  { 482, 11, 12, 13, 1, -15 },
  { 499, 8, 18, 9, 1, -18 },
  { 517, 18, 20, 20, 1, -18 },
  { 562, 13, 18, 13, 0, -18 },
  { 592, 11, 18, 14, 2, -18 },
  { 617, 12, 18, 14, 1, -18 },
  { 644, 12, 18, 16, 2, -18 },
  { 671, 9, 18, 12, 2, -18 },
  { 692, 9, 18, 11, 2, -18 },
  { 713, 14, 18, 16, 1, -18 },
  { 745, 12, 18, 16, 2, -18 },
  { 772, 5, 18, 7, 1, -18 },
  { 784, 6, 23, 6, -2, -18 },
  { 802, 11, 18, 13, 2, -18 },
  { 827, 9, 18, 11, 2, -18 },
  { 848, 16, 18, 20, 2, -18 },
  { 884, 12, 18, 16, 2, -18 },
  { 911, 15, 18, 17, 1, -18 },
  { 945, 10, 18, 13, 2, -18 },
  { 968, 15, 22, 17, 1, -18 },
  { 1010, 11, 18, 13, 2, -18 },
  { 1035, 10, 18, 12, 1, -18 },
  { 1058, 12, 18, 12, 0, -18 },
  { 1085, 12, 18, 16, 2, -18 },
  { 1112, 13, 18, 13, 0, -18 },
  { 1142, 20, 18, 21, 0, -18 },
  { 1187, 12, 18, 12, 0, -18 },
  { 1214, 12, 18, 12, 0, -18 },
  { 1241, 10, 18, 12, 1, -18 },
  { 1264, 5, 22, 8, 2, -18 },
  { 1278, 8, 18, 9, 0, -18 },
  { 1296, 5, 22, 8, 1, -18 },
  { 1310, 11, 10, 13, 1, -18 },
  { 1324, 10, 1, 10, 0, 2 },
  { 1326, 4, 4, 6, 1, -19 },
  { 1328, 9, 14, 12, 1, -14 },
  { 1344, 10, 19, 14, 2, -19 },
  { 1368, 9, 14, 11, 1, -14 },
  { 1384, 11, 19, 14, 1, -19 },
  { 1411, 10, 14, 12, 1, -14 },
  { 1429, 8, 19, 7, 0, -19 },
  { 1448, 11, 20, 14, 1, -14 },
  { 1476, 9, 19, 13, 2, -19 },
  { 1498, 2, 18, 5, 2, -18 },
  { 1503, 5, 24, 5, -1, -18 },
  { 1518, 9, 19, 11, 2, -19 },
  { 1540, 1, 19, 5, 2, -19 },
  { 1543, 16, 14, 20, 2, -14 },
  { 1571, 9, 14, 13, 2, -14 },
  { 1587, 11, 14, 13, 1, -14 },
  { 1607, 10, 20, 14, 2, -14 },
  { 1632, 11, 20, 14, 1, -14 },
  { 1660, 7, 14, 9, 2, -14 },
  { 1673, 8, 14, 10, 1, -14 },
  { 1687, 7, 16, 8, 0, -16 },
  { 1701, 9, 13, 13, 2, -13 },
  { 1716, 10, 13, 10, 0, -13 },
  { 1733, 16, 13, 17, 0, -13 },
  { 1759, 11, 13, 11, 0, -13 },
  { 1777, 11, 19, 11, 0, -13 },
  { 1804, 8, 13, 10, 1, -13 },
  { 1817, 7, 22, 9, 1, -18 },
  { 1837, 2, 25, 12, 5, -19 },
  { 1844, 7, 22, 9, 1, -18 },
  { 1864, 11, 3, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Light25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT25PT7B_H_
