#ifndef _NOTOSANS_SEMICONDENSED_LIGHT29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light29pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x24, 0x92, 0x49, 0x24, 0x92, 0x01, 0x7E, 0xC7, 0x1C, 0x71,
  0xC6, 0x18, 0x61, 0x06, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x20, 0x80, 0x43,
  0x00, 0x86, 0x03, 0x08, 0x3F, 0xFF, 0x08, 0x20, 0x10, 0x40, 0x21, 0x80,
  0x43, 0x01, 0x84, 0x1F, 0xFF, 0xBF, 0xFF, 0x08, 0x20, 0x10, 0xC0, 0x21,
  0x80, 0xC2, 0x01, 0x84, 0x02, 0x08, 0x00, 0x04, 0x00, 0x80, 0xFE, 0x3F,
  0xEC, 0x41, 0x08, 0x21, 0x04, 0x20, 0xC4, 0x1C, 0x81, 0xF0, 0x0F, 0x00,
  0x78, 0x09, 0x81, 0x18, 0x23, 0x04, 0x60, 0x8C, 0x11, 0x7B, 0xE7, 0xF0,
  0x08, 0x01, 0x00, 0x20, 0x3C, 0x02, 0x0C, 0xC0, 0xC1, 0x08, 0x10, 0x21,
  0x86, 0x04, 0x30, 0x81, 0x82, 0x30, 0x30, 0x44, 0x06, 0x19, 0x80, 0x43,
  0x33, 0x08, 0x64, 0xF9, 0x09, 0xB1, 0x13, 0x24, 0x33, 0xCC, 0x86, 0x01,
  0x10, 0x40, 0x62, 0x08, 0x08, 0x41, 0x03, 0x08, 0x20, 0x41, 0x0C, 0x18,
  0x21, 0x82, 0x06, 0x60, 0xC0, 0x78, 0x0F, 0x80, 0x1D, 0xC0, 0x10, 0x40,
  0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x10, 0x40, 0x18, 0xC0, 0x0F, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x33, 0x03, 0x61, 0x82, 0x60, 0xC6, 0xC0, 0x66,
  0xC0, 0x34, 0xC0, 0x1C, 0x40, 0x18, 0x60, 0x3C, 0x30, 0xE6, 0x1F, 0x83,
  0xFF, 0xEA, 0x0C, 0x21, 0x8C, 0x30, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0x41, 0x06, 0x18, 0x20, 0xC3, 0x06, 0x08, 0x30, 0xC1, 0x06,
  0x0C, 0x30, 0x41, 0x86, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x21,
  0x86, 0x10, 0xC3, 0x18, 0x43, 0x00, 0x06, 0x00, 0x60, 0x06, 0x08, 0x61,
  0xF6, 0xF1, 0xF8, 0x06, 0x00, 0x90, 0x19, 0x83, 0x0C, 0x10, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x6D, 0xB5,
  0xA0, 0xFF, 0xFC, 0x5F, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x00, 0x0F, 0x81, 0xDC, 0x30,
  0x62, 0x02, 0x60, 0x36, 0x03, 0x40, 0x34, 0x01, 0x40, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x40, 0x14, 0x01, 0x40, 0x36, 0x03, 0x60, 0x36, 0x02, 0x30,
  0x61, 0x8C, 0x0F, 0x80, 0x06, 0x1C, 0x79, 0xBE, 0x68, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x1F,
  0x87, 0xFC, 0x60, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xBC, 0xC0, 0x60,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x78, 0x1F, 0x80,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x6E,
  0x0E, 0x7F, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x02, 0x80, 0x34, 0x03,
  0x20, 0x11, 0x01, 0x88, 0x18, 0x40, 0x82, 0x0C, 0x10, 0x40, 0x86, 0x04,
  0x60, 0x23, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x7F, 0xCF, 0xF9, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xCC, 0x1F, 0xF0, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x03, 0x61, 0xCF, 0xF0, 0x07, 0xC3, 0xC8, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0x8F, 0x17, 0xFA, 0x83, 0x60, 0x3C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x0D, 0x81, 0x98, 0xE1, 0xF8,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x0F, 0x83, 0xDE, 0x30,
  0x66, 0x03, 0x60, 0x36, 0x03, 0x60, 0x33, 0x06, 0x18, 0xC0, 0xF8, 0x0F,
  0x83, 0x8C, 0x30, 0x66, 0x03, 0x40, 0x1C, 0x01, 0xC0, 0x14, 0x03, 0x60,
  0x33, 0x0E, 0x1F, 0xC0, 0x0F, 0x83, 0xFC, 0x60, 0x66, 0x06, 0x40, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x60, 0x53, 0x0D, 0x1F, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC4, 0x38, 0x3F, 0x00,
  0x5F, 0x00, 0x00, 0x00, 0x00, 0xBE, 0x27, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x66, 0x44, 0xC8, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x7E, 0x7F, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x00, 0x04, 0x07, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x0C,
  0xC0, 0x00, 0x90, 0x3E, 0x1E, 0x0C, 0x61, 0xC3, 0x0C, 0x30, 0xC1, 0x86,
  0x18, 0x30, 0xC2, 0x04, 0x18, 0x40, 0x83, 0x08, 0x10, 0x61, 0x86, 0x0C,
  0x30, 0xE3, 0x83, 0xF6, 0xD8, 0x38, 0x71, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x08, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x04, 0x60, 0x04,
  0x60, 0x0C, 0x20, 0x08, 0x30, 0x08, 0x30, 0x18, 0x10, 0x1F, 0xF8, 0x1F,
  0xF8, 0x30, 0x08, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x04, 0x60, 0x06, 0xC0,
  0x06, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x80, 0xE8, 0x06, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x06, 0x80, 0x4F, 0xF8, 0xFF, 0x88, 0x0E, 0x80, 0x28, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x68, 0x3C, 0xFF, 0x00, 0x07,
  0xF0, 0x7B, 0xCE, 0x02, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x30, 0xFF, 0x80, 0xFE, 0x03,
  0xFF, 0x08, 0x0E, 0x20, 0x0C, 0x80, 0x32, 0x00, 0x68, 0x01, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0A, 0x00, 0x28, 0x01,
  0xA0, 0x06, 0x80, 0x32, 0x00, 0xC8, 0x0E, 0x23, 0xF0, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xEF,
  0xFA, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFB, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x60, 0x11, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60,
  0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xF0, 0x70, 0x7F, 0xC0, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0xFD, 0xE3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0xC3, 0x9F, 0xE0, 0x80, 0x38, 0x06, 0x80,
  0xC8, 0x18, 0x81, 0x88, 0x30, 0x86, 0x08, 0xC0, 0x98, 0x09, 0x80, 0xBC,
  0x0E, 0xC0, 0xC6, 0x08, 0x60, 0x83, 0x08, 0x18, 0x81, 0x88, 0x0C, 0x80,
  0x68, 0x06, 0x80, 0x30, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3E, 0x80, 0x0F, 0xB0, 0x02, 0xEC, 0x01, 0xB9, 0x00, 0x6E, 0x60,
  0x13, 0x98, 0x0C, 0xE2, 0x02, 0x38, 0xC0, 0x8E, 0x30, 0x63, 0x84, 0x10,
  0xE1, 0x8C, 0x38, 0x23, 0x0E, 0x0C, 0x83, 0x83, 0x60, 0xE0, 0x58, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0xC0, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0x40, 0x1B, 0x00, 0xCC, 0x06, 0x60, 0x31, 0x81, 0x8C, 0x0C, 0x30, 0x60,
  0x83, 0x06, 0x18, 0x18, 0xC0, 0xC6, 0x03, 0x30, 0x19, 0x80, 0x6C, 0x01,
  0x60, 0x0F, 0x00, 0x38, 0x01, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x30, 0x1C,
  0x60, 0x0C, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x02, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1C, 0x38, 0x0F, 0xF0,
  0xFC, 0x1F, 0xF2, 0x07, 0x40, 0x28, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1A, 0x07, 0x7F, 0x8F, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x30, 0x1C, 0x60,
  0x0C, 0x60, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x02, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1C, 0x38, 0x0F, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0xFE, 0x0F, 0xF8,
  0x80, 0xC8, 0x06, 0x80, 0x68, 0x06, 0x80, 0x68, 0x06, 0x80, 0x68, 0x0C,
  0x87, 0x8F, 0xE0, 0x82, 0x08, 0x30, 0x81, 0x08, 0x18, 0x80, 0xC8, 0x0C,
  0x80, 0x68, 0x06, 0x80, 0x30, 0x0F, 0xC3, 0xFF, 0x60, 0x26, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x6E, 0x1E, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x50, 0x03, 0x40, 0x0D, 0x80, 0x37, 0x01, 0x8E, 0x1C, 0x0F,
  0xE0, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x66, 0x00, 0xC4, 0x01,
  0x0C, 0x06, 0x18, 0x0C, 0x10, 0x10, 0x30, 0x60, 0x60, 0xC0, 0x41, 0x00,
  0xC6, 0x01, 0x8C, 0x01, 0x10, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x00, 0x0A,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x30, 0x0D, 0x80,
  0xE0, 0x1B, 0x01, 0xC0, 0x32, 0x02, 0xC0, 0x44, 0x05, 0x81, 0x8C, 0x19,
  0x03, 0x18, 0x33, 0x06, 0x30, 0x46, 0x08, 0x20, 0x8C, 0x30, 0x63, 0x08,
  0x60, 0xC6, 0x18, 0xC1, 0x88, 0x31, 0x01, 0x10, 0x66, 0x03, 0x60, 0x4C,
  0x06, 0xC0, 0xD8, 0x0D, 0x01, 0xA0, 0x0A, 0x03, 0xC0, 0x14, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x09, 0x80, 0x63, 0x01, 0x0C,
  0x0C, 0x18, 0x60, 0x21, 0x80, 0xCC, 0x01, 0x30, 0x07, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xE0, 0x06, 0x80, 0x33, 0x00, 0x84, 0x06, 0x18, 0x10, 0x20,
  0xC0, 0xC6, 0x01, 0x98, 0x06, 0xC0, 0x0C, 0xC0, 0x0D, 0x00, 0x66, 0x01,
  0x88, 0x0C, 0x30, 0x30, 0xC1, 0x81, 0x86, 0x06, 0x30, 0x0C, 0xC0, 0x32,
  0x00, 0x58, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x02,
  0x00, 0x38, 0x01, 0x40, 0x1B, 0x00, 0x88, 0x0C, 0x60, 0x41, 0x06, 0x0C,
  0x20, 0x23, 0x01, 0x90, 0x05, 0x80, 0x30, 0xFF, 0xF0, 0xE3, 0x0C, 0x30,
  0x06, 0x07, 0xF8, 0x83, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x7F, 0x3C,
  0x6C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xD8, 0x79, 0xF9, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC7, 0x0D, 0xFC, 0xF0, 0x6E,
  0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x3E, 0x06, 0xD0, 0xEC, 0xF8, 0x0F, 0x1F, 0xD8, 0x08, 0x0C,
  0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x03, 0x01, 0xC2,
  0x3F, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x43, 0x09, 0xFD,
  0x60, 0xB8, 0x0F, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x38, 0x0F, 0x01, 0xE0, 0x37, 0x1A, 0x7E, 0x40, 0x0E, 0x07, 0xF1, 0x83,
  0x60, 0x2C, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0x80, 0x10, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x1C, 0x10, 0xFE, 0x0F, 0x86, 0x46, 0x03, 0x01, 0x00,
  0x80, 0x41, 0xFE, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x0E, 0x07, 0xF5, 0x83, 0xE0,
  0x3C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xDC, 0x69, 0xF9, 0x00, 0x20, 0x04, 0x00, 0x80, 0x38, 0x0D,
  0xF7, 0x8F, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x31,
  0xC6, 0xFE, 0xF0, 0x7C, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x40, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xED, 0xC0, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x06, 0xC1, 0x98, 0x63,
  0x18, 0x62, 0x0C, 0xC1, 0xB8, 0x3F, 0x07, 0x30, 0xC2, 0x18, 0x63, 0x06,
  0x60, 0xCC, 0x0D, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x07, 0x1B, 0xF3, 0xFB, 0xC3, 0x43, 0xF0, 0x30, 0x3C, 0x06, 0x07, 0x80,
  0xC0, 0xF0, 0x18, 0x1E, 0x03, 0x03, 0xC0, 0x60, 0x78, 0x0C, 0x0F, 0x01,
  0x81, 0xE0, 0x30, 0x3C, 0x06, 0x07, 0x80, 0xC0, 0xF0, 0x18, 0x1E, 0x03,
  0x03, 0x07, 0x1B, 0xFB, 0xC1, 0xF0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x0F,
  0x03, 0xF8, 0x60, 0xCC, 0x06, 0xC0, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x66, 0x06, 0x70, 0xC1, 0xF8, 0x07,
  0x0D, 0xFC, 0xF0, 0x6E, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x06, 0xD0, 0xCC, 0xF8, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x01,
  0xFD, 0x30, 0x56, 0x03, 0x60, 0x34, 0x01, 0x40, 0x1C, 0x01, 0xC0, 0x14,
  0x01, 0x40, 0x16, 0x03, 0x60, 0x36, 0x03, 0x38, 0xD1, 0xF9, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x07, 0xDF, 0xF0,
  0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x0F, 0x0F, 0xF6, 0x0B, 0x00, 0xC0, 0x10, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x3C, 0x19, 0xFC, 0x10, 0x10, 0x10,
  0x30, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x10, 0x18, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x34, 0x0E, 0xC3, 0x4F,
  0xC8, 0xC0, 0x34, 0x02, 0x60, 0x66, 0x06, 0x20, 0x43, 0x0C, 0x30, 0xC1,
  0x08, 0x19, 0x81, 0x98, 0x09, 0x00, 0xD0, 0x0F, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x60, 0x68, 0x1C, 0x0D, 0x83, 0xC1, 0x30, 0x58, 0x62, 0x09, 0x0C,
  0x43, 0x21, 0x8C, 0x66, 0x21, 0x88, 0xC4, 0x13, 0x09, 0x82, 0x61, 0x30,
  0x68, 0x34, 0x0D, 0x06, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0x80,
  0xC0, 0x6C, 0x18, 0x86, 0x18, 0xC1, 0xB0, 0x14, 0x03, 0x80, 0x70, 0x0A,
  0x03, 0x60, 0xC6, 0x18, 0xC6, 0x0D, 0x80, 0xB0, 0x18, 0xC0, 0x36, 0x03,
  0x60, 0x26, 0x06, 0x20, 0x63, 0x04, 0x10, 0xC1, 0x0C, 0x18, 0x80, 0x98,
  0x09, 0x80, 0xD0, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0xB8, 0x0F, 0x00, 0x7F, 0x80, 0x60, 0x10, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0F,
  0xFC, 0x03, 0x0F, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x30, 0xE0, 0xF0, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0xF0, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x07,
  0x07, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0xF0,
  0xC0, 0x38, 0x0F, 0xF8, 0xE0, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Light29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 6, 8, 10, 2, -21 },
  { 15, 15, 21, 17, 1, -21 },
  { 55, 11, 24, 15, 2, -22 },
  { 88, 19, 21, 21, 1, -21 },
  { 138, 16, 21, 18, 1, -21 },
  { 180, 2, 8, 6, 2, -21 },
  { 182, 6, 26, 8, 1, -21 },
  { 202, 6, 26, 8, 1, -21 },
  { 222, 12, 11, 14, 1, -22 },
  { 239, 13, 14, 15, 1, -17 },
  { 262, 3, 7, 6, 1, -3 },
  { 265, 7, 2, 9, 1, -9 },
  { 267, 3, 3, 7, 2, -3 },
  { 269, 10, 21, 10, 0, -21 },
  { 296, 12, 21, 15, 1, -21 },
  { 328, 7, 21, 15, 2, -21 },
  { 347, 12, 21, 15, 1, -21 },
  { 379, 12, 21, 15, 1, -21 },
  { 411, 13, 21, 15, 1, -21 },
  { 446, 11, 21, 15, 2, -21 },
  { 475, 11, 21, 15, 2, -21 },
  { 504, 12, 21, 15, 1, -21 },
  { 536, 12, 21, 15, 1, -21 },
  { 568, 12, 21, 15, 1, -21 },
  { 600, 3, 16, 7, 2, -16 },
  { 606, 4, 20, 7, 1, -16 },
  { 616, 13, 13, 15, 1, -17 },
  { 638, 13, 7, 15, 1, -14 },
  { 650, 13, 13, 15, 1, -17 },
  { 672, 9, 21, 11, 1, -21 },
  { 696, 19, 24, 23, 2, -21 },
  { 753, 16, 21, 16, 0, -21 },
  { 795, 12, 21, 16, 3, -21 },
  { 827, 13, 21, 16, 2, -21 },
  { 862, 14, 21, 18, 3, -21 },
  { 899, 10, 21, 14, 3, -21 },
  { 926, 10, 21, 13, 3, -21 },
  { 953, 15, 21, 19, 2, -21 },
  { 993, 13, 21, 19, 3, -21 },
  { 1028, 6, 21, 8, 1, -21 },
  { 1044, 6, 26, 7, -2, -21 },
  { 1064, 12, 21, 15, 3, -21 },
  { 1096, 10, 21, 13, 3, -21 },
  { 1123, 18, 21, 23, 3, -21 },
  { 1171, 13, 21, 19, 3, -21 },
  { 1206, 16, 21, 20, 2, -21 },
  { 1248, 11, 21, 15, 3, -21 },
  { 1277, 16, 26, 20, 2, -21 },
  { 1329, 12, 21, 16, 3, -21 },
  { 1361, 12, 21, 14, 1, -21 },
  { 1393, 13, 21, 14, 0, -21 },
  { 1428, 14, 21, 19, 2, -21 },
  { 1465, 15, 21, 15, 0, -21 },
  { 1505, 23, 21, 24, 0, -21 },
  { 1566, 14, 21, 14, 0, -21 },
  { 1603, 14, 21, 14, 0, -21 },
  { 1640, 12, 21, 14, 1, -21 },
  { 1672, 6, 26, 9, 2, -21 },
  { 1692, 10, 21, 10, 0, -21 },
  { 1719, 6, 26, 9, 1, -21 },
  { 1739, 13, 12, 15, 1, -21 },
  { 1759, 12, 1, 12, 0, 3 },
  { 1761, 5, 4, 7, 1, -22 },
  { 1764, 11, 16, 14, 1, -16 },
  { 1786, 12, 22, 16, 2, -22 },
  { 1819, 9, 16, 12, 2, -16 },
  { 1837, 11, 22, 16, 2, -22 },
  { 1868, 11, 16, 14, 2, -16 },
  { 1890, 9, 22, 8, 0, -22 },
  { 1915, 11, 23, 16, 2, -16 },
  { 1947, 11, 22, 16, 2, -22 },
  { 1978, 2, 21, 6, 2, -21 },
  { 1984, 5, 28, 6, -1, -21 },
  { 2002, 11, 22, 13, 2, -22 },
  { 2033, 2, 22, 6, 2, -22 },
  { 2039, 19, 16, 23, 2, -16 },
  { 2077, 11, 16, 16, 2, -16 },
  { 2099, 12, 16, 15, 2, -16 },
  { 2123, 12, 23, 16, 2, -16 },
  { 2158, 12, 23, 16, 1, -16 },
  { 2193, 8, 16, 10, 2, -16 },
  { 2209, 10, 16, 12, 1, -16 },
  { 2229, 8, 19, 9, 0, -19 },
  { 2248, 11, 15, 16, 2, -15 },
  { 2269, 12, 15, 12, 0, -15 },
  { 2292, 19, 15, 19, 0, -15 },
  { 2328, 11, 15, 13, 1, -15 },
  { 2349, 12, 22, 12, 0, -15 },
  { 2382, 10, 15, 11, 1, -15 },
  { 2401, 8, 26, 10, 1, -21 },
  { 2427, 2, 29, 14, 6, -22 },
  { 2435, 8, 26, 10, 1, -21 },
  { 2461, 13, 3, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Light29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT29PT7B_H_
