#ifndef _NOTOSANS_SEMICONDENSED_LIGHT33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light33pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0xFB, 0xC7, 0xC6,
  0xC2, 0xC2, 0xC2, 0xC2, 0xC2, 0x42, 0x42, 0x03, 0x04, 0x01, 0x82, 0x00,
  0xC3, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x30, 0x40, 0x18, 0x20, 0x0C, 0x10,
  0x7F, 0xFF, 0x82, 0x0C, 0x01, 0x06, 0x00, 0x83, 0x00, 0xC1, 0x00, 0x60,
  0x80, 0x30, 0x41, 0xFF, 0xFE, 0xFF, 0xFF, 0x04, 0x18, 0x06, 0x08, 0x03,
  0x04, 0x01, 0x82, 0x00, 0x83, 0x00, 0x41, 0x80, 0x60, 0xC0, 0x02, 0x00,
  0x10, 0x03, 0xE0, 0x7F, 0xE6, 0x23, 0x61, 0x03, 0x08, 0x18, 0x40, 0xC2,
  0x06, 0x10, 0x38, 0x80, 0xF4, 0x01, 0xE0, 0x03, 0xC0, 0x0B, 0x80, 0x46,
  0x02, 0x18, 0x10, 0xC0, 0x86, 0x04, 0x30, 0x23, 0x41, 0x3B, 0xFF, 0x87,
  0xF0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x38, 0x01, 0x83, 0xF0, 0x18, 0x30,
  0x80, 0xC1, 0x86, 0x04, 0x08, 0x30, 0x60, 0x41, 0x82, 0x02, 0x04, 0x30,
  0x10, 0x21, 0x00, 0x81, 0x18, 0x04, 0x18, 0x80, 0x20, 0xCC, 0xF9, 0x86,
  0x4C, 0x6C, 0x26, 0x61, 0x3F, 0x22, 0x08, 0xE3, 0x30, 0x60, 0x19, 0x83,
  0x01, 0x8C, 0x18, 0x0C, 0x60, 0xC0, 0xC3, 0x06, 0x06, 0x18, 0x30, 0x60,
  0x41, 0x03, 0x03, 0x18, 0x10, 0x18, 0xC1, 0x80, 0x7C, 0x07, 0x80, 0x07,
  0xF0, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x20, 0x0C, 0x08, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x18, 0xC0, 0x06, 0x60, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x3B, 0x00, 0x1C, 0x60, 0x6E, 0x1C, 0x1B, 0x03, 0x8C, 0xC0, 0x63, 0x20,
  0x0C, 0x88, 0x01, 0xE3, 0x00, 0x30, 0xC0, 0x1E, 0x38, 0x0D, 0xC7, 0x9E,
  0x38, 0xFF, 0x07, 0xFF, 0xFD, 0x40, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C,
  0x30, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x06,
  0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x81, 0x81,
  0x03, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x10, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x0C, 0x00, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xC6, 0x3F, 0xFF, 0x0F, 0x00, 0xF0, 0x09, 0x01,
  0x98, 0x30, 0xC7, 0x0E, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x3F, 0xFF, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x33, 0x36, 0x66, 0x4C, 0xFF,
  0xFF, 0x7F, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0x0F, 0x80, 0xFE, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x60, 0x0B, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xC0, 0x66, 0x03, 0x18, 0x30,
  0xF7, 0x83, 0xF8, 0x02, 0x1C, 0x79, 0xB6, 0x78, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x1F, 0x03, 0xFE, 0x38, 0x18, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0x86, 0x03, 0x10, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x03, 0xE0,
  0x0F, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1A, 0x00, 0xEF, 0x0F, 0x1F, 0xF0, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xCC, 0x03, 0x18,
  0x06, 0x30, 0x18, 0x60, 0x20, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x18,
  0x0C, 0x60, 0x18, 0xC0, 0x31, 0xFF, 0xFC, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x7F, 0xF3, 0xFF, 0x98, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xF0,
  0xE3, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x40, 0x3B, 0xC7, 0x8F, 0xF0, 0x03, 0xF0, 0x7F,
  0x87, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x0C, 0x37, 0xF9, 0xE0, 0xEE, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x06, 0xC0, 0x36, 0x01, 0x98, 0x18, 0xE3, 0x81, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6C, 0x01, 0x60,
  0x0F, 0x00, 0x6C, 0x06, 0x60, 0x31, 0x83, 0x07, 0x70, 0x1E, 0x01, 0xFC,
  0x18, 0x71, 0x80, 0xD8, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x19, 0xE3, 0xC3, 0xF8, 0x0F, 0x01, 0xFE, 0x1C, 0x19, 0xC0,
  0x6C, 0x03, 0x60, 0x0B, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x76, 0x07, 0xBF, 0xEC, 0x7E, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x61, 0x0E, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xEC, 0x37, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33,
  0x76, 0x66, 0x4C, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x08, 0x00, 0x00,
  0x3E, 0x3F, 0xE8, 0x1C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x60, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x60, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00,
  0x70, 0x1C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x62, 0x00,
  0x00, 0x98, 0x1F, 0x83, 0x40, 0xE7, 0x0F, 0x06, 0x0C, 0x1C, 0x10, 0x30,
  0x70, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x20, 0x30, 0x60,
  0xC0, 0x81, 0x83, 0x07, 0x0F, 0x0C, 0x1C, 0x3C, 0x18, 0xD1, 0xB0, 0x3E,
  0x7C, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x80, 0x1F, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0x20, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x08, 0xC0, 0x06, 0x18, 0x01, 0x86, 0x00, 0x41, 0x80, 0x30, 0x30,
  0x0C, 0x0C, 0x02, 0x03, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x10, 0x06, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x8C, 0x07, 0x30, 0x06, 0xC0, 0x1B,
  0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x07, 0x3F, 0xE0,
  0xC3, 0xF3, 0x00, 0xEC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1B, 0x00, 0xEF, 0xFF, 0x3F, 0xF0, 0x01, 0xF8, 0x0F,
  0xFC, 0x78, 0x08, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x80, 0x03, 0xE7, 0x83, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xC0, 0xF0,
  0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C,
  0xC0, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFC, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0xC3, 0x80, 0x63, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x6E, 0x00, 0x33, 0x80, 0x18, 0xE0, 0x0C, 0x3E,
  0x3E, 0x07, 0xFE, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x7F, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x6F, 0xDE, 0x00,
  0xC0, 0x0F, 0x00, 0x6C, 0x03, 0x30, 0x1C, 0xC0, 0xE3, 0x03, 0x0C, 0x18,
  0x30, 0xC0, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x37, 0x00, 0xF6, 0x03, 0x9C,
  0x0C, 0x30, 0x30, 0x60, 0xC1, 0xC3, 0x03, 0x0C, 0x06, 0x30, 0x18, 0xC0,
  0x33, 0x00, 0xEC, 0x01, 0xB0, 0x03, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xBF, 0x00, 0x0D, 0xEC, 0x00, 0x6F, 0x60, 0x02, 0x7B, 0x00, 0x33,
  0xCC, 0x01, 0x9E, 0x60, 0x18, 0xF1, 0x00, 0xC7, 0x8C, 0x06, 0x3C, 0x60,
  0x61, 0xE1, 0x03, 0x0F, 0x0C, 0x10, 0x78, 0x61, 0x83, 0xC1, 0x8C, 0x1E,
  0x0C, 0x40, 0xF0, 0x66, 0x07, 0x81, 0xB0, 0x3C, 0x0D, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xC0, 0x78, 0x0C, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xD8, 0x03, 0xCC, 0x03, 0xCC, 0x03, 0xC6, 0x03,
  0xC6, 0x03, 0xC3, 0x03, 0xC3, 0x83, 0xC1, 0x83, 0xC0, 0xC3, 0xC0, 0xC3,
  0xC0, 0x63, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x3B, 0xC0, 0x1B, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x70,
  0x38, 0x1C, 0x01, 0x83, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x07, 0x38, 0x00, 0xC3, 0x00, 0x38, 0x30, 0x0E, 0x03, 0xCF,
  0x80, 0x3F, 0xC0, 0xFC, 0x07, 0xFE, 0x30, 0x39, 0x80, 0x6C, 0x03, 0x60,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0xEC, 0x1E,
  0x7F, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x70,
  0x1C, 0x1C, 0x01, 0x83, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x07, 0x30, 0x00, 0xC3, 0x00, 0x38, 0x30, 0x0E, 0x03, 0xCF,
  0x80, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFE, 0x03, 0xFF, 0x0C, 0x0F, 0x30,
  0x0C, 0xC0, 0x3B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xCC,
  0x03, 0x30, 0x18, 0xFF, 0xC3, 0xFC, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xC3,
  0x03, 0x8C, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x6C, 0x01, 0xB0, 0x03,
  0x0F, 0xC1, 0xFF, 0x9C, 0x0D, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x40, 0x3B,
  0xC7, 0x9F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x36, 0x00, 0xEE, 0x03, 0x8F, 0x9E, 0x07, 0xF8, 0xC0, 0x01, 0xE0,
  0x00, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x0C, 0x10, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x80, 0x08, 0x00, 0xF0, 0x07, 0x00, 0x6C, 0x01, 0xC0, 0x1B, 0x00, 0x50,
  0x06, 0x40, 0x14, 0x01, 0x98, 0x0D, 0x80, 0xC6, 0x03, 0x60, 0x31, 0x80,
  0xD8, 0x0C, 0x20, 0x22, 0x03, 0x0C, 0x18, 0xC1, 0x83, 0x06, 0x30, 0x60,
  0xC1, 0x8C, 0x18, 0x10, 0xC1, 0x86, 0x06, 0x30, 0x63, 0x01, 0x8C, 0x18,
  0xC0, 0x63, 0x06, 0x30, 0x09, 0x80, 0xCC, 0x03, 0x60, 0x36, 0x00, 0xD8,
  0x0D, 0x80, 0x36, 0x03, 0x60, 0x05, 0x00, 0x58, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C,
  0x30, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0x20, 0x06, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60,
  0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x18, 0x30, 0x0C,
  0x70, 0x0C, 0x60, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0D, 0x80, 0x3B,
  0x00, 0x63, 0x00, 0xC6, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x0C, 0x30, 0x18,
  0xC0, 0x19, 0x80, 0x36, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xC0,
  0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0xFF, 0xFC, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x01, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x8C, 0x03, 0x18, 0x0C,
  0x18, 0x18, 0x30, 0x60, 0x30, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xD8, 0x00,
  0xC0, 0xFF, 0xFC, 0xE1, 0xC3, 0x06, 0x0C, 0x0F, 0xC3, 0xFE, 0x30, 0x70,
  0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x0F, 0xF3, 0xC1, 0x70, 0x16,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x05, 0x71, 0xD3, 0xF9, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0xF0, 0x9F,
  0xE5, 0x83, 0xB8, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1A, 0x81, 0xD7,
  0x3C, 0x8F, 0xC0, 0x07, 0xC3, 0xFC, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x3C, 0x63, 0xFC, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x61, 0xF3, 0x3F, 0xDB, 0x83, 0xD8, 0x0F, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xB0, 0x0D, 0x80, 0xA7, 0x19, 0x1F, 0x88, 0x0F, 0x80, 0xFE,
  0x0C, 0x18, 0xC0, 0x64, 0x03, 0x60, 0x0B, 0x00, 0x78, 0x03, 0xFF, 0xFE,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x3C,
  0x70, 0xFF, 0x00, 0x07, 0xE1, 0xC8, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xFC, 0xFF, 0x83, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x00, 0x0F, 0x89, 0xFE, 0x5C, 0x1A, 0xC0, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0D, 0x80, 0xEC, 0x07, 0x38, 0xD8, 0xFC, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE8, 0x0E, 0x7F, 0xE1, 0xFC, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x78, 0x9F, 0xEB, 0x06,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x7D,
  0x00, 0x1B, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x0C, 0x70, 0x80, 0x00,
  0x00, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x6F, 0xBC, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x06, 0x80, 0xC8, 0x18, 0x81,
  0x88, 0x30, 0x86, 0x08, 0xC0, 0x98, 0x09, 0xC0, 0xAC, 0x0E, 0x60, 0xC7,
  0x08, 0x30, 0x81, 0x88, 0x18, 0x80, 0xC8, 0x06, 0x80, 0x70, 0xFF, 0xFF,
  0xFF, 0x80, 0x8F, 0x03, 0xC4, 0xFE, 0x7F, 0xA8, 0x36, 0x0D, 0xC0, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x30, 0x0F, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xC0, 0x87, 0x89, 0xFE, 0xB0, 0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x0F, 0x80, 0x7F, 0x83, 0x07, 0x18, 0x0E,
  0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1B, 0x00, 0x66, 0x01, 0x98, 0x0C, 0x38, 0xE0, 0x7F,
  0x00, 0x87, 0x84, 0xFF, 0x2C, 0x1D, 0x40, 0x6C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xD4, 0x0E, 0xB8, 0xE4, 0x7E, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x0F, 0x89, 0xFE, 0x5C,
  0x1A, 0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xEC, 0x07, 0x38, 0xD8,
  0xFC, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x8F, 0x9F, 0xB0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x87, 0xFD,
  0x80, 0xB0, 0x04, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x1C, 0x03, 0xF1, 0xCF, 0xF0, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC8, 0x7C, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xA0, 0x0D, 0x80, 0xEC,
  0x07, 0x38, 0xD8, 0xFC, 0xC0, 0xC0, 0x0F, 0x00, 0x66, 0x01, 0x98, 0x06,
  0x60, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x08, 0x18, 0x60, 0x61, 0x81, 0x84,
  0x03, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0x58, 0x01, 0xE0, 0x07, 0x00, 0x0C,
  0x00, 0xC0, 0x30, 0x0D, 0x80, 0xC0, 0x26, 0x03, 0x81, 0x98, 0x1E, 0x06,
  0x60, 0x68, 0x18, 0xC1, 0x30, 0x43, 0x0C, 0xC3, 0x0C, 0x33, 0x0C, 0x30,
  0xC4, 0x30, 0x62, 0x18, 0x81, 0x98, 0x66, 0x06, 0x61, 0x98, 0x09, 0x82,
  0x60, 0x34, 0x0D, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x70, 0x06, 0x01, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x1B, 0x01, 0x98, 0x18, 0x60, 0xC3, 0x0C, 0x0C,
  0x60, 0x36, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1B, 0x01, 0x8C,
  0x18, 0x60, 0xC1, 0x8C, 0x0C, 0x60, 0x36, 0x00, 0xC0, 0xC0, 0x0D, 0x00,
  0x36, 0x01, 0x98, 0x06, 0x20, 0x18, 0xC0, 0xC3, 0x03, 0x04, 0x0C, 0x18,
  0x60, 0x61, 0x80, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x13, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xC1, 0xF0, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x0E, 0x03, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x1E, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x3C, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0x3C, 0x0F, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC1, 0xE0, 0xF0, 0x00, 0x7F, 0x07, 0x8F, 0xF8, 0x0F,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_Light33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 24, 8, 2, -24 },
  { 10, 8, 9, 12, 2, -24 },
  { 19, 17, 24, 19, 1, -24 },
  { 70, 13, 27, 17, 2, -25 },
  { 114, 21, 24, 24, 2, -24 },
  { 177, 18, 24, 20, 2, -24 },
  { 231, 2, 9, 6, 2, -24 },
  { 234, 7, 29, 9, 1, -24 },
  { 260, 7, 29, 9, 1, -24 },
  { 286, 12, 12, 16, 2, -25 },
  { 304, 14, 15, 17, 1, -19 },
  { 331, 4, 8, 7, 1, -4 },
  { 335, 8, 2, 10, 1, -10 },
  { 337, 3, 3, 8, 2, -3 },
  { 339, 11, 24, 11, 0, -24 },
  { 372, 13, 24, 17, 2, -24 },
  { 411, 7, 24, 17, 3, -24 },
  { 432, 13, 24, 17, 2, -24 },
  { 471, 14, 24, 17, 1, -24 },
  { 513, 15, 24, 17, 1, -24 },
  { 558, 13, 24, 17, 2, -24 },
  { 597, 13, 24, 17, 2, -24 },
  { 636, 13, 24, 17, 2, -24 },
  { 675, 13, 24, 17, 2, -24 },
  { 714, 13, 24, 17, 2, -24 },
  { 753, 3, 18, 8, 2, -18 },
  { 760, 4, 22, 8, 1, -18 },
  { 771, 14, 15, 17, 1, -19 },
  { 798, 13, 9, 17, 2, -16 },
  { 813, 14, 15, 17, 1, -19 },
  { 840, 10, 24, 12, 1, -24 },
  { 870, 22, 27, 26, 2, -24 },
  { 945, 18, 24, 18, 0, -24 },
  { 999, 14, 24, 19, 3, -24 },
  { 1041, 15, 24, 18, 2, -24 },
  { 1086, 16, 24, 21, 3, -24 },
  { 1134, 11, 24, 16, 3, -24 },
  { 1167, 11, 24, 15, 3, -24 },
  { 1200, 17, 24, 22, 2, -24 },
  { 1251, 15, 24, 21, 3, -24 },
  { 1296, 7, 24, 10, 1, -24 },
  { 1317, 7, 30, 8, -2, -24 },
  { 1344, 14, 24, 17, 3, -24 },
  { 1386, 11, 24, 15, 3, -24 },
  { 1419, 21, 24, 27, 3, -24 },
  { 1482, 16, 24, 22, 3, -24 },
  { 1530, 19, 24, 22, 2, -24 },
  { 1587, 13, 24, 17, 3, -24 },
  { 1626, 19, 30, 22, 2, -24 },
  { 1698, 14, 24, 18, 3, -24 },
  { 1740, 13, 24, 16, 2, -24 },
  { 1779, 15, 24, 15, 0, -24 },
  { 1824, 15, 24, 21, 3, -24 },
  { 1869, 17, 24, 17, 0, -24 },
  { 1920, 26, 24, 27, 1, -24 },
  { 1998, 16, 24, 16, 0, -24 },
  { 2046, 15, 24, 15, 0, -24 },
  { 2091, 14, 24, 16, 1, -24 },
  { 2133, 7, 29, 10, 3, -24 },
  { 2159, 11, 24, 11, 0, -24 },
  { 2192, 7, 29, 10, 1, -24 },
  { 2218, 15, 14, 17, 1, -24 },
  { 2245, 14, 1, 14, 0, 3 },
  { 2247, 6, 5, 9, 1, -25 },
  { 2251, 12, 18, 16, 1, -18 },
  { 2278, 13, 25, 18, 3, -25 },
  { 2319, 11, 18, 14, 2, -18 },
  { 2344, 13, 25, 18, 2, -25 },
  { 2385, 13, 18, 16, 2, -18 },
  { 2415, 11, 25, 9, 0, -25 },
  { 2450, 13, 26, 18, 2, -18 },
  { 2493, 12, 25, 18, 3, -25 },
  { 2531, 3, 24, 7, 2, -24 },
  { 2540, 6, 32, 7, -1, -24 },
  { 2564, 12, 25, 15, 3, -25 },
  { 2602, 1, 25, 7, 3, -25 },
  { 2606, 21, 18, 26, 3, -18 },
  { 2654, 12, 18, 18, 3, -18 },
  { 2681, 14, 18, 17, 2, -18 },
  { 2713, 13, 26, 18, 3, -18 },
  { 2756, 13, 26, 18, 2, -18 },
  { 2799, 8, 18, 12, 3, -18 },
  { 2817, 11, 18, 14, 1, -18 },
  { 2842, 9, 22, 10, 0, -22 },
  { 2867, 13, 18, 18, 2, -18 },
  { 2897, 14, 18, 14, 0, -18 },
  { 2929, 22, 18, 22, 0, -18 },
  { 2979, 13, 18, 15, 1, -18 },
  { 3009, 14, 26, 14, 0, -18 },
  { 3055, 11, 18, 13, 1, -18 },
  { 3080, 10, 29, 12, 1, -24 },
  { 3117, 2, 33, 16, 7, -25 },
  { 3126, 10, 29, 12, 1, -24 },
  { 3163, 14, 3, 17, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Light33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT33PT7B_H_
