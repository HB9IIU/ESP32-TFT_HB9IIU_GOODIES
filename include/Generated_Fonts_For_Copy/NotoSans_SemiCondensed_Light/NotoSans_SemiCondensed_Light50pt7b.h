#ifndef _NOTOSANS_SEMICONDENSED_LIGHT50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x40, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0E, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0,
  0x36, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x0E,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x38, 0x00, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x01,
  0xFF, 0xFC, 0x3C, 0xC3, 0xC7, 0x0C, 0x04, 0xE0, 0xC0, 0x0E, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0xC0,
  0x0F, 0x0C, 0x00, 0x78, 0xC0, 0x03, 0xEC, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xCF, 0x80, 0x0C, 0x3C, 0x00,
  0xC0, 0xE0, 0x0C, 0x0E, 0x00, 0xC0, 0x60, 0x0C, 0x07, 0x00, 0xC0, 0x60,
  0x0C, 0x06, 0x00, 0xC0, 0xE0, 0x0C, 0x0E, 0x80, 0xC3, 0xCF, 0x8C, 0xF8,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xC0, 0x0F, 0xF0,
  0x00, 0xE0, 0x0E, 0x1C, 0x00, 0x60, 0x06, 0x06, 0x00, 0x70, 0x07, 0x03,
  0x80, 0x30, 0x03, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x1C, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x0E, 0x00, 0x38,
  0x06, 0x06, 0x00, 0x1C, 0x03, 0x07, 0x00, 0x06, 0x01, 0x83, 0x00, 0x03,
  0x00, 0xC3, 0x80, 0x01, 0x80, 0x61, 0xC3, 0xC0, 0xC0, 0x30, 0xC7, 0xF8,
  0x60, 0x38, 0xE3, 0x9E, 0x38, 0x1C, 0x63, 0x83, 0x0C, 0x0C, 0x71, 0x81,
  0xC7, 0x0E, 0x31, 0xC0, 0xE1, 0xFE, 0x38, 0xC0, 0x30, 0x7E, 0x18, 0x60,
  0x18, 0x00, 0x1C, 0x30, 0x0C, 0x00, 0x0C, 0x18, 0x06, 0x00, 0x0E, 0x0C,
  0x03, 0x80, 0x06, 0x06, 0x01, 0xC0, 0x07, 0x03, 0x00, 0xE0, 0x03, 0x01,
  0x80, 0x60, 0x03, 0x80, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x18, 0x01, 0xC0,
  0x38, 0x0C, 0x00, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x06, 0x06, 0x00, 0x70,
  0x03, 0x87, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x38, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE3, 0xC0,
  0x0E, 0x1C, 0x1E, 0x00, 0xC3, 0x80, 0xF0, 0x1C, 0x70, 0x07, 0x01, 0xC7,
  0x00, 0x38, 0x1C, 0x70, 0x01, 0xC3, 0x8E, 0x00, 0x0E, 0x38, 0xE0, 0x00,
  0xF7, 0x0E, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xF0, 0x3C, 0x00, 0xF7, 0x81, 0xE0,
  0x7E, 0x3C, 0x0F, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x0F, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFE, 0xDB, 0x6D, 0xB6, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x06,
  0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60,
  0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60,
  0x60, 0x27, 0xC6, 0x1E, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0x98, 0x00, 0x39, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xF0,
  0x0E, 0x07, 0x01, 0xC0, 0x38, 0x04, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0xF3, 0x8E,
  0x38, 0xE7, 0x1C, 0x71, 0x8E, 0x30, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x40, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x9F, 0x01, 0xC0,
  0x78, 0x38, 0x03, 0xC3, 0x80, 0x1C, 0x70, 0x00, 0xC7, 0x00, 0x0E, 0x60,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C,
  0x03, 0x81, 0xE0, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x0F,
  0x03, 0xF0, 0x7F, 0x0F, 0x71, 0xE7, 0x38, 0x7F, 0x07, 0x60, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xC7, 0xE0, 0xF0,
  0x07, 0x82, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xC3, 0xF1, 0xF0, 0x07,
  0x86, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x80, 0x01, 0xE7, 0xC0, 0x3E, 0x3F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0x80,
  0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x30, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x02, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x80, 0x07, 0xCF, 0x01, 0xF8, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0xC0, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE1, 0xFE, 0x0E, 0x7F, 0xF0, 0xEF, 0x0F, 0x8F, 0xC0, 0x1C, 0xF8, 0x00,
  0xEF, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x07, 0x30, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x01, 0xC1,
  0xF0, 0x78, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xE1, 0xF0, 0x38, 0x03, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x38, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x71, 0x80, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x0F, 0x00, 0xE0, 0x3C, 0x1E,
  0x00, 0xFB, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x1E,
  0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x70, 0xE0, 0x01, 0xCE, 0x00, 0x0E,
  0x70, 0x00, 0x3B, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEF, 0x00, 0x0E, 0x3C, 0x00, 0xF0,
  0xF0, 0x1F, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xE3, 0xE0, 0x38, 0x07, 0x83, 0x80, 0x1C,
  0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x60, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D,
  0x80, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0xC0, 0x07, 0xCE, 0x00,
  0x6E, 0x3C, 0x0F, 0x70, 0xFF, 0xF3, 0x83, 0xFE, 0x18, 0x01, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x01, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0xEF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF4, 0x38, 0xF3, 0xCF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xCE, 0x38, 0xE7, 0x1C,
  0x71, 0x86, 0x38, 0xC3, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0xF8, 0xFC, 0x7E, 0x40, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x0F, 0x80,
  0x39, 0xC0, 0x1F, 0xFC, 0x06, 0x70, 0x0F, 0x8F, 0x01, 0x98, 0x07, 0x01,
  0xC0, 0x7E, 0x03, 0x80, 0x70, 0x1F, 0x80, 0xE0, 0x1C, 0x07, 0xE0, 0x30,
  0x07, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0x70, 0x0F, 0x01,
  0x80, 0x1C, 0x03, 0xC0, 0x60, 0x07, 0x01, 0xF0, 0x18, 0x01, 0xC0, 0x7C,
  0x06, 0x00, 0x70, 0x1F, 0x01, 0x80, 0x1C, 0x06, 0xC0, 0x70, 0x0F, 0x01,
  0xB0, 0x1C, 0x03, 0xC0, 0xEC, 0x03, 0x01, 0xB0, 0x33, 0x80, 0xE0, 0xEE,
  0x1C, 0xE0, 0x1F, 0xF1, 0xFE, 0x18, 0x03, 0xF8, 0x3F, 0x07, 0x00, 0x10,
  0x02, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x80, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0x80, 0x30, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x70, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0x80, 0x0F, 0x8C, 0x00, 0x1E,
  0x60, 0x00, 0x73, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00,
  0x03, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x0E, 0x60, 0x00, 0x73,
  0x00, 0x07, 0x18, 0x00, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0x80, 0x07, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xC0,
  0x03, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xF3, 0xF8, 0x3E, 0x00, 0x20, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x02, 0x07, 0xC0, 0x38,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x07, 0xC0, 0xC0, 0x01, 0xF0,
  0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x3C,
  0xC0, 0x00, 0x78, 0xC0, 0x00, 0xF0, 0xC0, 0x01, 0xE0, 0xC0, 0x07, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xD8, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEC, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xE1, 0xFC, 0x0F, 0x80, 0x06, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1C,
  0x3C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xF1, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF,
  0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3B, 0xBF,
  0x7F, 0xCF, 0xE0, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xB0, 0x00, 0x39, 0x80,
  0x03, 0x8C, 0x00, 0x38, 0x60, 0x03, 0xC3, 0x00, 0x3C, 0x18, 0x01, 0xC0,
  0xC0, 0x1C, 0x06, 0x01, 0xC0, 0x30, 0x1C, 0x01, 0x81, 0xE0, 0x0C, 0x1E,
  0x00, 0x60, 0xE0, 0x03, 0x0E, 0x00, 0x18, 0xE0, 0x00, 0xCF, 0x80, 0x06,
  0xFC, 0x00, 0x37, 0x70, 0x01, 0xF3, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x38,
  0x03, 0x01, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0xF0, 0x30,
  0x03, 0x81, 0x80, 0x1E, 0x0C, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x00, 0x0F,
  0x18, 0x00, 0x38, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0xB0, 0x00, 0x1D, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFB, 0x80, 0x00, 0x0D, 0xF7, 0x00, 0x00, 0x3B, 0xE6, 0x00,
  0x00, 0x77, 0xCE, 0x00, 0x01, 0xCF, 0x9C, 0x00, 0x03, 0x9F, 0x18, 0x00,
  0x06, 0x3E, 0x38, 0x00, 0x1C, 0x7C, 0x70, 0x00, 0x38, 0xF8, 0x60, 0x00,
  0x61, 0xF0, 0xE0, 0x01, 0xC3, 0xE1, 0xC0, 0x03, 0x87, 0xC1, 0xC0, 0x06,
  0x0F, 0x83, 0x80, 0x1C, 0x1F, 0x03, 0x00, 0x38, 0x3E, 0x07, 0x00, 0x60,
  0x7C, 0x0E, 0x01, 0xC0, 0xF8, 0x0C, 0x03, 0x01, 0xF0, 0x1C, 0x0E, 0x03,
  0xE0, 0x38, 0x1C, 0x07, 0xC0, 0x30, 0x30, 0x0F, 0x80, 0x70, 0xE0, 0x1F,
  0x00, 0xE1, 0xC0, 0x3E, 0x00, 0xC3, 0x00, 0x7C, 0x01, 0xCE, 0x00, 0xF8,
  0x03, 0x9C, 0x01, 0xF0, 0x03, 0xB0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x18, 0x00, 0x70, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xE7,
  0x00, 0x03, 0xCF, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x70, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xE0,
  0x3C, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0x83,
  0xC0, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x0F, 0x3C,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x60, 0x07, 0xCC, 0x00, 0x3D, 0x80, 0x03, 0xB0,
  0x00, 0x76, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xC0,
  0x03, 0xD8, 0x00, 0xF3, 0x00, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0x80, 0x1F, 0x0C,
  0x00, 0x3C, 0x60, 0x00, 0xE3, 0x00, 0x07, 0x98, 0x00, 0x1C, 0xC0, 0x00,
  0xE6, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x01, 0xCC, 0x00, 0x0E, 0x60,
  0x00, 0x73, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x07, 0x86, 0x00, 0x78,
  0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0xF0, 0x18, 0x03, 0x80, 0xC0, 0x0E, 0x06, 0x00, 0x70, 0x30, 0x01, 0xC1,
  0x80, 0x0E, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x07, 0x18, 0x00,
  0x38, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x1F, 0xCF, 0xE3, 0xE0, 0x06, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x80, 0x01, 0xEF, 0x80,
  0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x1F, 0x81, 0xF8, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x0E,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x18, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x70,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3B, 0x80, 0x03, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0xC0, 0x01, 0xCE, 0x00, 0x0D, 0x80, 0x03, 0x9C, 0x00,
  0x3B, 0x00, 0x07, 0x1C, 0x00, 0x77, 0x00, 0x0C, 0x38, 0x00, 0xEE, 0x00,
  0x38, 0x70, 0x01, 0x8C, 0x00, 0x70, 0xE0, 0x07, 0x18, 0x00, 0xE0, 0xC0,
  0x0E, 0x38, 0x01, 0x81, 0xC0, 0x1C, 0x70, 0x07, 0x03, 0x80, 0x30, 0x60,
  0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x1C, 0x06, 0x01, 0xC1, 0xC0, 0x30, 0x0E,
  0x03, 0x83, 0x80, 0xE0, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x38, 0x1C, 0x07,
  0x03, 0x80, 0x30, 0x38, 0x0E, 0x06, 0x00, 0x70, 0x70, 0x1C, 0x1C, 0x00,
  0xE0, 0xC0, 0x18, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x01, 0x87, 0x00,
  0x70, 0xC0, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x07, 0x18, 0x00, 0xC7, 0x00,
  0x0E, 0x70, 0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x03, 0x98, 0x00, 0x1D, 0xC0,
  0x07, 0x70, 0x00, 0x3B, 0x00, 0x06, 0xE0, 0x00, 0x76, 0x00, 0x0D, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x3C, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x76, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x01, 0xC3,
  0x80, 0x01, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0xC0, 0x00,
  0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x00,
  0xE7, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x30, 0x00, 0x18, 0xE0, 0x00,
  0xE1, 0x80, 0x03, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x38, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x0E, 0x0E, 0x00, 0x18,
  0x38, 0x00, 0x71, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x03, 0xFC, 0x07, 0xFF, 0xC1,
  0xF9, 0xF8, 0x60, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0x03, 0xFF,
  0xC3, 0xFF, 0xF3, 0xE0, 0x0D, 0xE0, 0x03, 0x70, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xC0,
  0x1B, 0x78, 0x1C, 0xCF, 0xFE, 0x31, 0xFF, 0x0C, 0x04, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC3, 0xF8, 0x0E, 0x3F, 0xF0, 0x77, 0xC7, 0xC3, 0xB0,
  0x0F, 0x1F, 0x00, 0x3C, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x1D,
  0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00,
  0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0xEE,
  0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00,
  0xE7, 0xC0, 0x0F, 0x3F, 0x00, 0x71, 0x9C, 0x0F, 0x0C, 0x7F, 0xF0, 0x61,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xF3, 0xC3,
  0xC0, 0x23, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x03, 0x87, 0xFF,
  0xC0, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x3F, 0x87, 0x0F,
  0xFE, 0x71, 0xF9, 0xF7, 0x3C, 0x03, 0xF3, 0x80, 0x1F, 0x70, 0x00, 0xF7,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0x70, 0x00, 0xF7, 0x00, 0x1F, 0x38, 0x01, 0xB3, 0xE0, 0x73, 0x1F,
  0xFE, 0x30, 0x7F, 0xC3, 0x00, 0x40, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x7C, 0x7C, 0x1E, 0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x37,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x02, 0x1F, 0x01, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x18, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x1E, 0x18, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x03, 0xF8, 0x30, 0xFF, 0xE3, 0x1F, 0x9F, 0x33, 0xC0, 0x3F,
  0x38, 0x01, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF3,
  0x80, 0x3F, 0x1E, 0x07, 0x70, 0xFF, 0xE7, 0x07, 0xFC, 0x70, 0x0C, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xE6, 0x00, 0x3C, 0x7F, 0x1F, 0x87, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0xFE, 0x0E, 0x3F, 0xF1, 0xDF,
  0x3F, 0x3B, 0x00, 0xF7, 0xC0, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x5F,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x3B, 0x7D, 0xFC, 0xFC, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0E,
  0xE0, 0x07, 0x38, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x38, 0x38,
  0x1C, 0x0E, 0x0F, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x78,
  0x03, 0xBE, 0x00, 0xED, 0xC0, 0x3E, 0x70, 0x0F, 0x8E, 0x03, 0xC3, 0xC0,
  0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0x73, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC1, 0xF8, 0x07, 0xF0, 0xC7, 0xFE, 0x0F, 0xFC, 0xCF, 0x1F,
  0x1E, 0x7E, 0xFC, 0x07, 0x30, 0x0E, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x03,
  0xE0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01,
  0xC0, 0x03, 0xC1, 0xFC, 0x18, 0x7F, 0xE3, 0x3E, 0x7E, 0x66, 0x01, 0xEF,
  0x80, 0x1D, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xE7, 0xE0, 0x78, 0x07, 0x83, 0x80, 0x1E, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xE7,
  0x00, 0x07, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x80, 0x38, 0x1E, 0x07,
  0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC1, 0xFC, 0x06,
  0x1F, 0xF8, 0x31, 0xE3, 0xE1, 0x98, 0x07, 0x8F, 0x80, 0x1E, 0x78, 0x00,
  0x73, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x1F, 0x80, 0x00,
  0xDC, 0x00, 0x06, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEF, 0x00, 0x07, 0x78, 0x00, 0x73, 0xE0, 0x07, 0x9F, 0x80, 0x38,
  0xEE, 0x07, 0xC7, 0x3F, 0xF8, 0x38, 0xFF, 0x81, 0xC0, 0x40, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x30, 0xFF, 0xE3, 0x1F, 0x0F, 0x33,
  0xC0, 0x3F, 0x38, 0x01, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x70,
  0x01, 0xF3, 0x80, 0x3F, 0x3E, 0x07, 0x71, 0xFF, 0xE7, 0x07, 0xFC, 0x70,
  0x0C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0xDC,
  0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0x87, 0xCF, 0x00, 0x27, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1D, 0x00, 0x0E, 0xF0, 0x1E, 0x7F, 0xFE, 0x0F, 0xFE, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x21, 0xFF, 0x03, 0xF8, 0x02, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0xFB, 0x80, 0x37, 0x7C, 0x1E, 0xE7, 0xFF, 0x9C,
  0x7F, 0xC3, 0x80, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0x9C, 0x00,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x18, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x60, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x06, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x18, 0x00, 0x19, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0xC0, 0x07,
  0xE0, 0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x0E, 0x60, 0x07, 0xE0, 0x0E,
  0x70, 0x06, 0xE0, 0x0E, 0x70, 0x06, 0x60, 0x0C, 0x70, 0x0E, 0x60, 0x1C,
  0x30, 0x0E, 0x70, 0x1C, 0x38, 0x0E, 0x70, 0x1C, 0x38, 0x0C, 0x30, 0x18,
  0x38, 0x1C, 0x38, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x18, 0x38, 0x38,
  0x1C, 0x38, 0x18, 0x30, 0x0C, 0x38, 0x1C, 0x70, 0x0E, 0x38, 0x1C, 0x70,
  0x0E, 0x30, 0x0C, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x06, 0x70, 0x0E, 0xE0,
  0x06, 0x60, 0x0E, 0xE0, 0x07, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x06, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x77, 0x00, 0x0E, 0x38, 0x01, 0xE3,
  0x80, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0x9C, 0x00, 0x39,
  0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C,
  0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0,
  0xE0, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81,
  0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00,
  0xE3, 0x80, 0x03, 0x1C, 0x00, 0x1C, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0C, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0xC0, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xE0, 0x0F, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xC0,
  0x7C, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xF8, 0x0F, 0xC0, 0x38, 0x00,
  0x3F, 0xC0, 0x0B, 0xFF, 0x80, 0x78, 0x3F, 0x9F, 0x80, 0x7F, 0xE8, 0x00,
  0x7E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 37, 12, 4, -36 },
  { 20, 11, 13, 18, 3, -36 },
  { 38, 26, 36, 29, 1, -36 },
  { 155, 20, 41, 26, 3, -38 },
  { 258, 33, 37, 37, 2, -36 },
  { 411, 28, 37, 31, 2, -36 },
  { 541, 3, 13, 10, 3, -36 },
  { 546, 10, 44, 14, 2, -36 },
  { 601, 10, 44, 14, 2, -36 },
  { 656, 20, 19, 24, 2, -38 },
  { 704, 21, 23, 26, 2, -29 },
  { 765, 6, 13, 11, 2, -6 },
  { 775, 11, 3, 15, 2, -15 },
  { 780, 4, 5, 11, 4, -4 },
  { 783, 16, 36, 17, 1, -36 },
  { 855, 20, 36, 26, 3, -36 },
  { 945, 12, 36, 26, 4, -36 },
  { 999, 21, 36, 26, 2, -36 },
  { 1094, 21, 37, 26, 2, -36 },
  { 1192, 24, 36, 26, 1, -36 },
  { 1300, 20, 37, 26, 3, -36 },
  { 1393, 20, 37, 26, 3, -36 },
  { 1486, 21, 36, 26, 2, -36 },
  { 1581, 21, 37, 26, 2, -36 },
  { 1679, 21, 37, 26, 2, -36 },
  { 1777, 4, 28, 11, 4, -27 },
  { 1791, 6, 34, 11, 2, -27 },
  { 1817, 21, 22, 26, 2, -29 },
  { 1875, 21, 13, 26, 2, -24 },
  { 1910, 21, 22, 26, 2, -29 },
  { 1968, 16, 37, 19, 1, -36 },
  { 2042, 34, 41, 40, 3, -36 },
  { 2217, 27, 36, 27, 0, -36 },
  { 2339, 21, 36, 28, 5, -36 },
  { 2434, 23, 37, 28, 3, -36 },
  { 2541, 24, 36, 32, 5, -36 },
  { 2649, 17, 36, 25, 5, -36 },
  { 2726, 17, 36, 23, 5, -36 },
  { 2803, 26, 37, 33, 3, -36 },
  { 2924, 23, 36, 32, 5, -36 },
  { 3028, 10, 36, 14, 2, -36 },
  { 3073, 11, 45, 12, -4, -36 },
  { 3135, 21, 36, 26, 5, -36 },
  { 3230, 17, 36, 23, 5, -36 },
  { 3307, 31, 36, 40, 5, -36 },
  { 3447, 23, 36, 33, 5, -36 },
  { 3551, 28, 37, 34, 3, -36 },
  { 3681, 19, 36, 26, 5, -36 },
  { 3767, 28, 45, 34, 3, -36 },
  { 3925, 21, 36, 27, 5, -36 },
  { 4020, 20, 37, 25, 2, -36 },
  { 4113, 23, 36, 23, 0, -36 },
  { 4217, 24, 37, 32, 4, -36 },
  { 4328, 26, 36, 26, 0, -36 },
  { 4445, 39, 36, 41, 1, -36 },
  { 4621, 24, 36, 24, 0, -36 },
  { 4729, 23, 36, 23, 0, -36 },
  { 4833, 21, 36, 25, 2, -36 },
  { 4928, 10, 44, 16, 4, -36 },
  { 4983, 16, 36, 17, 1, -36 },
  { 5055, 11, 44, 16, 1, -36 },
  { 5116, 22, 21, 26, 2, -36 },
  { 5174, 21, 3, 21, 0, 4 },
  { 5182, 9, 8, 13, 2, -38 },
  { 5191, 18, 28, 24, 2, -27 },
  { 5254, 21, 39, 27, 4, -38 },
  { 5357, 17, 28, 21, 3, -27 },
  { 5417, 20, 39, 27, 3, -38 },
  { 5515, 19, 28, 25, 3, -27 },
  { 5582, 15, 38, 14, 1, -38 },
  { 5654, 20, 39, 27, 3, -27 },
  { 5752, 19, 38, 27, 4, -38 },
  { 5843, 3, 37, 11, 4, -37 },
  { 5857, 9, 49, 11, -2, -37 },
  { 5913, 18, 38, 22, 4, -38 },
  { 5999, 3, 38, 11, 4, -38 },
  { 6014, 32, 27, 40, 4, -27 },
  { 6122, 19, 27, 27, 4, -27 },
  { 6187, 21, 28, 26, 3, -27 },
  { 6261, 21, 39, 27, 4, -27 },
  { 6364, 20, 39, 27, 3, -27 },
  { 6462, 13, 27, 18, 4, -27 },
  { 6506, 17, 28, 21, 2, -27 },
  { 6566, 13, 34, 15, 1, -33 },
  { 6622, 19, 28, 27, 4, -27 },
  { 6689, 21, 27, 21, 0, -27 },
  { 6760, 32, 27, 34, 1, -27 },
  { 6868, 20, 27, 22, 1, -27 },
  { 6936, 21, 39, 21, 0, -27 },
  { 7039, 16, 27, 20, 2, -27 },
  { 7093, 14, 44, 18, 2, -36 },
  { 7170, 2, 50, 24, 11, -38 },
  { 7183, 14, 44, 18, 2, -36 },
  { 7260, 21, 5, 26, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Light50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT50PT7B_H_
