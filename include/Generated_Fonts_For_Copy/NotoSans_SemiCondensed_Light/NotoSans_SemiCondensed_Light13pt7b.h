#ifndef _NOTOSANS_SEMICONDENSED_LIGHT13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0x80, 0x14, 0x49, 0xF9, 0x22, 0x9F, 0xCA, 0x24,
  0x48, 0x23, 0xE9, 0x4A, 0x38, 0xA5, 0xBB, 0x08, 0xE4, 0xA4, 0xA8, 0xAA,
  0xB5, 0x59, 0x29, 0x25, 0x47, 0x71, 0x21, 0x43, 0x06, 0x12, 0xA3, 0x46,
  0xF6, 0xE0, 0x6A, 0xAA, 0xA4, 0xC8, 0x92, 0x49, 0x2B, 0x00, 0x21, 0x3E,
  0xC9, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x58, 0xE0, 0x80, 0x11, 0x22, 0x24,
  0x44, 0x80, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x74, 0x92, 0x49, 0x20,
  0xF0, 0x42, 0x21, 0x11, 0x10, 0xF8, 0xF0, 0x42, 0x27, 0x04, 0x21, 0xF0,
  0x08, 0x62, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0xF4, 0x21, 0xC1, 0x84, 0x21,
  0xF0, 0x74, 0x21, 0xE8, 0xC6, 0x31, 0x70, 0xF8, 0x44, 0x22, 0x10, 0x88,
  0x40, 0xF4, 0x62, 0xA7, 0x46, 0x31, 0xF0, 0xF4, 0x63, 0x19, 0xB4, 0x22,
  0xE0, 0x82, 0x40, 0x05, 0x80, 0x08, 0x99, 0x06, 0x0C, 0xF8, 0x3E, 0x86,
  0x0C, 0x13, 0x60, 0xF0, 0x42, 0x22, 0x21, 0x00, 0x40, 0x3E, 0x20, 0xA7,
  0x34, 0x9A, 0x4D, 0x26, 0x95, 0x34, 0x80, 0x3E, 0x00, 0x10, 0x50, 0xA1,
  0x44, 0x4F, 0x91, 0x41, 0x82, 0xFA, 0x18, 0x62, 0xFA, 0x18, 0x61, 0xF8,
  0x7E, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7C, 0xFA, 0x18, 0x61, 0x86, 0x18,
  0x61, 0xF8, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0xF8, 0xFC, 0x21, 0x0F, 0x42,
  0x10, 0x80, 0x7D, 0x02, 0x04, 0x08, 0xF0, 0x60, 0xA1, 0x3E, 0x86, 0x18,
  0x61, 0xFE, 0x18, 0x61, 0x84, 0xEA, 0xAA, 0xC0, 0x24, 0x92, 0x49, 0x27,
  0x80, 0x8E, 0x4A, 0x28, 0xE2, 0x49, 0x22, 0x84, 0x84, 0x21, 0x08, 0x42,
  0x10, 0xF8, 0xC1, 0xC3, 0xC3, 0xA3, 0xA5, 0xA5, 0x95, 0x99, 0x89, 0x87,
  0x1A, 0x69, 0x96, 0x58, 0xE1, 0x84, 0x7D, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC2, 0x7C, 0xFC, 0x63, 0x1F, 0x42, 0x10, 0x80, 0x7D, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC2, 0x7C, 0x10, 0x10, 0xFA, 0x28, 0xA2, 0xF2, 0x49, 0x22,
  0x84, 0xFC, 0x21, 0x83, 0x04, 0x21, 0xF0, 0xFC, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0x83, 0x09, 0x12,
  0x24, 0x85, 0x0A, 0x18, 0x10, 0x84, 0x53, 0x14, 0xA5, 0x29, 0x4A, 0x8C,
  0xA3, 0x18, 0xC6, 0x21, 0x00, 0xC5, 0x22, 0x8C, 0x10, 0xC4, 0x92, 0x84,
  0x85, 0x24, 0x8C, 0x30, 0x41, 0x04, 0x10, 0x7C, 0x20, 0x84, 0x10, 0x84,
  0x10, 0xFC, 0xF2, 0x49, 0x24, 0x93, 0x80, 0x84, 0x44, 0x22, 0x11, 0x10,
  0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0xA2, 0x91, 0xC4, 0xF8, 0x90, 0xF1,
  0x1F, 0x99, 0xF0, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8F, 0x80, 0x78, 0x88,
  0x88, 0x70, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8B, 0xC0, 0x74, 0x63, 0xF8,
  0x41, 0xE0, 0x34, 0x4E, 0x44, 0x44, 0x44, 0x7C, 0x63, 0x18, 0xC5, 0xE1,
  0x0F, 0x80, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x40, 0xBF, 0x80, 0x45,
  0x55, 0x57, 0x84, 0x21, 0x3A, 0x53, 0x94, 0x94, 0x40, 0xFF, 0xC0, 0xF7,
  0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0xF4, 0x63, 0x18, 0xC6, 0x20, 0x74,
  0x63, 0x18, 0xC5, 0xC0, 0xF4, 0x63, 0x18, 0xC7, 0xD0, 0x84, 0x00, 0x7C,
  0x63, 0x18, 0xC5, 0xE1, 0x08, 0x40, 0xF2, 0x49, 0x20, 0xF8, 0x86, 0x11,
  0xE0, 0x44, 0xF4, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0x8C,
  0x52, 0xA5, 0x18, 0x80, 0x88, 0xCC, 0x95, 0x4A, 0xA5, 0x53, 0x30, 0x88,
  0xC9, 0x23, 0x08, 0x31, 0x28, 0xC0, 0x8C, 0x52, 0xA5, 0x18, 0x84, 0x26,
  0x00, 0x78, 0x84, 0x44, 0x23, 0xE0, 0x32, 0x22, 0x2C, 0x22, 0x22, 0x30,
  0xFF, 0xF8, 0xC2, 0x22, 0x21, 0x22, 0x22, 0xC0, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Light13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 3, 5, 1, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 8, 9, 10, 1, -9 },
  { 29, 7, 9, 8, 1, -9 },
  { 37, 1, 3, 3, 1, -9 },
  { 38, 2, 11, 4, 1, -9 },
  { 41, 3, 11, 4, 0, -9 },
  { 46, 5, 5, 6, 1, -10 },
  { 50, 5, 6, 7, 1, -8 },
  { 54, 2, 3, 3, 0, -1 },
  { 55, 3, 1, 4, 0, -4 },
  { 56, 1, 1, 3, 1, -1 },
  { 57, 4, 9, 5, 0, -9 },
  { 62, 5, 9, 7, 1, -9 },
  { 68, 3, 9, 7, 1, -9 },
  { 72, 5, 9, 7, 1, -9 },
  { 78, 5, 9, 7, 1, -9 },
  { 84, 6, 9, 7, 0, -9 },
  { 91, 5, 9, 7, 1, -9 },
  { 97, 5, 9, 7, 1, -9 },
  { 103, 5, 9, 7, 1, -9 },
  { 109, 5, 9, 7, 1, -9 },
  { 115, 5, 9, 7, 1, -9 },
  { 121, 1, 7, 3, 1, -7 },
  { 122, 2, 9, 3, 0, -7 },
  { 125, 5, 6, 7, 1, -8 },
  { 129, 5, 3, 7, 1, -6 },
  { 131, 5, 6, 7, 1, -8 },
  { 135, 5, 9, 5, 0, -9 },
  { 141, 9, 10, 10, 1, -9 },
  { 153, 7, 9, 7, 0, -9 },
  { 161, 6, 9, 7, 1, -9 },
  { 168, 6, 9, 7, 1, -9 },
  { 175, 6, 9, 8, 1, -9 },
  { 182, 5, 9, 6, 1, -9 },
  { 188, 5, 9, 6, 1, -9 },
  { 194, 7, 9, 9, 1, -9 },
  { 202, 6, 9, 8, 1, -9 },
  { 209, 2, 9, 4, 1, -9 },
  { 212, 3, 11, 3, -1, -9 },
  { 217, 6, 9, 7, 1, -9 },
  { 224, 5, 9, 6, 1, -9 },
  { 230, 8, 9, 10, 1, -9 },
  { 239, 6, 9, 9, 1, -9 },
  { 246, 7, 9, 9, 1, -9 },
  { 254, 5, 9, 7, 1, -9 },
  { 260, 7, 11, 9, 1, -9 },
  { 270, 6, 9, 7, 1, -9 },
  { 277, 5, 9, 6, 1, -9 },
  { 283, 6, 9, 6, 0, -9 },
  { 290, 6, 9, 8, 1, -9 },
  { 297, 7, 9, 7, 0, -9 },
  { 305, 10, 9, 11, 0, -9 },
  { 317, 6, 9, 6, 0, -9 },
  { 324, 6, 9, 6, 0, -9 },
  { 331, 6, 9, 6, 0, -9 },
  { 338, 3, 11, 4, 1, -9 },
  { 343, 4, 9, 5, 0, -9 },
  { 348, 3, 11, 4, 0, -9 },
  { 353, 6, 5, 7, 0, -9 },
  { 357, 5, 1, 5, 0, 1 },
  { 358, 2, 2, 3, 1, -10 },
  { 359, 4, 7, 6, 1, -7 },
  { 363, 5, 10, 7, 1, -10 },
  { 370, 4, 7, 5, 1, -7 },
  { 374, 5, 10, 7, 1, -10 },
  { 381, 5, 7, 6, 1, -7 },
  { 386, 4, 10, 4, 0, -10 },
  { 391, 5, 10, 7, 1, -7 },
  { 398, 5, 10, 7, 1, -10 },
  { 405, 1, 9, 3, 1, -9 },
  { 407, 2, 12, 3, 0, -9 },
  { 410, 5, 10, 6, 1, -10 },
  { 417, 1, 10, 3, 1, -10 },
  { 419, 8, 7, 10, 1, -7 },
  { 426, 5, 7, 7, 1, -7 },
  { 431, 5, 7, 7, 1, -7 },
  { 436, 5, 10, 7, 1, -7 },
  { 443, 5, 10, 7, 1, -7 },
  { 450, 3, 7, 5, 1, -7 },
  { 453, 4, 7, 5, 1, -7 },
  { 457, 4, 9, 4, 0, -9 },
  { 462, 5, 7, 7, 1, -7 },
  { 467, 5, 7, 5, 0, -7 },
  { 472, 9, 7, 9, 0, -7 },
  { 480, 6, 7, 6, 0, -7 },
  { 486, 5, 10, 6, 0, -7 },
  { 493, 5, 7, 5, 0, -7 },
  { 498, 4, 11, 5, 0, -9 },
  { 504, 1, 13, 6, 3, -10 },
  { 506, 4, 11, 5, 0, -9 },
  { 512, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_Light13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT13PT7B_H_
