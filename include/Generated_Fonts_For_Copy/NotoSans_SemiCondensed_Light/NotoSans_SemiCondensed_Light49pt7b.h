#ifndef _NOTOSANS_SEMICONDENSED_LIGHT49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light49pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x00, 0x00, 0x0E, 0xFF, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xD8, 0x3B, 0x07, 0x60, 0xEC, 0x1D, 0x81, 0xB0, 0x36,
  0x06, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01,
  0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80,
  0x01, 0x80, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x30, 0x1C, 0x00, 0x1C,
  0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x03, 0x01, 0xC0, 0x00, 0xC0,
  0x70, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x9E, 0x30, 0x67,
  0x86, 0x00, 0xE0, 0xC0, 0x1C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x0C, 0x01, 0xC1, 0x80, 0x38, 0x30, 0x03, 0x86, 0x00, 0x7C, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xBF, 0x00,
  0x30, 0xF0, 0x06, 0x0E, 0x00, 0xC0, 0xE0, 0x18, 0x1C, 0x03, 0x03, 0x80,
  0x60, 0x70, 0x0C, 0x0E, 0x01, 0x81, 0xC0, 0x30, 0x74, 0x06, 0x1E, 0xF0,
  0xCF, 0x9F, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x1F, 0xE0,
  0x01, 0x80, 0x38, 0x70, 0x03, 0x80, 0x70, 0x30, 0x03, 0x00, 0x70, 0x30,
  0x07, 0x00, 0x60, 0x38, 0x06, 0x00, 0x60, 0x38, 0x0E, 0x00, 0x60, 0x18,
  0x0C, 0x00, 0xE0, 0x18, 0x1C, 0x00, 0xE0, 0x18, 0x18, 0x00, 0xE0, 0x18,
  0x38, 0x00, 0xE0, 0x18, 0x30, 0x00, 0x60, 0x18, 0x70, 0x00, 0x60, 0x18,
  0x60, 0x00, 0x60, 0x38, 0xE3, 0xF8, 0x60, 0x38, 0xC7, 0xFC, 0x70, 0x31,
  0xC6, 0x0C, 0x30, 0x31, 0x8E, 0x0E, 0x38, 0x73, 0x8C, 0x06, 0x1F, 0xE3,
  0x0C, 0x06, 0x0F, 0xC7, 0x1C, 0x07, 0x00, 0x06, 0x1C, 0x07, 0x00, 0x06,
  0x1C, 0x07, 0x00, 0x0E, 0x1C, 0x07, 0x00, 0x0C, 0x1C, 0x07, 0x00, 0x1C,
  0x1C, 0x07, 0x00, 0x18, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x07, 0x00, 0x30,
  0x1C, 0x07, 0x00, 0x70, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x06, 0x00, 0xE0,
  0x0E, 0x0E, 0x00, 0xC0, 0x06, 0x0C, 0x01, 0xC0, 0x07, 0xFC, 0x01, 0x80,
  0x03, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00,
  0x70, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC1, 0xC0,
  0x1C, 0x70, 0x1C, 0x03, 0x9E, 0x03, 0xC0, 0x63, 0x80, 0x3C, 0x1C, 0x60,
  0x03, 0xC3, 0x9C, 0x00, 0x38, 0xE3, 0x80, 0x03, 0x9C, 0x70, 0x00, 0x3F,
  0x0E, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x83, 0x80,
  0x03, 0xF8, 0x38, 0x01, 0xE7, 0x07, 0xC0, 0xF8, 0x70, 0x7F, 0xFE, 0x07,
  0x03, 0xFF, 0x00, 0xF0, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6, 0x01, 0xC0, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x70, 0x30, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x18, 0x3F, 0xF3, 0x3F, 0x7F,
  0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0xDC, 0x00, 0x39, 0x80, 0x06,
  0x38, 0x01, 0xC3, 0x80, 0x70, 0x78, 0x1E, 0x07, 0x81, 0x80, 0x40, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0xF3, 0x8E, 0x38, 0xC7, 0x1C, 0x61, 0x8E, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xEF, 0xFE, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1E, 0x0F, 0x01, 0xE0, 0x1C, 0x0E,
  0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0x63, 0x80, 0x03,
  0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCE, 0x00,
  0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE3,
  0x00, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x38, 0x1E, 0x03,
  0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x3C,
  0x0F, 0x83, 0xB1, 0xE6, 0x78, 0xDE, 0x1F, 0x83, 0x40, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0xF0, 0x7E, 0x07, 0x87, 0x00, 0x3C, 0x20, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7C, 0x07, 0x8F, 0x00, 0x1C,
  0x40, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE8, 0x00, 0x1C, 0xF0, 0x07,
  0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x98, 0x00,
  0x07, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0x83, 0x00, 0x07, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xE0,
  0x30, 0x03, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0xE0, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30,
  0x70, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1B, 0xFE, 0x03, 0xFF,
  0xF0, 0x78, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF4, 0x00, 0x3C, 0xF0, 0x1F, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xC0, 0x40, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0xE3, 0xFE,
  0x0E, 0xFF, 0xF8, 0xEE, 0x03, 0xCD, 0x80, 0x1C, 0xF0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0x80, 0xF0, 0x78, 0x03, 0xC3,
  0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x71, 0x80, 0x03, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x1C, 0x07,
  0x01, 0xC0, 0x1E, 0x3C, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF0,
  0x01, 0xE3, 0xC0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x1C, 0x00, 0x71, 0xC0,
  0x01, 0xCE, 0x00, 0x0E, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x76, 0x00, 0x03, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00,
  0x1C, 0x1E, 0x03, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x00, 0x0E,
  0x70, 0x00, 0xE6, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0xF3, 0x80, 0x1B, 0x3C, 0x03, 0x71, 0xFF, 0xF7, 0x0F,
  0xFC, 0x70, 0x1F, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x20, 0x3E, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x60, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xEF, 0xFE, 0x38, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE3, 0x8E, 0x39, 0xC7,
  0x1C, 0x63, 0x8E, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFC, 0xF0, 0x3C, 0x40, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x03, 0x8C, 0x00, 0xFF, 0xC0, 0xCE, 0x01, 0xFF,
  0xC0, 0x66, 0x01, 0xE0, 0x60, 0x3B, 0x01, 0xE0, 0x30, 0x0F, 0x80, 0xE0,
  0x18, 0x07, 0xC0, 0xE0, 0x0C, 0x03, 0xC0, 0x70, 0x06, 0x01, 0xE0, 0x30,
  0x03, 0x00, 0xF0, 0x18, 0x01, 0x80, 0x78, 0x0C, 0x00, 0xC0, 0x3C, 0x06,
  0x00, 0x60, 0x1E, 0x03, 0x00, 0x70, 0x0F, 0x01, 0x80, 0x38, 0x0F, 0x80,
  0xC0, 0x1C, 0x07, 0xC0, 0x70, 0x0E, 0x03, 0x60, 0x38, 0x0F, 0x03, 0xB8,
  0x0E, 0x0E, 0xC1, 0x9C, 0x07, 0xFE, 0x7F, 0xC6, 0x01, 0xFE, 0x1F, 0xC3,
  0x80, 0x1C, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x38, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1C, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x38, 0x1F, 0xF1, 0xC0,
  0x03, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x73, 0x80, 0x07, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x38, 0x00, 0xF9, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xDC, 0x00, 0x3C, 0xE0, 0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0x80, 0xF0, 0x3C, 0x00, 0x20, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1C, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xE0, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0xF0, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x0F, 0xC0, 0x3E,
  0x07, 0xC0, 0x01, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0F, 0x80, 0x01, 0xC0, 0xFC,
  0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x38, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xDF, 0xFB, 0xFE, 0x3F, 0x00, 0xE0, 0x00,
  0x3B, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3,
  0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x0E, 0x07, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00,
  0x0E, 0x3C, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0xC0, 0x03, 0xBF, 0x80, 0x0F,
  0xCE, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xC0, 0x00,
  0x0D, 0xFB, 0x80, 0x00, 0x3B, 0xF3, 0x00, 0x00, 0x77, 0xE7, 0x00, 0x00,
  0xCF, 0xCE, 0x00, 0x03, 0x9F, 0x8C, 0x00, 0x07, 0x3F, 0x1C, 0x00, 0x0C,
  0x7E, 0x38, 0x00, 0x38, 0xFC, 0x30, 0x00, 0x71, 0xF8, 0x70, 0x00, 0xC3,
  0xF0, 0xE0, 0x03, 0x87, 0xE0, 0xC0, 0x06, 0x0F, 0xC1, 0xC0, 0x0C, 0x1F,
  0x83, 0x80, 0x38, 0x3F, 0x03, 0x80, 0x60, 0x7E, 0x07, 0x01, 0xC0, 0xFC,
  0x06, 0x03, 0x81, 0xF8, 0x0E, 0x06, 0x03, 0xF0, 0x1C, 0x1C, 0x07, 0xE0,
  0x18, 0x38, 0x0F, 0xC0, 0x38, 0x60, 0x1F, 0x80, 0x71, 0xC0, 0x3F, 0x00,
  0x63, 0x80, 0x7E, 0x00, 0xE6, 0x00, 0xFC, 0x01, 0xDC, 0x01, 0xF8, 0x01,
  0xB0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x07,
  0x00, 0x1F, 0x80, 0x0E, 0x00, 0x38, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xEE, 0x00, 0x07,
  0xEE, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE7, 0x80, 0x07, 0xE3, 0x80, 0x07,
  0xE1, 0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07,
  0xE0, 0x70, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x1C, 0x07,
  0xE0, 0x1C, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x07, 0x07,
  0xE0, 0x07, 0x87, 0xE0, 0x03, 0x87, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xC7,
  0xE0, 0x00, 0xE7, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xE0, 0xFF,
  0x8E, 0x00, 0x7C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0xCE,
  0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x1E,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xC0, 0x0F,
  0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x0C, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x0E,
  0x70, 0x00, 0x73, 0x80, 0x07, 0x9C, 0x00, 0x38, 0xE0, 0x07, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C,
  0x00, 0x1E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0x03, 0xFF,
  0x80, 0xFF, 0xFE, 0x1F, 0x01, 0xE3, 0xC0, 0x02, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE8, 0x00, 0x3C, 0xF8, 0x0F, 0x8F, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3B, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x8E, 0x00, 0x0F,
  0x1E, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x18, 0x00,
  0x70, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x01, 0xDC, 0x00, 0x1E, 0x00, 0x07, 0x70, 0x00, 0xFC,
  0x00, 0x39, 0xC0, 0x03, 0xF0, 0x00, 0xE7, 0x00, 0x0E, 0xC0, 0x03, 0x8E,
  0x00, 0x33, 0x00, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x70, 0xE0, 0x07, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x07, 0x06, 0x00, 0x61, 0x80, 0x1C, 0x1C,
  0x03, 0x87, 0x00, 0xE0, 0x70, 0x0E, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x70,
  0x0E, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x01, 0x81, 0x80, 0x60,
  0x70, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x30, 0xE0, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x06, 0x70, 0x00, 0x66,
  0x00, 0x19, 0xC0, 0x01, 0x98, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x81,
  0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x07,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x06, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0x71,
  0xC0, 0x00, 0xE3, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x36, 0x00, 0x01, 0xDC, 0x00, 0x06, 0x30, 0x00, 0x38, 0xE0, 0x00, 0xC1,
  0x80, 0x07, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x60,
  0x1C, 0x01, 0xC0, 0x70, 0x03, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x18, 0x70,
  0x00, 0x71, 0xC0, 0x00, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x00, 0x20, 0x01, 0xFF, 0x83, 0xFF, 0xF0, 0x70, 0x1E, 0x10,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x01, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0x1C,
  0xE0, 0x07, 0x70, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x1F, 0x78, 0x1C, 0xCF, 0xFE,
  0x31, 0xFF, 0x0C, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x0E, 0x3F, 0xE0, 0xE7, 0xFF, 0x0E,
  0xE0, 0x78, 0xF8, 0x01, 0xCF, 0x80, 0x1C, 0xF0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEF, 0x00, 0x0E, 0xF0,
  0x01, 0xCD, 0x80, 0x3C, 0xCE, 0x07, 0x8C, 0x7F, 0xF0, 0xC3, 0xFE, 0x00,
  0x00, 0x20, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0x03, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x03, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x60, 0x70, 0x7F, 0xC7,
  0x1F, 0xFE, 0x73, 0xE0, 0x77, 0x38, 0x03, 0x77, 0x00, 0x1F, 0x70, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xF7,
  0x00, 0x0F, 0x70, 0x01, 0xF3, 0x80, 0x37, 0x3E, 0x07, 0x71, 0xFF, 0xE7,
  0x07, 0xF8, 0x70, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x03,
  0x83, 0x80, 0x38, 0xE0, 0x03, 0x1C, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x00,
  0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x02,
  0x1E, 0x01, 0xC1, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x1C, 0x08, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC7, 0x1F,
  0xFE, 0x73, 0xE0, 0x77, 0x38, 0x03, 0xF7, 0x00, 0x1F, 0x70, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00,
  0x0F, 0x70, 0x01, 0xF3, 0x80, 0x37, 0x3E, 0x07, 0x71, 0xFF, 0xE7, 0x07,
  0xF8, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x40, 0x01, 0xC7, 0x00, 0x78,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0x03, 0x8F, 0xF8, 0xE7,
  0xFF, 0x3B, 0x81, 0xEF, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xC0, 0xDF, 0xF4, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x01,
  0xC0, 0xE0, 0x70, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x77, 0xFB, 0xF8, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1E, 0xE0, 0x0F, 0x38, 0x03, 0x8E,
  0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x0E, 0x0E, 0x03, 0x87,
  0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0xF8, 0x03, 0xBE, 0x00, 0xFD, 0xC0,
  0x3E, 0x78, 0x0F, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x0E,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x73, 0x80,
  0x0E, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x80, 0xC3, 0xFC,
  0x0F, 0xF0, 0xCF, 0xFE, 0x1F, 0xFC, 0xCC, 0x0F, 0x38, 0x3C, 0xD8, 0x07,
  0x60, 0x0E, 0xF0, 0x03, 0xE0, 0x0E, 0xF0, 0x03, 0xC0, 0x06, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x60, 0x30, 0xFF, 0x8C, 0x7F,
  0xF3, 0x38, 0x1E, 0xD8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x01, 0xE0, 0x78, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00,
  0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x67,
  0x00, 0x0E, 0x70, 0x01, 0xE3, 0x80, 0x1C, 0x1E, 0x07, 0x80, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0x60, 0x0C, 0x3F, 0xE0, 0xC7, 0xFF, 0x0C, 0xE0,
  0x78, 0xD8, 0x01, 0xCD, 0x80, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x06, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF8, 0x01,
  0xCF, 0x80, 0x3C, 0xEE, 0x07, 0x8E, 0x7F, 0xF0, 0xE3, 0xFE, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF1, 0xC3, 0xFF,
  0xCE, 0x3E, 0x07, 0x71, 0xC0, 0x1B, 0x9C, 0x00, 0x7C, 0xE0, 0x01, 0xEE,
  0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xC0, 0x00,
  0x76, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x07,
  0x9C, 0x00, 0x3C, 0xE0, 0x03, 0xE3, 0x80, 0x37, 0x1E, 0x03, 0xB8, 0x7F,
  0xF9, 0xC0, 0xFF, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x46, 0x1F, 0xF1, 0xFD, 0x9C, 0x1D, 0xC0, 0x6C, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x80, 0x0F, 0xFE,
  0x3F, 0xFF, 0x78, 0x06, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x1E, 0xFF, 0xFC,
  0x7F, 0xF8, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03,
  0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xF7, 0x00, 0x6D, 0xE0, 0x73,
  0x3F, 0xF8, 0xC7, 0xFC, 0x30, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xC1, 0x80,
  0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x07, 0x00, 0x60, 0x70, 0x07, 0x07, 0x00, 0x70, 0x60, 0x03, 0x0E, 0x00,
  0x38, 0xE0, 0x03, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0x9C, 0x00, 0x1D, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3B, 0x00, 0x36,
  0x00, 0x67, 0x00, 0x6C, 0x01, 0xCE, 0x00, 0xDC, 0x03, 0x9C, 0x03, 0xB8,
  0x07, 0x18, 0x07, 0x30, 0x0C, 0x38, 0x0C, 0x60, 0x38, 0x70, 0x38, 0xE0,
  0x70, 0xE0, 0x71, 0xC0, 0xE0, 0xC0, 0xC1, 0x81, 0x81, 0xC1, 0x83, 0x87,
  0x03, 0x87, 0x07, 0x0E, 0x07, 0x0E, 0x06, 0x1C, 0x06, 0x18, 0x0C, 0x30,
  0x0E, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x39, 0xC0, 0x39, 0x80, 0x33, 0x80,
  0x33, 0x00, 0x66, 0x00, 0x6E, 0x00, 0xEC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0,
  0x38, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x03,
  0x9C, 0x00, 0x39, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x70, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0x60, 0x03, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0x60, 0x30, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0x60, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0x63, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0xFC, 0x03, 0xC0, 0x0F, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xF0,
  0x0F, 0xC0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0xFE, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x00, 0x7E, 0xFE, 0x0F, 0x80, 0xFF, 0xE8,
  0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 35, 11, 4, -35 },
  { 19, 11, 13, 17, 3, -35 },
  { 37, 26, 35, 28, 1, -35 },
  { 151, 19, 40, 25, 3, -37 },
  { 246, 32, 35, 36, 2, -35 },
  { 386, 27, 36, 30, 2, -36 },
  { 508, 3, 13, 9, 3, -35 },
  { 513, 10, 43, 14, 2, -35 },
  { 567, 9, 43, 14, 2, -35 },
  { 616, 19, 18, 24, 2, -37 },
  { 659, 21, 23, 25, 2, -29 },
  { 720, 6, 12, 11, 2, -6 },
  { 729, 11, 3, 15, 2, -15 },
  { 734, 4, 4, 11, 4, -4 },
  { 736, 15, 35, 17, 1, -35 },
  { 802, 21, 36, 25, 2, -36 },
  { 897, 11, 35, 25, 4, -35 },
  { 946, 20, 35, 25, 2, -35 },
  { 1034, 20, 35, 25, 2, -35 },
  { 1122, 23, 35, 25, 1, -35 },
  { 1223, 19, 35, 25, 3, -35 },
  { 1307, 20, 36, 25, 3, -35 },
  { 1397, 21, 35, 25, 2, -35 },
  { 1489, 21, 35, 25, 2, -35 },
  { 1581, 20, 36, 25, 2, -35 },
  { 1671, 4, 26, 11, 4, -26 },
  { 1684, 6, 32, 11, 2, -26 },
  { 1708, 21, 23, 25, 2, -29 },
  { 1769, 21, 12, 25, 2, -23 },
  { 1801, 21, 23, 25, 2, -29 },
  { 1862, 16, 35, 18, 1, -35 },
  { 1932, 33, 40, 39, 3, -35 },
  { 2097, 26, 35, 26, 0, -35 },
  { 2211, 21, 35, 28, 4, -35 },
  { 2303, 23, 35, 27, 3, -35 },
  { 2404, 24, 35, 31, 4, -35 },
  { 2509, 17, 35, 24, 4, -35 },
  { 2584, 18, 35, 22, 4, -35 },
  { 2663, 26, 36, 32, 3, -36 },
  { 2780, 23, 35, 32, 4, -35 },
  { 2881, 10, 35, 14, 2, -35 },
  { 2925, 11, 44, 12, -4, -35 },
  { 2986, 22, 35, 26, 4, -35 },
  { 3083, 17, 35, 22, 4, -35 },
  { 3158, 31, 35, 39, 4, -35 },
  { 3294, 24, 35, 32, 4, -35 },
  { 3399, 27, 36, 33, 3, -36 },
  { 3521, 20, 35, 26, 4, -35 },
  { 3609, 27, 44, 33, 3, -36 },
  { 3758, 21, 35, 26, 4, -35 },
  { 3850, 20, 35, 24, 2, -35 },
  { 3938, 23, 35, 23, 0, -35 },
  { 4039, 23, 35, 31, 4, -35 },
  { 4140, 25, 35, 25, 0, -35 },
  { 4250, 38, 35, 40, 1, -35 },
  { 4417, 23, 35, 24, 0, -35 },
  { 4518, 23, 35, 23, 0, -35 },
  { 4619, 20, 35, 24, 2, -35 },
  { 4707, 10, 43, 16, 4, -35 },
  { 4761, 15, 35, 17, 1, -35 },
  { 4827, 11, 43, 16, 1, -35 },
  { 4887, 22, 20, 25, 2, -35 },
  { 4942, 20, 3, 20, 0, 4 },
  { 4950, 9, 7, 13, 2, -37 },
  { 4958, 18, 27, 24, 2, -27 },
  { 5019, 20, 37, 27, 4, -37 },
  { 5112, 16, 27, 21, 3, -27 },
  { 5166, 20, 37, 27, 3, -37 },
  { 5259, 19, 27, 24, 3, -27 },
  { 5324, 15, 37, 14, 1, -37 },
  { 5394, 20, 39, 27, 3, -27 },
  { 5492, 18, 37, 26, 4, -37 },
  { 5576, 3, 36, 11, 4, -36 },
  { 5590, 9, 48, 11, -2, -36 },
  { 5644, 18, 37, 22, 4, -37 },
  { 5728, 3, 37, 11, 4, -37 },
  { 5742, 32, 27, 39, 4, -27 },
  { 5850, 18, 27, 26, 4, -27 },
  { 5911, 20, 27, 26, 3, -27 },
  { 5979, 20, 39, 27, 4, -27 },
  { 6077, 21, 39, 27, 2, -27 },
  { 6180, 13, 27, 17, 4, -27 },
  { 6224, 16, 27, 20, 2, -27 },
  { 6278, 13, 32, 15, 1, -32 },
  { 6330, 18, 26, 26, 4, -26 },
  { 6389, 20, 26, 21, 0, -26 },
  { 6454, 31, 26, 33, 1, -26 },
  { 6555, 20, 26, 22, 1, -26 },
  { 6620, 21, 38, 21, 0, -26 },
  { 6720, 16, 26, 19, 2, -26 },
  { 6772, 14, 43, 18, 2, -35 },
  { 6848, 2, 49, 24, 11, -37 },
  { 6861, 14, 43, 18, 2, -35 },
  { 6937, 21, 5, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Light49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT49PT7B_H_
