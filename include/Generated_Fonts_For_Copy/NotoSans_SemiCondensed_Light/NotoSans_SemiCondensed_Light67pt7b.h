#ifndef _NOTOSANS_SEMICONDENSED_LIGHT67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light67pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBE, 0xFF, 0xFF,
  0xDE, 0x30, 0xF8, 0x1F, 0xF0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xEE,
  0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x3F, 0x9C, 0x7F, 0x0F, 0x87, 0x01,
  0xC7, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF8, 0x1C, 0x00,
  0x1F, 0x07, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x7E, 0x70, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0x7F, 0x00, 0x01, 0xC7, 0xF0, 0x00, 0x70, 0x7C,
  0x00, 0x1C, 0x0F, 0x80, 0x07, 0x01, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x70,
  0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x3C, 0x00,
  0x70, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x7A,
  0x00, 0x70, 0x3C, 0xF0, 0x1C, 0x3F, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x03, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x01, 0xE0,
  0xE0, 0x00, 0x07, 0x00, 0x38, 0x3C, 0x1F, 0xC0, 0xE0, 0x07, 0x07, 0x07,
  0xFE, 0x1C, 0x00, 0xE1, 0xE1, 0xF7, 0xC3, 0xC0, 0x3C, 0x38, 0x78, 0x3C,
  0x38, 0x07, 0x0F, 0x0E, 0x03, 0xC7, 0x00, 0xE1, 0xC3, 0xC0, 0x38, 0xF0,
  0x3C, 0x78, 0x70, 0x07, 0x0F, 0x9F, 0x0E, 0x0E, 0x00, 0xF0, 0xFF, 0xC1,
  0xC3, 0xC0, 0x0E, 0x0F, 0xF0, 0x70, 0x78, 0x01, 0xC0, 0x30, 0x0E, 0x0E,
  0x00, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0x00, 0xF0, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x80, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x0E,
  0x00, 0x01, 0xE3, 0xE0, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x70, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x07, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x78, 0x00, 0x3E, 0x03, 0xC3, 0x80, 0x00, 0xF8, 0x1E, 0x3C, 0x00, 0x03,
  0xE1, 0xE1, 0xE0, 0x00, 0x0F, 0x8F, 0x0F, 0x00, 0x00, 0x3E, 0xF0, 0x78,
  0x00, 0x00, 0xFF, 0x83, 0xC0, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x00, 0x1F,
  0x80, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0x00,
  0x00, 0x7F, 0xC0, 0x78, 0x00, 0x07, 0xDF, 0x03, 0xE0, 0x00, 0xFC, 0x78,
  0x0F, 0xC0, 0x1F, 0xC3, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0x80, 0xFF, 0xFF,
  0x80, 0x3E, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x0E, 0x00,
  0x9E, 0x03, 0x81, 0xFF, 0xF0, 0xC3, 0xFF, 0xFF, 0xB7, 0xFF, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x83, 0x80,
  0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00,
  0xF0, 0x03, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F,
  0x1E, 0x38, 0xF1, 0xE3, 0x87, 0x1E, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xEF, 0xBF, 0xFB, 0xE3, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xFB, 0xC3,
  0xE7, 0x8F, 0x8F, 0x7E, 0x1F, 0xF0, 0x3F, 0xC0, 0x7B, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0xF8,
  0x00, 0x3E, 0x0E, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0x3E,
  0x1C, 0x00, 0x03, 0xE1, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xCC, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78, 0x03,
  0x80, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x7F, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF2, 0x00, 0x00, 0x7C, 0x60, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0x10, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x07,
  0xFF, 0x01, 0xE3, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0x87, 0xBC, 0x00, 0xF8,
  0xEF, 0x00, 0x0F, 0x9D, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0x7C, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x78, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x06, 0xE7,
  0xC0, 0x01, 0xDC, 0x7C, 0x00, 0xF3, 0x87, 0xF0, 0xFC, 0x70, 0x7F, 0xFF,
  0x0E, 0x07, 0xFF, 0xC3, 0xC0, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7B, 0xEF, 0xFF, 0xFB, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3E,
  0xFF, 0xFF, 0xBE, 0x30, 0x0F, 0x0F, 0x87, 0xE3, 0xF1, 0xF0, 0xF8, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0,
  0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7C, 0x03, 0xF1, 0x80, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x02, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x0E, 0x00, 0x1F,
  0xFF, 0xC0, 0x1C, 0x78, 0x00, 0xFE, 0x3F, 0x00, 0x79, 0xE0, 0x07, 0xC0,
  0x1C, 0x00, 0xE7, 0x00, 0x1E, 0x00, 0x70, 0x03, 0x9C, 0x00, 0xF0, 0x01,
  0xC0, 0x0E, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x3B, 0x80, 0x1E, 0x00, 0x1C,
  0x00, 0xEE, 0x00, 0x70, 0x00, 0x70, 0x03, 0xF8, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x3C, 0x00,
  0xFE, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x0E,
  0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x3B, 0x80, 0x38, 0x00, 0x3C, 0x00, 0xEE,
  0x00, 0xE0, 0x00, 0xF0, 0x03, 0xB8, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0xE0,
  0x0F, 0x00, 0x1F, 0x00, 0x7B, 0x80, 0x3C, 0x00, 0x7C, 0x01, 0xCE, 0x00,
  0x70, 0x03, 0xF0, 0x07, 0x38, 0x01, 0xE0, 0x0E, 0xC0, 0x38, 0xF0, 0x03,
  0xC0, 0x73, 0x81, 0xE1, 0xC0, 0x0F, 0xC7, 0x8F, 0x9F, 0x07, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1C, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x78, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x01, 0xF8,
  0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xF0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x00, 0xFC, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x8F, 0x00, 0x0F,
  0xF8, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0x80,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x40, 0x3F, 0xC0, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0xF0, 0x00,
  0x0F, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x3F, 0x80, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x00, 0x20, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0xC1, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00,
  0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xE0,
  0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xCF, 0xE0, 0x00, 0x1E, 0xFF, 0x00,
  0x00, 0xFF, 0x3C, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x3F, 0x07, 0x80, 0x01,
  0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0,
  0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x80, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFB, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xBF, 0xDC,
  0x00, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xFD, 0xE0, 0x00,
  0x00, 0x1C, 0xFF, 0x38, 0x00, 0x00, 0x0F, 0x3F, 0xCF, 0x00, 0x00, 0x03,
  0xCF, 0xF3, 0xC0, 0x00, 0x00, 0xE3, 0xFC, 0x78, 0x00, 0x00, 0x78, 0xFF,
  0x1E, 0x00, 0x00, 0x1E, 0x3F, 0xC3, 0x80, 0x00, 0x07, 0x0F, 0xF0, 0xF0,
  0x00, 0x03, 0xC3, 0xFC, 0x3C, 0x00, 0x00, 0xE0, 0xFF, 0x07, 0x00, 0x00,
  0x38, 0x3F, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0xF0, 0x78, 0x00, 0x07, 0x03,
  0xFC, 0x0E, 0x00, 0x03, 0xC0, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x3F, 0xC0,
  0xF0, 0x00, 0x38, 0x0F, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0xFC, 0x07, 0x80,
  0x07, 0x80, 0xFF, 0x01, 0xE0, 0x01, 0xC0, 0x3F, 0xC0, 0x3C, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0x38, 0x03, 0xFC, 0x01, 0xC0, 0x0E, 0x00, 0xFF,
  0x00, 0x78, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x01, 0xC0, 0x0F, 0xF0, 0x03,
  0x80, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x3C, 0x00, 0xFF, 0x00, 0x3C, 0x0E,
  0x00, 0x3F, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xFC, 0x00, 0x78, 0x70, 0x00, 0xFF, 0x00, 0x0E, 0x3C, 0x00, 0x3F, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0xF0, 0x00, 0xF3, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x0F, 0xF3, 0xC0,
  0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x0F, 0xF1, 0xF0,
  0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x0F, 0xF0, 0x78,
  0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x0F, 0xF0, 0x1E,
  0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F,
  0x80, 0x0F, 0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x0F, 0xF0, 0x00,
  0xF0, 0x0F, 0xF0, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x78, 0x0F, 0xF0, 0x00,
  0x3C, 0x0F, 0xF0, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x1E, 0x0F, 0xF0, 0x00,
  0x1F, 0x0F, 0xF0, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x07, 0x8F, 0xF0, 0x00,
  0x07, 0x8F, 0xF0, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x03, 0xE7, 0xF0, 0x00,
  0x01, 0xE7, 0xF0, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00, 0xF7, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x7E,
  0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0xF8, 0xF0, 0x01, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x78,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0xFE, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xCC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x3C, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x03,
  0x81, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x70,
  0x01, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0x80,
  0x7C, 0x0C, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0x1F, 0x80,
  0x07, 0x3E, 0x00, 0x07, 0x7C, 0x00, 0x07, 0x78, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x37, 0x78, 0x00,
  0x77, 0x7E, 0x01, 0xE7, 0x3F, 0xDF, 0xC7, 0x1F, 0xFF, 0x87, 0x0F, 0xFF,
  0x07, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xFF, 0x00,
  0xF0, 0xFF, 0xFC, 0x0F, 0x1F, 0xFF, 0xE0, 0xF3, 0xE0, 0x3F, 0x0F, 0x78,
  0x00, 0xF8, 0xF6, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x03,
  0xCF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3C, 0xFC, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x78, 0xF7, 0x00, 0x0F,
  0x8F, 0x7C, 0x03, 0xF0, 0xF3, 0xFF, 0xFE, 0x0E, 0x1F, 0xFF, 0xC0, 0xE0,
  0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xF8, 0x0F, 0x0F, 0x80, 0x04, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x0C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0x01, 0xFF, 0xF0, 0xF0,
  0x3F, 0xFF, 0xCF, 0x07, 0xE0, 0x3C, 0xF0, 0xF8, 0x00, 0xEF, 0x1F, 0x00,
  0x07, 0xF1, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F,
  0x3C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xF1, 0xE0, 0x00, 0x77, 0x1F, 0x00, 0x0E, 0x70, 0xFC, 0x01, 0xE7,
  0x07, 0xFF, 0xFC, 0x70, 0x3F, 0xFF, 0x87, 0x00, 0xFF, 0xE0, 0x70, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x0F, 0xC0,
  0x07, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xE0, 0x20, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x70, 0x1F, 0xFF, 0x07,
  0x03, 0xFF, 0xFC, 0x70, 0x7E, 0x03, 0xE7, 0x0F, 0x80, 0x0E, 0xF1, 0xF0,
  0x00, 0x7F, 0x1E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x3F, 0x1E, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0xEF, 0x0F, 0xC0, 0x1E,
  0xF0, 0x7F, 0xFF, 0xCF, 0x03, 0xFF, 0xF8, 0xF0, 0x0F, 0xFE, 0x0F, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x20, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xC0, 0xF0,
  0xFF, 0xFC, 0x3C, 0x7F, 0xFF, 0x8F, 0x3E, 0x07, 0xF3, 0xDE, 0x00, 0x7C,
  0xF6, 0x00, 0x0F, 0xBF, 0x80, 0x01, 0xEF, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x0E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3C, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC8, 0x7C, 0xFF, 0x8F, 0xF0,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03,
  0xC7, 0xC0, 0x01, 0xE7, 0xF0, 0x00, 0xF3, 0xF8, 0x00, 0x7B, 0x9E, 0x00,
  0x3F, 0x8F, 0x00, 0x1F, 0xC3, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x01,
  0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0xBC, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x3F, 0xC0, 0x07,
  0xFC, 0x0E, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0x3C, 0x0F, 0xC7, 0xC0, 0xFC, 0xF7, 0x00, 0x3C, 0xF0, 0x07, 0xCF,
  0xE0, 0x01, 0xEE, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xEF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x38, 0x3F, 0xFF, 0x0F, 0x1F, 0xFF, 0xE3,
  0xCF, 0x81, 0xFC, 0xF7, 0x80, 0x1F, 0x3D, 0x80, 0x03, 0xEF, 0xE0, 0x00,
  0x7B, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xBE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x3F, 0xF0, 0x0F, 0x0F, 0xFF, 0xC0, 0xF1, 0xFF, 0xFE,
  0x0F, 0x3E, 0x03, 0xF0, 0xF7, 0x80, 0x1F, 0x8F, 0x70, 0x00, 0x78, 0xFE,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3C, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xCF, 0xE0, 0x00, 0x7C, 0xFE,
  0x00, 0x07, 0x8F, 0x70, 0x00, 0xF8, 0xF3, 0xC0, 0x3F, 0x0F, 0x1F, 0xFF,
  0xE0, 0xF0, 0xFF, 0xFC, 0x0F, 0x07, 0xFF, 0x00, 0xF0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x70, 0x1F, 0xFF, 0x07, 0x03,
  0xFF, 0xFC, 0x70, 0x7E, 0x03, 0xC7, 0x0F, 0x80, 0x0E, 0xF1, 0xF0, 0x00,
  0x7F, 0x1E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x3F, 0x1E, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0xEF, 0x0F, 0xC0, 0x1C, 0xF0,
  0x7F, 0xFF, 0xCF, 0x03, 0xFF, 0xF0, 0xF0, 0x0F, 0xFE, 0x0F, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFB, 0xCF, 0xC6, 0xF7, 0x80, 0x3D, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xC0, 0x3E, 0x7C, 0x00, 0x11, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xA0, 0x00, 0x1E, 0xF0, 0x01, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x7D, 0xE0, 0x00, 0x6E, 0xF8, 0x00, 0x77, 0x3F, 0x00, 0xF3, 0x8F, 0xFF,
  0xF1, 0xC3, 0xFF, 0xF0, 0xE0, 0xFF, 0xF0, 0x70, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xB8, 0x00, 0x0F,
  0xC0, 0x00, 0xE7, 0x80, 0x01, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x77, 0x00,
  0x07, 0x9E, 0x00, 0x0E, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xDE, 0x00, 0x1C,
  0x3C, 0x00, 0x79, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x38, 0x00, 0xF0, 0xF0,
  0x01, 0xC7, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0xF0, 0x03, 0x81, 0xE0, 0x0F,
  0x0E, 0x00, 0xF0, 0x3C, 0x01, 0xE1, 0xC0, 0x1E, 0x07, 0x80, 0x38, 0x3C,
  0x03, 0xC0, 0x70, 0x0F, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x70, 0x1E,
  0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x03,
  0x81, 0xE0, 0x3C, 0x0E, 0x00, 0x78, 0x3C, 0x03, 0x83, 0xC0, 0x0F, 0x07,
  0x00, 0x78, 0x78, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x1C, 0x3C, 0x00,
  0xE1, 0xC0, 0x03, 0xC7, 0x00, 0x1C, 0x78, 0x00, 0x78, 0xE0, 0x03, 0xCF,
  0x00, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x80, 0x07, 0x38, 0x00,
  0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xDC, 0x00, 0x1F, 0xE0, 0x00, 0x3B,
  0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xC0,
  0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x83, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x13, 0xFF, 0xC0, 0x01, 0x7F, 0xFF, 0x00, 0x3F, 0x03, 0xFF, 0x1F,
  0xE0, 0x07, 0xFF, 0xE8, 0x00, 0x1F, 0xFC, 0x80, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 49, 16, 5, -48 },
  { 38, 15, 17, 24, 4, -48 },
  { 70, 35, 48, 38, 2, -48 },
  { 280, 26, 55, 34, 4, -51 },
  { 459, 43, 50, 50, 3, -49 },
  { 728, 37, 50, 41, 3, -49 },
  { 960, 5, 17, 13, 4, -48 },
  { 971, 13, 59, 19, 3, -48 },
  { 1067, 14, 59, 19, 2, -48 },
  { 1171, 26, 25, 32, 3, -51 },
  { 1253, 28, 31, 34, 3, -39 },
  { 1362, 7, 17, 15, 3, -8 },
  { 1377, 16, 4, 20, 2, -20 },
  { 1385, 6, 7, 15, 5, -6 },
  { 1391, 21, 48, 23, 1, -48 },
  { 1517, 28, 50, 34, 3, -49 },
  { 1692, 15, 48, 34, 6, -48 },
  { 1782, 27, 49, 34, 3, -49 },
  { 1948, 27, 50, 34, 3, -49 },
  { 2117, 32, 48, 34, 1, -48 },
  { 2309, 27, 49, 34, 4, -48 },
  { 2475, 27, 50, 34, 4, -49 },
  { 2644, 28, 48, 34, 3, -48 },
  { 2812, 28, 50, 34, 3, -49 },
  { 2987, 27, 50, 34, 3, -49 },
  { 3156, 6, 37, 15, 5, -36 },
  { 3184, 9, 45, 15, 2, -36 },
  { 3235, 28, 30, 34, 3, -39 },
  { 3340, 28, 17, 34, 3, -32 },
  { 3400, 28, 30, 34, 3, -39 },
  { 3505, 22, 50, 25, 1, -49 },
  { 3643, 46, 54, 53, 4, -48 },
  { 3954, 36, 48, 36, 0, -48 },
  { 4170, 29, 48, 38, 6, -48 },
  { 4344, 31, 50, 37, 4, -49 },
  { 4538, 32, 48, 42, 6, -48 },
  { 4730, 23, 48, 33, 6, -48 },
  { 4868, 23, 48, 30, 6, -48 },
  { 5006, 35, 50, 44, 4, -49 },
  { 5225, 31, 48, 43, 6, -48 },
  { 5411, 13, 48, 19, 3, -48 },
  { 5489, 15, 60, 16, -5, -48 },
  { 5602, 29, 48, 35, 6, -48 },
  { 5776, 23, 48, 31, 6, -48 },
  { 5914, 42, 48, 54, 6, -48 },
  { 6166, 32, 48, 44, 6, -48 },
  { 6358, 38, 50, 46, 4, -49 },
  { 6596, 26, 48, 35, 6, -48 },
  { 6752, 38, 60, 46, 4, -49 },
  { 7037, 29, 48, 36, 6, -48 },
  { 7211, 27, 50, 33, 3, -49 },
  { 7380, 31, 48, 31, 0, -48 },
  { 7566, 31, 49, 43, 6, -48 },
  { 7756, 35, 48, 35, 0, -48 },
  { 7966, 53, 48, 55, 1, -48 },
  { 8284, 32, 48, 32, 0, -48 },
  { 8476, 31, 48, 31, 0, -48 },
  { 8662, 29, 48, 33, 2, -48 },
  { 8836, 14, 59, 21, 5, -48 },
  { 8940, 21, 48, 23, 1, -48 },
  { 9066, 14, 59, 21, 2, -48 },
  { 9170, 30, 28, 35, 2, -48 },
  { 9275, 28, 3, 28, 0, 6 },
  { 9286, 12, 10, 17, 3, -51 },
  { 9301, 24, 37, 32, 3, -36 },
  { 9412, 28, 52, 36, 5, -51 },
  { 9594, 22, 37, 28, 4, -36 },
  { 9696, 28, 52, 36, 3, -51 },
  { 9878, 26, 37, 33, 4, -36 },
  { 9999, 21, 51, 19, 1, -51 },
  { 10133, 28, 52, 36, 3, -36 },
  { 10315, 26, 51, 36, 5, -51 },
  { 10481, 5, 49, 15, 5, -49 },
  { 10512, 12, 65, 15, -2, -49 },
  { 10610, 25, 51, 30, 5, -51 },
  { 10770, 4, 51, 14, 5, -51 },
  { 10796, 44, 36, 54, 5, -36 },
  { 10994, 26, 36, 36, 5, -36 },
  { 11111, 29, 37, 35, 3, -36 },
  { 11246, 28, 52, 36, 5, -36 },
  { 11428, 28, 52, 36, 3, -36 },
  { 11610, 18, 36, 24, 5, -36 },
  { 11691, 22, 37, 28, 3, -36 },
  { 11793, 18, 45, 20, 1, -44 },
  { 11895, 25, 37, 36, 5, -36 },
  { 12011, 28, 36, 28, 0, -36 },
  { 12137, 43, 36, 45, 1, -36 },
  { 12331, 27, 36, 30, 1, -36 },
  { 12453, 28, 52, 28, 0, -36 },
  { 12635, 22, 36, 27, 2, -36 },
  { 12734, 19, 59, 24, 2, -48 },
  { 12875, 3, 67, 33, 15, -51 },
  { 12901, 19, 59, 24, 3, -48 },
  { 13042, 28, 7, 34, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_Light67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT67PT7B_H_
