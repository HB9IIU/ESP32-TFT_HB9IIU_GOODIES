#ifndef _NOTOSANS_SEMICONDENSED_LIGHT55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light55pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x00, 0x00, 0x1D, 0xFF,
  0xFF, 0xC4, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x6C, 0x06, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x18,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0x8C, 0x3C, 0x78, 0x30, 0x11, 0xC0, 0xC0,
  0x0E, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x0E,
  0x03, 0x00, 0x38, 0x0C, 0x00, 0xF0, 0x30, 0x01, 0xE0, 0xC0, 0x03, 0xC3,
  0x00, 0x0F, 0xCC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x37, 0xE0, 0x00, 0xC7, 0xC0, 0x03, 0x07, 0x80,
  0x0C, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C,
  0x07, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0xA0, 0x0C, 0x1E,
  0xE0, 0x31, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0xFF, 0xC0,
  0x03, 0x80, 0x3C, 0x38, 0x00, 0x70, 0x07, 0x03, 0x80, 0x0C, 0x00, 0xC0,
  0x70, 0x03, 0x80, 0x38, 0x06, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x1C, 0x03, 0x80, 0xE0, 0x03, 0x00, 0x70, 0x18,
  0x00, 0x60, 0x0E, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0x38,
  0x38, 0x00, 0x30, 0x07, 0x07, 0x00, 0x06, 0x00, 0xE1, 0xC0, 0x00, 0xE0,
  0x1C, 0x38, 0x7E, 0x1C, 0x03, 0x8E, 0x1F, 0xE3, 0x80, 0x61, 0xC7, 0x9E,
  0x30, 0x1C, 0x71, 0xC1, 0xC7, 0x03, 0x8E, 0x38, 0x1C, 0xF0, 0xE3, 0x86,
  0x03, 0x8F, 0xFC, 0x71, 0xC0, 0x30, 0xFF, 0x0C, 0x38, 0x07, 0x07, 0x83,
  0x87, 0x00, 0xE0, 0x00, 0x60, 0xE0, 0x1C, 0x00, 0x1C, 0x18, 0x03, 0x80,
  0x03, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x60, 0x0E, 0x00, 0x18, 0x0C, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x38, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x00, 0x38,
  0x01, 0x80, 0xE0, 0x0E, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x03, 0x87, 0x00,
  0x70, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x01,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x23,
  0xE1, 0xE0, 0x07, 0x0E, 0x03, 0xC0, 0x1C, 0x78, 0x07, 0x80, 0x73, 0xC0,
  0x0F, 0x03, 0xCE, 0x00, 0x1C, 0x0E, 0x38, 0x00, 0x38, 0x38, 0xE0, 0x00,
  0xF1, 0xC3, 0x80, 0x01, 0xE7, 0x0E, 0x00, 0x03, 0xF8, 0x38, 0x00, 0x07,
  0xE0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF8,
  0x1E, 0x00, 0x1E, 0xF0, 0x7C, 0x00, 0xF1, 0xE0, 0xFC, 0x1F, 0x83, 0xC1,
  0xFF, 0xFC, 0x07, 0x81, 0xFF, 0xC0, 0x0F, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0xF0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xF0, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x18,
  0x0C, 0x06, 0xFC, 0x61, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xE0, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xEC, 0x00, 0x0E, 0x70, 0x00, 0x71, 0xC0, 0x07,
  0x0F, 0x00, 0x70, 0x38, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x80, 0x40, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x71, 0xCF, 0x38, 0xE3,
  0x8E, 0x71, 0xC7, 0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xBF,
  0xFF, 0x10, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0xF0,
  0x1E, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1E, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xF7,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x78, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0xC0,
  0x07, 0x07, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x3E, 0x3F, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x7F,
  0x0F, 0x73, 0xE7, 0x78, 0x7F, 0x07, 0xE0, 0x74, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF8, 0x1F, 0x81, 0xF0, 0xF0, 0x01, 0xE1, 0x80, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0x83, 0xF0, 0x0F, 0x87, 0x80, 0x0F, 0x84, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xCE, 0x00, 0x0F, 0x1F, 0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x7E, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0x80, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE8, 0x00, 0x0F,
  0x38, 0x00, 0x78, 0xFC, 0x0F, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0x00, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0xFF, 0x81, 0xC7, 0xFF, 0x83, 0x9F, 0x0F, 0x87, 0x70, 0x07, 0x8E,
  0xC0, 0x07, 0x9F, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xF0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x78, 0xF0, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xE0, 0x0F,
  0x01, 0xF0, 0x7C, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x78, 0x3C,
  0x00, 0xF0, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x78, 0x00, 0x38,
  0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0x83, 0xC0, 0x1F,
  0x3E, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3E, 0x3F,
  0x01, 0xE0, 0x3E, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0xDE, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xFC, 0x0F, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0x81, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x00, 0x07,
  0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x1F,
  0x78, 0x00, 0xDC, 0xF0, 0x07, 0x71, 0xFF, 0xF9, 0xC3, 0xFF, 0xC7, 0x03,
  0xFC, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x80,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x67, 0xBF,
  0xFF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xBD, 0xFF, 0xF8, 0x80, 0x18, 0x78, 0xF9, 0xF3, 0xC3, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0xE1,
  0x87, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x7C, 0x40,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x3F, 0xF0, 0x0C, 0x38, 0x03, 0xFF, 0xE0,
  0x39, 0xC0, 0x1F, 0x03, 0x80, 0xE7, 0x00, 0xF0, 0x0E, 0x01, 0x9C, 0x03,
  0x80, 0x38, 0x06, 0x60, 0x1C, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x03, 0x80,
  0x7E, 0x01, 0x80, 0x0C, 0x01, 0xF8, 0x0E, 0x00, 0x30, 0x07, 0xE0, 0x38,
  0x00, 0xC0, 0x1F, 0x80, 0xE0, 0x03, 0x00, 0x7E, 0x03, 0x80, 0x1C, 0x01,
  0xF8, 0x0E, 0x00, 0x70, 0x06, 0xE0, 0x38, 0x01, 0xC0, 0x1B, 0x80, 0xE0,
  0x07, 0x00, 0xEE, 0x03, 0x80, 0x1C, 0x03, 0xB8, 0x06, 0x00, 0xF0, 0x0C,
  0xE0, 0x1C, 0x03, 0xE0, 0x71, 0x80, 0x78, 0x19, 0x83, 0x87, 0x00, 0xFB,
  0xE7, 0xBE, 0x1C, 0x01, 0xFF, 0x0F, 0xF0, 0x70, 0x01, 0xF0, 0x1F, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x38,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0x80, 0xFF, 0xC7, 0x00,
  0x07, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x38,
  0xE0, 0x01, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0E,
  0x00, 0x1F, 0x1C, 0x00, 0x0F, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xF7, 0x00, 0x07, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xE0, 0x1E, 0x03, 0xE0, 0x00, 0x81,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x80, 0x7F, 0x07, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0xFC, 0x0E, 0x00,
  0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0F, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x83, 0x80, 0x03, 0xF0, 0x70, 0x01, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEE, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xB8, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x0F, 0x80,
  0x00, 0x70, 0x3E, 0x00, 0x03, 0x80, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0x60, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xFF, 0xFF,
  0xFC, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x1E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0,
  0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00,
  0xE0, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0xC0, 0x00,
  0xEF, 0xE0, 0x00, 0xEE, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0xF0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0x80, 0x00,
  0x03, 0x7E, 0xE0, 0x00, 0x01, 0xDF, 0xB8, 0x00, 0x00, 0x77, 0xE7, 0x00,
  0x00, 0x39, 0xF9, 0xC0, 0x00, 0x0E, 0x7E, 0x70, 0x00, 0x03, 0x9F, 0x8E,
  0x00, 0x01, 0xC7, 0xE3, 0x80, 0x00, 0x71, 0xF8, 0x70, 0x00, 0x1C, 0x7E,
  0x1C, 0x00, 0x0E, 0x1F, 0x87, 0x00, 0x03, 0x87, 0xE0, 0xE0, 0x00, 0xC1,
  0xF8, 0x38, 0x00, 0x70, 0x7E, 0x0E, 0x00, 0x1C, 0x1F, 0x81, 0xC0, 0x0E,
  0x07, 0xE0, 0x70, 0x03, 0x81, 0xF8, 0x1C, 0x00, 0xE0, 0x7E, 0x03, 0x80,
  0x70, 0x1F, 0x80, 0xE0, 0x1C, 0x07, 0xE0, 0x3C, 0x07, 0x01, 0xF8, 0x07,
  0x03, 0x80, 0x7E, 0x01, 0xC0, 0xE0, 0x1F, 0x80, 0x38, 0x38, 0x07, 0xE0,
  0x0E, 0x1C, 0x01, 0xF8, 0x03, 0x87, 0x00, 0x7E, 0x00, 0x71, 0x80, 0x1F,
  0x80, 0x1C, 0xE0, 0x07, 0xE0, 0x07, 0x38, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1C, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0xE0, 0x00, 0x1F, 0x9C, 0x00, 0x07,
  0xE7, 0x80, 0x01, 0xF8, 0xE0, 0x00, 0x7E, 0x3C, 0x00, 0x1F, 0x87, 0x00,
  0x07, 0xE1, 0xE0, 0x01, 0xF8, 0x38, 0x00, 0x7E, 0x07, 0x00, 0x1F, 0x81,
  0xE0, 0x07, 0xE0, 0x38, 0x01, 0xF8, 0x0F, 0x00, 0x7E, 0x01, 0xC0, 0x1F,
  0x80, 0x78, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x01, 0xC0, 0x7E, 0x00, 0x78,
  0x1F, 0x80, 0x0E, 0x07, 0xE0, 0x03, 0xC1, 0xF8, 0x00, 0x70, 0x7E, 0x00,
  0x1E, 0x1F, 0x80, 0x03, 0xC7, 0xE0, 0x00, 0x71, 0xF8, 0x00, 0x1E, 0x7E,
  0x00, 0x03, 0x9F, 0x80, 0x00, 0xF7, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x38, 0x3F, 0xF1, 0xC0, 0x07, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3B,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x79, 0xC0, 0x0F,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x03,
  0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xC0, 0x3C, 0x3C, 0x00, 0x11,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0xC0, 0x01, 0xE3, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0xF8, 0x1F, 0xC1, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x38, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xB8, 0x00, 0x0F, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xB0, 0x00, 0x1C, 0xF0,
  0x00, 0x77, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0xE0, 0x00, 0xF1, 0xC0, 0x01,
  0xDC, 0x00, 0x1C, 0x38, 0x00, 0x3B, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x38,
  0x00, 0x70, 0x70, 0x01, 0xC7, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0xE0, 0x03,
  0x81, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x03,
  0x80, 0x38, 0x38, 0x03, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x01,
  0xC0, 0x78, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x0E, 0x0F, 0x00,
  0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x38, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0x7B, 0x80, 0x03, 0xBC, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0xDC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C,
  0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x78,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x0E, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x00,
  0x7C, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC1, 0xE0, 0x3E, 0x08, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x07, 0xFF, 0x03, 0xFF,
  0xF0, 0xFF, 0x07, 0x1F, 0x00, 0x73, 0xC0, 0x07, 0x78, 0x00, 0x77, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x70,
  0x00, 0xF7, 0x00, 0x1B, 0x78, 0x03, 0xB3, 0xE0, 0xF3, 0x1F, 0xFE, 0x30,
  0xFF, 0x83, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0x1C, 0x3F, 0xF0, 0x38, 0xFF, 0xF8,
  0x73, 0xC0, 0xF8, 0xEE, 0x00, 0x79, 0xD8, 0x00, 0xF3, 0xE0, 0x00, 0xF7,
  0xC0, 0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0xC0, 0x01,
  0xEF, 0x80, 0x03, 0x9D, 0x80, 0x0F, 0x3B, 0x80, 0x3C, 0x73, 0xC1, 0xF0,
  0xE3, 0xFF, 0xC1, 0xC3, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xC0, 0x61, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x87, 0xE0, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xFC, 0x1C, 0x0F,
  0xFC, 0x70, 0xFF, 0xF9, 0xC7, 0xC0, 0x77, 0x1E, 0x00, 0xFC, 0xF0, 0x01,
  0xB7, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x01, 0xB3, 0xE0, 0x0E, 0xC7, 0xE0,
  0xF3, 0x0F, 0xFF, 0x8C, 0x0F, 0xF8, 0x30, 0x02, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1E, 0x07, 0xC1, 0xC0, 0x0E, 0x1E,
  0x00, 0x78, 0xE0, 0x01, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x04, 0x1F, 0x83, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x07,
  0xFF, 0xE3, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x30, 0xFF, 0xF8, 0xC7, 0xC0,
  0x73, 0x1E, 0x00, 0xFC, 0xF0, 0x01, 0xF7, 0x80, 0x03, 0xDC, 0x00, 0x0F,
  0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x77, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0,
  0x01, 0xF1, 0xE0, 0x0D, 0xC7, 0xE0, 0xF7, 0x0F, 0xFF, 0x9C, 0x0F, 0xF8,
  0x70, 0x02, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE4, 0x00,
  0x07, 0x8C, 0x00, 0x7C, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xE0, 0x70,
  0xFF, 0xE3, 0x8F, 0xFF, 0x9C, 0xF0, 0x3E, 0xEE, 0x00, 0xF7, 0x60, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x81, 0xEF, 0xF3, 0xFC, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0,
  0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00,
  0xE7, 0xE0, 0x0E, 0xEE, 0x00, 0xFC, 0xF0, 0x0F, 0x87, 0x80, 0xF0, 0x38,
  0x0F, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x1E, 0xE0,
  0x00, 0xEE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x0E, 0x1F, 0xF0, 0x1F, 0xF8, 0xE7, 0xFF, 0x87, 0xFF, 0xCE, 0x70, 0x3C,
  0xF0, 0x3C, 0xEC, 0x01, 0xEC, 0x01, 0xEF, 0x80, 0x0F, 0xC0, 0x0E, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x00,
  0x7F, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x07,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x3E, 0x07, 0x0F, 0xFE, 0x38, 0xFF, 0xF9, 0xCE, 0x03, 0xEE, 0xE0, 0x0F,
  0x76, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0xF8, 0x0F, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x07, 0x0E,
  0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0x3C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x78, 0x00, 0xF0, 0x78, 0x03, 0xC0,
  0x7C, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x3E, 0x01, 0xC3, 0xFF, 0x83, 0x8F, 0xFF, 0x87, 0x3C, 0x0F, 0x8E,
  0xE0, 0x07, 0x9D, 0x80, 0x0F, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x0E, 0xF0,
  0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x39,
  0xD8, 0x00, 0xF3, 0xB8, 0x03, 0xC7, 0x3C, 0x1F, 0x0E, 0x3F, 0xFC, 0x1C,
  0x1F, 0xF0, 0x38, 0x02, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x30, 0xFF, 0xF8,
  0xC7, 0xC0, 0xF3, 0x3C, 0x00, 0xEC, 0xF0, 0x01, 0xF7, 0x80, 0x03, 0xDC,
  0x00, 0x0F, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00,
  0x7C, 0xF0, 0x01, 0xF3, 0xE0, 0x0D, 0xC7, 0xC0, 0xF7, 0x0F, 0xFF, 0x9C,
  0x0F, 0xF8, 0x70, 0x03, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x7D, 0xC3, 0xFF, 0x8F, 0xF7, 0x3C, 0x2E, 0xE0,
  0x1D, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1E, 0x01, 0xC7, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x3B, 0x00, 0x0F, 0x7C, 0x07, 0xCF, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0x20, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x10, 0x7F, 0xC0, 0xFF, 0x00, 0x20, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEE, 0x00, 0x1F, 0x78, 0x01,
  0xFB, 0xC0, 0x1D, 0xCF, 0x83, 0xCE, 0x3F, 0xFC, 0x70, 0xFF, 0xC3, 0x80,
  0x30, 0x00, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0xC0,
  0x01, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x07, 0xB8, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0x1B, 0x80, 0x1C,
  0xE0, 0x07, 0x70, 0x03, 0x9E, 0x00, 0xEE, 0x00, 0xF1, 0xC0, 0x1C, 0xC0,
  0x1C, 0x38, 0x03, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x70, 0xF0, 0x1C,
  0x70, 0x1E, 0x0E, 0x03, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x1C, 0x0E, 0x07, 0x83, 0x83, 0x81, 0xC0, 0x70, 0xE0, 0x38, 0x70,
  0x0E, 0x1C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x1C, 0x70, 0x0C,
  0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x0E, 0x70,
  0x07, 0x38, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x80, 0x07, 0x1C,
  0x00, 0x1C, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0xE1, 0xC0, 0x07, 0x83, 0x80, 0x1C, 0x0F, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0x38, 0x1C, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x9C,
  0x00, 0x0E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x03,
  0xC0, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x67, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x3F, 0x80, 0x78, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0x7F, 0xF8, 0x03, 0xF8, 0xFE, 0x0F,
  0xE0, 0x1F, 0xFE, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 40, 13, 4, -39 },
  { 26, 12, 14, 19, 4, -39 },
  { 47, 29, 39, 31, 1, -39 },
  { 189, 22, 45, 28, 3, -42 },
  { 313, 35, 41, 41, 3, -40 },
  { 493, 30, 41, 34, 3, -40 },
  { 647, 3, 14, 11, 4, -39 },
  { 653, 11, 48, 15, 2, -39 },
  { 719, 11, 48, 15, 2, -39 },
  { 785, 21, 21, 27, 3, -42 },
  { 841, 24, 26, 28, 2, -32 },
  { 919, 6, 13, 12, 2, -6 },
  { 929, 13, 3, 17, 2, -16 },
  { 934, 5, 6, 13, 4, -5 },
  { 938, 17, 39, 19, 1, -39 },
  { 1021, 22, 41, 28, 3, -40 },
  { 1134, 12, 39, 28, 5, -39 },
  { 1193, 22, 40, 28, 3, -40 },
  { 1303, 23, 41, 28, 2, -40 },
  { 1421, 26, 39, 28, 1, -39 },
  { 1548, 22, 40, 28, 3, -39 },
  { 1658, 23, 41, 28, 3, -40 },
  { 1776, 22, 39, 28, 3, -39 },
  { 1884, 22, 41, 28, 3, -40 },
  { 1997, 22, 41, 28, 3, -40 },
  { 2110, 5, 31, 13, 4, -30 },
  { 2130, 7, 37, 13, 2, -30 },
  { 2163, 24, 25, 28, 2, -32 },
  { 2238, 23, 14, 28, 3, -26 },
  { 2279, 24, 25, 28, 2, -32 },
  { 2354, 18, 41, 21, 1, -40 },
  { 2447, 38, 44, 44, 3, -39 },
  { 2656, 29, 39, 30, 0, -39 },
  { 2798, 23, 39, 31, 5, -39 },
  { 2911, 26, 41, 30, 3, -40 },
  { 3045, 27, 39, 35, 5, -39 },
  { 3177, 19, 39, 27, 5, -39 },
  { 3270, 19, 39, 25, 5, -39 },
  { 3363, 29, 41, 36, 3, -40 },
  { 3512, 25, 39, 35, 5, -39 },
  { 3634, 11, 39, 16, 2, -39 },
  { 3688, 12, 49, 13, -4, -39 },
  { 3762, 24, 39, 29, 5, -39 },
  { 3879, 19, 39, 25, 5, -39 },
  { 3972, 34, 39, 44, 5, -39 },
  { 4138, 26, 39, 36, 5, -39 },
  { 4265, 31, 41, 37, 3, -40 },
  { 4424, 21, 39, 29, 5, -39 },
  { 4527, 31, 49, 37, 3, -40 },
  { 4717, 24, 39, 30, 5, -39 },
  { 4834, 22, 41, 27, 3, -40 },
  { 4947, 25, 39, 26, 0, -39 },
  { 5069, 26, 40, 35, 5, -39 },
  { 5199, 28, 39, 28, 0, -39 },
  { 5336, 43, 39, 45, 1, -39 },
  { 5546, 26, 39, 26, 0, -39 },
  { 5673, 26, 39, 26, 0, -39 },
  { 5800, 23, 39, 27, 2, -39 },
  { 5913, 11, 48, 17, 5, -39 },
  { 5979, 17, 39, 19, 1, -39 },
  { 6062, 11, 48, 17, 2, -39 },
  { 6128, 25, 22, 28, 2, -39 },
  { 6197, 23, 2, 23, 0, 5 },
  { 6203, 10, 9, 14, 2, -42 },
  { 6215, 20, 31, 27, 2, -30 },
  { 6293, 23, 43, 30, 4, -42 },
  { 6417, 19, 31, 23, 3, -30 },
  { 6491, 22, 43, 30, 3, -42 },
  { 6610, 21, 31, 27, 3, -30 },
  { 6692, 17, 42, 15, 1, -42 },
  { 6782, 22, 43, 30, 3, -30 },
  { 6901, 21, 42, 29, 4, -42 },
  { 7012, 4, 40, 12, 4, -40 },
  { 7032, 10, 53, 12, -2, -40 },
  { 7099, 20, 42, 24, 4, -42 },
  { 7204, 3, 42, 12, 4, -42 },
  { 7220, 36, 30, 44, 4, -30 },
  { 7355, 21, 30, 29, 4, -30 },
  { 7434, 23, 31, 29, 3, -30 },
  { 7524, 23, 43, 30, 4, -30 },
  { 7648, 22, 43, 30, 3, -30 },
  { 7767, 15, 30, 19, 4, -30 },
  { 7824, 19, 31, 23, 2, -30 },
  { 7898, 14, 37, 17, 1, -36 },
  { 7963, 21, 30, 29, 4, -29 },
  { 8042, 23, 29, 23, 0, -29 },
  { 8126, 35, 29, 37, 1, -29 },
  { 8253, 22, 29, 24, 1, -29 },
  { 8333, 23, 42, 23, 0, -29 },
  { 8454, 18, 29, 22, 2, -29 },
  { 8520, 15, 48, 20, 2, -39 },
  { 8610, 3, 55, 27, 12, -42 },
  { 8631, 16, 48, 20, 2, -39 },
  { 8727, 24, 6, 28, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Light55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT55PT7B_H_
