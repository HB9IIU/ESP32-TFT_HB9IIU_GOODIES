#ifndef _NOTOSANS_SEMICONDENSED_LIGHT32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light32pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD2, 0x40, 0x07, 0xD8, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0x03, 0x0C, 0x01, 0x06, 0x00, 0x82, 0x00,
  0x41, 0x00, 0x60, 0x80, 0x30, 0x40, 0x18, 0x60, 0xFF, 0xFF, 0x04, 0x18,
  0x02, 0x08, 0x03, 0x04, 0x01, 0x82, 0x00, 0xC3, 0x00, 0x41, 0x83, 0xFF,
  0xF9, 0xFF, 0xFC, 0x18, 0x20, 0x0C, 0x10, 0x06, 0x18, 0x02, 0x0C, 0x01,
  0x06, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x06, 0x00, 0x60, 0x1F, 0xC7, 0xFF,
  0xE6, 0x2C, 0x60, 0x86, 0x08, 0x60, 0xC6, 0x0C, 0x60, 0x76, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x06, 0x60, 0x63, 0x06, 0x10, 0x61, 0x06, 0x10, 0x63,
  0x86, 0x7F, 0xFE, 0x7F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x03, 0x06,
  0x60, 0x20, 0xC2, 0x06, 0x08, 0x30, 0x60, 0x83, 0x0C, 0x08, 0x30, 0xC0,
  0x83, 0x18, 0x08, 0x31, 0x80, 0x83, 0x30, 0x08, 0x33, 0x3C, 0x83, 0x26,
  0xEC, 0x26, 0x42, 0x66, 0x4C, 0x33, 0xCC, 0xC3, 0x00, 0x8C, 0x30, 0x18,
  0x81, 0x01, 0x08, 0x10, 0x30, 0x83, 0x02, 0x0C, 0x30, 0x60, 0xC3, 0x04,
  0x0C, 0x20, 0xC0, 0x66, 0x08, 0x03, 0xC0, 0x0F, 0x80, 0x0C, 0xE0, 0x0C,
  0x18, 0x04, 0x0C, 0x02, 0x06, 0x01, 0x03, 0x00, 0xC1, 0x80, 0x61, 0x80,
  0x19, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x30, 0x33, 0x0C,
  0x1B, 0x03, 0x0D, 0x80, 0xC4, 0x80, 0x76, 0x40, 0x1F, 0x20, 0x07, 0x18,
  0x03, 0x8E, 0x03, 0x63, 0xC7, 0x18, 0xFE, 0x0E, 0xFF, 0xFF, 0x06, 0x18,
  0x60, 0xC3, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x60,
  0xC0, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30, 0xC1,
  0x83, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x41, 0x04,
  0x30, 0xC3, 0x0C, 0x61, 0x86, 0x30, 0xC6, 0x30, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x07, 0x27, 0xDF, 0xF8, 0x0C, 0x00, 0xB0, 0x0C, 0x80, 0xC6,
  0x0E, 0x18, 0x20, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x33, 0x26, 0x66, 0x4C, 0xFF,
  0x7F, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0x81,
  0xEE, 0x1C, 0x18, 0xC0, 0x44, 0x03, 0x60, 0x1B, 0x00, 0x58, 0x02, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x16, 0x01, 0x90, 0x0C, 0xC0, 0x66, 0x06, 0x1C, 0xE0, 0x7E, 0x00,
  0x06, 0x1C, 0x7B, 0xBE, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x1F, 0xC0, 0xF7,
  0x86, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC3, 0xEF, 0x38, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x38, 0x03,
  0x78, 0x79, 0xFF, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x0D, 0x80,
  0x1B, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x10, 0x60, 0x60,
  0xC1, 0x81, 0x83, 0x03, 0x0C, 0x06, 0x10, 0x0C, 0x60, 0x18, 0xFF, 0xFE,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x7F, 0xE3, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0xF8, 0x3F, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x68, 0x06, 0x70, 0xE1,
  0xFE, 0x00, 0x07, 0xE0, 0x79, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x7E, 0x36, 0x79, 0xC0, 0x6C, 0x03, 0x60,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD0, 0x06, 0xC0, 0x67, 0x03,
  0x1C, 0x70, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x1F, 0x81, 0xCF,
  0x18, 0x1D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xCC, 0x06, 0x70, 0x61,
  0xCE, 0x03, 0xC0, 0x3F, 0x03, 0x1C, 0x30, 0x33, 0x00, 0xD8, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x6E, 0x03, 0x38, 0x70, 0xFF, 0x00, 0x0F,
  0xC0, 0x7F, 0x83, 0x03, 0x18, 0x0C, 0x60, 0x19, 0x00, 0x64, 0x00, 0xB0,
  0x02, 0x40, 0x0D, 0x80, 0x76, 0x01, 0xDC, 0x0F, 0x38, 0x68, 0x7F, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x87, 0x03, 0xF8, 0x00, 0xFD, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x77,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x36, 0x66, 0x64, 0xC0, 0x00, 0x04,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x40, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x08, 0x00, 0x00, 0x7F, 0x3D, 0xE8, 0x1C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x01, 0x80, 0x00,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x18, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x90, 0x3F, 0x82, 0xC1, 0x82, 0x0B,
  0x0C, 0x08, 0x3C, 0x30, 0x20, 0xE0, 0x80, 0x83, 0x82, 0x06, 0x0E, 0x08,
  0x18, 0x38, 0x20, 0x60, 0xA0, 0x81, 0x82, 0x83, 0x06, 0x1B, 0x0C, 0x2C,
  0x4C, 0x1F, 0x9F, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x40, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x19, 0x00,
  0x08, 0xC0, 0x0C, 0x60, 0x06, 0x10, 0x02, 0x0C, 0x03, 0x06, 0x01, 0x81,
  0x00, 0x80, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x20, 0x0C, 0x30, 0x06, 0x18,
  0x03, 0x08, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x06,
  0xFF, 0x83, 0xFF, 0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x6C, 0x01,
  0xB0, 0x06, 0xC0, 0x33, 0x01, 0xCF, 0xFC, 0x3F, 0xF8, 0xC0, 0x73, 0x00,
  0x6C, 0x01, 0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xB0, 0x06, 0xC0,
  0x33, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0x7C, 0x70, 0x11, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xE3, 0x81, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0xC3, 0x01, 0xC6, 0x00, 0xCC, 0x00, 0xD8, 0x01,
  0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1B, 0x00,
  0x36, 0x00, 0xCC, 0x07, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF,
  0x7F, 0xEC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x00, 0x03, 0xFE, 0x07, 0xEF, 0x87, 0x00, 0x47, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x40,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x31, 0xC0, 0x18, 0x7C, 0x7C,
  0x1F, 0xFC, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0x80, 0xFE, 0x70,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x3F, 0x80, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x37, 0xCF, 0x00, 0xC0, 0x1F, 0x00,
  0xCC, 0x07, 0x30, 0x18, 0xC0, 0xC3, 0x06, 0x0C, 0x30, 0x31, 0xC0, 0xC6,
  0x03, 0x30, 0x0D, 0xC0, 0x3F, 0x00, 0xE6, 0x03, 0x0C, 0x0C, 0x30, 0x30,
  0x60, 0xC1, 0xC3, 0x03, 0x0C, 0x06, 0x30, 0x1C, 0xC0, 0x33, 0x00, 0x6C,
  0x01, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xFF, 0xF8, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xBD, 0x80,
  0x1B, 0xD8, 0x01, 0xBD, 0x80, 0x33, 0xCC, 0x03, 0x3C, 0xC0, 0x23, 0xC4,
  0x06, 0x3C, 0x60, 0x63, 0xC6, 0x04, 0x3C, 0x20, 0xC3, 0xC3, 0x0C, 0x3C,
  0x30, 0x83, 0xC1, 0x18, 0x3C, 0x19, 0x83, 0xC1, 0x90, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0xC0, 0x60, 0x30, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7B, 0x00, 0xF3, 0x01, 0xE6, 0x03, 0xC6,
  0x07, 0x8C, 0x0F, 0x0C, 0x1E, 0x0C, 0x3C, 0x18, 0x78, 0x18, 0xF0, 0x31,
  0xE0, 0x33, 0xC0, 0x67, 0x80, 0x6F, 0x00, 0x7E, 0x00, 0xDC, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0x80, 0x60, 0xC0,
  0x0C, 0x60, 0x03, 0x98, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0x98, 0x00, 0x66, 0x00, 0x18, 0xC0,
  0x0C, 0x38, 0x06, 0x07, 0xCF, 0x00, 0x7F, 0x80, 0xFF, 0x0F, 0xFC, 0xC0,
  0xEC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x0E, 0xFF, 0xCF, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01,
  0x80, 0x60, 0xC0, 0x0C, 0x60, 0x03, 0x98, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x18, 0xC0, 0x0C, 0x38, 0x06, 0x07, 0xCF, 0x00, 0x7F, 0x80, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0xFF, 0x03,
  0xFF, 0x0C, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x01, 0x30, 0x0C,
  0xC0, 0x33, 0x00, 0xCC, 0x06, 0x30, 0xF0, 0xFF, 0x03, 0x0C, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0xC3, 0x01, 0x8C, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0x6C, 0x01, 0xC0, 0x1F, 0xE7, 0xFF, 0x60, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x6F, 0x1C,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x37, 0x00, 0x66,
  0x01, 0x87, 0x8F, 0x07, 0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x46, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x06, 0x01, 0x03, 0x00, 0xC1, 0x80, 0x61, 0x80,
  0x10, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x01, 0x30, 0x00, 0xD8, 0x00, 0x68,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x80, 0x18, 0x01, 0xE0, 0x0C,
  0x00, 0xB0, 0x07, 0x00, 0xD8, 0x07, 0x80, 0x64, 0x03, 0xC0, 0x33, 0x01,
  0xA0, 0x11, 0x80, 0x98, 0x18, 0xC0, 0xCC, 0x0C, 0x20, 0x66, 0x06, 0x18,
  0x31, 0x02, 0x0C, 0x10, 0xC3, 0x06, 0x18, 0x61, 0x81, 0x0C, 0x30, 0xC0,
  0xC6, 0x08, 0x40, 0x62, 0x06, 0x60, 0x33, 0x03, 0x30, 0x09, 0x81, 0x98,
  0x06, 0xC0, 0x48, 0x03, 0x40, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x0F,
  0x00, 0x38, 0x03, 0x00, 0x18, 0x01, 0x80, 0x60, 0x06, 0xC0, 0x18, 0xC0,
  0x30, 0xC0, 0xC1, 0x81, 0x81, 0x86, 0x03, 0x18, 0x03, 0x30, 0x06, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xD8, 0x01, 0x98, 0x06,
  0x30, 0x0C, 0x30, 0x30, 0x60, 0x60, 0x61, 0x80, 0xC6, 0x00, 0xCC, 0x01,
  0xB0, 0x01, 0x80, 0xC0, 0x06, 0xC0, 0x19, 0x80, 0x31, 0x80, 0xC3, 0x01,
  0x82, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x1B, 0x00,
  0x36, 0x00, 0x38, 0x00, 0x70, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x3F, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0xFF, 0xFC, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x03, 0x00,
  0x0E, 0x00, 0x78, 0x01, 0xB0, 0x0C, 0xC0, 0x31, 0x81, 0x86, 0x06, 0x0C,
  0x30, 0x30, 0xC0, 0x66, 0x01, 0x98, 0x03, 0xC0, 0x0C, 0xFF, 0xF8, 0xE0,
  0xC1, 0x02, 0x04, 0x1F, 0xC3, 0x8E, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x7F, 0x3F, 0x37, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x60, 0x77, 0x1B, 0x3F, 0x10, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x13, 0xF8, 0xB1, 0xE5, 0x03, 0x30, 0x0D, 0x80,
  0x6C, 0x01, 0x40, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x05,
  0x80, 0x6C, 0x03, 0x70, 0x32, 0xE7, 0x93, 0xF0, 0x1F, 0xE7, 0x09, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0xC2, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x63, 0xF3, 0x38, 0xDB, 0x03,
  0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xB0, 0x1C, 0xE3, 0x63, 0xF3, 0x1F,
  0x83, 0x8C, 0x60, 0x64, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0xC7, 0x1F,
  0xE0, 0x07, 0xC3, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x83, 0xFC, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0x99, 0xC6, 0xD8, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1D, 0x81, 0xE7, 0x3B, 0x1F, 0x98, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x19, 0x01, 0x8F, 0xF8, 0x0F, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x09, 0xFC,
  0xB0, 0xEA, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0xFC, 0x00, 0x12, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x1C, 0x70, 0x00,
  0x00, 0x00, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0x1B, 0xCC, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x07, 0x81, 0x90, 0x32, 0x0C,
  0x43, 0x08, 0xC1, 0x30, 0x26, 0x05, 0xE0, 0xEE, 0x18, 0xC2, 0x0C, 0x41,
  0x88, 0x19, 0x01, 0xA0, 0x34, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0x8F, 0xCB,
  0x1D, 0xC6, 0xE0, 0xD0, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x38, 0x06, 0x03,
  0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60,
  0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06,
  0x03, 0x80, 0x60, 0x30, 0x9F, 0xCB, 0x8E, 0xA0, 0x6C, 0x02, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x1F, 0xC1, 0xC7, 0x18, 0x0C, 0xC0,
  0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xB0, 0x19, 0x80, 0xC7, 0x1C, 0x1F, 0xC0, 0x9F, 0xC5,
  0xCF, 0x28, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x0A, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x2C, 0x03, 0x60, 0x1A, 0x81, 0x97, 0x1C,
  0x9F, 0x84, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x00, 0x1F, 0x99, 0xC6, 0xD8, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1D, 0x81, 0xE7, 0x1B, 0x1F, 0x98, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x9F, 0xB9, 0xA0, 0xC0,
  0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x3F, 0xEE, 0x19, 0x80, 0x20, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1F, 0x0E, 0x7F,
  0x80, 0x10, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x90,
  0xF8, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xB0, 0x1D,
  0x81, 0xEF, 0x1B, 0x1F, 0x98, 0xC0, 0x1A, 0x00, 0xD8, 0x06, 0xC0, 0x62,
  0x03, 0x18, 0x18, 0xC1, 0x82, 0x0C, 0x18, 0x60, 0xC6, 0x02, 0x30, 0x19,
  0x80, 0xD8, 0x02, 0xC0, 0x14, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x30, 0x1B,
  0x03, 0x80, 0xD8, 0x1E, 0x04, 0xC0, 0xB0, 0x62, 0x05, 0x83, 0x18, 0x64,
  0x18, 0xC3, 0x30, 0x86, 0x11, 0x8C, 0x11, 0x8C, 0x60, 0xCC, 0x23, 0x06,
  0x61, 0x90, 0x32, 0x0D, 0x80, 0xB0, 0x2C, 0x07, 0x81, 0x60, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x06, 0x01, 0x80, 0xC0, 0x33, 0x03, 0x18, 0x18, 0x61,
  0x81, 0x8C, 0x0C, 0xC0, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x78, 0x03, 0x60,
  0x33, 0x03, 0x0C, 0x18, 0x61, 0x81, 0x8C, 0x06, 0xC0, 0x38, 0xC0, 0x1B,
  0x00, 0xD8, 0x06, 0xC0, 0x63, 0x03, 0x18, 0x18, 0xC1, 0x83, 0x0C, 0x18,
  0x60, 0xC6, 0x03, 0x30, 0x19, 0x80, 0xC8, 0x02, 0xC0, 0x1E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x1F,
  0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0x83, 0xC3, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x87, 0x83, 0xC0, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0xE0, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x3C, 0x0E,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x3E, 0x1C, 0x00, 0x3E, 0x07, 0xFE, 0x38, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Light32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 23, 7, 2, -23 },
  { 10, 7, 8, 11, 2, -23 },
  { 17, 17, 23, 18, 1, -23 },
  { 66, 12, 26, 16, 2, -24 },
  { 105, 20, 23, 24, 2, -23 },
  { 163, 17, 23, 20, 2, -23 },
  { 212, 2, 8, 6, 2, -23 },
  { 214, 7, 28, 9, 1, -23 },
  { 239, 6, 28, 9, 1, -23 },
  { 260, 13, 12, 15, 1, -24 },
  { 280, 14, 15, 16, 1, -19 },
  { 307, 4, 8, 7, 1, -4 },
  { 311, 8, 1, 10, 1, -9 },
  { 312, 3, 3, 7, 2, -3 },
  { 314, 11, 23, 11, 0, -23 },
  { 346, 13, 23, 16, 2, -23 },
  { 384, 7, 23, 16, 3, -23 },
  { 405, 14, 23, 16, 1, -23 },
  { 446, 13, 23, 16, 1, -23 },
  { 484, 15, 23, 16, 1, -23 },
  { 528, 13, 23, 16, 2, -23 },
  { 566, 13, 23, 16, 2, -23 },
  { 604, 14, 23, 16, 1, -23 },
  { 645, 13, 23, 16, 2, -23 },
  { 683, 14, 23, 16, 1, -23 },
  { 724, 3, 17, 7, 2, -17 },
  { 731, 4, 21, 7, 1, -17 },
  { 742, 14, 15, 16, 1, -19 },
  { 769, 14, 8, 16, 1, -15 },
  { 783, 14, 15, 16, 1, -19 },
  { 810, 10, 23, 12, 1, -23 },
  { 839, 22, 26, 25, 2, -23 },
  { 911, 17, 23, 17, 0, -23 },
  { 960, 14, 23, 18, 3, -23 },
  { 1001, 15, 23, 18, 2, -23 },
  { 1045, 15, 23, 20, 3, -23 },
  { 1089, 11, 23, 16, 3, -23 },
  { 1121, 11, 23, 15, 3, -23 },
  { 1153, 17, 23, 21, 2, -23 },
  { 1202, 15, 23, 21, 3, -23 },
  { 1246, 7, 23, 9, 1, -23 },
  { 1267, 7, 29, 8, -2, -23 },
  { 1293, 14, 23, 17, 3, -23 },
  { 1334, 11, 23, 15, 3, -23 },
  { 1366, 20, 23, 26, 3, -23 },
  { 1424, 15, 23, 21, 3, -23 },
  { 1468, 18, 23, 22, 2, -23 },
  { 1520, 12, 23, 17, 3, -23 },
  { 1555, 18, 28, 22, 2, -23 },
  { 1618, 14, 23, 17, 3, -23 },
  { 1659, 12, 23, 16, 2, -23 },
  { 1694, 15, 23, 15, 0, -23 },
  { 1738, 15, 23, 21, 3, -23 },
  { 1782, 17, 23, 17, 0, -23 },
  { 1831, 25, 23, 26, 1, -23 },
  { 1903, 15, 23, 15, 0, -23 },
  { 1947, 15, 23, 15, 0, -23 },
  { 1991, 14, 23, 16, 1, -23 },
  { 2032, 6, 28, 10, 3, -23 },
  { 2053, 11, 23, 11, 0, -23 },
  { 2085, 7, 28, 10, 1, -23 },
  { 2110, 14, 13, 16, 1, -23 },
  { 2133, 13, 1, 13, 0, 3 },
  { 2135, 6, 5, 8, 1, -24 },
  { 2139, 12, 17, 15, 1, -17 },
  { 2165, 13, 24, 17, 3, -24 },
  { 2204, 11, 17, 14, 2, -17 },
  { 2228, 13, 24, 17, 2, -24 },
  { 2267, 12, 17, 16, 2, -17 },
  { 2293, 10, 24, 9, 0, -24 },
  { 2323, 13, 25, 17, 2, -17 },
  { 2364, 12, 24, 17, 3, -24 },
  { 2400, 3, 23, 7, 2, -23 },
  { 2409, 6, 31, 7, -1, -23 },
  { 2433, 11, 24, 14, 3, -24 },
  { 2466, 1, 24, 7, 3, -24 },
  { 2469, 20, 17, 26, 3, -17 },
  { 2512, 12, 17, 17, 3, -17 },
  { 2538, 13, 17, 17, 2, -17 },
  { 2566, 13, 25, 17, 3, -17 },
  { 2607, 13, 25, 17, 2, -17 },
  { 2648, 8, 17, 11, 3, -17 },
  { 2665, 11, 17, 13, 1, -17 },
  { 2689, 9, 21, 10, 0, -21 },
  { 2713, 13, 17, 17, 2, -17 },
  { 2741, 13, 17, 13, 0, -17 },
  { 2769, 21, 17, 21, 0, -17 },
  { 2814, 13, 17, 14, 1, -17 },
  { 2842, 13, 25, 14, 0, -17 },
  { 2883, 11, 17, 13, 1, -17 },
  { 2907, 9, 28, 11, 1, -23 },
  { 2939, 2, 32, 16, 7, -24 },
  { 2947, 9, 28, 11, 1, -23 },
  { 2979, 14, 3, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Light32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT32PT7B_H_
