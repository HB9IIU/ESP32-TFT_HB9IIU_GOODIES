#ifndef _NOTOSANS_SEMICONDENSED_LIGHT61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light61pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0x8C, 0x60, 0x00, 0x00,
  0x00, 0x1E, 0xFF, 0xFF, 0xE6, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC,
  0x0E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xE0, 0x3B, 0x80, 0xEE,
  0x03, 0x98, 0x0E, 0x60, 0x39, 0x80, 0xE6, 0x03, 0x98, 0x0E, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x38, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x1F, 0x18, 0x7C, 0x3C, 0x18, 0x04, 0x78, 0x18, 0x00,
  0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0xF0, 0x18, 0x00, 0xF0, 0x18, 0x00,
  0xF0, 0x18, 0x00, 0xF0, 0x18, 0x00, 0xF0, 0x18, 0x00, 0x70, 0x18, 0x00,
  0x78, 0x18, 0x00, 0x3C, 0x18, 0x00, 0x1F, 0x18, 0x00, 0x0F, 0xD8, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x1B, 0xF8, 0x00, 0x18, 0x7C, 0x00, 0x18, 0x3E, 0x00, 0x18, 0x0F,
  0x00, 0x18, 0x0F, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07,
  0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x0F,
  0x00, 0x18, 0x1E, 0xC0, 0x18, 0x3E, 0xFC, 0x18, 0xFC, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x00, 0x79, 0xE0,
  0x00, 0x78, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x07, 0x81, 0xC0, 0x03, 0xC0,
  0x0E, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x01, 0xC0,
  0x0E, 0x1C, 0x0F, 0x03, 0x80, 0x38, 0x38, 0x7F, 0x83, 0x80, 0x70, 0xE1,
  0xFF, 0x87, 0x00, 0xE1, 0xC3, 0x87, 0x8E, 0x01, 0xC7, 0x0E, 0x07, 0x8E,
  0x07, 0x0E, 0x1C, 0x07, 0x1C, 0x1E, 0x3C, 0x70, 0x0E, 0x1F, 0xF8, 0x70,
  0xE0, 0x0E, 0x3F, 0xE0, 0xE1, 0xC0, 0x1C, 0x1F, 0x83, 0x83, 0x80, 0x38,
  0x00, 0x07, 0x06, 0x00, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x00, 0x38,
  0x38, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0x38,
  0x03, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x00, 0x78,
  0xF0, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1F, 0x07,
  0x80, 0x0F, 0x0F, 0x80, 0xF0, 0x03, 0xC3, 0xC0, 0x3E, 0x00, 0xE1, 0xE0,
  0x07, 0xC0, 0x38, 0x70, 0x00, 0xF0, 0x1E, 0x3C, 0x00, 0x1E, 0x07, 0x0F,
  0x00, 0x03, 0xC3, 0xC3, 0x80, 0x00, 0x78, 0xF0, 0xE0, 0x00, 0x0F, 0x78,
  0x38, 0x00, 0x03, 0xFE, 0x0E, 0x00, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x01, 0xFC, 0x07, 0x80, 0x00,
  0xFF, 0x80, 0xF0, 0x00, 0x7D, 0xF0, 0x3E, 0x00, 0x7E, 0x3E, 0x07, 0xFF,
  0xFE, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xE6, 0x66, 0x66,
  0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x60, 0x1C, 0x03, 0xF8, 0x38, 0x3F, 0xFF, 0x33, 0xFD, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x07,
  0x00, 0x78, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xC0, 0x1C, 0x00, 0x80, 0x10,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0x87, 0x0E,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xEF, 0xFE, 0x78,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07,
  0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0x70, 0xF1, 0xCF, 0x87, 0x7C, 0x1F, 0xE0,
  0x77, 0x01, 0xC8, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F,
  0x07, 0x80, 0x07, 0x81, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x79, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0xFC, 0x7F, 0x87, 0xFC, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x70, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x30, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x80, 0x00, 0xF8, 0xE0, 0x01, 0xF0, 0xFF, 0xBF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x00, 0x40, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x1F, 0xE0, 0x1C, 0x3F, 0xFC, 0x0E, 0x3F, 0xFF,
  0x07, 0x3C, 0x07, 0xC3, 0xB8, 0x00, 0xF3, 0xF8, 0x00, 0x3D, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x07, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x3C, 0x03, 0xF8, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xF0,
  0x0F, 0x81, 0xE0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCF,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x38, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0x87, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x39,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x0F, 0xE0, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x07, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0xFC, 0xF0, 0x00, 0xFE, 0x7C, 0x01,
  0xEF, 0x1F, 0xE7, 0xE7, 0x87, 0xFF, 0xE3, 0x80, 0xFF, 0xC1, 0xC0, 0x02,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1E, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x39, 0xEF, 0xFF, 0x79, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xDF, 0x78, 0xC0, 0x0C, 0x1E, 0x3F,
  0x3F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x60, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x80,
  0x7C, 0x60, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0xE3, 0xC0, 0x0F,
  0xFF, 0xC0, 0x38, 0xE0, 0x07, 0xC0, 0xF0, 0x0E, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xDC, 0x00, 0xE0, 0x07, 0x00, 0x77, 0x00, 0x70, 0x01, 0xC0, 0x1D,
  0xC0, 0x1C, 0x00, 0x70, 0x07, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xDC, 0x03,
  0x80, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x00,
  0x70, 0x07, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0x80, 0x0E, 0x00,
  0x7E, 0x01, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x78, 0x00, 0xE0, 0x07, 0xE0,
  0x1E, 0x00, 0x38, 0x01, 0xF8, 0x03, 0x80, 0x0E, 0x00, 0xEE, 0x00, 0xE0,
  0x07, 0x80, 0x39, 0xC0, 0x38, 0x01, 0xF0, 0x0E, 0x70, 0x0F, 0x00, 0xEC,
  0x07, 0x1C, 0x01, 0xE0, 0x73, 0x83, 0xC7, 0x00, 0x3E, 0x7C, 0xF3, 0xE1,
  0xC0, 0x0F, 0xFE, 0x1F, 0xF0, 0x38, 0x00, 0xFE, 0x03, 0xF8, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xE0, 0x00,
  0x7E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x3C, 0xE0,
  0x00, 0x0F, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xC3, 0x80,
  0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83,
  0x80, 0x01, 0xF0, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03,
  0xCE, 0x00, 0x01, 0xF3, 0x80, 0x00, 0xF8, 0xE0, 0x01, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x1E, 0x03, 0xE0,
  0x00, 0x60, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x60, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x0E, 0x00, 0x0F, 0xE0, 0x70, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x3E, 0x1C,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1F, 0x38, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0xC0, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x0C, 0x07, 0xC0, 0x00, 0x04, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x0F, 0x03, 0xF8,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3D, 0x07, 0xCF, 0xFE,
  0x7F, 0xE3, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0E,
  0x00, 0x0F, 0x83, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0xF0,
  0x0E, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x07,
  0x80, 0x0E, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x38,
  0x7C, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE7, 0xE0, 0x00,
  0x3B, 0xFC, 0x00, 0x0E, 0xEF, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xE3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3B, 0xFB, 0x80, 0x00, 0x00,
  0xEF, 0xEF, 0x00, 0x00, 0x07, 0xBF, 0x9C, 0x00, 0x00, 0x1C, 0xFE, 0x70,
  0x00, 0x00, 0x73, 0xF9, 0xE0, 0x00, 0x03, 0xCF, 0xE3, 0x80, 0x00, 0x0E,
  0x3F, 0x8E, 0x00, 0x00, 0x38, 0xFE, 0x3C, 0x00, 0x01, 0xE3, 0xF8, 0x70,
  0x00, 0x07, 0x0F, 0xE1, 0xC0, 0x00, 0x1C, 0x3F, 0x87, 0x80, 0x00, 0xE0,
  0xFE, 0x0E, 0x00, 0x03, 0x83, 0xF8, 0x3C, 0x00, 0x0E, 0x0F, 0xE0, 0xF0,
  0x00, 0x70, 0x3F, 0x81, 0xC0, 0x01, 0xC0, 0xFE, 0x07, 0x80, 0x0F, 0x03,
  0xF8, 0x0E, 0x00, 0x38, 0x0F, 0xE0, 0x38, 0x00, 0xE0, 0x3F, 0x80, 0xF0,
  0x07, 0x80, 0xFE, 0x01, 0xC0, 0x1C, 0x03, 0xF8, 0x07, 0x00, 0x70, 0x0F,
  0xE0, 0x1E, 0x03, 0xC0, 0x3F, 0x80, 0x38, 0x0E, 0x00, 0xFE, 0x00, 0xE0,
  0x38, 0x03, 0xF8, 0x03, 0xC1, 0xC0, 0x0F, 0xE0, 0x07, 0x07, 0x00, 0x3F,
  0x80, 0x1E, 0x3C, 0x00, 0xFE, 0x00, 0x78, 0xE0, 0x03, 0xF8, 0x00, 0xE3,
  0x80, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x00, 0xFE,
  0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xF8,
  0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x0F, 0xEF, 0x00, 0x00,
  0x7F, 0x3C, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0xFE,
  0x1C, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x3F, 0x83, 0xC0, 0x01, 0xFC, 0x1E,
  0x00, 0x0F, 0xE0, 0x78, 0x00, 0x7F, 0x03, 0xC0, 0x03, 0xF8, 0x0F, 0x00,
  0x1F, 0xC0, 0x38, 0x00, 0xFE, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x3F,
  0x80, 0x3C, 0x01, 0xFC, 0x00, 0xF0, 0x0F, 0xE0, 0x03, 0x80, 0x7F, 0x00,
  0x1E, 0x03, 0xF8, 0x00, 0x78, 0x1F, 0xC0, 0x03, 0xC0, 0xFE, 0x00, 0x0F,
  0x07, 0xF0, 0x00, 0x78, 0x3F, 0x80, 0x01, 0xE1, 0xFC, 0x00, 0x07, 0x0F,
  0xE0, 0x00, 0x3C, 0x7F, 0x00, 0x00, 0xF3, 0xF8, 0x00, 0x07, 0x9F, 0xC0,
  0x00, 0x1E, 0xFE, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8E, 0x00, 0x1F, 0x9C, 0x00,
  0x0F, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x07, 0x9C, 0x00, 0x1F, 0x38,
  0x01, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xF8, 0x38, 0x00, 0x1F,
  0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x00,
  0xF8, 0x38, 0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0xE0, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x07,
  0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xC0, 0x3E, 0x3E, 0x00, 0x04, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x01, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x03,
  0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0,
  0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x38, 0x00,
  0x0F, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0x3C, 0x00,
  0x0E, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0x1C, 0x00,
  0x1E, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x38, 0x1E, 0x00,
  0x1C, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x0E, 0x00,
  0x3C, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x0F, 0x00,
  0x38, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x07, 0x80,
  0x70, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x03, 0x80,
  0xF0, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x03, 0xC0,
  0xE0, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0x01, 0xC1,
  0xE0, 0x07, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x01, 0xE1,
  0xC0, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x03, 0x87, 0x80, 0x00, 0xE3,
  0xC0, 0x03, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x00, 0xF3,
  0x80, 0x01, 0xCF, 0x00, 0x00, 0xF3, 0x80, 0x01, 0xCF, 0x00, 0x00, 0x77,
  0x80, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0x80,
  0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xC0, 0x7C,
  0x18, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7E, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xDD, 0xE0, 0x0E, 0x77,
  0xF0, 0xF9, 0xCF, 0xFF, 0x87, 0x0F, 0xFC, 0x1C, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x03, 0xFC, 0x03, 0x87, 0xFF, 0x81, 0xC7, 0xFF,
  0xE0, 0xE7, 0x80, 0xF8, 0x77, 0x00, 0x1E, 0x3B, 0x00, 0x07, 0x9F, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1D, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x3D, 0xF0, 0x00, 0x3C, 0xFC, 0x00, 0x1E, 0x76, 0x00, 0x1E, 0x3B, 0xC0,
  0x1E, 0x1C, 0xFC, 0xFF, 0x0E, 0x3F, 0xFF, 0x07, 0x07, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC0,
  0x60, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x04, 0x1F, 0xEF, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x03, 0xF8, 0x1C, 0x0F, 0xFF, 0x0E, 0x0F, 0xFF, 0xC7, 0x0F, 0xC0,
  0xF3, 0x8F, 0x80, 0x1D, 0xC7, 0x80, 0x07, 0xE7, 0x80, 0x01, 0xF3, 0xC0,
  0x00, 0xFB, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x1F, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x0D, 0xC7, 0xC0, 0x1E, 0xE1, 0xFC,
  0x3E, 0x70, 0x7F, 0xFE, 0x38, 0x0F, 0xFC, 0x1C, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F,
  0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x02, 0x0F, 0x80, 0x0E, 0x07, 0xF8, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFC, 0x60, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xE1, 0xC1, 0xFF, 0xF8, 0xE1, 0xF8, 0x1E, 0x71, 0xF0, 0x03,
  0xB8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0x70, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x03,
  0xF1, 0xE0, 0x01, 0xB8, 0xF8, 0x03, 0xDC, 0x3F, 0x8F, 0xCE, 0x0F, 0xFF,
  0xC7, 0x01, 0xFF, 0x83, 0x80, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x88, 0x00, 0x07, 0x87,
  0x00, 0x07, 0xC3, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x0F, 0xF0, 0x38, 0x7F, 0xF8, 0x71, 0xFF,
  0xF8, 0xE7, 0x80, 0xF9, 0xDC, 0x00, 0xFB, 0xB0, 0x00, 0xF7, 0xC0, 0x00,
  0xEF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xC0, 0x23, 0xFF, 0xF7, 0xB8, 0x00, 0x00, 0x00, 0x00,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x00, 0x80, 0x3C,
  0x0F, 0x81, 0xF0, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x8F, 0x9F, 0xF3, 0xF8, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x2E, 0x00,
  0x0F, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x78,
  0x38, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0x78, 0x0E, 0x03, 0xC0, 0x38,
  0x1E, 0x00, 0xE0, 0xF0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xF8,
  0x00, 0xE7, 0xE0, 0x03, 0xBF, 0xC0, 0x0E, 0xE7, 0x00, 0x3F, 0x1E, 0x00,
  0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xE0, 0x38, 0x03, 0x80, 0xE0,
  0x0F, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x8E, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x7B,
  0x80, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x1F, 0xC1, 0xC3, 0xFF, 0x81, 0xFF, 0xE3, 0x8F, 0xFF, 0x87, 0xFF, 0xE7,
  0x38, 0x1F, 0x1E, 0x07, 0xEE, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x80, 0x0E,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00,
  0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00,
  0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xF8,
  0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x7F, 0x81, 0xC3, 0xFF, 0xC3, 0x8F, 0xFF, 0xC7, 0x3C,
  0x07, 0xCE, 0xE0, 0x07, 0xDD, 0x80, 0x07, 0xBE, 0x00, 0x07, 0x7C, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03,
  0xE0, 0x0F, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x70, 0xFF, 0xF0, 0x38, 0xFF,
  0xFC, 0x1C, 0xF0, 0x1F, 0x0E, 0xE0, 0x03, 0xC7, 0x60, 0x00, 0xF3, 0xE0,
  0x00, 0x79, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xBC,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x7C, 0x00,
  0x07, 0xBE, 0x00, 0x07, 0x9F, 0x80, 0x03, 0xCE, 0xE0, 0x03, 0xC7, 0x38,
  0x03, 0xE3, 0x9F, 0xDF, 0xE1, 0xC7, 0xFF, 0xE0, 0xE0, 0xFF, 0xC0, 0x70,
  0x06, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xE1, 0xC1, 0xFF, 0xF8, 0xE1, 0xF0, 0x1E, 0x71, 0xF0, 0x03, 0xB8, 0xF0,
  0x00, 0xFC, 0xF0, 0x00, 0x3E, 0x70, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xBC, 0x00, 0x07, 0xCE, 0x00, 0x03, 0xE7, 0x80, 0x03, 0xF1, 0xE0,
  0x03, 0xB8, 0xF8, 0x03, 0x9C, 0x3F, 0x8F, 0xCE, 0x0F, 0xFF, 0xC7, 0x01,
  0xFF, 0x83, 0x80, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x7F,
  0xE1, 0xFF, 0xE3, 0xFE, 0xE7, 0xC2, 0xEF, 0x00, 0xEE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xFC,
  0x7E, 0x01, 0xE3, 0xC0, 0x02, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE8, 0x00, 0x0F, 0x70, 0x00, 0xFB, 0xFC,
  0x7F, 0x9F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xE3, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x38, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xBB, 0xC0, 0x07, 0x77, 0xC0, 0x1C, 0xE7, 0xF3, 0xF1, 0xC7, 0xFF,
  0xC3, 0x87, 0xFF, 0x07, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x70, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F,
  0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0xF0,
  0x01, 0xC0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C,
  0x00, 0x0F, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xF0,
  0x00, 0x73, 0x80, 0x03, 0xF0, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x01, 0xCF,
  0x00, 0x1D, 0xC0, 0x07, 0x8E, 0x00, 0x3B, 0x80, 0x0E, 0x1C, 0x00, 0x73,
  0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x78, 0x03, 0x8E, 0x00, 0xF0,
  0x70, 0x07, 0x1E, 0x01, 0xC0, 0xE0, 0x1E, 0x1C, 0x03, 0x81, 0xC0, 0x38,
  0x38, 0x07, 0x03, 0xC0, 0x70, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0xF0, 0x38,
  0x07, 0x03, 0xC0, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x1E, 0x0E,
  0x03, 0x83, 0xC0, 0x1C, 0x3C, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x0E,
  0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x00, 0xE7,
  0x80, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x73,
  0x80, 0x07, 0xB8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x80,
  0xF0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0x01, 0xC0,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0x70, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x0E, 0x03,
  0xC0, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x78, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0xE0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00,
  0xF0, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0E,
  0x00, 0x78, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xF0,
  0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x03, 0x1F,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x4F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xA0, 0x00, 0xFF, 0x88,
  0x00, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Light61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 45, 14, 5, -44 },
  { 30, 14, 16, 22, 4, -44 },
  { 58, 32, 44, 35, 1, -44 },
  { 234, 24, 50, 31, 3, -46 },
  { 384, 39, 45, 45, 3, -44 },
  { 604, 34, 45, 37, 3, -44 },
  { 796, 4, 16, 12, 4, -44 },
  { 804, 12, 54, 17, 3, -44 },
  { 885, 12, 54, 17, 2, -44 },
  { 966, 23, 23, 30, 3, -46 },
  { 1033, 26, 29, 31, 3, -36 },
  { 1128, 7, 15, 13, 2, -7 },
  { 1142, 14, 3, 18, 2, -18 },
  { 1148, 6, 6, 14, 4, -5 },
  { 1153, 19, 44, 21, 1, -44 },
  { 1258, 25, 45, 31, 3, -44 },
  { 1399, 14, 44, 31, 5, -44 },
  { 1476, 25, 44, 31, 3, -44 },
  { 1614, 25, 45, 31, 3, -44 },
  { 1755, 29, 44, 31, 1, -44 },
  { 1915, 24, 45, 31, 4, -44 },
  { 2050, 25, 45, 31, 3, -44 },
  { 2191, 25, 44, 31, 3, -44 },
  { 2329, 25, 45, 31, 3, -44 },
  { 2470, 25, 45, 31, 3, -44 },
  { 2611, 6, 34, 14, 4, -33 },
  { 2637, 8, 41, 14, 2, -33 },
  { 2678, 26, 28, 31, 3, -36 },
  { 2769, 25, 15, 31, 3, -29 },
  { 2816, 26, 28, 31, 3, -36 },
  { 2907, 20, 45, 23, 1, -44 },
  { 3020, 42, 50, 48, 3, -44 },
  { 3283, 33, 44, 33, 0, -44 },
  { 3465, 26, 44, 35, 6, -44 },
  { 3608, 28, 45, 34, 4, -44 },
  { 3766, 29, 44, 38, 6, -44 },
  { 3926, 21, 44, 30, 6, -44 },
  { 4042, 21, 44, 28, 6, -44 },
  { 4158, 32, 45, 40, 4, -44 },
  { 4338, 28, 44, 39, 6, -44 },
  { 4492, 12, 44, 18, 3, -44 },
  { 4558, 13, 55, 14, -4, -44 },
  { 4648, 26, 44, 32, 6, -44 },
  { 4791, 21, 44, 28, 6, -44 },
  { 4907, 38, 44, 49, 6, -44 },
  { 5116, 29, 44, 40, 6, -44 },
  { 5276, 34, 45, 42, 4, -44 },
  { 5468, 23, 44, 32, 6, -44 },
  { 5595, 34, 54, 42, 4, -44 },
  { 5825, 26, 44, 33, 6, -44 },
  { 5968, 24, 45, 30, 3, -44 },
  { 6103, 28, 44, 28, 0, -44 },
  { 6257, 29, 45, 39, 5, -44 },
  { 6421, 31, 44, 31, 0, -44 },
  { 6592, 48, 44, 50, 1, -44 },
  { 6856, 29, 44, 29, 0, -44 },
  { 7016, 29, 44, 29, 0, -44 },
  { 7176, 26, 44, 30, 2, -44 },
  { 7319, 13, 54, 19, 5, -44 },
  { 7407, 19, 44, 21, 1, -44 },
  { 7512, 12, 54, 19, 2, -44 },
  { 7593, 27, 26, 31, 2, -44 },
  { 7681, 26, 3, 25, 0, 5 },
  { 7691, 11, 10, 16, 2, -47 },
  { 7705, 22, 34, 29, 3, -33 },
  { 7799, 25, 47, 33, 5, -46 },
  { 7946, 21, 34, 26, 3, -33 },
  { 8036, 25, 47, 33, 3, -46 },
  { 8183, 24, 34, 30, 3, -33 },
  { 8285, 19, 47, 17, 1, -47 },
  { 8397, 25, 48, 33, 3, -33 },
  { 8547, 23, 46, 33, 5, -46 },
  { 8680, 5, 45, 13, 4, -45 },
  { 8709, 11, 60, 13, -2, -45 },
  { 8792, 22, 46, 27, 5, -46 },
  { 8919, 3, 46, 13, 5, -46 },
  { 8937, 39, 33, 49, 5, -33 },
  { 9098, 23, 33, 33, 5, -33 },
  { 9193, 26, 34, 32, 3, -33 },
  { 9304, 25, 47, 33, 5, -33 },
  { 9451, 25, 47, 33, 3, -33 },
  { 9598, 16, 33, 22, 5, -33 },
  { 9664, 21, 34, 25, 2, -33 },
  { 9754, 16, 41, 18, 1, -40 },
  { 9836, 23, 33, 33, 5, -32 },
  { 9931, 25, 32, 26, 0, -32 },
  { 10031, 39, 32, 41, 1, -32 },
  { 10187, 25, 32, 27, 1, -32 },
  { 10287, 26, 47, 26, 0, -32 },
  { 10440, 20, 32, 24, 2, -32 },
  { 10520, 17, 54, 22, 2, -44 },
  { 10635, 3, 61, 30, 13, -46 },
  { 10658, 18, 54, 22, 2, -44 },
  { 10780, 26, 7, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_Light61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT61PT7B_H_
