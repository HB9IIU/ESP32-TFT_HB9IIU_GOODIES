#ifndef _NOTOSANS_SEMICONDENSED_LIGHT51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x40, 0xF0, 0x7E, 0x07, 0xE0,
  0x76, 0x07, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0x6F, 0xC7,
  0x86, 0x0C, 0x70, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x00,
  0xC0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0x70, 0x60,
  0x07, 0xC6, 0x00, 0x1F, 0x60, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x06, 0x7C, 0x00, 0x61, 0xE0, 0x06, 0x0E, 0x00,
  0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70,
  0x06, 0x07, 0x00, 0x60, 0xE8, 0x06, 0x1C, 0xF8, 0x6F, 0xCF, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x3F, 0xC0, 0x01, 0x80, 0x39,
  0xE0, 0x03, 0x80, 0x70, 0x60, 0x03, 0x00, 0x60, 0x70, 0x07, 0x00, 0xE0,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0xC0,
  0x38, 0x1C, 0x00, 0xC0, 0x38, 0x1C, 0x00, 0xC0, 0x38, 0x18, 0x00, 0xC0,
  0x38, 0x38, 0x00, 0xC0, 0x38, 0x30, 0x00, 0xC0, 0x38, 0x70, 0x00, 0xC0,
  0x38, 0x60, 0x00, 0xC0, 0x30, 0xE1, 0xF8, 0xC0, 0x30, 0xC7, 0xFC, 0xE0,
  0x31, 0xC7, 0x0E, 0x60, 0x71, 0x8E, 0x0E, 0x70, 0x63, 0x8C, 0x06, 0x39,
  0xE3, 0x0C, 0x07, 0x3F, 0xC7, 0x1C, 0x07, 0x0F, 0x06, 0x1C, 0x03, 0x00,
  0x0E, 0x1C, 0x03, 0x00, 0x0C, 0x1C, 0x03, 0x00, 0x1C, 0x1C, 0x03, 0x00,
  0x1C, 0x1C, 0x03, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x38, 0x1C, 0x03, 0x00,
  0x30, 0x1C, 0x03, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x60, 0x0C, 0x07, 0x00,
  0xE0, 0x0C, 0x06, 0x00, 0xC0, 0x0E, 0x0E, 0x01, 0xC0, 0x07, 0x0E, 0x01,
  0x80, 0x07, 0xFC, 0x03, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x0E, 0x1E, 0x07, 0x00, 0x70, 0xE0, 0x1C, 0x03, 0x8E, 0x00,
  0x70, 0x38, 0x70, 0x03, 0xC1, 0xC3, 0x80, 0x0F, 0x0E, 0x38, 0x00, 0x3C,
  0xE1, 0xC0, 0x00, 0xF7, 0x0E, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x0F, 0x81,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x7F, 0x81, 0xE0,
  0x07, 0x9E, 0x07, 0xC1, 0xF8, 0x78, 0x1F, 0xFF, 0x01, 0xC0, 0x7F, 0xF0,
  0x07, 0x80, 0x30, 0x00, 0x00, 0xFE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x40, 0x60, 0x17, 0x86, 0x0F, 0xFF, 0x67,
  0xF3, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xD8, 0x00, 0x19,
  0xC0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x07, 0x01, 0xE0, 0x38, 0x0C,
  0x03, 0x00, 0x40, 0x20, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0xF3,
  0x8E, 0x38, 0xE7, 0x1C, 0x71, 0x86, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x4F, 0xFF, 0xF4, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3C, 0x0F, 0x03, 0xC0, 0x3C, 0x1C, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0x67, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00,
  0x37, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x70,
  0x00, 0x1B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0xC3, 0xE0,
  0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x77,
  0x1E, 0x73, 0xC7, 0xF8, 0x77, 0x07, 0x20, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0xF8, 0x07, 0x83, 0x00,
  0x1E, 0x10, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF1, 0xF0, 0x07,
  0x86, 0x00, 0x0E, 0x20, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF6, 0x00, 0x0F, 0x3E, 0x01, 0xF1, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0,
  0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x77, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0xC0, 0x03, 0xCF, 0x80, 0xF8, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x1C, 0x3F, 0xE0,
  0xE7, 0xFF, 0x87, 0x70, 0x1E, 0x3F, 0x00, 0x79, 0xF0, 0x01, 0xCF, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xE0, 0x0F, 0x03,
  0xC1, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x78,
  0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x38, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x3C, 0x00,
  0x70, 0x70, 0x03, 0x80, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xF3, 0xE0, 0x0F, 0x03, 0xC0, 0x78,
  0x07, 0x83, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x70, 0x00, 0x39, 0xC0, 0x00,
  0xE6, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x67,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xC1, 0xF0,
  0x3E, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x1C,
  0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0x80,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x3E,
  0x78, 0x03, 0xF1, 0xF0, 0x7B, 0x87, 0xFF, 0x9C, 0x0F, 0xF0, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x08, 0x07, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x4F, 0xFF, 0xF4, 0x3C, 0xF3, 0xCF, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCE, 0x38, 0xE3,
  0x9C, 0x71, 0xC6, 0x38, 0xC3, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x8C, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x07, 0xFC, 0x07, 0x38, 0x03, 0xFF, 0xC0,
  0xE7, 0x00, 0xF0, 0x38, 0x0C, 0xC0, 0x38, 0x06, 0x01, 0xB8, 0x06, 0x00,
  0xC0, 0x37, 0x01, 0xC0, 0x18, 0x07, 0xE0, 0x30, 0x03, 0x00, 0xF8, 0x0E,
  0x00, 0x60, 0x1F, 0x01, 0xC0, 0x0C, 0x03, 0xE0, 0x38, 0x01, 0x80, 0x7C,
  0x07, 0x00, 0x30, 0x0F, 0x80, 0xE0, 0x0E, 0x01, 0xF0, 0x1C, 0x01, 0xC0,
  0x36, 0x03, 0x80, 0x38, 0x06, 0xC0, 0x70, 0x07, 0x01, 0xD8, 0x06, 0x01,
  0xE0, 0x3B, 0x80, 0xE0, 0x36, 0x0E, 0x70, 0x1E, 0x0C, 0xC3, 0x86, 0x01,
  0xFF, 0x9F, 0xF0, 0xC0, 0x1F, 0xC1, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x04, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0E, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x03, 0xF1, 0xC0, 0x03, 0xCE,
  0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x73, 0x80, 0x07, 0x1C, 0x07, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x38, 0x03, 0xF1, 0xC0, 0x03, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00,
  0x1E, 0xE0, 0x01, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xE0, 0x0E,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x02, 0x03, 0xF0, 0x1E, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xE0, 0x1F, 0xE0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xB8, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x08, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x1C, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x70, 0xFF, 0xDF, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0xC7, 0xCF, 0xF8,
  0xFF, 0x00, 0xE0, 0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE1,
  0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xEF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xDE, 0x00, 0x3E, 0x38, 0x00, 0xF0, 0xF0, 0x03,
  0x81, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0F,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0xC0, 0x00,
  0x01, 0xBD, 0xC0, 0x00, 0x07, 0x7B, 0x80, 0x00, 0x0E, 0xF3, 0x00, 0x00,
  0x1B, 0xE7, 0x00, 0x00, 0x77, 0xCE, 0x00, 0x00, 0xEF, 0x8C, 0x00, 0x03,
  0x9F, 0x1C, 0x00, 0x07, 0x3E, 0x38, 0x00, 0x0C, 0x7C, 0x38, 0x00, 0x38,
  0xF8, 0x70, 0x00, 0x71, 0xF0, 0xE0, 0x00, 0xC3, 0xE0, 0xE0, 0x03, 0x87,
  0xC1, 0xC0, 0x07, 0x0F, 0x81, 0x80, 0x0C, 0x1F, 0x03, 0x80, 0x38, 0x3E,
  0x07, 0x00, 0x70, 0x7C, 0x06, 0x00, 0xC0, 0xF8, 0x0E, 0x03, 0x81, 0xF0,
  0x1C, 0x07, 0x03, 0xE0, 0x1C, 0x1C, 0x07, 0xC0, 0x38, 0x38, 0x0F, 0x80,
  0x70, 0x60, 0x1F, 0x00, 0x71, 0xC0, 0x3E, 0x00, 0xE3, 0x80, 0x7C, 0x01,
  0xC6, 0x00, 0xF8, 0x01, 0xDC, 0x01, 0xF0, 0x03, 0xB8, 0x03, 0xE0, 0x03,
  0x60, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0E,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xDC, 0x00, 0x07,
  0xCE, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xC7, 0x00, 0x07, 0xC7, 0x80, 0x07,
  0xC3, 0x80, 0x07, 0xC1, 0xC0, 0x07, 0xC1, 0xC0, 0x07, 0xC0, 0xE0, 0x07,
  0xC0, 0xF0, 0x07, 0xC0, 0x70, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x38, 0x07,
  0xC0, 0x1C, 0x07, 0xC0, 0x1C, 0x07, 0xC0, 0x0E, 0x07, 0xC0, 0x0F, 0x07,
  0xC0, 0x07, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0x87, 0xC0, 0x01, 0xC7,
  0xC0, 0x01, 0xE7, 0xC0, 0x00, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x77,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x1F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x3F, 0x8E, 0x00, 0x3C, 0xE0, 0x01,
  0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xE0, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x1F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x38, 0x07,
  0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0xE0, 0x00, 0x67, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01,
  0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x9C, 0x00, 0x38, 0xE0,
  0x07, 0x87, 0x00, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x0E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0x78, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xB8, 0x00,
  0x1F, 0xC0, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x3C, 0x00, 0xC3, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF6, 0x00, 0x0F, 0x3F, 0x03, 0xF1,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x38, 0x00,
  0x0E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x0F, 0x80, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x7C, 0x00, 0x0E,
  0x70, 0x00, 0x7E, 0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x38, 0x00,
  0x6E, 0x00, 0x1C, 0x38, 0x00, 0xE6, 0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00,
  0x1C, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x18, 0x00, 0xC7, 0x00, 0x38, 0x1C,
  0x01, 0xC3, 0x00, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x0C, 0x01, 0x83, 0x80, 0x70, 0x0E, 0x03, 0x81, 0x80, 0x70,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x06, 0x03,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x03,
  0x8E, 0x00, 0x61, 0xC0, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x03, 0x8C, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x33, 0x80,
  0x01, 0xDC, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x01, 0xD8,
  0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x77, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xE3,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0xE0, 0x07, 0x80,
  0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00,
  0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3,
  0x80, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x06, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x30, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x38,
  0x0C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xE3,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x03,
  0x00, 0x70, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x0E, 0x03, 0xC1, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x03, 0xFE, 0x0F, 0xFF, 0xC7, 0xF8, 0x39,
  0xF0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0x70, 0x06, 0xEF,
  0x81, 0xDC, 0xFF, 0xF3, 0x8F, 0xF8, 0x30, 0x18, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x70, 0x0E, 0x3F, 0xF0, 0x73, 0xFF, 0xC3, 0xB8, 0x0F,
  0x1F, 0x80, 0x3C, 0xF8, 0x00, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0,
  0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0x77,
  0x80, 0x07, 0xBE, 0x00, 0x39, 0xF8, 0x03, 0xCE, 0xF0, 0x7C, 0x63, 0xFF,
  0xC3, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xC3, 0xFF,
  0xE3, 0xE0, 0x23, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x81, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0xE0, 0x70, 0x7F, 0xC3, 0x87, 0xFF, 0x9C, 0x78, 0x1E, 0xE7,
  0x80, 0x37, 0x78, 0x00, 0xFB, 0x80, 0x07, 0xDC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80,
  0x07, 0xDE, 0x00, 0x3E, 0x78, 0x03, 0x71, 0xE0, 0x73, 0x87, 0xFF, 0x1C,
  0x1F, 0xF0, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x21, 0xF0, 0x1E, 0x0F, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xEE,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x3F, 0xE1, 0xC3, 0xFF, 0xCE, 0x3C, 0x07, 0x73, 0xC0,
  0x1B, 0xBC, 0x00, 0x7D, 0xC0, 0x03, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x03,
  0xEF, 0x00, 0x1F, 0x3C, 0x01, 0xB8, 0xF0, 0x39, 0xC3, 0xFF, 0x8E, 0x0F,
  0xF8, 0x70, 0x04, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC6, 0x00,
  0x1E, 0x3E, 0x07, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x0E, 0x3F, 0xF1, 0xCF, 0xFF, 0x3B, 0x80, 0xF7, 0xE0, 0x0E, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x18, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xE0, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE8, 0xF3,
  0xF8, 0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x3D, 0xC0, 0x0E,
  0x38, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0x81, 0xC0,
  0x70, 0x78, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x3C, 0x00,
  0xEF, 0xC0, 0x1D, 0xB8, 0x03, 0xE3, 0x80, 0x7C, 0x70, 0x0F, 0x07, 0x01,
  0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x1E, 0x1C, 0x01, 0xC3,
  0x80, 0x3C, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0xB8, 0x00, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0xE0, 0x61, 0xFF, 0x03, 0xFE, 0x39,
  0xFF, 0xC3, 0xFF, 0x9D, 0xC0, 0xF3, 0x83, 0xEF, 0x80, 0x3B, 0x00, 0x77,
  0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x07,
  0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00,
  0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00,
  0x1F, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0,
  0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38,
  0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x07,
  0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x78, 0x18, 0x3F, 0xE3, 0x9F, 0xFE, 0x77, 0x01, 0xEF, 0xC0, 0x1D, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x1C, 0x00, 0x71, 0xC0, 0x01,
  0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xB8, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x1C, 0x3C, 0x01, 0xE0,
  0xF8, 0x3E, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x06, 0x0F, 0xF8, 0x39, 0xFF, 0xE1, 0xDE, 0x07, 0x8E, 0xC0, 0x1E,
  0x7C, 0x00, 0x73, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x03, 0xDF,
  0x00, 0x1C, 0xEC, 0x01, 0xE7, 0x78, 0x3E, 0x39, 0xFF, 0xE1, 0xC3, 0xFC,
  0x0E, 0x03, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xE1, 0xC3, 0xFF, 0xCE, 0x3C, 0x0F, 0x73, 0xC0, 0x1B, 0xBC, 0x00, 0x7D,
  0xC0, 0x03, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0x3C,
  0x01, 0xB8, 0xF0, 0x39, 0xC3, 0xFF, 0x8E, 0x0F, 0xF8, 0x70, 0x0C, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x76, 0x1F, 0xF9, 0xFF, 0xDE, 0x1E,
  0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0xE7, 0x80, 0xE7,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x78, 0x0F, 0xBF, 0xFF,
  0x87, 0xFF, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xF8, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE1, 0x07, 0xF8, 0x1F,
  0xC0, 0x10, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xDB, 0x80, 0x3B, 0x7C,
  0x0E, 0x67, 0xFF, 0x8C, 0x3F, 0xE1, 0x80, 0xC0, 0x00, 0xE0, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x03,
  0x00, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x03, 0x01, 0xC0, 0x1C, 0x0C,
  0x00, 0xE0, 0xE0, 0x03, 0x07, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x03,
  0x1C, 0x00, 0x1C, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xF0, 0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF8, 0x01, 0xCC, 0x00, 0x7C, 0x00,
  0xE7, 0x00, 0x76, 0x00, 0x63, 0x80, 0x3B, 0x00, 0x71, 0xC0, 0x1D, 0xC0,
  0x38, 0x60, 0x0C, 0xE0, 0x1C, 0x38, 0x0E, 0x30, 0x0C, 0x1C, 0x07, 0x18,
  0x0E, 0x0E, 0x03, 0x0E, 0x07, 0x03, 0x03, 0x87, 0x03, 0x81, 0xC1, 0xC1,
  0x81, 0x80, 0xE0, 0xE0, 0xE1, 0xC0, 0x70, 0x60, 0x70, 0xE0, 0x18, 0x70,
  0x38, 0x70, 0x0E, 0x38, 0x0C, 0x30, 0x07, 0x18, 0x07, 0x38, 0x03, 0x9C,
  0x03, 0x9C, 0x00, 0xCE, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x66, 0x00, 0x3B,
  0x00, 0x3B, 0x00, 0x1D, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x73, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x38, 0x03, 0x81, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x03, 0x8E, 0x00,
  0x1C, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x0E, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x00, 0xE3, 0x80, 0x03, 0xBC, 0x00, 0x1E, 0xE0,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0x60, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x60,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x38, 0x03, 0x81, 0xC0,
  0x1C, 0x0E, 0x00, 0x60, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0x63,
  0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x08, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x03, 0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x7C,
  0x03, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x04, 0xFF, 0x80, 0x17,
  0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0x80, 0x1F, 0xF2, 0x00, 0x07, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 37, 12, 4, -36 },
  { 20, 12, 13, 18, 3, -36 },
  { 40, 27, 36, 29, 1, -36 },
  { 162, 20, 42, 26, 3, -39 },
  { 267, 32, 38, 38, 3, -37 },
  { 419, 29, 38, 31, 2, -37 },
  { 557, 4, 13, 10, 3, -36 },
  { 564, 10, 44, 14, 2, -36 },
  { 619, 10, 44, 14, 2, -36 },
  { 674, 20, 20, 25, 2, -39 },
  { 724, 22, 24, 26, 2, -30 },
  { 790, 6, 13, 11, 2, -6 },
  { 800, 12, 3, 15, 2, -15 },
  { 805, 4, 6, 12, 4, -5 },
  { 808, 16, 36, 18, 1, -36 },
  { 880, 21, 37, 26, 3, -37 },
  { 978, 12, 36, 26, 4, -36 },
  { 1032, 21, 37, 26, 2, -37 },
  { 1130, 21, 38, 26, 2, -37 },
  { 1230, 24, 37, 26, 1, -37 },
  { 1341, 20, 37, 26, 3, -36 },
  { 1434, 21, 38, 26, 3, -37 },
  { 1534, 22, 36, 26, 2, -36 },
  { 1633, 22, 38, 26, 2, -37 },
  { 1738, 21, 38, 26, 2, -37 },
  { 1838, 4, 28, 12, 4, -27 },
  { 1852, 6, 34, 12, 2, -27 },
  { 1878, 22, 23, 26, 2, -30 },
  { 1942, 22, 12, 26, 2, -24 },
  { 1975, 22, 23, 26, 2, -30 },
  { 2039, 17, 38, 19, 1, -37 },
  { 2120, 35, 41, 40, 3, -36 },
  { 2300, 27, 37, 27, 0, -37 },
  { 2425, 21, 36, 29, 5, -36 },
  { 2520, 24, 38, 28, 3, -37 },
  { 2634, 24, 36, 32, 5, -36 },
  { 2742, 17, 36, 25, 5, -36 },
  { 2819, 17, 36, 23, 5, -36 },
  { 2896, 27, 38, 33, 3, -37 },
  { 3025, 23, 36, 33, 5, -36 },
  { 3129, 10, 36, 15, 2, -36 },
  { 3174, 12, 45, 12, -4, -36 },
  { 3242, 22, 36, 27, 5, -36 },
  { 3341, 17, 36, 23, 5, -36 },
  { 3418, 31, 36, 41, 5, -36 },
  { 3558, 24, 36, 34, 5, -36 },
  { 3666, 29, 38, 35, 3, -37 },
  { 3804, 20, 36, 27, 5, -36 },
  { 3894, 29, 46, 35, 3, -37 },
  { 4061, 21, 36, 27, 5, -36 },
  { 4156, 21, 38, 25, 2, -37 },
  { 4256, 23, 36, 24, 0, -36 },
  { 4360, 24, 37, 33, 4, -36 },
  { 4471, 26, 36, 26, 0, -36 },
  { 4588, 40, 36, 42, 1, -36 },
  { 4768, 24, 36, 25, 0, -36 },
  { 4876, 24, 36, 24, 0, -36 },
  { 4984, 21, 36, 25, 2, -36 },
  { 5079, 11, 44, 16, 4, -36 },
  { 5140, 16, 36, 18, 1, -36 },
  { 5212, 11, 44, 16, 1, -36 },
  { 5273, 23, 22, 26, 2, -37 },
  { 5337, 21, 2, 21, 0, 5 },
  { 5343, 9, 8, 13, 2, -39 },
  { 5352, 19, 29, 25, 2, -28 },
  { 5421, 21, 40, 28, 4, -39 },
  { 5526, 17, 29, 22, 3, -28 },
  { 5588, 21, 40, 28, 3, -39 },
  { 5693, 20, 29, 25, 3, -28 },
  { 5766, 16, 39, 14, 1, -39 },
  { 5844, 21, 40, 28, 3, -28 },
  { 5949, 19, 39, 27, 4, -39 },
  { 6042, 4, 37, 11, 4, -37 },
  { 6061, 10, 49, 11, -2, -37 },
  { 6123, 19, 39, 23, 4, -39 },
  { 6216, 3, 39, 11, 4, -39 },
  { 6231, 33, 28, 41, 4, -28 },
  { 6347, 19, 28, 27, 4, -28 },
  { 6414, 21, 29, 27, 3, -28 },
  { 6491, 21, 40, 28, 4, -28 },
  { 6596, 21, 40, 28, 3, -28 },
  { 6701, 13, 28, 18, 4, -28 },
  { 6747, 17, 29, 21, 2, -28 },
  { 6809, 13, 35, 15, 1, -34 },
  { 6866, 19, 28, 27, 4, -27 },
  { 6933, 21, 27, 21, 0, -27 },
  { 7004, 33, 27, 34, 1, -27 },
  { 7116, 21, 27, 23, 1, -27 },
  { 7187, 21, 39, 22, 0, -27 },
  { 7290, 16, 27, 20, 2, -27 },
  { 7344, 14, 44, 18, 2, -36 },
  { 7421, 3, 51, 25, 11, -39 },
  { 7441, 14, 44, 18, 2, -36 },
  { 7518, 22, 6, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Light51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT51PT7B_H_
