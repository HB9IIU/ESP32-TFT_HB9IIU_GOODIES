#ifndef _NOTOSANS_SEMICONDENSED_LIGHT72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x7E, 0xFE, 0xF9, 0xF1, 0xC0, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFC, 0xE0, 0xFC, 0x3E, 0x0E, 0x01, 0xC7, 0xC0, 0xE0,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x80, 0xE0, 0x00,
  0x7C, 0x0E, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x3F, 0x0E, 0x00, 0x01, 0xFC,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0E, 0x3F, 0x80, 0x00, 0xE0, 0xFC, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0xE0,
  0x1E, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1E,
  0x80, 0x0E, 0x03, 0xEE, 0x00, 0xE0, 0x7C, 0xFE, 0x0E, 0x3F, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x38, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0xE0, 0x08, 0x03, 0x80,
  0x0F, 0x07, 0x83, 0xFC, 0x0F, 0x00, 0x3C, 0x1C, 0x1F, 0xFC, 0x3C, 0x00,
  0xF0, 0xF0, 0xFF, 0xF8, 0x70, 0x03, 0x83, 0x83, 0xC1, 0xE1, 0xC0, 0x1E,
  0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0x70, 0x70, 0x07, 0x0F, 0x03, 0xC3,
  0xC3, 0xC0, 0x1E, 0x3E, 0x1F, 0x0E, 0x0E, 0x00, 0x78, 0x7F, 0xF8, 0x78,
  0x38, 0x00, 0xE0, 0xFF, 0xC1, 0xC0, 0xE0, 0x03, 0x80, 0xFC, 0x0F, 0x07,
  0x80, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x0F,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x78, 0xFC, 0x00, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x7C,
  0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x00, 0x78,
  0x7C, 0x00, 0x1F, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x78, 0x00,
  0x07, 0xC0, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0xF8, 0x00, 0x01, 0xF1,
  0xE0, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x7F, 0xC0,
  0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xFB, 0xF0, 0x1F, 0x80,
  0x07, 0xF1, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7C, 0x03, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x76, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x70, 0x03, 0x7C, 0x07, 0x01, 0xF7, 0xF8, 0x71,
  0xFF, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x1F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70,
  0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xF3, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C,
  0x0F, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xF7, 0x03, 0xE7, 0x0F, 0xCF, 0x1F, 0x8F, 0x3F, 0x0F,
  0x7C, 0x0F, 0xF8, 0x0F, 0x70, 0x0F, 0x20, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0x80,
  0x00, 0x3C, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0x00, 0x00, 0x3E, 0x08, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC8, 0x00, 0x00, 0x3E, 0x38,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x8F,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x7F,
  0xE0, 0x18, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x40, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x7E,
  0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x78,
  0x1F, 0xFE, 0x03, 0xC3, 0xFF, 0xFC, 0x1E, 0x3F, 0xFF, 0xF0, 0xF3, 0xE0,
  0x0F, 0xC7, 0xBC, 0x00, 0x1F, 0x3D, 0xC0, 0x00, 0x79, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x01, 0xF8,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x3C, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xF1, 0xE0,
  0x00, 0x3B, 0xC7, 0xE0, 0x03, 0xCF, 0x0F, 0xE0, 0x3F, 0x3C, 0x1F, 0xFF,
  0xF8, 0xE0, 0x3F, 0xFF, 0x87, 0x80, 0x3F, 0xF8, 0x1E, 0x00, 0x04, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x10, 0x01, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xCE, 0x0E, 0x1F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFE, 0xFF, 0x8F,
  0x00, 0x1F, 0x88, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0xFC, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0xFF, 0xC0, 0x1E, 0x3C,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0x1C, 0x00, 0x3F, 0x00, 0xF0, 0x03, 0x9E,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF7,
  0x80, 0x1E, 0x00, 0x1E, 0x00, 0x7B, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1D,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07,
  0xF0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x01,
  0xFC, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x1F, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0x80,
  0x0F, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xBC, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xDE, 0x00, 0x70, 0x00, 0xF8,
  0x01, 0xEF, 0x00, 0x3C, 0x00, 0x6E, 0x00, 0xE7, 0x80, 0x1E, 0x00, 0x77,
  0x00, 0xF1, 0xC0, 0x07, 0x80, 0x7B, 0x80, 0xF0, 0xE0, 0x03, 0xF0, 0x78,
  0xF0, 0xF8, 0x78, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x3C, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0E, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x3F, 0xF0, 0xF0, 0x00,
  0x0F, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x01, 0xFC,
  0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0xCF,
  0x00, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x00, 0x40, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x00, 0xFF, 0x80, 0x1F, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0xF0, 0x00,
  0x1F, 0xE0, 0x3C, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x1F, 0x83, 0xC0,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x00, 0x03, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x00, 0x3C,
  0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0x79, 0xFC,
  0x00, 0x00, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x78, 0x00, 0x03, 0xFC, 0xF8,
  0x00, 0x07, 0xF0, 0xF8, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0xC0,
  0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xF0,
  0x00, 0x00, 0x01, 0xEF, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0xFE, 0x78, 0x00,
  0x00, 0x01, 0xEF, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0xFE, 0x3C, 0x00, 0x00,
  0x03, 0xCF, 0xE3, 0xC0, 0x00, 0x00, 0x38, 0xFE, 0x1E, 0x00, 0x00, 0x07,
  0x8F, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0xFE, 0x1E, 0x00, 0x00, 0x07, 0x0F,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xFE, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xFE, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0xE0, 0x78,
  0x00, 0x01, 0xE0, 0xFE, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0xFE, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0xE0, 0x1E, 0x00, 0x07,
  0x80, 0xFE, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xE0, 0x1E, 0x00, 0x07, 0x00,
  0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xFE,
  0x00, 0xF0, 0x00, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFE, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xFE, 0x00, 0x3C,
  0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xFE, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFE, 0xF0, 0x00, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0x0F, 0xE7,
  0x80, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x00, 0xFE, 0x3C, 0x00, 0x00, 0x3F,
  0x8F, 0x80, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x00,
  0xFE, 0x0F, 0x80, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x03, 0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x7C,
  0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0xFE, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF8,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x0F,
  0xE0, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x3F, 0x80, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0xFE, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x3E, 0x0F, 0xE0, 0x00,
  0x07, 0xC3, 0xF8, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x00, 0x3E, 0x3F, 0x80,
  0x00, 0x07, 0x8F, 0xE0, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x00, 0x3C, 0xFE,
  0x00, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x3F, 0xF0,
  0xF0, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x1F, 0x8F, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3C, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x3F, 0x0F,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7E, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x0F,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0x0C, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x80, 0x00, 0x07, 0xCE, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x0F, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF7, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xC7, 0xE0, 0x00,
  0xF3, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xDE, 0x00, 0x07, 0x77, 0xC0, 0x03, 0x9C, 0xFC, 0x03, 0xC7, 0x1F, 0xFF,
  0xF1, 0xC3, 0xFF, 0xF0, 0x70, 0x7F, 0xF8, 0x1C, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0xE0,
  0x07, 0x83, 0xFF, 0xE0, 0x3C, 0x7F, 0xFF, 0x81, 0xE7, 0xFF, 0xFE, 0x0F,
  0x7C, 0x01, 0xF8, 0x7B, 0x80, 0x03, 0xE3, 0xF8, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x3C, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x3C, 0xFE, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x3E,
  0x39, 0xC0, 0x03, 0xF1, 0xCF, 0x80, 0x7F, 0x0E, 0x3F, 0xFF, 0xF0, 0x70,
  0x7F, 0xFF, 0x03, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xE0,
  0x06, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x07, 0xF0, 0x07, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x78,
  0x07, 0xFF, 0x83, 0xC0, 0xFF, 0xFF, 0x1E, 0x0F, 0xFF, 0xFC, 0xF0, 0xFC,
  0x01, 0xF7, 0x8F, 0xC0, 0x03, 0xBC, 0x7C, 0x00, 0x0F, 0xE7, 0xC0, 0x00,
  0x3F, 0x3C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x1D, 0xC7,
  0xE0, 0x01, 0xCE, 0x1F, 0x80, 0x3C, 0x70, 0x7F, 0xFF, 0xC3, 0x81, 0xFF,
  0xFC, 0x1C, 0x03, 0xFF, 0xC0, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x60,
  0x7F, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0x8F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC1, 0xC0, 0xFF, 0xFF, 0x0E,
  0x0F, 0xFF, 0xFC, 0x70, 0xFC, 0x00, 0xF3, 0x8F, 0xC0, 0x03, 0xFC, 0x7C,
  0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xDE, 0x1F, 0x80, 0x3C, 0xF0,
  0x7F, 0xFF, 0xC7, 0x81, 0xFF, 0xFC, 0x3C, 0x03, 0xFF, 0xC1, 0xE0, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x08, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x83, 0xFC, 0x07,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1F, 0xE0, 0x1E, 0x0F, 0xFF,
  0x83, 0xC7, 0xFF, 0xF8, 0x79, 0xFF, 0xFF, 0x8F, 0x7C, 0x01, 0xF9, 0xEE,
  0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x1E, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x21, 0xEF, 0xFF, 0xFD, 0xE3, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x20,
  0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xCC, 0x7F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xBC, 0x00, 0x07, 0xCF,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x3E,
  0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF1, 0xF0, 0x00,
  0x3C, 0x7E, 0x00, 0x0F, 0x3F, 0x80, 0x03, 0xDF, 0xF0, 0x00, 0xFF, 0x3C,
  0x00, 0x3F, 0x8F, 0x80, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0x83, 0xFF,
  0xC0, 0x1F, 0xFF, 0x0E, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0xE7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xBC, 0x00, 0x7D,
  0xE0, 0x03, 0xEE, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xBF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xE0, 0x1C, 0x0F, 0xFF, 0x83, 0x87, 0xFF, 0xF8, 0x71,
  0xFF, 0xFF, 0x8E, 0x7C, 0x01, 0xF9, 0xCE, 0x00, 0x1F, 0xBB, 0x80, 0x01,
  0xF7, 0xE0, 0x00, 0x1E, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0x03,
  0xFF, 0xE0, 0x38, 0x3F, 0xFF, 0x81, 0xC3, 0xFF, 0xFE, 0x0E, 0x3C, 0x01,
  0xF8, 0x73, 0x80, 0x03, 0xE3, 0xB8, 0x00, 0x0F, 0x9D, 0xC0, 0x00, 0x3C,
  0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x3C, 0xFE, 0x00, 0x03, 0xE7, 0xF8, 0x00, 0x3E, 0x3D, 0xE0,
  0x03, 0xF1, 0xE7, 0xC0, 0x7F, 0x0F, 0x1F, 0xFF, 0xF0, 0x78, 0x7F, 0xFF,
  0x03, 0xC1, 0xFF, 0xE0, 0x1E, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0x81, 0xC0, 0xFF, 0xFF, 0x0E, 0x0F, 0xFF, 0xFC, 0x70, 0xFC, 0x01, 0xF3,
  0x8F, 0xC0, 0x03, 0xBC, 0x7C, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x3F, 0x3C,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x3F, 0xC7, 0xE0, 0x03,
  0xDE, 0x1F, 0x80, 0x3C, 0xF0, 0x7F, 0xFF, 0xC7, 0x81, 0xFF, 0xFC, 0x3C,
  0x03, 0xFF, 0x81, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xE0, 0x79, 0xE0, 0x0E, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xF3, 0xFE, 0x3F, 0x00, 0x1C,
  0x7C, 0x00, 0x04, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x10, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F,
  0x78, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0x3C, 0x00, 0x0E, 0xF3, 0xE0,
  0x01, 0xEF, 0x1F, 0x80, 0x7C, 0xF1, 0xFF, 0xFF, 0x8F, 0x07, 0xFF, 0xF0,
  0xF0, 0x3F, 0xFC, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xDE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x79,
  0xE0, 0x00, 0x3B, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0x8F,
  0x00, 0x07, 0xBC, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF1, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE0, 0x78, 0x01,
  0xE0, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0xC0, 0x1E,
  0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x70, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x38, 0x07,
  0x80, 0xE0, 0x07, 0x81, 0xE0, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1,
  0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x38, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0x80,
  0x01, 0xE7, 0x80, 0x03, 0x9E, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x20, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x02, 0x7F, 0xFC, 0x00, 0x0D, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xFF, 0xD8, 0x00, 0x3F, 0xFF, 0x20,
  0x00, 0x0F, 0xF8, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 52, 17, 5, -51 },
  { 47, 16, 18, 25, 5, -51 },
  { 83, 37, 51, 41, 2, -51 },
  { 319, 28, 59, 37, 4, -55 },
  { 526, 46, 53, 53, 4, -52 },
  { 831, 40, 53, 44, 3, -52 },
  { 1096, 4, 18, 14, 5, -51 },
  { 1105, 15, 62, 20, 3, -51 },
  { 1222, 15, 62, 20, 2, -51 },
  { 1339, 28, 28, 35, 3, -55 },
  { 1437, 31, 34, 37, 3, -42 },
  { 1569, 8, 17, 16, 3, -8 },
  { 1586, 16, 3, 22, 3, -21 },
  { 1592, 6, 7, 16, 5, -6 },
  { 1598, 23, 51, 25, 1, -51 },
  { 1745, 29, 53, 37, 4, -52 },
  { 1938, 16, 51, 37, 6, -51 },
  { 2040, 30, 52, 37, 3, -52 },
  { 2235, 30, 53, 37, 3, -52 },
  { 2434, 35, 52, 37, 1, -52 },
  { 2662, 29, 52, 37, 4, -51 },
  { 2851, 29, 53, 37, 4, -52 },
  { 3044, 30, 51, 37, 3, -51 },
  { 3236, 29, 53, 37, 4, -52 },
  { 3429, 30, 53, 37, 3, -52 },
  { 3628, 6, 40, 16, 5, -39 },
  { 3658, 8, 48, 16, 3, -39 },
  { 3706, 31, 33, 37, 3, -42 },
  { 3834, 31, 18, 37, 3, -34 },
  { 3904, 31, 33, 37, 3, -42 },
  { 4032, 23, 53, 27, 2, -52 },
  { 4185, 49, 58, 57, 4, -51 },
  { 4541, 39, 52, 39, 0, -52 },
  { 4795, 30, 51, 41, 7, -51 },
  { 4987, 34, 53, 40, 4, -52 },
  { 5213, 34, 51, 45, 7, -51 },
  { 5430, 25, 51, 36, 7, -51 },
  { 5590, 25, 51, 33, 7, -51 },
  { 5750, 38, 53, 47, 4, -52 },
  { 6002, 33, 51, 46, 7, -51 },
  { 6213, 15, 51, 21, 3, -51 },
  { 6309, 16, 64, 17, -5, -51 },
  { 6437, 31, 51, 38, 7, -51 },
  { 6635, 24, 51, 33, 7, -51 },
  { 6788, 44, 51, 58, 7, -51 },
  { 7069, 34, 51, 47, 7, -51 },
  { 7286, 41, 53, 49, 4, -52 },
  { 7558, 28, 51, 38, 7, -51 },
  { 7737, 41, 64, 49, 4, -52 },
  { 8065, 30, 51, 39, 7, -51 },
  { 8257, 28, 53, 36, 4, -52 },
  { 8443, 33, 51, 34, 0, -51 },
  { 8654, 34, 52, 46, 6, -51 },
  { 8875, 37, 51, 37, 0, -51 },
  { 9111, 57, 51, 59, 1, -51 },
  { 9475, 34, 51, 35, 0, -51 },
  { 9692, 34, 51, 34, 0, -51 },
  { 9909, 31, 51, 35, 2, -51 },
  { 10107, 15, 62, 23, 6, -51 },
  { 10224, 23, 51, 25, 1, -51 },
  { 10371, 15, 62, 23, 2, -51 },
  { 10488, 33, 30, 37, 2, -52 },
  { 10612, 30, 4, 30, 0, 6 },
  { 10627, 13, 11, 19, 3, -55 },
  { 10645, 26, 40, 35, 3, -39 },
  { 10775, 29, 56, 39, 6, -55 },
  { 10978, 24, 40, 30, 4, -39 },
  { 11098, 29, 56, 39, 4, -55 },
  { 11301, 28, 40, 36, 4, -39 },
  { 11441, 22, 55, 20, 1, -55 },
  { 11593, 29, 56, 39, 4, -39 },
  { 11796, 27, 55, 39, 6, -55 },
  { 11982, 6, 53, 16, 5, -53 },
  { 12022, 14, 70, 16, -3, -53 },
  { 12145, 26, 55, 32, 6, -55 },
  { 12324, 4, 55, 16, 6, -55 },
  { 12352, 46, 39, 58, 6, -39 },
  { 12577, 27, 39, 39, 6, -39 },
  { 12709, 30, 40, 38, 4, -39 },
  { 12859, 29, 56, 39, 6, -39 },
  { 13062, 29, 56, 39, 4, -39 },
  { 13265, 18, 39, 25, 6, -39 },
  { 13353, 24, 40, 30, 3, -39 },
  { 13473, 19, 48, 22, 1, -47 },
  { 13587, 28, 39, 39, 5, -38 },
  { 13724, 30, 38, 30, 0, -38 },
  { 13867, 46, 38, 48, 1, -38 },
  { 14086, 30, 38, 32, 1, -38 },
  { 14229, 30, 55, 30, 0, -38 },
  { 14436, 23, 38, 29, 3, -38 },
  { 14546, 21, 62, 26, 2, -51 },
  { 14709, 3, 73, 35, 16, -55 },
  { 14737, 20, 62, 26, 3, -51 },
  { 14892, 31, 7, 37, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_Light72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT72PT7B_H_
