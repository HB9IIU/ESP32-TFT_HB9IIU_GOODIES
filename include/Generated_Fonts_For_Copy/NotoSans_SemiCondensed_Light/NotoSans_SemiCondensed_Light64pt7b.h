#ifndef _NOTOSANS_SEMICONDENSED_LIGHT64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x77, 0xFF, 0xFF, 0xFC, 0xC0, 0xF0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0,
  0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0x8C, 0x3F, 0x0F, 0x83, 0x01, 0x83, 0xC0, 0xC0, 0x01, 0xE0,
  0x30, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x0F, 0x00, 0xC0, 0x03,
  0xC0, 0x30, 0x00, 0xF0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xC0,
  0x01, 0xE0, 0x30, 0x00, 0x3C, 0x0C, 0x00, 0x0F, 0x83, 0x00, 0x01, 0xF8,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0D, 0xFC, 0x00, 0x03, 0x0F,
  0x80, 0x00, 0xC1, 0xF0, 0x00, 0x30, 0x1E, 0x00, 0x0C, 0x07, 0x80, 0x03,
  0x00, 0xF0, 0x00, 0xC0, 0x3C, 0x00, 0x30, 0x0F, 0x00, 0x0C, 0x03, 0xC0,
  0x03, 0x00, 0xF0, 0x00, 0xC0, 0x3C, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x07,
  0xA0, 0x03, 0x03, 0xCF, 0x00, 0xC3, 0xF3, 0xFC, 0x37, 0xF8, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x07, 0xFC, 0x00,
  0x03, 0xC0, 0x07, 0x9F, 0x00, 0x01, 0xC0, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x1C, 0x00,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x00, 0x70, 0x03, 0xC1, 0xC0, 0x00,
  0x3C, 0x01, 0xE1, 0xE0, 0xFC, 0x0E, 0x00, 0xE0, 0xE1, 0xFF, 0x07, 0x00,
  0x70, 0xF0, 0xFF, 0xC3, 0x80, 0x38, 0x70, 0xF0, 0xF1, 0xC0, 0x3C, 0x78,
  0xF0, 0x3C, 0x70, 0x1C, 0x38, 0x70, 0x0E, 0x3C, 0x1E, 0x3C, 0x38, 0x07,
  0x0F, 0xBE, 0x1C, 0x38, 0x03, 0xC3, 0xFE, 0x0E, 0x1C, 0x00, 0xE0, 0xFE,
  0x0E, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x07, 0x00, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1E,
  0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x03, 0xDF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x43, 0xE0, 0xF8, 0x00, 0x70, 0x78,
  0x0F, 0x80, 0x0E, 0x1E, 0x00, 0xF8, 0x03, 0xC7, 0x80, 0x0F, 0x00, 0x78,
  0xF0, 0x00, 0xF0, 0x0E, 0x1C, 0x00, 0x0F, 0x03, 0xC7, 0x80, 0x00, 0xF0,
  0x78, 0xF0, 0x00, 0x1F, 0x0E, 0x1E, 0x00, 0x01, 0xF3, 0xC3, 0xC0, 0x00,
  0x1F, 0xF0, 0x78, 0x00, 0x01, 0xFE, 0x0F, 0x00, 0x00, 0x1F, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x1F, 0xE0,
  0x7C, 0x00, 0x07, 0xFE, 0x07, 0xC0, 0x01, 0xF3, 0xE0, 0x7C, 0x00, 0xFC,
  0x3C, 0x0F, 0xFF, 0xFE, 0x03, 0xC0, 0x7F, 0xFF, 0x80, 0x3C, 0x07, 0xFF,
  0xC0, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x70, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x40, 0x1C, 0x01, 0x7C, 0x0E,
  0x07, 0xBF, 0xC7, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x0F, 0x00,
  0x7C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0C, 0x00, 0xE0, 0x02, 0x00, 0x20,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x67, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0xFB, 0xC3, 0xE7, 0x8F, 0x8F, 0x3E, 0x1F,
  0xF8, 0x3D, 0xC0, 0x79, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x03, 0xF0, 0x7C,
  0x00, 0x3E, 0x0C, 0x00, 0x07, 0x82, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x81, 0xFC, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x18, 0x00, 0x07, 0xC4,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x40, 0x00, 0x3E, 0x3C,
  0x00, 0x7E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x07, 0xE0, 0x08, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x07, 0xFE, 0x03, 0x87, 0xFF, 0xC0, 0xE3, 0xFF, 0xFC, 0x39,
  0xE0, 0x1F, 0x8E, 0xE0, 0x01, 0xE3, 0xB0, 0x00, 0x3C, 0xF8, 0x00, 0x0F,
  0x3E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xC0,
  0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE1, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0xFC, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3E, 0x03, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xDE,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0xFC, 0xF0, 0x00, 0x77, 0x1F, 0x00, 0x7B,
  0xC3, 0xF8, 0xFC, 0xF0, 0x7F, 0xFE, 0x3C, 0x0F, 0xFE, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x79,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x27, 0xFF, 0xFF, 0xFD, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xFE, 0x40, 0x04,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xF8, 0x0F, 0xC6, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x7F, 0x80,
  0x0E, 0x1C, 0x00, 0x3F, 0xFF, 0x00, 0xE3, 0xC0, 0x07, 0xFF, 0xF0, 0x0E,
  0x38, 0x00, 0xF8, 0x0F, 0x00, 0xF3, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0x77, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x70, 0x07,
  0x80, 0x0E, 0x00, 0x77, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x70, 0x07, 0x00,
  0x0E, 0x00, 0x77, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x70, 0x0F, 0x00, 0x0E,
  0x00, 0x7F, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xF0, 0x0E, 0x00, 0x0E, 0x00,
  0x7F, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x7F,
  0x00, 0xE0, 0x01, 0xE0, 0x07, 0x70, 0x0F, 0x00, 0x1E, 0x00, 0xF7, 0x00,
  0xF0, 0x01, 0xE0, 0x0E, 0x70, 0x07, 0x00, 0x3E, 0x00, 0xE7, 0x00, 0x78,
  0x03, 0x60, 0x1E, 0x70, 0x07, 0x80, 0x77, 0x01, 0xC7, 0x00, 0x3C, 0x0E,
  0x78, 0x78, 0x78, 0x01, 0xFF, 0xE3, 0xFF, 0x83, 0x80, 0x0F, 0xF8, 0x1F,
  0xF0, 0x38, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0E,
  0x00, 0x03, 0xF1, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x7C, 0x70, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x3F, 0x1C, 0x00,
  0x01, 0xF3, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3E, 0xE0, 0x00, 0x0F, 0x9C, 0x00, 0x03, 0xE3, 0x80, 0x03, 0xFC, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x80,
  0x3E, 0x03, 0xF0, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x07, 0xF0, 0x1C, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x01, 0xF0, 0x70, 0x00,
  0x01, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0xF8, 0x70, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1F, 0x81, 0xC0, 0x00,
  0xFE, 0x03, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x08, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00,
  0x73, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00,
  0x0E, 0x1F, 0x00, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x03, 0x81, 0xF8, 0x00,
  0x01, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xEF, 0xFF,
  0x3F, 0xF8, 0xFF, 0xC0, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1F, 0x0E,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x1F, 0x00, 0xE0, 0x03, 0xE0, 0x0E, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x03,
  0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x0E, 0x3F, 0x00, 0x00, 0xE7,
  0xF8, 0x00, 0x0E, 0xF7, 0x80, 0x00, 0xFE, 0x3C, 0x00, 0x0F, 0xC3, 0xC0,
  0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x01,
  0xE0, 0x0E, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3E, 0x0E, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xEE, 0x00, 0x00, 0x00, 0xFF,
  0xEE, 0x00, 0x00, 0x00, 0xEF, 0xEF, 0x00, 0x00, 0x00, 0xEF, 0xE7, 0x00,
  0x00, 0x01, 0xEF, 0xE7, 0x80, 0x00, 0x01, 0xCF, 0xE7, 0x80, 0x00, 0x01,
  0xCF, 0xE3, 0x80, 0x00, 0x03, 0xCF, 0xE3, 0xC0, 0x00, 0x03, 0x8F, 0xE3,
  0xC0, 0x00, 0x07, 0x8F, 0xE1, 0xC0, 0x00, 0x07, 0x8F, 0xE1, 0xE0, 0x00,
  0x07, 0x0F, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0xE0, 0xE0, 0x00, 0x0E, 0x0F,
  0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0xE0, 0x70,
  0x00, 0x1C, 0x0F, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0xE0, 0x38, 0x00, 0x3C,
  0x0F, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0xE0,
  0x1C, 0x00, 0x78, 0x0F, 0xE0, 0x1E, 0x00, 0x70, 0x0F, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0xE0, 0x0F, 0x00, 0xE0, 0x0F,
  0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0x01, 0xC0, 0x0F, 0xE0, 0x07,
  0x81, 0xC0, 0x0F, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0xE0, 0x03, 0x83, 0x80,
  0x0F, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0xE0,
  0x01, 0xE7, 0x00, 0x0F, 0xE0, 0x01, 0xE7, 0x00, 0x0F, 0xE0, 0x00, 0xEF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFB, 0xC0,
  0x00, 0x07, 0xE7, 0x80, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x7E, 0x3C, 0x00,
  0x01, 0xF8, 0xF0, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x7E, 0x0F, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x1F,
  0x80, 0xF0, 0x00, 0x7E, 0x03, 0xC0, 0x01, 0xF8, 0x07, 0x80, 0x07, 0xE0,
  0x0F, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x1E,
  0x01, 0xF8, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0xF0, 0x1F, 0x80, 0x01, 0xE0,
  0x7E, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x78, 0x7E, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x03, 0xC7, 0xE0,
  0x00, 0x07, 0x9F, 0x80, 0x00, 0x1E, 0x7E, 0x00, 0x00, 0x3D, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0E, 0x00, 0x0F,
  0xC7, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE,
  0x00, 0x01, 0xE7, 0x00, 0x01, 0xF3, 0x80, 0x01, 0xF1, 0xC0, 0x07, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0E, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x7C, 0x38, 0x00,
  0x07, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x03,
  0xE1, 0xC0, 0x00, 0xF8, 0x38, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x00, 0x78, 0x07, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0,
  0x70, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x7C, 0x38, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x20, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE7,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x9E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0xE0, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x03, 0x87, 0x80, 0x07, 0x80, 0x70,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x01,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x70, 0x03,
  0x80, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x03,
  0x80, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0,
  0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x78, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC7, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x03,
  0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0x1F, 0xC1, 0xE0, 0x07, 0xC1,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x7F, 0x80, 0x39, 0xF8, 0x00, 0x77, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xDE,
  0x00, 0x3B, 0xBE, 0x00, 0xE7, 0x3F, 0x9F, 0x8E, 0x3F, 0xFE, 0x1C, 0x3F,
  0xF8, 0x38, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x70, 0x03, 0xC1, 0xFF, 0x80, 0xF1, 0xFF, 0xF8,
  0x3C, 0xFE, 0xFF, 0x0F, 0x78, 0x03, 0xE3, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x0F, 0x3F, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0xC0, 0x00,
  0xF3, 0xF0, 0x00, 0x3C, 0xEE, 0x00, 0x1E, 0x39, 0xE0, 0x1F, 0x8E, 0x3F,
  0xFF, 0xC3, 0x87, 0xFF, 0xE0, 0xE0, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xC0, 0x08, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x03, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x07, 0xFE, 0x0F, 0x03, 0xFF, 0xF1,
  0xE0, 0xFF, 0x7F, 0x3C, 0x3E, 0x00, 0xF7, 0x8F, 0x80, 0x06, 0xF1, 0xE0,
  0x00, 0xFE, 0x78, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0xDE, 0x1F,
  0x00, 0x7B, 0xC1, 0xFE, 0xFE, 0x78, 0x1F, 0xFF, 0x87, 0x01, 0xFF, 0xC0,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xF8, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x04, 0x1F, 0x80, 0x0E, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x06, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x1C, 0x0F, 0xFF, 0xC7, 0x83, 0xFD,
  0xFC, 0xF0, 0xF8, 0x03, 0xDE, 0x3E, 0x00, 0x1F, 0xC7, 0x80, 0x01, 0xF9,
  0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x7E, 0x3C, 0x00, 0x1F, 0xC7, 0xC0, 0x07, 0x78, 0x7C, 0x01, 0xEF,
  0x07, 0xFB, 0xF9, 0xE0, 0x7F, 0xFE, 0x3C, 0x07, 0xFF, 0x07, 0x80, 0x0E,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x60, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F,
  0xE0, 0xF1, 0xFF, 0xF8, 0xF3, 0xFB, 0xFC, 0xF7, 0x80, 0x3E, 0xFE, 0x00,
  0x1E, 0xEC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x6F, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x1F, 0x7F, 0xCF, 0xF1, 0xFC, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xFC, 0x00, 0x7B,
  0xF8, 0x00, 0xFF, 0x78, 0x01, 0xFC, 0x78, 0x03, 0xF0, 0xF0, 0x07, 0xC0,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x03,
  0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x3F, 0xF0,
  0x07, 0xFE, 0x0E, 0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0x8F, 0xDF, 0xC3, 0xFB,
  0xF8, 0xE7, 0x00, 0xF9, 0xE0, 0x1F, 0x3B, 0x80, 0x1E, 0x70, 0x03, 0xCF,
  0xC0, 0x03, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xFC, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xE0,
  0x00, 0x3B, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xE0,
  0x7F, 0xE0, 0xE1, 0xFF, 0xF8, 0xE3, 0xFB, 0xFC, 0xE7, 0x80, 0x3E, 0xEE,
  0x00, 0x1E, 0xEC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x38, 0x1F, 0xF8, 0x0E, 0x1F, 0xFF, 0x83, 0x8F, 0xEF, 0xF0,
  0xE7, 0x80, 0x3E, 0x39, 0x80, 0x07, 0xCE, 0xE0, 0x00, 0xF3, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0xBF, 0x80, 0x03,
  0xCF, 0xE0, 0x01, 0xE3, 0xDE, 0x01, 0xF8, 0xF3, 0xFF, 0xFC, 0x3C, 0x7F,
  0xFE, 0x0F, 0x07, 0xFE, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF8,
  0x1C, 0x0F, 0xFF, 0xC7, 0x83, 0xFD, 0xFC, 0xF0, 0xF8, 0x03, 0xDE, 0x3E,
  0x00, 0x3B, 0xC7, 0x80, 0x03, 0xF9, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x07,
  0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x0F, 0x9E, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xC7,
  0xC0, 0x07, 0x78, 0x7C, 0x01, 0xCF, 0x07, 0xFB, 0xF9, 0xE0, 0x7F, 0xFC,
  0x3C, 0x07, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x70, 0x7F, 0xF8,
  0x7F, 0xFC, 0x7F, 0xEE, 0x78, 0x07, 0x38, 0x03, 0xB8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0x7F, 0x8F, 0xE7, 0xC0, 0x07, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3A, 0x00, 0x03, 0xDC, 0x00, 0x3E, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xEF, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x37, 0x7C, 0x00, 0x77, 0x3E,
  0x01, 0xE7, 0x3F, 0xFF, 0xC7, 0x1F, 0xFF, 0x87, 0x07, 0xFF, 0x07, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x38, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xEE, 0x00, 0x07, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xB8, 0x00, 0x79, 0xE0, 0x01, 0xDC, 0x00, 0x3C, 0x70, 0x00, 0xEF,
  0x00, 0x1C, 0x3C, 0x00, 0xF3, 0x80, 0x1E, 0x1E, 0x00, 0x71, 0xC0, 0x0F,
  0x07, 0x00, 0x38, 0xF0, 0x07, 0x83, 0x80, 0x1C, 0x78, 0x03, 0x81, 0xE0,
  0x1E, 0x1C, 0x03, 0xC0, 0xF0, 0x0E, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x81, 0xC0, 0x70, 0x0F, 0x03, 0x80, 0xE0, 0x78,
  0x07, 0x81, 0xC0, 0x70, 0x3C, 0x01, 0xC1, 0xE0, 0x3C, 0x1C, 0x00, 0xE0,
  0xF0, 0x0E, 0x0E, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0x3C, 0x38, 0x03,
  0xC7, 0x80, 0x0E, 0x3C, 0x01, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x03, 0xCE, 0x00, 0x38, 0xE0, 0x01, 0xE7, 0x00, 0x1E, 0xF0, 0x00, 0x77,
  0x80, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01,
  0xDC, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x3C, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38,
  0x78, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00,
  0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00,
  0x70, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x01,
  0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x27, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0xFD,
  0x00, 0x07, 0xFF, 0x20, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Light64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 47, 15, 5, -46 },
  { 31, 14, 17, 23, 4, -46 },
  { 61, 33, 46, 37, 2, -46 },
  { 251, 26, 53, 33, 3, -49 },
  { 424, 41, 47, 47, 3, -46 },
  { 665, 35, 47, 39, 3, -46 },
  { 871, 4, 17, 12, 4, -46 },
  { 880, 13, 56, 18, 3, -46 },
  { 971, 13, 56, 18, 2, -46 },
  { 1062, 25, 25, 31, 3, -49 },
  { 1141, 27, 30, 33, 3, -38 },
  { 1243, 8, 15, 14, 2, -7 },
  { 1258, 15, 3, 19, 2, -19 },
  { 1264, 5, 7, 15, 5, -6 },
  { 1269, 20, 46, 22, 1, -46 },
  { 1384, 27, 47, 33, 3, -46 },
  { 1543, 15, 46, 33, 5, -46 },
  { 1630, 26, 46, 33, 3, -46 },
  { 1780, 26, 47, 33, 3, -46 },
  { 1933, 31, 46, 33, 1, -46 },
  { 2112, 25, 47, 33, 4, -46 },
  { 2259, 26, 47, 33, 4, -46 },
  { 2412, 27, 46, 33, 3, -46 },
  { 2568, 27, 47, 33, 3, -46 },
  { 2727, 26, 47, 33, 3, -46 },
  { 2880, 5, 36, 15, 5, -35 },
  { 2903, 8, 43, 15, 2, -35 },
  { 2946, 27, 30, 33, 3, -38 },
  { 3048, 27, 17, 33, 3, -31 },
  { 3106, 27, 30, 33, 3, -38 },
  { 3208, 21, 47, 24, 1, -46 },
  { 3332, 44, 52, 51, 3, -46 },
  { 3618, 34, 46, 34, 0, -46 },
  { 3814, 27, 46, 36, 6, -46 },
  { 3970, 30, 47, 35, 4, -46 },
  { 4147, 31, 46, 40, 6, -46 },
  { 4326, 22, 46, 32, 6, -46 },
  { 4453, 22, 46, 29, 6, -46 },
  { 4580, 33, 47, 42, 4, -46 },
  { 4774, 29, 46, 41, 6, -46 },
  { 4941, 13, 46, 19, 3, -46 },
  { 5016, 14, 58, 15, -5, -46 },
  { 5118, 28, 46, 34, 6, -46 },
  { 5279, 22, 46, 29, 6, -46 },
  { 5406, 40, 46, 51, 6, -46 },
  { 5636, 30, 46, 42, 6, -46 },
  { 5809, 36, 47, 44, 4, -46 },
  { 6021, 25, 46, 34, 6, -46 },
  { 6165, 36, 57, 44, 4, -46 },
  { 6422, 27, 46, 34, 6, -46 },
  { 6578, 26, 47, 32, 3, -46 },
  { 6731, 29, 46, 30, 0, -46 },
  { 6898, 31, 47, 41, 5, -46 },
  { 7081, 33, 46, 33, 0, -46 },
  { 7271, 51, 46, 52, 1, -46 },
  { 7565, 31, 46, 31, 0, -46 },
  { 7744, 30, 46, 30, 0, -46 },
  { 7917, 27, 46, 31, 2, -46 },
  { 8073, 13, 56, 20, 5, -46 },
  { 8164, 20, 46, 22, 1, -46 },
  { 8279, 13, 56, 20, 2, -46 },
  { 8370, 29, 27, 33, 2, -46 },
  { 8468, 27, 3, 27, 0, 6 },
  { 8479, 11, 10, 17, 3, -49 },
  { 8493, 23, 36, 31, 3, -35 },
  { 8597, 26, 50, 35, 5, -49 },
  { 8760, 22, 36, 27, 3, -35 },
  { 8859, 27, 50, 35, 3, -49 },
  { 9028, 25, 36, 32, 3, -35 },
  { 9141, 20, 49, 18, 1, -49 },
  { 9264, 27, 50, 35, 3, -35 },
  { 9433, 24, 49, 34, 5, -49 },
  { 9580, 4, 47, 14, 5, -47 },
  { 9604, 11, 62, 14, -2, -47 },
  { 9690, 23, 49, 28, 5, -49 },
  { 9831, 4, 49, 14, 5, -49 },
  { 9856, 42, 35, 51, 5, -35 },
  { 10040, 24, 35, 34, 5, -35 },
  { 10145, 28, 36, 34, 3, -35 },
  { 10271, 26, 50, 35, 5, -35 },
  { 10434, 27, 50, 35, 3, -35 },
  { 10603, 17, 35, 23, 5, -35 },
  { 10678, 21, 36, 27, 3, -35 },
  { 10773, 17, 43, 19, 1, -42 },
  { 10865, 24, 35, 34, 5, -34 },
  { 10970, 27, 34, 27, 0, -34 },
  { 11085, 41, 34, 43, 1, -34 },
  { 11260, 26, 34, 28, 1, -34 },
  { 11371, 27, 49, 27, 0, -34 },
  { 11537, 21, 34, 25, 2, -34 },
  { 11627, 18, 56, 23, 2, -46 },
  { 11753, 3, 65, 31, 14, -49 },
  { 11778, 19, 56, 23, 2, -46 },
  { 11911, 27, 7, 33, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_Light64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT64PT7B_H_
