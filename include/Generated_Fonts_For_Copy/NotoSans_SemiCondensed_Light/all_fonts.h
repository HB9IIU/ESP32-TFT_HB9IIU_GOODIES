#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_SemiCondensed_Light
// Headers: 67

#include "NotoSans_SemiCondensed_Light6pt7b.h"
#include "NotoSans_SemiCondensed_Light7pt7b.h"
#include "NotoSans_SemiCondensed_Light8pt7b.h"
#include "NotoSans_SemiCondensed_Light9pt7b.h"
#include "NotoSans_SemiCondensed_Light10pt7b.h"
#include "NotoSans_SemiCondensed_Light11pt7b.h"
#include "NotoSans_SemiCondensed_Light12pt7b.h"
#include "NotoSans_SemiCondensed_Light13pt7b.h"
#include "NotoSans_SemiCondensed_Light14pt7b.h"
#include "NotoSans_SemiCondensed_Light15pt7b.h"
#include "NotoSans_SemiCondensed_Light16pt7b.h"
#include "NotoSans_SemiCondensed_Light17pt7b.h"
#include "NotoSans_SemiCondensed_Light18pt7b.h"
#include "NotoSans_SemiCondensed_Light19pt7b.h"
#include "NotoSans_SemiCondensed_Light20pt7b.h"
#include "NotoSans_SemiCondensed_Light21pt7b.h"
#include "NotoSans_SemiCondensed_Light22pt7b.h"
#include "NotoSans_SemiCondensed_Light23pt7b.h"
#include "NotoSans_SemiCondensed_Light24pt7b.h"
#include "NotoSans_SemiCondensed_Light25pt7b.h"
#include "NotoSans_SemiCondensed_Light26pt7b.h"
#include "NotoSans_SemiCondensed_Light27pt7b.h"
#include "NotoSans_SemiCondensed_Light28pt7b.h"
#include "NotoSans_SemiCondensed_Light29pt7b.h"
#include "NotoSans_SemiCondensed_Light30pt7b.h"
#include "NotoSans_SemiCondensed_Light31pt7b.h"
#include "NotoSans_SemiCondensed_Light32pt7b.h"
#include "NotoSans_SemiCondensed_Light33pt7b.h"
#include "NotoSans_SemiCondensed_Light34pt7b.h"
#include "NotoSans_SemiCondensed_Light35pt7b.h"
#include "NotoSans_SemiCondensed_Light36pt7b.h"
#include "NotoSans_SemiCondensed_Light37pt7b.h"
#include "NotoSans_SemiCondensed_Light38pt7b.h"
#include "NotoSans_SemiCondensed_Light39pt7b.h"
#include "NotoSans_SemiCondensed_Light40pt7b.h"
#include "NotoSans_SemiCondensed_Light41pt7b.h"
#include "NotoSans_SemiCondensed_Light42pt7b.h"
#include "NotoSans_SemiCondensed_Light43pt7b.h"
#include "NotoSans_SemiCondensed_Light44pt7b.h"
#include "NotoSans_SemiCondensed_Light45pt7b.h"
#include "NotoSans_SemiCondensed_Light46pt7b.h"
#include "NotoSans_SemiCondensed_Light47pt7b.h"
#include "NotoSans_SemiCondensed_Light48pt7b.h"
#include "NotoSans_SemiCondensed_Light49pt7b.h"
#include "NotoSans_SemiCondensed_Light50pt7b.h"
#include "NotoSans_SemiCondensed_Light51pt7b.h"
#include "NotoSans_SemiCondensed_Light52pt7b.h"
#include "NotoSans_SemiCondensed_Light53pt7b.h"
#include "NotoSans_SemiCondensed_Light54pt7b.h"
#include "NotoSans_SemiCondensed_Light55pt7b.h"
#include "NotoSans_SemiCondensed_Light56pt7b.h"
#include "NotoSans_SemiCondensed_Light57pt7b.h"
#include "NotoSans_SemiCondensed_Light58pt7b.h"
#include "NotoSans_SemiCondensed_Light59pt7b.h"
#include "NotoSans_SemiCondensed_Light60pt7b.h"
#include "NotoSans_SemiCondensed_Light61pt7b.h"
#include "NotoSans_SemiCondensed_Light62pt7b.h"
#include "NotoSans_SemiCondensed_Light63pt7b.h"
#include "NotoSans_SemiCondensed_Light64pt7b.h"
#include "NotoSans_SemiCondensed_Light65pt7b.h"
#include "NotoSans_SemiCondensed_Light66pt7b.h"
#include "NotoSans_SemiCondensed_Light67pt7b.h"
#include "NotoSans_SemiCondensed_Light68pt7b.h"
#include "NotoSans_SemiCondensed_Light69pt7b.h"
#include "NotoSans_SemiCondensed_Light70pt7b.h"
#include "NotoSans_SemiCondensed_Light71pt7b.h"
#include "NotoSans_SemiCondensed_Light72pt7b.h"
