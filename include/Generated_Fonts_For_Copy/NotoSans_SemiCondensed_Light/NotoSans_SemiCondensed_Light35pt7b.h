#ifndef _NOTOSANS_SEMICONDENSED_LIGHT35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light35pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00, 0x37, 0xC0, 0xC3,
  0xC3, 0xC3, 0xC3, 0x43, 0x43, 0x43, 0x43, 0x43, 0x01, 0x02, 0x00, 0x41,
  0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x20, 0x40,
  0x08, 0x30, 0x7F, 0xFF, 0xC1, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x20, 0x04,
  0x08, 0x01, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0xFF, 0xFF, 0x83, 0x04,
  0x00, 0x81, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0x80, 0x10, 0x20, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x07, 0xF8,
  0x3F, 0xF9, 0x88, 0x4C, 0x20, 0x30, 0x80, 0xC2, 0x03, 0x08, 0x0C, 0x20,
  0x18, 0x80, 0x7A, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF8, 0x02, 0x38, 0x08,
  0x60, 0x20, 0xC0, 0x83, 0x02, 0x0C, 0x08, 0x30, 0x21, 0xB0, 0x8E, 0xFF,
  0xE0, 0xFE, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x3E, 0x00, 0xC1, 0x9C,
  0x06, 0x0C, 0x30, 0x18, 0x30, 0x40, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x18,
  0x08, 0x18, 0x60, 0x20, 0x63, 0x00, 0x81, 0x8C, 0x03, 0x06, 0x20, 0x0C,
  0x19, 0x9F, 0x30, 0x44, 0xE6, 0x43, 0x33, 0x09, 0x9C, 0x88, 0x33, 0xE6,
  0x60, 0xC0, 0x11, 0x83, 0x00, 0xC6, 0x0C, 0x02, 0x18, 0x30, 0x18, 0x60,
  0xC0, 0x61, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x08, 0x30, 0x60, 0x30, 0x81,
  0x80, 0xE6, 0x0C, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0x9C, 0x00, 0xE0, 0xC0,
  0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x18, 0x60, 0x01, 0x98, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x73, 0x01, 0x98, 0x30, 0x37, 0x07, 0x06, 0xC0, 0x71, 0x98, 0x07, 0x33,
  0x00, 0x6C, 0x60, 0x07, 0x8C, 0x00, 0x61, 0x80, 0x1E, 0x18, 0x0E, 0xE3,
  0xEF, 0x8E, 0x1F, 0xC0, 0xE0, 0xFF, 0x55, 0x40, 0x0E, 0x30, 0x61, 0x83,
  0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x81, 0x80,
  0xE0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x30, 0x61,
  0x83, 0x0C, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x71, 0x1F, 0xFF, 0xE0, 0xE0, 0x07, 0x00, 0x6C, 0x06, 0x30, 0x71, 0x83,
  0x06, 0x08, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x33, 0x33, 0x66,
  0x64, 0xC0, 0xFF, 0xDF, 0x00, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x03, 0x18, 0x06, 0x60,
  0x19, 0x80, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xD8, 0x06, 0x60, 0x19, 0x80, 0x63, 0x03, 0x07, 0xF8, 0x0F, 0xC0,
  0x03, 0x0F, 0x1F, 0x3B, 0x63, 0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x1F, 0xC1, 0xE7, 0x8E, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC3, 0xE7,
  0xCC, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x68,
  0x03, 0xBE, 0x7C, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xD8, 0x00, 0xD8, 0x01, 0x98, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x18, 0x60, 0x18, 0x60,
  0x18, 0xC0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x3F, 0xF1, 0xFF, 0xC6, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x68, 0x03, 0x3E,
  0x78, 0x7F, 0xC0, 0x03, 0xF8, 0x3E, 0x61, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x04, 0x0C, 0xFE, 0x36, 0x1C,
  0xF0, 0x1B, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xD8, 0x03, 0x60, 0x0D, 0x80, 0x63, 0x03, 0x87, 0x3C, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0xF3, 0xC7, 0x03,
  0x98, 0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x01, 0x98, 0x06, 0x60, 0x38, 0xE1,
  0xC1, 0xCE, 0x03, 0xE0, 0x0F, 0xC0, 0xE3, 0x87, 0x03, 0x98, 0x06, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x76, 0x01, 0x8F,
  0x3C, 0x1F, 0xE0, 0x1F, 0xC0, 0xF7, 0x86, 0x03, 0x38, 0x0E, 0xC0, 0x1B,
  0x00, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x60, 0x3D, 0xC1, 0xB3, 0xFC, 0xC0, 0x83, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x10, 0xF0, 0x7F, 0x00, 0xDF,
  0x40, 0x00, 0x00, 0x00, 0x00, 0xDF, 0x00, 0x31, 0xCC, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x31, 0x9C, 0xC6, 0x33, 0x18, 0x00, 0x04,
  0x00, 0x30, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x7F, 0x9E,
  0x7A, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x3F, 0x06, 0x60, 0x77, 0x82,
  0x40, 0xC1, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x81, 0x83, 0xC3, 0x01, 0x83,
  0xC3, 0x01, 0x83, 0xC3, 0x01, 0x83, 0xC3, 0x01, 0x83, 0xC3, 0x03, 0x82,
  0xC1, 0x03, 0x86, 0xC1, 0x82, 0x86, 0xC1, 0xEC, 0xCC, 0x40, 0x78, 0x78,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x40, 0x07, 0xC7, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03,
  0x06, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x18,
  0x03, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0,
  0x01, 0x98, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0x60, 0xFF, 0xC1, 0xFF,
  0xF3, 0x00, 0xE6, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0xC0, 0x0D, 0x80, 0x3B, 0x00, 0xE7, 0xFF, 0x0F, 0xFF, 0x18, 0x03, 0xB0,
  0x03, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xB0, 0x07, 0x7F, 0xFC, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xDF,
  0x1E, 0x01, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xDF, 0x03, 0xFE, 0xFF, 0xC0,
  0x7F, 0xF8, 0x30, 0x0F, 0x18, 0x01, 0xCC, 0x00, 0x66, 0x00, 0x3B, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x66, 0x00, 0x63, 0x00, 0xE1, 0xFF,
  0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x81, 0xFB,
  0xF0, 0xE0, 0x0C, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x0D, 0xC0, 0x03, 0x30, 0x00, 0xCE, 0x00, 0x31, 0xE0, 0x0C,
  0x1F, 0xBF, 0x03, 0xFF, 0x80, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFE, 0xF0, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x3C, 0xFE, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0xDE, 0xFC,
  0xC0, 0x0F, 0x80, 0x3B, 0x00, 0x66, 0x01, 0x8C, 0x06, 0x18, 0x1C, 0x30,
  0x70, 0x60, 0xC0, 0xC3, 0x01, 0x8C, 0x03, 0x38, 0x06, 0xF0, 0x0D, 0xE0,
  0x1E, 0x60, 0x38, 0xE0, 0x60, 0xC0, 0xC0, 0xC1, 0x81, 0xC3, 0x01, 0x86,
  0x03, 0x8C, 0x03, 0x98, 0x03, 0x30, 0x07, 0x60, 0x06, 0xC0, 0x06, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xD8, 0x00, 0x6F, 0x60, 0x01, 0xBC, 0x80, 0x06, 0xF3, 0x00, 0x33, 0xCC,
  0x00, 0xCF, 0x18, 0x02, 0x3C, 0x60, 0x18, 0xF1, 0x80, 0x63, 0xC3, 0x01,
  0x0F, 0x0C, 0x0C, 0x3C, 0x30, 0x30, 0xF0, 0x61, 0x83, 0xC1, 0x86, 0x0F,
  0x06, 0x18, 0x3C, 0x0C, 0xC0, 0xF0, 0x33, 0x03, 0xC0, 0x4C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0C, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x1E, 0xE0, 0x0F, 0x30,
  0x07, 0x8C, 0x03, 0xC6, 0x01, 0xE1, 0x80, 0xF0, 0xE0, 0x78, 0x30, 0x3C,
  0x1C, 0x1E, 0x06, 0x0F, 0x01, 0x87, 0x80, 0xC3, 0xC0, 0x31, 0xE0, 0x1C,
  0xF0, 0x06, 0x78, 0x03, 0xBC, 0x00, 0xDE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0x80, 0x03, 0xFC, 0x00, 0xFD, 0xF0, 0x1C, 0x03, 0x83,
  0x80, 0x1C, 0x30, 0x00, 0xC6, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x1C,
  0x03, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x8C, 0x07,
  0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xB0, 0x0E, 0xC0, 0x73, 0xFF, 0x8F, 0xE0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFD, 0xF0, 0x1C, 0x03, 0x83, 0x80,
  0x1C, 0x30, 0x00, 0xC6, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x1C, 0x03,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0xFF, 0xC1, 0xFF,
  0xE3, 0x01, 0xE6, 0x00, 0xCC, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8F, 0xFE, 0x1F, 0xF0, 0x30,
  0x60, 0x60, 0x60, 0xC0, 0xE1, 0x80, 0xC3, 0x01, 0xC6, 0x01, 0x8C, 0x03,
  0x98, 0x03, 0x30, 0x03, 0x60, 0x06, 0xC0, 0x06, 0x1F, 0xF0, 0xFF, 0xE7,
  0x00, 0xB8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x68, 0x03,
  0x3F, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xD8, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x38, 0xC0, 0x38, 0x7E, 0xF8, 0x0F, 0xF0, 0x00,
  0xC0, 0x00, 0xF8, 0x00, 0x76, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x8C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80,
  0x60, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x03, 0xE0, 0x0F, 0x00, 0x66, 0x01,
  0xA0, 0x0C, 0xC0, 0x36, 0x01, 0x98, 0x06, 0xC0, 0x73, 0x01, 0x98, 0x0C,
  0x30, 0x31, 0x01, 0x86, 0x06, 0x30, 0x30, 0xC0, 0xC6, 0x06, 0x18, 0x30,
  0xC1, 0x81, 0x86, 0x08, 0x30, 0x30, 0xC1, 0x86, 0x06, 0x18, 0x30, 0xC0,
  0xC6, 0x06, 0x30, 0x0C, 0xC0, 0x66, 0x01, 0x98, 0x0C, 0xC0, 0x33, 0x01,
  0x98, 0x06, 0xC0, 0x36, 0x00, 0x78, 0x02, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x18, 0x03, 0x0C, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC0, 0x60, 0xC0, 0x30,
  0x60, 0x0C, 0x60, 0x07, 0x30, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x0C, 0xE0, 0x06, 0x30, 0x06, 0x0C,
  0x03, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC1, 0x80, 0x31, 0xC0, 0x18, 0xC0,
  0x06, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x06,
  0x30, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0E, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0x80, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0xFF, 0xFC, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20,
  0x0C, 0x30, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04,
  0x60, 0x06, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x07, 0xC1, 0xFF, 0x84, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x03, 0xF8, 0xFF, 0xCE, 0x06, 0xC0, 0x36, 0x01, 0xB0,
  0x0F, 0x80, 0x6C, 0x07, 0x60, 0x3B, 0xCE, 0x47, 0xE2, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC7,
  0xC3, 0x7F, 0xCF, 0x03, 0x38, 0x06, 0xE0, 0x1B, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xB8, 0x06, 0xF0, 0x3B, 0x73, 0xC8, 0xFE, 0x00, 0x07, 0xE1, 0xFF,
  0x38, 0x17, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0xEF,
  0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x0F, 0x8C, 0x7F, 0xB3, 0x03, 0xD8, 0x07, 0x60,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xD8, 0x07, 0x70, 0x3C, 0xF3, 0xB1,
  0xFC, 0x40, 0x0F, 0xC0, 0x7F, 0x83, 0x03, 0x18, 0x0E, 0x60, 0x1B, 0x00,
  0x6C, 0x01, 0xB0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x08, 0xF1, 0xE0, 0xFF, 0x00,
  0x03, 0xC0, 0xFC, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x3F,
  0x9F, 0xF0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x00, 0x0F, 0x84, 0x7F, 0xB3, 0x03, 0xD8, 0x07, 0x60, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xD8, 0x07, 0x70, 0x3C, 0xF3, 0xB1, 0xFC, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x40, 0x19, 0xE3, 0xC7,
  0xFE, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC7, 0xC6, 0xFF, 0x3C, 0x0D, 0xC0, 0x7E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xBE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x30, 0xC2, 0x00, 0x00, 0x03, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC7, 0x9B, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3C, 0x06, 0xC0, 0xCC,
  0x18, 0xC3, 0x8C, 0x30, 0xC6, 0x0C, 0xC0, 0xDC, 0x0F, 0xE0, 0xE6, 0x0E,
  0x30, 0xC3, 0x0C, 0x18, 0xC1, 0xCC, 0x0C, 0xC0, 0x6C, 0x07, 0xC0, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x87, 0x81, 0xF2, 0x7F, 0x9F,
  0xEF, 0x06, 0xC1, 0xF8, 0x0E, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0xC0, 0x3C,
  0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03,
  0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00,
  0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xC0,
  0x87, 0xC4, 0xFF, 0x3C, 0x0D, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0x07, 0xC0, 0x3F, 0xE0, 0xE0,
  0xE3, 0x00, 0xC6, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xD8, 0x01, 0x98, 0x03, 0x30,
  0x0E, 0x30, 0x18, 0x79, 0xE0, 0x3F, 0x80, 0x87, 0xC2, 0x7F, 0xCF, 0x03,
  0x38, 0x06, 0xE0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xB8, 0x06, 0xF0,
  0x3B, 0x73, 0xCC, 0xFE, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x84, 0x7F, 0xB3, 0x03,
  0xD8, 0x07, 0x60, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xD8, 0x07, 0x70,
  0x3C, 0xF3, 0xB1, 0xFC, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x87, 0xCF, 0xF6, 0x1C, 0x0E,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x00, 0x0F, 0xC3, 0xFF, 0x70, 0x26, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x7F, 0x9E, 0x7F, 0xC0, 0x30, 0x18,
  0x0C, 0x06, 0x07, 0xFF, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xE4, 0x7E,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xE0, 0x7B, 0xCE, 0xCF, 0xE6, 0xC0, 0x0F, 0x80, 0x19, 0x80,
  0x33, 0x00, 0x66, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x18, 0x30,
  0x30, 0x60, 0x61, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x01, 0xB0, 0x03,
  0x60, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x18, 0x06, 0xC0, 0x30,
  0x0D, 0x80, 0xF0, 0x1B, 0x01, 0xE0, 0x66, 0x02, 0xC0, 0xC6, 0x0C, 0x81,
  0x8C, 0x19, 0x83, 0x18, 0x33, 0x0C, 0x10, 0x46, 0x18, 0x31, 0x84, 0x30,
  0x63, 0x0C, 0x60, 0xC6, 0x19, 0x80, 0x98, 0x33, 0x01, 0xB0, 0x36, 0x03,
  0x60, 0x68, 0x06, 0x80, 0xF0, 0x07, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x00, 0xC0, 0x1D, 0x80, 0x66, 0x03, 0x0C, 0x1C, 0x18, 0x60, 0x63,
  0x00, 0xCC, 0x03, 0x60, 0x07, 0x80, 0x0C, 0x00, 0x78, 0x03, 0x60, 0x0C,
  0xC0, 0x63, 0x03, 0x86, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0x6C, 0x01, 0xC0,
  0xC0, 0x06, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x63, 0x01, 0x86, 0x03, 0x0C,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x31, 0x80, 0x63, 0x00, 0xC6,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x01, 0x38,
  0x03, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xC1, 0xF0, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x06, 0x0F, 0x83, 0xC0, 0x38, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x3E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x3C, 0x07,
  0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x3E, 0x0C, 0x00, 0x7E, 0x07, 0xBE, 0x38, 0x1F,
  0xC0, 0x08,
};

const GFXglyph NotoSans_SemiCondensed_Light35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 25, 8, 3, -25 },
  { 11, 8, 9, 12, 2, -25 },
  { 20, 18, 25, 20, 1, -25 },
  { 77, 14, 29, 18, 2, -27 },
  { 128, 22, 25, 26, 2, -25 },
  { 197, 19, 25, 21, 2, -25 },
  { 257, 2, 9, 7, 2, -25 },
  { 260, 7, 31, 10, 2, -25 },
  { 288, 7, 31, 10, 1, -25 },
  { 316, 13, 14, 17, 2, -27 },
  { 339, 14, 17, 18, 2, -21 },
  { 369, 4, 9, 8, 1, -4 },
  { 374, 8, 1, 11, 1, -10 },
  { 375, 3, 3, 8, 3, -3 },
  { 377, 11, 25, 12, 1, -25 },
  { 412, 14, 25, 18, 2, -25 },
  { 456, 8, 25, 18, 3, -25 },
  { 481, 14, 25, 18, 2, -25 },
  { 525, 14, 25, 18, 2, -25 },
  { 569, 16, 25, 18, 1, -25 },
  { 619, 14, 25, 18, 2, -25 },
  { 663, 14, 25, 18, 2, -25 },
  { 707, 14, 25, 18, 2, -25 },
  { 751, 14, 25, 18, 2, -25 },
  { 795, 14, 25, 18, 2, -25 },
  { 839, 3, 19, 8, 3, -19 },
  { 847, 5, 24, 8, 1, -19 },
  { 862, 14, 16, 18, 2, -21 },
  { 890, 14, 9, 18, 2, -17 },
  { 906, 14, 16, 18, 2, -21 },
  { 934, 11, 25, 13, 1, -25 },
  { 969, 24, 28, 28, 2, -25 },
  { 1053, 19, 25, 19, 0, -25 },
  { 1113, 15, 25, 20, 3, -25 },
  { 1160, 16, 25, 19, 2, -25 },
  { 1210, 17, 25, 22, 3, -25 },
  { 1264, 12, 25, 17, 3, -25 },
  { 1302, 12, 25, 16, 3, -25 },
  { 1340, 18, 25, 23, 2, -25 },
  { 1397, 16, 25, 23, 3, -25 },
  { 1447, 7, 25, 10, 2, -25 },
  { 1469, 8, 31, 8, -3, -25 },
  { 1500, 15, 25, 18, 3, -25 },
  { 1547, 12, 25, 16, 3, -25 },
  { 1585, 22, 25, 28, 3, -25 },
  { 1654, 17, 25, 23, 3, -25 },
  { 1708, 20, 25, 24, 2, -25 },
  { 1771, 14, 25, 18, 3, -25 },
  { 1815, 20, 31, 24, 2, -25 },
  { 1893, 15, 25, 19, 3, -25 },
  { 1940, 14, 25, 17, 2, -25 },
  { 1984, 16, 25, 16, 0, -25 },
  { 2034, 17, 25, 22, 3, -25 },
  { 2088, 18, 25, 18, 0, -25 },
  { 2145, 27, 25, 29, 1, -25 },
  { 2230, 17, 25, 17, 0, -25 },
  { 2284, 16, 25, 16, 0, -25 },
  { 2334, 15, 25, 17, 1, -25 },
  { 2381, 7, 31, 11, 3, -25 },
  { 2409, 11, 25, 12, 1, -25 },
  { 2444, 7, 31, 11, 1, -25 },
  { 2472, 16, 14, 18, 1, -25 },
  { 2500, 15, 2, 15, 0, 3 },
  { 2504, 7, 6, 9, 1, -27 },
  { 2510, 13, 19, 17, 1, -19 },
  { 2541, 14, 27, 19, 3, -27 },
  { 2589, 12, 19, 15, 2, -19 },
  { 2618, 14, 27, 19, 2, -27 },
  { 2666, 14, 19, 17, 2, -19 },
  { 2700, 11, 27, 10, 0, -27 },
  { 2738, 14, 27, 19, 2, -19 },
  { 2786, 13, 27, 19, 3, -27 },
  { 2830, 2, 26, 8, 3, -26 },
  { 2837, 6, 34, 8, -1, -26 },
  { 2863, 12, 27, 16, 3, -27 },
  { 2904, 2, 27, 8, 3, -27 },
  { 2911, 22, 19, 28, 3, -19 },
  { 2964, 13, 19, 19, 3, -19 },
  { 2995, 15, 19, 19, 2, -19 },
  { 3031, 14, 27, 19, 3, -19 },
  { 3079, 14, 27, 19, 2, -19 },
  { 3127, 9, 19, 12, 3, -19 },
  { 3149, 12, 19, 15, 1, -19 },
  { 3178, 9, 23, 11, 1, -23 },
  { 3204, 13, 19, 19, 3, -19 },
  { 3235, 15, 19, 15, 0, -19 },
  { 3271, 23, 19, 23, 0, -19 },
  { 3326, 14, 19, 16, 1, -19 },
  { 3360, 15, 27, 15, 0, -19 },
  { 3411, 12, 19, 14, 1, -19 },
  { 3440, 10, 31, 13, 1, -25 },
  { 3479, 1, 36, 17, 8, -27 },
  { 3484, 10, 31, 13, 1, -25 },
  { 3523, 14, 4, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_Light35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT35PT7B_H_
