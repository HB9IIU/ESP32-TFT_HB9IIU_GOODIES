#ifndef _NOTOSANS_SEMICONDENSED_LIGHT57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light57pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x18, 0x00, 0x00, 0x00, 0x07,
  0x7F, 0xFF, 0x79, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x70, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60,
  0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x03,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1E, 0x18, 0x1C,
  0x78, 0x30, 0x00, 0xE0, 0x60, 0x03, 0xC0, 0xC0, 0x07, 0x01, 0x80, 0x0E,
  0x03, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x78, 0x18, 0x00, 0x70,
  0x30, 0x00, 0xF0, 0x60, 0x00, 0xF0, 0xC0, 0x00, 0xF9, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x37,
  0xE0, 0x00, 0x63, 0xE0, 0x00, 0xC1, 0xE0, 0x01, 0x81, 0xE0, 0x03, 0x01,
  0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x80, 0x18, 0x07, 0x00, 0x30, 0x0E,
  0x00, 0x60, 0x38, 0x00, 0xC0, 0x70, 0x01, 0x81, 0xE8, 0x03, 0x07, 0x9E,
  0x06, 0x1E, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x01, 0xFF, 0x00, 0x03, 0x80, 0x3C,
  0x70, 0x00, 0x70, 0x07, 0x03, 0x80, 0x07, 0x00, 0x70, 0x18, 0x00, 0xE0,
  0x06, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x38, 0x00, 0xE0,
  0x0E, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x0E, 0x06, 0x00,
  0x0E, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x0E, 0x0C, 0x00, 0x0E, 0x00, 0xC1,
  0xC0, 0x00, 0xE0, 0x0C, 0x1C, 0x1E, 0x0E, 0x01, 0xC3, 0x87, 0xF8, 0xE0,
  0x1C, 0x38, 0xF7, 0xC6, 0x01, 0xC7, 0x1E, 0x1E, 0x70, 0x38, 0x71, 0xC0,
  0xE7, 0x03, 0x8E, 0x18, 0x06, 0x3C, 0x70, 0xE3, 0x80, 0x71, 0xFF, 0x1C,
  0x38, 0x07, 0x0F, 0xC1, 0xC3, 0x80, 0x70, 0x00, 0x38, 0x38, 0x07, 0x00,
  0x03, 0x83, 0x00, 0x30, 0x00, 0x70, 0x30, 0x03, 0x00, 0x07, 0x03, 0x00,
  0x30, 0x00, 0xE0, 0x30, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0xE0, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x00, 0xE1, 0xC0, 0x0E, 0x00,
  0x0F, 0xFC, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x07, 0x87, 0x80, 0x0F, 0x1E, 0x07, 0x80, 0x1C, 0x78, 0x07, 0x80, 0x38,
  0xE0, 0x07, 0x80, 0x73, 0xC0, 0x07, 0x81, 0xE7, 0x00, 0x07, 0x83, 0x8E,
  0x00, 0x07, 0x8F, 0x1C, 0x00, 0x0F, 0x1C, 0x38, 0x00, 0x0F, 0x78, 0x70,
  0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3F, 0x03, 0x80, 0x00, 0xFF, 0x07, 0x80, 0x03, 0xDE, 0x07, 0x80,
  0x1F, 0x1E, 0x07, 0xE3, 0xFC, 0x1E, 0x07, 0xFF, 0xF0, 0x1E, 0x07, 0xFF,
  0x80, 0x1E, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x38, 0x0C, 0x0E, 0xFE, 0x31, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0xE3, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0x90, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x0F,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xE1,
  0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x01, 0xE0, 0x1E, 0x03, 0xF1, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x7E, 0x07, 0xF0, 0x7B, 0x87, 0x9C, 0xF8, 0xEF, 0x87, 0xF0, 0x3B, 0x01,
  0xD0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x07,
  0xE0, 0x0F, 0x07, 0x00, 0x0F, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xC0, 0x0F,
  0x8E, 0x00, 0x0F, 0x88, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE8, 0x00, 0x07, 0x98,
  0x00, 0x3E, 0x3F, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x38, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFF, 0x81, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC8, 0x00, 0x0F, 0x9C, 0x00, 0x3E, 0x3F, 0x83,
  0xF8, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x7F, 0x81, 0xE3,
  0xFF, 0xC3, 0x8F, 0xFF, 0xC7, 0x38, 0x03, 0xCE, 0xE0, 0x03, 0xDF, 0x00,
  0x03, 0xBE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x3C,
  0xE0, 0x00, 0x71, 0xE0, 0x00, 0xE1, 0xE0, 0x03, 0x81, 0xE0, 0x0F, 0x01,
  0xF0, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xBF, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x80, 0x03, 0xC7, 0x00,
  0x07, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x83, 0xE0, 0x0F, 0xCF,
  0x80, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xF9, 0xF8,
  0x03, 0xC0, 0xF8, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0x79,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7B, 0x80, 0x00, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0xE0,
  0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0F,
  0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xF7, 0x80, 0x06, 0xE7, 0x80,
  0x1D, 0xC7, 0xC0, 0xF3, 0x87, 0xFF, 0xC7, 0x07, 0xFE, 0x1E, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0C,
  0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x77,
  0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFD, 0xE4, 0x1C, 0x7C, 0xF9, 0xF3, 0xE3,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38,
  0xE1, 0xC3, 0x86, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x38, 0x03, 0xC4, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x07, 0xFE, 0x01,
  0xC7, 0x00, 0x3F, 0xFE, 0x03, 0x8C, 0x00, 0xF0, 0x3C, 0x03, 0x38, 0x03,
  0xC0, 0x38, 0x07, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0xE0, 0x1C, 0x00, 0xE0,
  0x1D, 0x80, 0x70, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x03, 0x80, 0x7E, 0x01,
  0xC0, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x0C, 0x01, 0xF8, 0x06, 0x00, 0x18,
  0x03, 0xF0, 0x1C, 0x00, 0x70, 0x07, 0xE0, 0x38, 0x00, 0xE0, 0x0F, 0xC0,
  0x70, 0x01, 0xC0, 0x1F, 0x80, 0x60, 0x03, 0x80, 0x3F, 0x00, 0xE0, 0x07,
  0x00, 0x6E, 0x01, 0xC0, 0x1E, 0x01, 0xDC, 0x03, 0x80, 0x3E, 0x03, 0x98,
  0x03, 0x80, 0xEC, 0x0E, 0x38, 0x07, 0x83, 0x9C, 0x3C, 0x70, 0x07, 0xFE,
  0x3F, 0xF0, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0xE0, 0x03, 0xC0, 0x1E, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xF8, 0xE0, 0x00, 0x7C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0xE0, 0x01, 0xF8, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0xE0, 0x3E, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x80, 0x7F, 0x87, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0xFF, 0x80,
  0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x7E, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x18, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3,
  0xE0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0xF0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFD,
  0xFF, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x8E,
  0x00, 0x07, 0x87, 0x00, 0x07, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0,
  0xE0, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0xC0,
  0x0E, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x81, 0xE0, 0x01, 0xC1, 0xE0,
  0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xF8, 0x00, 0x1C, 0xFC,
  0x00, 0x0E, 0xFF, 0x00, 0x07, 0xF3, 0x80, 0x03, 0xF1, 0xE0, 0x01, 0xF0,
  0x78, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01,
  0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x79, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0x7E, 0xE0, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x07, 0x7E, 0xF0,
  0x00, 0x00, 0xEF, 0xE7, 0x00, 0x00, 0x0E, 0xFE, 0x70, 0x00, 0x00, 0xEF,
  0xE7, 0x80, 0x00, 0x1C, 0xFE, 0x38, 0x00, 0x01, 0xCF, 0xE3, 0x80, 0x00,
  0x38, 0xFE, 0x1C, 0x00, 0x03, 0x8F, 0xE1, 0xC0, 0x00, 0x38, 0xFE, 0x1C,
  0x00, 0x07, 0x0F, 0xE0, 0xE0, 0x00, 0x70, 0xFE, 0x0E, 0x00, 0x07, 0x0F,
  0xE0, 0xE0, 0x00, 0xE0, 0xFE, 0x07, 0x00, 0x0E, 0x0F, 0xE0, 0x70, 0x00,
  0xE0, 0xFE, 0x07, 0x80, 0x1C, 0x0F, 0xE0, 0x38, 0x01, 0xC0, 0xFE, 0x03,
  0x80, 0x3C, 0x0F, 0xE0, 0x3C, 0x03, 0x80, 0xFE, 0x01, 0xC0, 0x38, 0x0F,
  0xE0, 0x1C, 0x07, 0x00, 0xFE, 0x00, 0xE0, 0x70, 0x0F, 0xE0, 0x0E, 0x07,
  0x00, 0xFE, 0x00, 0xE0, 0xE0, 0x0F, 0xE0, 0x07, 0x0E, 0x00, 0xFE, 0x00,
  0x70, 0xE0, 0x0F, 0xE0, 0x07, 0x9C, 0x00, 0xFE, 0x00, 0x39, 0xC0, 0x0F,
  0xE0, 0x03, 0x9C, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x07, 0xE7,
  0x80, 0x00, 0xFC, 0x70, 0x00, 0x1F, 0x8F, 0x00, 0x03, 0xF0, 0xE0, 0x00,
  0x7E, 0x1E, 0x00, 0x0F, 0xC1, 0xC0, 0x01, 0xF8, 0x3C, 0x00, 0x3F, 0x03,
  0xC0, 0x07, 0xE0, 0x38, 0x00, 0xFC, 0x07, 0x80, 0x1F, 0x80, 0x70, 0x03,
  0xF0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x0F, 0xC0, 0x1E, 0x01, 0xF8, 0x01,
  0xE0, 0x3F, 0x00, 0x1C, 0x07, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0x38, 0x1F,
  0x80, 0x07, 0x83, 0xF0, 0x00, 0x78, 0x7E, 0x00, 0x07, 0x0F, 0xC0, 0x00,
  0xF1, 0xF8, 0x00, 0x0E, 0x3F, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x1C, 0xFC,
  0x00, 0x03, 0xDF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x38,
  0x03, 0xF8, 0xE0, 0x01, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3C, 0xE0, 0x03,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1C, 0x01, 0xFE, 0x0E, 0x00, 0x0F, 0x87,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00,
  0x3C, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x3E, 0x0E, 0x01,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xC0, 0x3C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0x3C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x8E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x79, 0xC0, 0x00,
  0x1E, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xC0, 0x0E, 0x3C, 0x00, 0x09, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7B, 0x00,
  0x07, 0xCF, 0xF1, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x05, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x03,
  0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x07,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x76, 0x00, 0x03, 0x87, 0x00, 0x03,
  0xB8, 0x00, 0x1C, 0x38, 0x00, 0x1D, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xCE,
  0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x78, 0x00, 0x70, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xE0, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x70, 0x07, 0x80, 0x70, 0x07, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x38, 0x1E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0x1E, 0x07,
  0x00, 0xF0, 0x38, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0,
  0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xE0, 0x03,
  0x87, 0x00, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x00, 0xE3, 0x80, 0x07, 0x1E, 0x00, 0x07, 0x9C, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x70, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x3C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01,
  0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x1C,
  0x07, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xF8, 0x1E, 0x03, 0xE0, 0x80, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x1F, 0x80, 0x39, 0xF0, 0x01, 0xCE, 0x00, 0x0E, 0xF0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x70,
  0x00, 0x7B, 0x80, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x07, 0x73, 0xE0, 0xF3,
  0x8F, 0xFF, 0x0C, 0x3F, 0xF0, 0x60, 0x3C, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x07, 0xE0, 0x1C, 0x3F, 0xF0,
  0x39, 0xFF, 0xF8, 0x77, 0x80, 0xF8, 0xFC, 0x00, 0xF1, 0xF0, 0x00, 0xF3,
  0xE0, 0x00, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x1E,
  0x67, 0x00, 0x78, 0xCF, 0x87, 0xE1, 0x8F, 0xFF, 0x83, 0x07, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC,
  0x0E, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x02, 0x0F, 0xE3, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x0F, 0xC0,
  0xE0, 0x7F, 0xF1, 0xC1, 0xFF, 0xF3, 0x87, 0xC0, 0xF7, 0x1E, 0x00, 0x6E,
  0x78, 0x00, 0x7C, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xEE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x00, 0x07,
  0xCF, 0x00, 0x0F, 0x8F, 0x00, 0x73, 0x0F, 0x83, 0xC6, 0x0F, 0xFF, 0x0C,
  0x0F, 0xFC, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xE0, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0x80,
  0x03, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x06, 0x0F,
  0xC1, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7C, 0x30, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x0C, 0x3F, 0xFF, 0x18, 0x7C, 0x0F, 0x71, 0xE0, 0x07, 0xE7, 0x80,
  0x07, 0xCE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x7C, 0xF0,
  0x01, 0xF8, 0xF0, 0x07, 0x70, 0xF8, 0x3C, 0xE0, 0xFF, 0xF1, 0xC0, 0xFF,
  0xC3, 0x80, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x30, 0x00, 0x78, 0x7C, 0x07, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x17, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x07, 0xE0, 0x70, 0xFF, 0xC3, 0x9F, 0xFF, 0x9D, 0xE0, 0x7C,
  0xFC, 0x00, 0xF7, 0xC0, 0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x2F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x00, 0x80, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0E, 0x87, 0xBF, 0xCF, 0xE1, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xE0, 0x07,
  0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x07,
  0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x78, 0x00, 0xE7,
  0xC0, 0x0E, 0xFE, 0x00, 0xFC, 0xE0, 0x0F, 0x8F, 0x00, 0xF0, 0x70, 0x0E,
  0x07, 0x80, 0xE0, 0x3C, 0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0,
  0xE0, 0x07, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x3C, 0xE0, 0x01,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x7E, 0x0C, 0x3F, 0xF0, 0x1F, 0xF8, 0xC7, 0xFF, 0x87, 0xFF,
  0xCC, 0xE0, 0x7C, 0xF0, 0x3E, 0xDC, 0x01, 0xCE, 0x01, 0xEF, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x06, 0x0F, 0xFC,
  0x31, 0xFF, 0xF9, 0x9E, 0x07, 0xCC, 0xC0, 0x0F, 0x6C, 0x00, 0x3B, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0x81, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x01, 0x83, 0xFF, 0x03, 0x1F,
  0xFF, 0x86, 0x78, 0x0F, 0x8C, 0xC0, 0x0F, 0x1B, 0x00, 0x0F, 0x3E, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xF0, 0x01, 0xE7, 0x70,
  0x07, 0x8E, 0x78, 0x7E, 0x1C, 0xFF, 0xF8, 0x38, 0x7F, 0xE0, 0x70, 0x08,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0x0C, 0x3F, 0xFF, 0x18, 0xFC, 0x0F, 0x71,
  0xE0, 0x06, 0xE7, 0x80, 0x07, 0xCE, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x70,
  0x00, 0x1E, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x7C, 0xF0, 0x01, 0xF8, 0xF0, 0x07, 0x70, 0xF8, 0x3C, 0xE0,
  0xFF, 0xF1, 0xC0, 0xFF, 0xC3, 0x80, 0x30, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF3, 0xE1, 0xCE, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0x00, 0xE7,
  0x80, 0x04, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xEF, 0xC0, 0xFD, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x10, 0x7F, 0xE0, 0x3F, 0xC0, 0x08, 0x00, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC,
  0x00, 0x1F, 0x70, 0x00, 0x7D, 0xE0, 0x03, 0x73, 0xC0, 0x1D, 0xCF, 0xC3,
  0xE7, 0x1F, 0xFF, 0x1C, 0x1F, 0xF0, 0x70, 0x04, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3,
  0x80, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x03, 0xBC, 0x00, 0x3E, 0x00, 0x1C, 0xE0, 0x01, 0xF0, 0x01, 0xE7, 0x00,
  0x1D, 0x80, 0x0E, 0x38, 0x00, 0xEE, 0x00, 0x71, 0xE0, 0x07, 0x70, 0x03,
  0x87, 0x00, 0x73, 0x80, 0x3C, 0x38, 0x03, 0x9C, 0x01, 0xC1, 0xC0, 0x1C,
  0x70, 0x0E, 0x0F, 0x00, 0xE3, 0x80, 0x70, 0x38, 0x0E, 0x1C, 0x07, 0x81,
  0xC0, 0x70, 0x70, 0x38, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0x38, 0x38, 0x1C,
  0x0E, 0x01, 0xC1, 0xC0, 0xE0, 0xF0, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0x70,
  0x70, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x07, 0x1E,
  0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x0E, 0xE0,
  0x07, 0x38, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xFC, 0x00,
  0x1D, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1E, 0x70, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0xE0,
  0x0F, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0xC3,
  0x80, 0x03, 0x8F, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x9C, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0x38, 0x00,
  0xF0, 0x78, 0x01, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xF0, 0x38,
  0x00, 0xE0, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xDE, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01,
  0xC3, 0x80, 0x01, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x87, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x0F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0x7F,
  0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC, 0x80,
  0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Light57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 42, 13, 4, -41 },
  { 28, 12, 15, 20, 4, -41 },
  { 51, 30, 41, 33, 1, -41 },
  { 205, 23, 46, 29, 3, -43 },
  { 338, 36, 42, 42, 3, -41 },
  { 527, 31, 42, 35, 3, -41 },
  { 690, 3, 15, 11, 4, -41 },
  { 696, 11, 50, 16, 3, -41 },
  { 765, 11, 50, 16, 2, -41 },
  { 834, 22, 21, 28, 3, -43 },
  { 892, 24, 27, 29, 3, -34 },
  { 973, 7, 13, 12, 2, -6 },
  { 985, 13, 3, 17, 2, -17 },
  { 990, 5, 6, 13, 4, -5 },
  { 994, 18, 41, 20, 1, -41 },
  { 1087, 23, 42, 29, 3, -41 },
  { 1208, 13, 41, 29, 5, -41 },
  { 1275, 23, 41, 29, 3, -41 },
  { 1393, 23, 42, 29, 3, -41 },
  { 1514, 27, 41, 29, 1, -41 },
  { 1653, 23, 42, 29, 3, -41 },
  { 1774, 23, 42, 29, 3, -41 },
  { 1895, 23, 41, 29, 3, -41 },
  { 2013, 23, 42, 29, 3, -41 },
  { 2134, 23, 42, 29, 3, -41 },
  { 2255, 5, 32, 13, 4, -31 },
  { 2275, 7, 38, 13, 2, -31 },
  { 2309, 24, 25, 29, 3, -33 },
  { 2384, 24, 14, 29, 3, -27 },
  { 2426, 24, 25, 29, 3, -33 },
  { 2501, 19, 42, 21, 1, -41 },
  { 2601, 39, 46, 45, 3, -41 },
  { 2826, 31, 41, 31, 0, -41 },
  { 2985, 24, 41, 32, 5, -41 },
  { 3108, 27, 42, 31, 3, -41 },
  { 3250, 28, 41, 36, 5, -41 },
  { 3394, 20, 41, 28, 5, -41 },
  { 3497, 20, 41, 26, 5, -41 },
  { 3600, 30, 42, 37, 3, -41 },
  { 3758, 27, 41, 37, 5, -41 },
  { 3897, 11, 41, 16, 3, -41 },
  { 3954, 12, 51, 13, -4, -41 },
  { 4031, 25, 41, 30, 5, -41 },
  { 4160, 20, 41, 26, 5, -41 },
  { 4263, 36, 41, 46, 5, -41 },
  { 4448, 27, 41, 38, 5, -41 },
  { 4587, 32, 42, 39, 3, -41 },
  { 4755, 22, 41, 30, 5, -41 },
  { 4868, 32, 51, 39, 3, -41 },
  { 5072, 25, 41, 31, 5, -41 },
  { 5201, 22, 42, 28, 3, -41 },
  { 5317, 26, 41, 27, 0, -41 },
  { 5451, 27, 42, 37, 5, -41 },
  { 5593, 29, 41, 29, 0, -41 },
  { 5742, 45, 41, 47, 1, -41 },
  { 5973, 27, 41, 27, 0, -41 },
  { 6112, 27, 41, 27, 0, -41 },
  { 6251, 24, 41, 28, 2, -41 },
  { 6374, 11, 50, 18, 5, -41 },
  { 6443, 18, 41, 20, 1, -41 },
  { 6536, 11, 50, 18, 2, -41 },
  { 6605, 26, 24, 29, 2, -41 },
  { 6683, 24, 3, 24, 0, 5 },
  { 6692, 10, 9, 15, 2, -44 },
  { 6704, 21, 32, 28, 2, -31 },
  { 6788, 23, 44, 31, 5, -43 },
  { 6915, 20, 32, 24, 3, -31 },
  { 6995, 23, 44, 31, 3, -43 },
  { 7122, 22, 32, 28, 3, -31 },
  { 7210, 17, 44, 16, 1, -44 },
  { 7304, 23, 45, 31, 3, -31 },
  { 7434, 21, 43, 31, 5, -43 },
  { 7547, 4, 42, 12, 4, -42 },
  { 7568, 10, 56, 12, -2, -42 },
  { 7638, 20, 43, 25, 5, -43 },
  { 7746, 3, 43, 12, 5, -43 },
  { 7763, 36, 31, 46, 5, -31 },
  { 7903, 21, 31, 31, 5, -31 },
  { 7985, 24, 32, 30, 3, -31 },
  { 8081, 23, 44, 31, 5, -31 },
  { 8208, 23, 44, 31, 3, -31 },
  { 8335, 14, 31, 20, 5, -31 },
  { 8390, 19, 32, 24, 2, -31 },
  { 8466, 15, 39, 17, 1, -38 },
  { 8540, 22, 31, 31, 4, -30 },
  { 8626, 24, 30, 24, 0, -30 },
  { 8716, 37, 30, 38, 1, -30 },
  { 8855, 23, 30, 25, 1, -30 },
  { 8942, 24, 44, 24, 0, -30 },
  { 9074, 19, 30, 23, 2, -30 },
  { 9146, 16, 50, 20, 2, -41 },
  { 9246, 3, 57, 28, 12, -43 },
  { 9268, 16, 50, 20, 2, -41 },
  { 9368, 24, 6, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_Light57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT57PT7B_H_
