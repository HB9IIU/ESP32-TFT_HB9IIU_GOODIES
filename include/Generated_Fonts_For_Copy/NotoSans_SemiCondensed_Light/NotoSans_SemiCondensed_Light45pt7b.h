#ifndef _NOTOSANS_SEMICONDENSED_LIGHT45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light45pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x00, 0x00, 0x7F, 0xF7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x08, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x01, 0xC0,
  0xC0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x81, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x8F, 0xB3, 0xE7, 0x8C, 0x09, 0xC3,
  0x00, 0x60, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x03, 0x83, 0x00, 0x60, 0xC0,
  0x1C, 0x30, 0x03, 0x8C, 0x00, 0xFB, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x03, 0x7C, 0x00, 0xC7, 0x80, 0x30, 0xE0, 0x0C, 0x1C, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x07, 0x00, 0xC3,
  0xB8, 0x31, 0xEF, 0xFF, 0xF1, 0xFF, 0xF0, 0x02, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x30, 0x0E, 0x70, 0x03, 0x80, 0xE1, 0xC0, 0x18, 0x06, 0x06, 0x01,
  0xC0, 0x30, 0x30, 0x0C, 0x01, 0x81, 0xC0, 0xE0, 0x1C, 0x06, 0x06, 0x00,
  0xC0, 0x30, 0x30, 0x06, 0x01, 0x83, 0x00, 0x30, 0x0C, 0x18, 0x01, 0x80,
  0x61, 0x80, 0x0C, 0x03, 0x0C, 0x00, 0x70, 0x18, 0xC1, 0xC1, 0x81, 0xC6,
  0x3F, 0x8C, 0x0C, 0x63, 0x9C, 0x60, 0x63, 0x18, 0x33, 0x87, 0x39, 0x81,
  0x8E, 0x71, 0x8C, 0x0E, 0x3F, 0x1C, 0x60, 0x30, 0x60, 0xC3, 0x01, 0x80,
  0x0E, 0x18, 0x0C, 0x00, 0x61, 0xC0, 0x60, 0x07, 0x0E, 0x03, 0x00, 0x30,
  0x70, 0x18, 0x03, 0x81, 0x80, 0xC0, 0x18, 0x0C, 0x06, 0x00, 0xC0, 0x60,
  0x30, 0x0C, 0x03, 0x03, 0x80, 0x60, 0x1C, 0x18, 0x06, 0x00, 0x61, 0xC0,
  0x30, 0x03, 0xFC, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x18, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0x39, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x1E, 0x01, 0xC7, 0x07, 0x00, 0xC7, 0x01, 0xC0,
  0x63, 0x00, 0x70, 0x73, 0x80, 0x1C, 0x39, 0xC0, 0x07, 0x18, 0xE0, 0x01,
  0xDC, 0x70, 0x00, 0xFC, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x0F, 0x83, 0x80, 0x1E, 0xE0, 0xF0, 0x1E, 0x38, 0x3F, 0xFE, 0x0E, 0x0F,
  0xFC, 0x07, 0x80, 0xFF, 0xFF, 0xF6, 0xDB, 0x00, 0x03, 0x83, 0x81, 0x81,
  0xC1, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0xE0, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0C,
  0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0x60, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x30, 0x2F, 0x8C, 0x7B, 0xFF,
  0xFF, 0x0F, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0C, 0xC0, 0x06, 0x38,
  0x03, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x08, 0x08, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x39, 0xCC, 0xE7, 0x39, 0x8C, 0xE6, 0x30, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0x07, 0x81, 0xC0, 0x30, 0x70, 0x07, 0x0C, 0x00,
  0x63, 0x80, 0x0E, 0x70, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x6E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xD8, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCE, 0x00, 0x39, 0xC0, 0x07,
  0x18, 0x00, 0xC3, 0x80, 0x38, 0x38, 0x0E, 0x07, 0x83, 0xC0, 0x7F, 0xF0,
  0x03, 0xF8, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x7B, 0x3C, 0xDC, 0x3E, 0x0D,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x03, 0xFE, 0x03,
  0xFF, 0xE1, 0xE0, 0x3C, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0,
  0x07, 0xFF, 0x03, 0xFF, 0xE3, 0xC0, 0x3C, 0x60, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xA0, 0x00, 0xEE, 0x00, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xE3,
  0x80, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x07, 0x00, 0x30, 0x38, 0x03,
  0x81, 0xC0, 0x18, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xC0, 0x1C,
  0x0E, 0x00, 0xE0, 0x60, 0x07, 0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0xC1, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x80, 0x0F, 0x30, 0x07, 0x8F, 0xFF, 0xC1, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x7C, 0x0C, 0x7F, 0xC3, 0x78,
  0x78, 0xD8, 0x07, 0x3C, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x19, 0x80, 0x06, 0x70, 0x03, 0x8E, 0x01, 0xC1, 0xC0, 0xF0, 0x7F,
  0xF8, 0x07, 0xF8, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xE0, 0x03,
  0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x38, 0xC0, 0x06,
  0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x3C, 0x1C, 0x01, 0xEF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x01, 0xF7, 0x80, 0x78, 0x3C, 0x1C, 0x03, 0xC7, 0x00, 0x3C,
  0xE0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x67, 0x00, 0x1C, 0xE0, 0x03, 0x8F, 0x01, 0xE0,
  0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xE0,
  0xF0, 0x3C, 0x38, 0x07, 0x1C, 0x00, 0xE6, 0x00, 0x1B, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0xCE, 0x01, 0xB1, 0xE3, 0xCC,
  0x3F, 0xE3, 0x03, 0xE0, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0x7F, 0xF7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x3B, 0xDE,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xB9,
  0xCE, 0x63, 0x39, 0x8C, 0x60, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0xFF, 0xC3, 0xFF, 0xE3, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x70,
  0x07, 0xF8, 0x18, 0xC0, 0x3F, 0xF0, 0x3B, 0x80, 0xE0, 0x60, 0x36, 0x03,
  0x80, 0xC0, 0x6C, 0x06, 0x01, 0x80, 0xD8, 0x1C, 0x03, 0x01, 0xB0, 0x30,
  0x06, 0x03, 0x60, 0x60, 0x0C, 0x07, 0xC0, 0xC0, 0x18, 0x0F, 0x81, 0x80,
  0x30, 0x1F, 0x03, 0x00, 0x60, 0x3E, 0x06, 0x01, 0xC0, 0x6C, 0x0C, 0x03,
  0x81, 0xD8, 0x18, 0x07, 0x03, 0x30, 0x38, 0x1A, 0x06, 0x60, 0x38, 0x66,
  0x18, 0xC0, 0x3F, 0xCF, 0xE1, 0xC0, 0x3E, 0x0F, 0x81, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x02, 0x00, 0x07, 0xC0, 0x1C, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE3, 0x80, 0x3E, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0x37, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x07, 0x70, 0x00,
  0xEE, 0x00, 0x39, 0xC0, 0x1E, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xE0, 0x1F,
  0x1C, 0x00, 0x7B, 0x80, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x3F, 0x3F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0x00, 0x60, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0E, 0x01, 0xF8, 0x38,
  0x00, 0xF0, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB8, 0x00, 0x06,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x07, 0x83, 0x80,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3E, 0x00, 0xE0, 0xF0, 0x00, 0x43, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x70, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x31,
  0xC0, 0x00, 0x61, 0xE0, 0x00, 0xC1, 0xF0, 0x07, 0x81, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3,
  0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0xA1, 0xCF, 0xF3, 0xF0, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0x8E,
  0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0x80,
  0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xF8, 0x00, 0xF9, 0xC0, 0x0F, 0x1C,
  0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0,
  0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0F,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFD, 0x80, 0x00, 0x1B, 0xDC, 0x00, 0x01, 0xBD, 0xC0, 0x00,
  0x3B, 0xCC, 0x00, 0x03, 0x3E, 0xE0, 0x00, 0x33, 0xEE, 0x00, 0x07, 0x3E,
  0x60, 0x00, 0x63, 0xE7, 0x00, 0x0E, 0x3E, 0x30, 0x00, 0xE3, 0xE3, 0x00,
  0x0C, 0x3E, 0x38, 0x01, 0xC3, 0xE1, 0x80, 0x18, 0x3E, 0x18, 0x01, 0x83,
  0xE1, 0xC0, 0x38, 0x3E, 0x0C, 0x03, 0x03, 0xE0, 0xE0, 0x30, 0x3E, 0x0E,
  0x07, 0x03, 0xE0, 0x60, 0x60, 0x3E, 0x07, 0x06, 0x03, 0xE0, 0x70, 0xE0,
  0x3E, 0x03, 0x0C, 0x03, 0xE0, 0x39, 0xC0, 0x3E, 0x01, 0x98, 0x03, 0xE0,
  0x19, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xDC, 0x00, 0x1F, 0x70, 0x00,
  0x7C, 0xE0, 0x01, 0xF1, 0x80, 0x07, 0xC7, 0x00, 0x1F, 0x8E, 0x00, 0x7E,
  0x38, 0x01, 0xF8, 0x70, 0x07, 0xE1, 0xC0, 0x1F, 0x83, 0x80, 0x7E, 0x06,
  0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x01, 0xC1,
  0xF8, 0x07, 0x07, 0xE0, 0x0E, 0x1F, 0x80, 0x1C, 0x7E, 0x00, 0x71, 0xF8,
  0x00, 0xE7, 0xE0, 0x03, 0x9F, 0x80, 0x07, 0x7E, 0x00, 0x0D, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xE0, 0x1F,
  0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0D,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x3E, 0x03,
  0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0E, 0x03, 0xE3, 0x80, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1B,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x03, 0xC1,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1,
  0xC0, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x3E, 0x03, 0xC0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0x80, 0xFC,
  0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x67, 0x00, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x39,
  0xC0, 0x07, 0x38, 0x01, 0xC7, 0x01, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0x03,
  0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x07, 0x07,
  0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x01, 0xCE,
  0x00, 0x19, 0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0x00, 0xF0, 0x01,
  0xFF, 0xC1, 0xFF, 0xF8, 0xF0, 0x0E, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xA0, 0x01, 0xEE, 0x00, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xE0,
  0x00, 0xE3, 0x80, 0x0E, 0x1F, 0x01, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x80, 0x00, 0xE7,
  0x00, 0x01, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x18,
  0x00, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x60, 0x03, 0x80, 0xE0,
  0x06, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x60, 0x07, 0x01,
  0xC0, 0x06, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x38,
  0x00, 0x30, 0x60, 0x00, 0x71, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xC6, 0x00,
  0x01, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0xB0, 0x00, 0xF8,
  0x00, 0x67, 0x00, 0x1B, 0x00, 0x1C, 0xE0, 0x03, 0x60, 0x03, 0x9C, 0x00,
  0xEC, 0x00, 0x71, 0x80, 0x1D, 0xC0, 0x0C, 0x30, 0x03, 0x38, 0x03, 0x87,
  0x00, 0x63, 0x00, 0x70, 0xE0, 0x1C, 0x60, 0x0E, 0x0C, 0x03, 0x8E, 0x01,
  0x81, 0x80, 0x61, 0xC0, 0x70, 0x38, 0x0C, 0x18, 0x0E, 0x07, 0x03, 0x83,
  0x01, 0xC0, 0x60, 0x70, 0x70, 0x30, 0x0C, 0x0C, 0x0E, 0x0E, 0x01, 0xC1,
  0x80, 0xC1, 0xC0, 0x38, 0x70, 0x18, 0x38, 0x03, 0x0E, 0x03, 0x86, 0x00,
  0x61, 0x80, 0x31, 0xC0, 0x0E, 0x30, 0x06, 0x38, 0x01, 0xCE, 0x00, 0xC7,
  0x00, 0x19, 0xC0, 0x1C, 0xC0, 0x03, 0x30, 0x01, 0xB8, 0x00, 0x76, 0x00,
  0x37, 0x00, 0x0E, 0xC0, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0xD8, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x06,
  0x07, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x18, 0x01,
  0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x80, 0x01,
  0x86, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xE0, 0x0E, 0x01,
  0x80, 0x30, 0x07, 0x01, 0xC0, 0x0E, 0x06, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xC0, 0x01, 0xC7, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80,
  0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x0C, 0x00, 0x60,
  0x70, 0x07, 0x01, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x30, 0x1C, 0x01, 0xC1,
  0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00, 0x07, 0x30, 0x00,
  0x3B, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x1C, 0xC0, 0x00, 0xC6,
  0x00, 0x0E, 0x38, 0x00, 0x60, 0xC0, 0x07, 0x07, 0x00, 0x30, 0x18, 0x03,
  0x80, 0xE0, 0x18, 0x03, 0x01, 0xC0, 0x1C, 0x0C, 0x00, 0x60, 0xE0, 0x03,
  0x86, 0x00, 0x0C, 0x70, 0x00, 0x77, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF8, 0x3F,
  0xFC, 0x18, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x01, 0xFF, 0x0F, 0xFF, 0x3E, 0x03, 0x78,
  0x03, 0x70, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0x70, 0x1B, 0x3F, 0xF3, 0x1F, 0xE3, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x7F, 0x83, 0x3F, 0xF8,
  0xDC, 0x0F, 0x3C, 0x01, 0xCF, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xB0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x06,
  0xE0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x73, 0x70, 0x3C, 0xCF, 0xFE, 0x31,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x1E, 0x02, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0x0F, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x1F, 0xE3, 0x87, 0xFE, 0x71, 0xE0, 0x6E, 0x70, 0x07, 0xCE,
  0x00, 0x7B, 0x80, 0x0F, 0x70, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E, 0x60,
  0x03, 0xCE, 0x00, 0xD8, 0xE0, 0x33, 0x0F, 0xFC, 0x60, 0xFF, 0x0C, 0x03,
  0xFC, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0, 0x0C, 0x38, 0x03, 0x9C, 0x00,
  0x67, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x60, 0xFF, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x07, 0xFE,
  0x3F, 0xF8, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x61, 0xFF, 0xCC, 0x78, 0x1B,
  0x9C, 0x01, 0xF3, 0x80, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x3B, 0x00, 0x07,
  0x60, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x07, 0x98, 0x00, 0xF3, 0x80, 0x3E, 0x38, 0x0D, 0xC3, 0xFF, 0x38,
  0x3F, 0xC7, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x71, 0x00, 0x1C, 0x3F, 0x3F, 0x07,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x31, 0xFE, 0x19, 0xFF, 0xCD, 0xC0, 0xE7, 0x80, 0x3B, 0xC0,
  0x0D, 0xC0, 0x06, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x6F, 0xF6, 0x00, 0x00, 0x06, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x03,
  0x03, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x4F, 0x3F, 0x8F,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0xC0,
  0x1C, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0xE0, 0xC1, 0xC0, 0xC3,
  0x80, 0xC7, 0x00, 0xC7, 0x00, 0xCF, 0x00, 0xDF, 0x00, 0xFB, 0x80, 0xF1,
  0x80, 0xE1, 0xC0, 0xC0, 0xE0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x30, 0xC0,
  0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0xF0, 0x3F, 0xC6, 0x7F, 0xE3,
  0xFF, 0x36, 0x07, 0x38, 0x3D, 0xE0, 0x1F, 0x00, 0xEE, 0x00, 0xF8, 0x03,
  0x70, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0xC0,
  0x06, 0x00, 0x3E, 0x00, 0x30, 0x01, 0xF0, 0x01, 0x80, 0x0F, 0x80, 0x0C,
  0x00, 0x7C, 0x00, 0x60, 0x03, 0xE0, 0x03, 0x00, 0x1F, 0x00, 0x18, 0x00,
  0xF8, 0x00, 0xC0, 0x07, 0xC0, 0x06, 0x00, 0x3E, 0x00, 0x30, 0x01, 0xF0,
  0x01, 0x80, 0x0F, 0x80, 0x0C, 0x00, 0x7C, 0x00, 0x60, 0x03, 0xE0, 0x03,
  0x00, 0x1F, 0x00, 0x18, 0x00, 0xF8, 0x00, 0xC0, 0x07, 0xC3, 0xF8, 0x67,
  0xFF, 0x37, 0x03, 0x9E, 0x00, 0xEF, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x1C,
  0xE0, 0x01, 0x9C, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0x1C, 0x00, 0xE3,
  0x80, 0x38, 0x3C, 0x0F, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0xC3, 0xF8, 0x33,
  0xFF, 0x8D, 0xC0, 0xF3, 0x60, 0x1C, 0xF0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x1B, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x6E, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x07, 0x37, 0x03, 0xCC, 0xFF,
  0xE3, 0x1F, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0x61, 0xFF, 0x8C, 0x78, 0x1B, 0x9C,
  0x01, 0xF3, 0x80, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x3B, 0x00, 0x07, 0x60,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x07, 0x98, 0x00, 0xF3, 0x80, 0x3E, 0x38, 0x0D, 0xC3, 0xFF, 0x38, 0x3F,
  0xC7, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0xC7, 0xF9, 0xFF, 0x70, 0x6C, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x1F, 0xF8, 0x7F, 0xFD, 0xC0, 0x37, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xD8, 0x07, 0xBF, 0xFE, 0x3F, 0xF8, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x7F, 0xEF, 0xFE, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x0F, 0xF0, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xD8, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x79, 0xC0, 0xEC, 0xFF, 0xE6, 0x1F, 0xE3, 0xE0, 0x00,
  0xEC, 0x00, 0x19, 0x80, 0x07, 0x38, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x07,
  0x0E, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x18,
  0x06, 0x07, 0x00, 0xE0, 0xE0, 0x0C, 0x18, 0x01, 0x87, 0x00, 0x38, 0xE0,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x0E, 0xE0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x3E, 0x00,
  0x38, 0x01, 0xB8, 0x03, 0xC0, 0x0D, 0xC0, 0x1F, 0x00, 0xE6, 0x00, 0xD8,
  0x07, 0x30, 0x0E, 0xC0, 0x31, 0xC0, 0x66, 0x01, 0x8E, 0x03, 0x38, 0x1C,
  0x30, 0x38, 0xC0, 0xE1, 0x81, 0xC6, 0x06, 0x0E, 0x0C, 0x30, 0x30, 0x30,
  0x61, 0xC3, 0x81, 0x87, 0x06, 0x1C, 0x0E, 0x30, 0x30, 0xC0, 0x71, 0x81,
  0xC6, 0x01, 0x9C, 0x0E, 0x70, 0x0C, 0xE0, 0x33, 0x00, 0x66, 0x01, 0x98,
  0x03, 0xB0, 0x0E, 0xC0, 0x0D, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0, 0xE0, 0x01,
  0xDC, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x0E, 0x03, 0x03, 0x00,
  0xE1, 0xC0, 0x1C, 0xE0, 0x03, 0x38, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x33, 0x00, 0x1C, 0xE0, 0x06, 0x18,
  0x03, 0x87, 0x01, 0xC0, 0xE0, 0x60, 0x18, 0x38, 0x07, 0x1C, 0x00, 0xE7,
  0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0xC0, 0x07, 0x38,
  0x00, 0xE3, 0x00, 0x18, 0x70, 0x03, 0x0E, 0x00, 0xE0, 0xC0, 0x18, 0x1C,
  0x03, 0x03, 0x80, 0xE0, 0x30, 0x18, 0x07, 0x03, 0x00, 0x60, 0xE0, 0x0C,
  0x18, 0x01, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x06,
  0xE0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x9E, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x3F, 0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0xF8, 0x0E, 0x00, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F, 0xC0,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x01, 0xF0, 0x07, 0x01, 0xF0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x1C, 0x0F, 0xC0, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFC,
  0x0F, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_Light45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 32, 11, 3, -32 },
  { 17, 10, 11, 16, 3, -32 },
  { 31, 24, 32, 26, 1, -32 },
  { 127, 18, 37, 23, 2, -34 },
  { 211, 29, 33, 33, 2, -33 },
  { 331, 25, 33, 28, 2, -33 },
  { 435, 3, 11, 9, 3, -32 },
  { 440, 9, 39, 12, 2, -32 },
  { 484, 8, 39, 12, 2, -32 },
  { 523, 18, 17, 22, 2, -34 },
  { 562, 19, 21, 23, 2, -26 },
  { 612, 5, 11, 10, 2, -5 },
  { 619, 10, 2, 14, 2, -13 },
  { 622, 4, 4, 10, 3, -4 },
  { 624, 14, 32, 16, 1, -32 },
  { 680, 19, 33, 23, 2, -33 },
  { 759, 10, 32, 23, 4, -32 },
  { 799, 18, 33, 23, 2, -33 },
  { 874, 18, 33, 23, 2, -33 },
  { 949, 21, 32, 23, 1, -32 },
  { 1033, 18, 32, 23, 3, -32 },
  { 1105, 18, 34, 23, 3, -33 },
  { 1182, 19, 32, 23, 2, -32 },
  { 1258, 19, 33, 23, 2, -33 },
  { 1337, 18, 34, 23, 2, -33 },
  { 1414, 4, 24, 10, 3, -24 },
  { 1426, 5, 30, 10, 2, -24 },
  { 1445, 19, 20, 23, 2, -26 },
  { 1493, 19, 12, 23, 2, -22 },
  { 1522, 19, 20, 23, 2, -26 },
  { 1570, 15, 33, 17, 1, -33 },
  { 1632, 31, 36, 36, 2, -32 },
  { 1772, 24, 32, 24, 0, -32 },
  { 1868, 19, 32, 25, 4, -32 },
  { 1944, 21, 33, 25, 3, -33 },
  { 2031, 22, 32, 28, 4, -32 },
  { 2119, 16, 32, 22, 4, -32 },
  { 2183, 16, 32, 20, 4, -32 },
  { 2247, 23, 33, 29, 3, -33 },
  { 2342, 21, 32, 29, 4, -32 },
  { 2426, 9, 32, 13, 2, -32 },
  { 2462, 10, 40, 11, -3, -32 },
  { 2512, 20, 32, 24, 4, -32 },
  { 2592, 16, 32, 21, 4, -32 },
  { 2656, 28, 32, 36, 4, -32 },
  { 2768, 22, 32, 30, 4, -32 },
  { 2856, 25, 33, 31, 3, -33 },
  { 2960, 18, 32, 24, 4, -32 },
  { 3032, 25, 41, 31, 3, -33 },
  { 3161, 19, 32, 24, 4, -32 },
  { 3237, 18, 33, 22, 2, -33 },
  { 3312, 21, 32, 21, 0, -32 },
  { 3396, 21, 32, 29, 4, -32 },
  { 3480, 23, 32, 23, 0, -32 },
  { 3572, 35, 32, 37, 1, -32 },
  { 3712, 22, 32, 22, 0, -32 },
  { 3800, 21, 32, 21, 0, -32 },
  { 3884, 20, 32, 22, 1, -32 },
  { 3964, 9, 39, 14, 4, -32 },
  { 4008, 14, 32, 16, 1, -32 },
  { 4064, 10, 39, 14, 1, -32 },
  { 4113, 21, 18, 23, 1, -32 },
  { 4161, 19, 2, 19, 0, 4 },
  { 4166, 8, 7, 12, 2, -34 },
  { 4173, 16, 24, 22, 2, -24 },
  { 4221, 18, 34, 24, 4, -34 },
  { 4298, 16, 24, 19, 2, -24 },
  { 4346, 19, 34, 24, 2, -34 },
  { 4427, 18, 24, 22, 2, -24 },
  { 4481, 14, 34, 13, 1, -34 },
  { 4541, 19, 35, 24, 2, -24 },
  { 4625, 17, 34, 24, 4, -34 },
  { 4698, 4, 33, 10, 3, -33 },
  { 4715, 9, 44, 10, -2, -33 },
  { 4765, 16, 34, 20, 4, -34 },
  { 4833, 2, 34, 10, 4, -34 },
  { 4842, 29, 24, 36, 4, -24 },
  { 4929, 17, 24, 24, 4, -24 },
  { 4980, 19, 24, 24, 2, -24 },
  { 5037, 18, 35, 24, 4, -24 },
  { 5116, 19, 35, 24, 2, -24 },
  { 5200, 11, 24, 16, 4, -24 },
  { 5233, 15, 24, 19, 2, -24 },
  { 5278, 12, 30, 14, 1, -30 },
  { 5323, 17, 24, 24, 3, -24 },
  { 5374, 19, 24, 19, 0, -24 },
  { 5431, 29, 24, 30, 1, -24 },
  { 5518, 18, 24, 20, 1, -24 },
  { 5572, 19, 35, 19, 0, -24 },
  { 5656, 14, 24, 18, 2, -24 },
  { 5698, 12, 39, 16, 2, -32 },
  { 5757, 2, 45, 22, 10, -34 },
  { 5769, 12, 39, 16, 2, -32 },
  { 5828, 19, 5, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Light45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT45PT7B_H_
