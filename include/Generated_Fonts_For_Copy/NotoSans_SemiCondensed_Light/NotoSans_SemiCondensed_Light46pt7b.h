#ifndef _NOTOSANS_SEMICONDENSED_LIGHT46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light46pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66,
  0x66, 0x00, 0x00, 0x07, 0xFF, 0x70, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x34, 0x0D, 0x03, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x80, 0x06, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x0E, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x8E, 0x30, 0x63, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03,
  0x83, 0x00, 0x70, 0x60, 0x06, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x01,
  0xE6, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x0C, 0xF0, 0x01, 0x87, 0x00, 0x30, 0x70, 0x06, 0x06, 0x00, 0xC0, 0xE0,
  0x18, 0x1C, 0x03, 0x03, 0x80, 0x60, 0x70, 0x0C, 0x1D, 0x01, 0x83, 0xB8,
  0x31, 0xE7, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x03, 0x00, 0xFF,
  0x00, 0x18, 0x03, 0x0E, 0x00, 0x60, 0x1C, 0x18, 0x03, 0x00, 0x60, 0x70,
  0x0C, 0x01, 0x80, 0xC0, 0x60, 0x0E, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x0E,
  0x00, 0xE0, 0x30, 0x30, 0x03, 0x80, 0xC1, 0xC0, 0x0E, 0x03, 0x06, 0x00,
  0x38, 0x0C, 0x38, 0x00, 0xE0, 0x30, 0xC0, 0x01, 0x80, 0xC7, 0x1F, 0x06,
  0x03, 0x18, 0xFF, 0x18, 0x1C, 0xE7, 0x0C, 0x70, 0x63, 0x18, 0x38, 0xC3,
  0x9C, 0x60, 0x63, 0xFC, 0x63, 0x81, 0x87, 0xE3, 0x8C, 0x07, 0x00, 0x0C,
  0x30, 0x1C, 0x00, 0x30, 0xC0, 0x70, 0x01, 0x83, 0x00, 0xC0, 0x06, 0x0C,
  0x03, 0x00, 0x30, 0x30, 0x1C, 0x00, 0xC0, 0xC0, 0x70, 0x06, 0x03, 0x01,
  0xC0, 0x18, 0x0C, 0x06, 0x00, 0xE0, 0x38, 0x18, 0x03, 0x00, 0x60, 0x60,
  0x1C, 0x01, 0xC3, 0x00, 0x60, 0x03, 0xFC, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x18,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC3, 0x80,
  0x30, 0xE0, 0x70, 0x1C, 0x70, 0x0E, 0x07, 0x18, 0x01, 0xC1, 0x8E, 0x00,
  0x78, 0xE3, 0x80, 0x0F, 0x38, 0xE0, 0x01, 0xDC, 0x38, 0x00, 0x3F, 0x0E,
  0x00, 0x07, 0x81, 0x80, 0x01, 0xE0, 0x70, 0x00, 0xFC, 0x1E, 0x00, 0x77,
  0x83, 0xC0, 0x78, 0xF0, 0x7F, 0xFC, 0x1C, 0x0F, 0xFC, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF9, 0x20, 0x03, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0C, 0x07,
  0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x07, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x03, 0x83, 0x81, 0x81, 0xC0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F,
  0x0C, 0x1F, 0xFB, 0x7F, 0x3F, 0xFF, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0C,
  0xC0, 0x07, 0x38, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x38, 0x1C, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x39, 0xCE, 0x67, 0x39,
  0x8C, 0xE6, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF7, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x38, 0x3C, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x03, 0x8C, 0x00, 0x73,
  0x80, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xC0, 0x01, 0xD8,
  0x00, 0x3B, 0x00, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x18, 0xC0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x38, 0x38, 0x07, 0x03, 0x83, 0xC0, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0xC0, 0xF0, 0x7C, 0x3B, 0x1C, 0xCE, 0x3F, 0x0D, 0x83,
  0x40, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x07, 0xF8, 0x03, 0xFF,
  0xC1, 0xF0, 0x3C, 0x38, 0x03, 0xC2, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0xC1, 0xF0, 0x3C, 0x70, 0x01,
  0xC4, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1D,
  0x00, 0x07, 0x38, 0x03, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x1D, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x71, 0x80, 0x03,
  0x86, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x06,
  0x00, 0x70, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x06, 0x01,
  0x80, 0x18, 0x0E, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00,
  0x18, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x19, 0xF8,
  0x07, 0xFF, 0xC1, 0xF1, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xA0, 0x01,
  0xCE, 0x01, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x78, 0x08, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0xFF, 0x0C, 0xFF, 0xE3, 0x70, 0x3C, 0xD8, 0x03, 0xBC, 0x00,
  0x6E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0xC0, 0x07, 0x70,
  0x03, 0x8E, 0x00, 0xE1, 0xC0, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x78, 0x1E, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0x33, 0x80, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01,
  0xC1, 0xC0, 0x70, 0x1E, 0x1C, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xFC,
  0x01, 0xE3, 0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01,
  0xD8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xB0, 0x00, 0x77, 0x00, 0x0E, 0xF0, 0x03, 0x8F, 0x01, 0xE0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x3C, 0x1C, 0x03,
  0x87, 0x00, 0x38, 0xE0, 0x03, 0x98, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00,
  0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xD8, 0x00, 0x3B, 0x80, 0x0F, 0x78, 0x03, 0xE7, 0x80, 0xDC, 0x7F, 0xF3,
  0x87, 0xFC, 0x70, 0x0C, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xC0, 0x00,
  0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x70, 0x33, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x9C, 0xCE, 0x73, 0x98, 0xCE, 0x63, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0xE1, 0xFF, 0xF3, 0xC1, 0xF2, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0xF0, 0x06, 0x38, 0x07, 0xFE, 0x06, 0x30, 0x0F,
  0x0E, 0x06, 0x70, 0x1C, 0x0E, 0x07, 0x60, 0x38, 0x0E, 0x03, 0x60, 0x30,
  0x0E, 0x03, 0x60, 0x70, 0x0E, 0x03, 0x60, 0x70, 0x0E, 0x03, 0x60, 0x60,
  0x0E, 0x03, 0xE0, 0x60, 0x0E, 0x03, 0xE0, 0x60, 0x0C, 0x03, 0xE0, 0x60,
  0x0C, 0x03, 0x60, 0x60, 0x0C, 0x07, 0x60, 0x60, 0x1C, 0x06, 0x60, 0x70,
  0x1E, 0x06, 0x60, 0x30, 0x36, 0x0C, 0x60, 0x38, 0x77, 0x1C, 0x70, 0x1F,
  0xE3, 0xF8, 0x30, 0x07, 0x81, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x01, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C,
  0x06, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xE0, 0x7F, 0x8E, 0x00, 0x3C,
  0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00,
  0x38, 0xE0, 0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0E, 0x00, 0x78, 0xE0,
  0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E,
  0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC1, 0xF0, 0x1E, 0x1E, 0x00, 0x21,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x38, 0x01, 0xF0, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xE3,
  0x80, 0x1F, 0x0E, 0x07, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x06, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x1E,
  0x00, 0x07, 0x0F, 0x00, 0x07, 0x07, 0xC0, 0x0F, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x18, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x71, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE8, 0x7B, 0xFC, 0xFE, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x0E,
  0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x00,
  0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00,
  0x0E, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9C, 0x00, 0xF0, 0xE0, 0x0E, 0x0F,
  0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xE0,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x1C, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xB0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xDF, 0xB0, 0x00, 0x06, 0xFD, 0xC0, 0x00, 0x77, 0xEE, 0x00, 0x03,
  0x3F, 0x30, 0x00, 0x19, 0xF9, 0xC0, 0x01, 0xCF, 0xC6, 0x00, 0x0C, 0x7E,
  0x30, 0x00, 0xE3, 0xF1, 0xC0, 0x07, 0x1F, 0x86, 0x00, 0x30, 0xFC, 0x38,
  0x03, 0x87, 0xE1, 0xC0, 0x18, 0x3F, 0x06, 0x00, 0xC1, 0xF8, 0x38, 0x0E,
  0x0F, 0xC1, 0xC0, 0x60, 0x7E, 0x06, 0x03, 0x03, 0xF0, 0x38, 0x38, 0x1F,
  0x80, 0xC1, 0x80, 0xFC, 0x06, 0x0C, 0x07, 0xE0, 0x38, 0xE0, 0x3F, 0x00,
  0xC6, 0x01, 0xF8, 0x06, 0x70, 0x0F, 0xC0, 0x3B, 0x80, 0x7E, 0x00, 0xD8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3C, 0x00, 0xFC, 0x00, 0xE0, 0x07,
  0xE0, 0x07, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0xE0, 0x00, 0xFB,
  0x80, 0x03, 0xE7, 0x00, 0x0F, 0x8E, 0x00, 0x3E, 0x38, 0x00, 0xF8, 0x70,
  0x03, 0xE1, 0xC0, 0x0F, 0x83, 0x80, 0x3E, 0x06, 0x00, 0xF8, 0x1C, 0x03,
  0xE0, 0x38, 0x0F, 0x80, 0xE0, 0x3E, 0x01, 0xC0, 0xF8, 0x07, 0x03, 0xE0,
  0x0E, 0x0F, 0x80, 0x18, 0x3E, 0x00, 0x70, 0xF8, 0x00, 0xE3, 0xE0, 0x03,
  0x8F, 0x80, 0x07, 0x3E, 0x00, 0x1C, 0xF8, 0x00, 0x3B, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x38, 0x00, 0xF0,
  0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0x0E, 0x0F, 0xF3, 0x80, 0x3C, 0xE0, 0x03, 0xB8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1E, 0xE0,
  0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFC, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x0F, 0x80,
  0x38, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0E,
  0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0xF0, 0xE0, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0E, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xE0,
  0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0x70, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x78, 0x0E, 0x1C, 0x00,
  0x47, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1D,
  0x00, 0x07, 0x3C, 0x03, 0xC7, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x80, 0x00,
  0x6E, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x70, 0xE0, 0x03, 0xC1,
  0xE0, 0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0x00, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0x80, 0x01,
  0x83, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x66, 0x00, 0x0F, 0x00, 0x0E, 0x70, 0x01, 0xF0, 0x00, 0xE7, 0x00, 0x1B,
  0x00, 0x0E, 0x70, 0x01, 0xB8, 0x00, 0xC3, 0x00, 0x19, 0x80, 0x1C, 0x30,
  0x03, 0x98, 0x01, 0xC3, 0x80, 0x39, 0x80, 0x1C, 0x38, 0x03, 0x1C, 0x01,
  0x81, 0x80, 0x30, 0xC0, 0x38, 0x18, 0x07, 0x0C, 0x03, 0x81, 0xC0, 0x70,
  0xE0, 0x38, 0x1C, 0x06, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x60, 0x30, 0x0C,
  0x0E, 0x06, 0x07, 0x00, 0xE0, 0xE0, 0x70, 0x70, 0x0E, 0x0C, 0x07, 0x06,
  0x00, 0x60, 0xC0, 0x30, 0x60, 0x06, 0x1C, 0x03, 0x0E, 0x00, 0x71, 0xC0,
  0x38, 0xE0, 0x07, 0x18, 0x03, 0x8C, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x03,
  0x38, 0x01, 0x9C, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x03, 0xB0, 0x01, 0xD8,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x00, 0x60, 0x1C, 0x01,
  0xC0, 0x60, 0x03, 0x03, 0x80, 0x0E, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x73,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x33, 0x80, 0x01,
  0xCE, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x30, 0x01, 0xC0, 0xE0, 0x07, 0x01,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0x38, 0x18, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0x60, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xC0, 0x03, 0x87, 0x00, 0x0E,
  0x18, 0x00, 0x18, 0xE0, 0x00, 0x73, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0xFF, 0xFF, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0x98, 0x00, 0x39,
  0x80, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0C,
  0x03, 0x01, 0xC0, 0x30, 0x18, 0x01, 0x83, 0x80, 0x18, 0x30, 0x01, 0xC7,
  0x00, 0x0C, 0x60, 0x00, 0xEE, 0x00, 0x06, 0xC0, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x03, 0x03, 0xF0,
  0x0F, 0xFE, 0x0F, 0xCF, 0x82, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x7F, 0xF1,
  0xFF, 0xF9, 0xF0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7D, 0xC0, 0x6E, 0x7F,
  0xE3, 0x1F, 0xE1, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x07, 0xE0, 0x63, 0xFE, 0x0C, 0xF1, 0xF1, 0xB0,
  0x0E, 0x3C, 0x00, 0xE7, 0x80, 0x0C, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x70, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x03, 0xBC, 0x00, 0xE7, 0x80, 0x3C, 0xDC, 0x0F, 0x19, 0xFF,
  0xC3, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x0F, 0xCF, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x01, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x07, 0xC1, 0x83, 0xFE, 0x30, 0xF0,
  0xE6, 0x38, 0x06, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x70, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00,
  0x77, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x1B, 0x1E, 0x07,
  0x61, 0xFF, 0xCC, 0x1F, 0xE1, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xF1,
  0xF0, 0x70, 0x1C, 0x38, 0x03, 0x8C, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x3F, 0xFF,
  0x03, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x70, 0x43, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x3F, 0xF8,
  0xFF, 0xE0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x8C, 0x3E, 0x79,
  0x8E, 0x01, 0xB3, 0x80, 0x1E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0x60, 0x00, 0xEC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x06, 0xC7, 0x81, 0xD8,
  0x7F, 0xF3, 0x07, 0xF8, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x20, 0x03, 0xC7,
  0x81, 0xF0, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x7E, 0x18, 0xFF, 0x8C, 0xF3, 0xE6, 0xC0,
  0x3B, 0xC0, 0x0D, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0x2F, 0xFF,
  0x20, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0xA3, 0xDF, 0xCF, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x70,
  0xC0, 0x70, 0xC0, 0xE0, 0xC1, 0xC0, 0xC3, 0x80, 0xC7, 0x00, 0xC7, 0x00,
  0xCF, 0x00, 0xDF, 0x80, 0xFB, 0x80, 0xF1, 0xC0, 0xE0, 0xC0, 0xC0, 0xE0,
  0xC0, 0x70, 0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0x86, 0x3F, 0xC1, 0xFF, 0x37, 0x8F, 0x1E, 0x7D,
  0xB0, 0x1D, 0x80, 0xFF, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x1F, 0x80,
  0x1C, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x18, 0x01, 0xF8, 0x63, 0xFE,
  0x33, 0xCF, 0x9B, 0x00, 0xEF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x81, 0xC0, 0x3C,
  0x38, 0x01, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00,
  0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x06, 0x70,
  0x00, 0xE3, 0x00, 0x0E, 0x38, 0x00, 0xC1, 0xC0, 0x1C, 0x1E, 0x07, 0x80,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x18, 0xFF, 0xC3, 0x3C, 0x7C,
  0x6C, 0x03, 0x8D, 0x00, 0x39, 0xE0, 0x03, 0x38, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x00, 0xEF, 0x00, 0x39, 0xB0, 0x0F, 0x37, 0x03, 0xC6,
  0x7F, 0xF0, 0xC7, 0xFC, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x8C,
  0x3C, 0x79, 0x8E, 0x01, 0xB3, 0x80, 0x1E, 0x70, 0x03, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xEC,
  0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x06, 0xC7,
  0x81, 0xD8, 0x7F, 0xF3, 0x07, 0xF8, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x01, 0xFC, 0x7E,
  0xCF, 0xED, 0xC0, 0xD8, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07,
  0xF0, 0x3F, 0xFC, 0xF0, 0xF3, 0x80, 0x2E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x7F, 0xFC, 0x7F, 0xF0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76,
  0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x06, 0xCE, 0x03, 0x31, 0xFF, 0x8C, 0x3F,
  0xC3, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x00, 0xE3, 0x00,
  0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE0, 0xC0, 0x1C, 0x1C, 0x03, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x03, 0x00, 0xE0, 0xE0, 0x0C, 0x1C, 0x01, 0xC3,
  0x00, 0x38, 0xE0, 0x03, 0x1C, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x00, 0xDC,
  0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0xC0, 0x07,
  0x00, 0x3F, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x0E, 0xC0, 0x1B, 0x00,
  0x66, 0x00, 0xD8, 0x07, 0x38, 0x06, 0xE0, 0x39, 0xC0, 0x73, 0x01, 0xC6,
  0x03, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x61, 0xC1, 0xC7, 0x07, 0x0E, 0x0E,
  0x18, 0x38, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x07, 0x0C, 0x0E, 0x38, 0x38,
  0xE0, 0x71, 0x80, 0xC7, 0x01, 0x8C, 0x06, 0x30, 0x0C, 0xE0, 0x39, 0x80,
  0x77, 0x01, 0xDC, 0x03, 0xB0, 0x06, 0xE0, 0x0D, 0x80, 0x36, 0x00, 0x6C,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0xF0, 0x01, 0xCE, 0x00, 0x70, 0xE0, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0xE0, 0x1C, 0x18, 0x01, 0x87, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0xEE,
  0x00, 0x38, 0xC0, 0x06, 0x1C, 0x01, 0xC1, 0x80, 0x70, 0x38, 0x0E, 0x03,
  0x83, 0x80, 0x30, 0xE0, 0x07, 0x1C, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03,
  0x06, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x01, 0x80, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x00, 0x60, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x18, 0xE0,
  0x03, 0x9C, 0x00, 0x73, 0x00, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x8F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0xC0, 0xF8,
  0x0F, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0xF0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0F, 0x03, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0,
  0x7C, 0x07, 0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 33, 11, 3, -33 },
  { 18, 10, 12, 16, 3, -33 },
  { 33, 24, 33, 26, 1, -33 },
  { 132, 19, 38, 24, 2, -35 },
  { 223, 30, 33, 34, 2, -33 },
  { 347, 26, 33, 28, 2, -33 },
  { 455, 3, 12, 9, 3, -33 },
  { 460, 9, 40, 13, 2, -33 },
  { 505, 9, 40, 13, 2, -33 },
  { 550, 18, 17, 22, 2, -35 },
  { 589, 20, 22, 24, 2, -27 },
  { 644, 5, 11, 10, 2, -5 },
  { 651, 10, 3, 14, 2, -14 },
  { 655, 4, 4, 11, 3, -4 },
  { 657, 14, 33, 16, 1, -33 },
  { 715, 19, 33, 24, 2, -33 },
  { 794, 10, 33, 24, 4, -33 },
  { 836, 19, 33, 24, 2, -33 },
  { 915, 19, 33, 24, 2, -33 },
  { 994, 22, 33, 24, 1, -33 },
  { 1085, 18, 33, 24, 3, -33 },
  { 1160, 18, 34, 24, 3, -33 },
  { 1237, 19, 33, 24, 2, -33 },
  { 1316, 19, 33, 24, 2, -33 },
  { 1395, 19, 34, 24, 2, -33 },
  { 1476, 4, 25, 11, 3, -25 },
  { 1489, 5, 31, 11, 2, -25 },
  { 1509, 20, 21, 24, 2, -27 },
  { 1562, 19, 12, 24, 2, -22 },
  { 1591, 20, 21, 24, 2, -27 },
  { 1644, 15, 33, 17, 1, -33 },
  { 1706, 32, 37, 36, 2, -33 },
  { 1854, 25, 33, 25, 0, -33 },
  { 1958, 20, 33, 26, 4, -33 },
  { 2041, 21, 33, 25, 3, -33 },
  { 2128, 22, 33, 29, 4, -33 },
  { 2219, 16, 33, 23, 4, -33 },
  { 2285, 16, 33, 21, 4, -33 },
  { 2351, 24, 33, 30, 3, -33 },
  { 2450, 21, 33, 30, 4, -33 },
  { 2537, 9, 33, 13, 2, -33 },
  { 2575, 10, 41, 11, -3, -33 },
  { 2627, 20, 33, 24, 4, -33 },
  { 2710, 16, 33, 21, 4, -33 },
  { 2776, 29, 33, 37, 4, -33 },
  { 2896, 22, 33, 30, 4, -33 },
  { 2987, 26, 33, 31, 3, -33 },
  { 3095, 18, 33, 24, 4, -33 },
  { 3170, 26, 41, 31, 3, -33 },
  { 3304, 20, 33, 25, 4, -33 },
  { 3387, 19, 33, 23, 2, -33 },
  { 3466, 21, 33, 21, 0, -33 },
  { 3553, 22, 33, 30, 4, -33 },
  { 3644, 24, 33, 24, 0, -33 },
  { 3743, 36, 33, 38, 1, -33 },
  { 3892, 22, 33, 22, 0, -33 },
  { 3983, 22, 33, 22, 0, -33 },
  { 4074, 19, 33, 23, 2, -33 },
  { 4153, 9, 40, 15, 4, -33 },
  { 4198, 14, 33, 16, 1, -33 },
  { 4256, 10, 40, 15, 1, -33 },
  { 4306, 20, 19, 24, 2, -33 },
  { 4354, 19, 2, 19, 0, 4 },
  { 4359, 8, 7, 12, 2, -35 },
  { 4366, 17, 25, 22, 2, -25 },
  { 4420, 19, 35, 25, 4, -35 },
  { 4504, 16, 25, 19, 2, -25 },
  { 4554, 19, 35, 25, 2, -35 },
  { 4638, 18, 25, 23, 2, -25 },
  { 4695, 14, 35, 13, 1, -35 },
  { 4757, 19, 36, 25, 2, -25 },
  { 4843, 17, 35, 25, 4, -35 },
  { 4918, 4, 34, 10, 3, -34 },
  { 4935, 9, 45, 10, -2, -34 },
  { 4986, 16, 35, 20, 4, -35 },
  { 5056, 2, 35, 10, 4, -35 },
  { 5065, 29, 25, 37, 4, -25 },
  { 5156, 17, 25, 25, 4, -25 },
  { 5210, 20, 25, 24, 2, -25 },
  { 5273, 19, 36, 25, 4, -25 },
  { 5359, 19, 36, 25, 2, -25 },
  { 5445, 12, 25, 16, 4, -25 },
  { 5483, 15, 25, 19, 2, -25 },
  { 5530, 12, 30, 14, 1, -30 },
  { 5575, 18, 24, 25, 3, -24 },
  { 5629, 19, 24, 19, 0, -24 },
  { 5686, 29, 24, 31, 1, -24 },
  { 5773, 19, 24, 20, 1, -24 },
  { 5830, 19, 35, 19, 0, -24 },
  { 5914, 15, 24, 18, 2, -24 },
  { 5959, 13, 40, 16, 2, -33 },
  { 6024, 2, 46, 22, 10, -35 },
  { 6036, 13, 40, 16, 2, -33 },
  { 6101, 20, 5, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Light46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT46PT7B_H_
