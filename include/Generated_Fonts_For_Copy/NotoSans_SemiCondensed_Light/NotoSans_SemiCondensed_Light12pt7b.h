#ifndef _NOTOSANS_SEMICONDENSED_LIGHT12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x24, 0x48, 0xA3, 0xF2, 0x85, 0x37, 0x24, 0x50,
  0x4F, 0xCC, 0x65, 0x55, 0xE4, 0xC5, 0x52, 0xA5, 0x4B, 0xFB, 0x4A, 0x95,
  0x4E, 0x62, 0x49, 0x18, 0x42, 0x99, 0x62, 0xF4, 0xF0, 0x6A, 0xAA, 0xA4,
  0x89, 0x12, 0x49, 0x2B, 0x00, 0x4D, 0x6F, 0x21, 0x3E, 0x42, 0x10, 0x58,
  0xE0, 0x80, 0x11, 0x22, 0x24, 0x44, 0x80, 0x64, 0xA5, 0x18, 0xC6, 0x32,
  0x70, 0x2E, 0x92, 0x49, 0x20, 0x69, 0x11, 0x12, 0x48, 0xF0, 0x69, 0x11,
  0x61, 0x11, 0xF0, 0x08, 0x62, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0xF4, 0x21,
  0x0F, 0x04, 0x22, 0xF0, 0x36, 0x21, 0x4D, 0x46, 0x31, 0x70, 0xF8, 0x84,
  0x22, 0x11, 0x08, 0x40, 0x64, 0xA5, 0x26, 0x4A, 0x31, 0xF0, 0x69, 0x99,
  0x97, 0x11, 0xE0, 0x84, 0x40, 0x16, 0x1B, 0x20, 0x83, 0x80, 0xF8, 0x3E,
  0x83, 0x06, 0x4C, 0x00, 0x69, 0x11, 0x24, 0x40, 0x40, 0x3C, 0x42, 0x81,
  0xBD, 0xA5, 0xA5, 0xA9, 0x96, 0x80, 0x7C, 0x10, 0x43, 0x0A, 0x49, 0xE4,
  0x61, 0x84, 0xF4, 0x63, 0x1F, 0x46, 0x31, 0xF0, 0x3A, 0x21, 0x08, 0x42,
  0x10, 0x78, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x62, 0xF0, 0xF8, 0x88, 0xF8,
  0x88, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0x80, 0x39, 0x18, 0x20, 0x9A, 0x18,
  0x61, 0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xEA, 0xAA, 0xC0,
  0x24, 0x92, 0x49, 0x27, 0x00, 0x8C, 0xA5, 0x4C, 0x52, 0x52, 0x88, 0x88,
  0x88, 0x88, 0x88, 0xF0, 0x81, 0x83, 0xC3, 0xC5, 0xA5, 0xA5, 0xA9, 0x99,
  0x91, 0x86, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x84, 0x3B, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x78, 0xE4, 0xE3, 0x19, 0x72, 0x10, 0x80, 0x3B, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x78, 0x20, 0xC0, 0xE4, 0xE3, 0x19, 0x72, 0x51, 0x88,
  0x78, 0x88, 0x61, 0x11, 0xF0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0x86, 0x18, 0x52, 0x49, 0x23,
  0x0C, 0x10, 0x88, 0x63, 0x14, 0xC9, 0x32, 0x54, 0x94, 0xA3, 0x30, 0x8C,
  0x21, 0x00, 0x85, 0x24, 0x8C, 0x20, 0xC4, 0x92, 0x84, 0x86, 0x24, 0x94,
  0x30, 0x82, 0x08, 0x20, 0x78, 0x42, 0x22, 0x11, 0x08, 0xF8, 0xEA, 0xAA,
  0xAC, 0x88, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10,
  0xC2, 0x92, 0xC4, 0xF8, 0xC4, 0xF1, 0x79, 0x9F, 0x84, 0x29, 0xA8, 0xC6,
  0x31, 0xF0, 0x69, 0x88, 0x88, 0x70, 0x08, 0x5B, 0x38, 0xC6, 0x31, 0xF8,
  0x69, 0x9F, 0x88, 0x70, 0x74, 0xE4, 0x44, 0x44, 0x40, 0x64, 0xE3, 0x18,
  0xC7, 0xE1, 0x17, 0x80, 0x84, 0x29, 0xA8, 0xC6, 0x31, 0x88, 0x9F, 0x80,
  0x41, 0x55, 0x56, 0x88, 0x89, 0xAC, 0xAA, 0x90, 0xFF, 0x80, 0x66, 0x99,
  0x91, 0x91, 0x91, 0x91, 0x91, 0x26, 0xA3, 0x18, 0xC6, 0x20, 0x64, 0xA3,
  0x18, 0xC5, 0xC0, 0x26, 0xA3, 0x18, 0xC7, 0xD0, 0x84, 0x00, 0x64, 0xE3,
  0x18, 0xC7, 0xE1, 0x08, 0x40, 0xF2, 0x49, 0x00, 0x32, 0x20, 0xC1, 0x07,
  0xC0, 0x5D, 0x24, 0x93, 0x99, 0x99, 0x9F, 0x8C, 0x54, 0xA5, 0x10, 0x99,
  0x99, 0x5A, 0x66, 0x66, 0x24, 0xCA, 0x88, 0x65, 0x44, 0x8A, 0x54, 0xA2,
  0x10, 0x84, 0xC0, 0x71, 0x24, 0x4F, 0x12, 0x22, 0x2C, 0x42, 0x22, 0x30,
  0xFF, 0xF0, 0xC2, 0x22, 0x23, 0x22, 0x22, 0xC0, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Light12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 7, 9, 7, 0, -9 },
  { 12, 4, 10, 6, 1, -9 },
  { 17, 7, 9, 9, 1, -9 },
  { 25, 6, 9, 7, 1, -9 },
  { 32, 1, 4, 2, 1, -9 },
  { 33, 2, 11, 3, 1, -9 },
  { 36, 3, 11, 3, 0, -9 },
  { 41, 4, 4, 6, 1, -9 },
  { 43, 5, 6, 6, 1, -7 },
  { 47, 2, 3, 3, 0, -1 },
  { 48, 3, 1, 4, 0, -4 },
  { 49, 1, 1, 3, 1, -1 },
  { 50, 4, 9, 4, 0, -9 },
  { 55, 5, 9, 6, 1, -9 },
  { 61, 3, 9, 6, 1, -9 },
  { 65, 4, 9, 6, 1, -9 },
  { 70, 4, 9, 6, 1, -9 },
  { 75, 6, 9, 6, 0, -9 },
  { 82, 5, 9, 6, 1, -9 },
  { 88, 5, 9, 6, 1, -9 },
  { 94, 5, 9, 6, 1, -9 },
  { 100, 5, 9, 6, 1, -9 },
  { 106, 4, 9, 6, 1, -9 },
  { 111, 1, 6, 3, 1, -6 },
  { 112, 2, 8, 3, 0, -6 },
  { 114, 5, 5, 6, 1, -7 },
  { 118, 5, 3, 6, 1, -6 },
  { 120, 5, 5, 6, 1, -7 },
  { 124, 4, 9, 5, 0, -9 },
  { 129, 8, 10, 10, 1, -9 },
  { 139, 6, 9, 6, 0, -9 },
  { 146, 5, 9, 7, 1, -9 },
  { 152, 5, 9, 7, 1, -9 },
  { 158, 6, 9, 8, 1, -9 },
  { 165, 4, 9, 6, 1, -9 },
  { 170, 4, 9, 5, 1, -9 },
  { 175, 6, 9, 8, 1, -9 },
  { 182, 6, 9, 8, 1, -9 },
  { 189, 2, 9, 3, 1, -9 },
  { 192, 3, 11, 3, -1, -9 },
  { 197, 5, 9, 6, 1, -9 },
  { 203, 4, 9, 5, 1, -9 },
  { 208, 8, 9, 10, 1, -9 },
  { 217, 6, 9, 8, 1, -9 },
  { 224, 6, 9, 8, 1, -9 },
  { 231, 5, 9, 6, 1, -9 },
  { 237, 6, 11, 8, 1, -9 },
  { 246, 5, 9, 6, 1, -9 },
  { 252, 4, 9, 6, 1, -9 },
  { 257, 6, 9, 6, 0, -9 },
  { 264, 6, 9, 8, 1, -9 },
  { 271, 6, 9, 6, 0, -9 },
  { 278, 10, 9, 10, 0, -9 },
  { 290, 6, 9, 6, 0, -9 },
  { 297, 6, 9, 6, 0, -9 },
  { 304, 5, 9, 6, 0, -9 },
  { 310, 2, 11, 4, 1, -9 },
  { 313, 4, 9, 4, 0, -9 },
  { 318, 3, 11, 4, 0, -9 },
  { 323, 6, 5, 6, 0, -9 },
  { 327, 5, 1, 5, 0, 1 },
  { 328, 3, 2, 3, 0, -9 },
  { 329, 4, 6, 6, 1, -6 },
  { 332, 5, 9, 7, 1, -9 },
  { 338, 4, 7, 5, 1, -7 },
  { 342, 5, 9, 7, 1, -9 },
  { 348, 4, 7, 6, 1, -7 },
  { 352, 4, 9, 3, 0, -9 },
  { 357, 5, 10, 6, 1, -7 },
  { 364, 5, 9, 6, 1, -9 },
  { 370, 1, 9, 3, 1, -9 },
  { 372, 2, 12, 3, 0, -9 },
  { 375, 4, 9, 5, 1, -9 },
  { 380, 1, 9, 3, 1, -9 },
  { 382, 8, 7, 10, 1, -7 },
  { 389, 5, 7, 6, 1, -7 },
  { 394, 5, 7, 6, 1, -7 },
  { 399, 5, 10, 7, 1, -7 },
  { 406, 5, 10, 6, 1, -7 },
  { 413, 3, 6, 4, 1, -6 },
  { 416, 5, 7, 5, 0, -7 },
  { 421, 3, 8, 4, 0, -8 },
  { 424, 4, 6, 6, 1, -6 },
  { 427, 5, 6, 5, 0, -6 },
  { 431, 8, 6, 8, 0, -6 },
  { 437, 5, 6, 5, 0, -6 },
  { 441, 5, 9, 5, 0, -6 },
  { 447, 4, 6, 5, 0, -6 },
  { 450, 4, 11, 4, 0, -9 },
  { 456, 1, 12, 6, 2, -9 },
  { 458, 4, 11, 4, 0, -9 },
  { 464, 5, 1, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_Light12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT12PT7B_H_
