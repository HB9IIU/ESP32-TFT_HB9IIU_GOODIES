#ifndef _NOTOSANS_SEMICONDENSED_LIGHT27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xD5, 0x50, 0x3C, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x80,
  0x04, 0x30, 0x10, 0x80, 0x42, 0x03, 0x08, 0x08, 0x20, 0x21, 0x87, 0xFF,
  0xC2, 0x10, 0x08, 0x40, 0x61, 0x01, 0x04, 0x04, 0x30, 0xFF, 0xF8, 0x42,
  0x01, 0x08, 0x0C, 0x20, 0x20, 0x80, 0x86, 0x02, 0x10, 0x00, 0x04, 0x00,
  0x80, 0x1C, 0x1F, 0xE6, 0x44, 0x88, 0x31, 0x06, 0x20, 0x44, 0x0C, 0x80,
  0xF0, 0x07, 0x80, 0x5C, 0x08, 0xC1, 0x18, 0x21, 0x04, 0x20, 0x8F, 0x97,
  0x3F, 0xC0, 0x40, 0x08, 0x01, 0x00, 0x10, 0x00, 0x0F, 0x01, 0x04, 0x60,
  0x81, 0x08, 0x20, 0xC2, 0x10, 0x30, 0x84, 0x0C, 0x23, 0x03, 0x08, 0x80,
  0xC2, 0x66, 0x10, 0x93, 0x64, 0x6D, 0x88, 0xF2, 0x42, 0x11, 0x90, 0xC0,
  0x44, 0x30, 0x31, 0x0C, 0x08, 0x43, 0x06, 0x10, 0x81, 0x04, 0x20, 0xC1,
  0x98, 0x20, 0x3C, 0x02, 0x00, 0x3F, 0x00, 0xC3, 0x01, 0x86, 0x03, 0x0C,
  0x06, 0x18, 0x0C, 0x30, 0x0C, 0xC0, 0x0B, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0x98, 0x26, 0x18, 0x58, 0x19, 0xB0, 0x1A, 0x60, 0x3C, 0xC0, 0x30, 0xC0,
  0xF1, 0xC3, 0x31, 0xFC, 0x30, 0xFE, 0x1C, 0x43, 0x08, 0x61, 0x84, 0x10,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x41, 0x86, 0x08, 0x30, 0x41, 0xC0,
  0xC3, 0x08, 0x61, 0x08, 0x63, 0x08, 0x42, 0x10, 0x84, 0x23, 0x18, 0x84,
  0x62, 0x33, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0E, 0x4E, 0x7F, 0x03,
  0x80, 0x50, 0x11, 0x06, 0x30, 0x44, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x6D, 0xA5, 0xA0, 0xFC, 0xF0, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0x40, 0x60, 0x30, 0x30, 0x00, 0x04, 0x03, 0xF0, 0xC3, 0x30, 0x26,
  0x06, 0x80, 0xD0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02,
  0x80, 0x50, 0x0A, 0x03, 0x60, 0x64, 0x08, 0xC7, 0x0F, 0xC0, 0x0C, 0x73,
  0x79, 0x44, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x40, 0x04, 0x07, 0xF1, 0x83, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x7F, 0xF0, 0x04, 0x0F, 0xF3, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x83, 0xE0, 0x7E, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x60, 0x0F, 0x07, 0x3F, 0xC0, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x2C, 0x04, 0xC0, 0xCC, 0x08, 0xC1, 0x8C, 0x30, 0xC2, 0x0C,
  0x60, 0xC4, 0x0C, 0x80, 0xCF, 0xFF, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x7F, 0x90, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x70,
  0xFF, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xA0,
  0xEF, 0xE0, 0x01, 0x03, 0xF0, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x9F, 0x16, 0x73, 0x03, 0x60, 0x28, 0x05, 0x00, 0xE0, 0x1C, 0x02,
  0xC0, 0x48, 0x19, 0x86, 0x1F, 0x80, 0xFF, 0xE0, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x00, 0x04, 0x03, 0xF8,
  0x30, 0xC6, 0x06, 0x40, 0x64, 0x06, 0x60, 0x62, 0x0C, 0x19, 0x80, 0xF0,
  0x1F, 0x03, 0x0C, 0x60, 0x64, 0x02, 0xC0, 0x2C, 0x03, 0xC0, 0x26, 0x06,
  0x70, 0xC1, 0xF8, 0x04, 0x07, 0xF1, 0x83, 0x30, 0x24, 0x07, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0x28, 0x0D, 0x82, 0x9F, 0xD0, 0xC2, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x0E, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x2D,
  0x80, 0x00, 0x00, 0x06, 0xDA, 0xDA, 0x00, 0x00, 0x10, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x0C, 0x00, 0x10, 0xFE, 0x83, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x03, 0xFC, 0x00, 0xC0, 0xE0, 0x60, 0x06, 0x08, 0x00, 0x43,
  0x00, 0x04, 0xC1, 0xF0, 0x98, 0x63, 0x1A, 0x18, 0x61, 0x42, 0x0C, 0x28,
  0xC1, 0x07, 0x18, 0x20, 0xE3, 0x04, 0x1C, 0x60, 0x86, 0x84, 0x30, 0x90,
  0xCD, 0x32, 0x0F, 0x3C, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0E,
  0x02, 0x00, 0x7F, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x28, 0x01, 0xA0, 0x04,
  0xC0, 0x11, 0x00, 0xC4, 0x02, 0x18, 0x08, 0x60, 0x60, 0x81, 0x03, 0x07,
  0xFC, 0x30, 0x10, 0x80, 0x62, 0x01, 0x98, 0x02, 0x40, 0x0F, 0x00, 0x3C,
  0x00, 0x40, 0xFF, 0x8C, 0x0E, 0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x02, 0xC0,
  0x6C, 0x04, 0xFF, 0x8F, 0xFC, 0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x6C, 0x1C, 0xFF, 0x80, 0x01, 0x00, 0xFF, 0x38, 0x17,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x30,
  0xFF, 0xFF, 0x86, 0x07, 0x30, 0x1D, 0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x06, 0xC0, 0x66, 0x1E, 0x3F, 0xC0, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFC, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xEC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x80, 0x3F, 0xF1,
  0x80, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x60, 0x0C, 0xC0, 0x31, 0xC1, 0xC3, 0xFE, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x06, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xBC, 0xC0,
  0x7C, 0x04, 0xC0, 0xCC, 0x18, 0xC3, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xD8,
  0x0F, 0xC0, 0xE6, 0x0C, 0x20, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0,
  0x6C, 0x06, 0xC0, 0x30, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0F, 0xFC, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xBA, 0x00,
  0x5D, 0x00, 0x6E, 0xC0, 0x27, 0x20, 0x13, 0x98, 0x19, 0xCC, 0x08, 0xE2,
  0x0C, 0x71, 0x86, 0x38, 0xC2, 0x1C, 0x23, 0x0E, 0x19, 0x07, 0x04, 0x83,
  0x82, 0xC1, 0xC1, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x20, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xA0, 0x1D, 0x80, 0xE6, 0x07, 0x30, 0x38, 0xC1, 0xC2, 0x0E,
  0x18, 0x70, 0x43, 0x83, 0x1C, 0x0C, 0xE0, 0x67, 0x01, 0xB8, 0x05, 0xC0,
  0x3E, 0x00, 0xF0, 0x06, 0x01, 0x80, 0x3F, 0xC0, 0xC0, 0xC3, 0x00, 0xC4,
  0x00, 0xD8, 0x01, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0x60, 0x06, 0x60, 0x0C,
  0xC0, 0x30, 0xE1, 0xC0, 0x7F, 0x00, 0xFF, 0x98, 0x3B, 0x01, 0x60, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xD8, 0x73, 0xFC, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x3F,
  0xC0, 0xC0, 0xC3, 0x00, 0xC4, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x40, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0x60, 0x06, 0x60, 0x0C, 0xC0, 0x30, 0xE1, 0xC0, 0x7F, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0xFF, 0x8C, 0x1C, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCF, 0xF8, 0xFE,
  0x0C, 0x30, 0xC1, 0x0C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x6C, 0x06, 0xC0,
  0x30, 0x06, 0x07, 0xFD, 0xC1, 0x30, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0B, 0x07, 0x7F, 0xC0, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x68, 0x03,
  0x60, 0x31, 0xC3, 0x07, 0xF0, 0xC0, 0x0D, 0x00, 0x24, 0x01, 0x98, 0x06,
  0x20, 0x10, 0x80, 0xC3, 0x03, 0x0C, 0x08, 0x10, 0x20, 0x61, 0x81, 0x86,
  0x02, 0x10, 0x0C, 0xC0, 0x33, 0x00, 0x48, 0x01, 0xE0, 0x07, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x30, 0x0D, 0x00, 0xC0, 0x26, 0x03, 0x81, 0x98,
  0x1E, 0x06, 0x20, 0x48, 0x18, 0x81, 0x20, 0x43, 0x04, 0xC3, 0x0C, 0x33,
  0x0C, 0x10, 0x84, 0x30, 0x42, 0x10, 0x81, 0x88, 0x66, 0x06, 0x61, 0x98,
  0x09, 0x02, 0x60, 0x24, 0x09, 0x00, 0xD0, 0x3C, 0x03, 0xC0, 0xF0, 0x06,
  0x01, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x00, 0x60, 0x39, 0x01, 0x8C,
  0x18, 0x20, 0xC1, 0x8C, 0x04, 0x40, 0x36, 0x00, 0xA0, 0x07, 0x00, 0x38,
  0x01, 0x40, 0x1B, 0x00, 0x88, 0x0C, 0x60, 0x41, 0x06, 0x0C, 0x60, 0x33,
  0x01, 0xB0, 0x06, 0xC0, 0x1A, 0x01, 0x98, 0x08, 0x40, 0xC3, 0x04, 0x08,
  0x60, 0x62, 0x01, 0x30, 0x0D, 0x80, 0x28, 0x01, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFF, 0xE0,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0xFF,
  0x80, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0, 0xC0, 0x30, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08,
  0x06, 0x01, 0x00, 0x80, 0x60, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x06, 0x00, 0x60, 0x09,
  0x00, 0x90, 0x11, 0x81, 0x08, 0x20, 0xC2, 0x04, 0x60, 0x64, 0x02, 0xC0,
  0x30, 0xFF, 0xFF, 0xFC, 0xC3, 0x08, 0x20, 0x80, 0x04, 0x1F, 0xE2, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0xFF, 0x60, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xD8, 0xD3, 0xE4, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x31,
  0x86, 0xFC, 0xE0, 0xD8, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x81, 0x78, 0xE9, 0xF8, 0x07, 0x07, 0xF3, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60,
  0x0C, 0x11, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41,
  0x88, 0xFD, 0x30, 0xEC, 0x0D, 0x00, 0xA0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x40, 0x28, 0x0D, 0x81, 0x98, 0x51, 0xF2, 0x06, 0x03, 0xF0, 0xC3,
  0x30, 0x24, 0x06, 0x80, 0xF0, 0x1F, 0xFF, 0xC0, 0x08, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x87, 0xF0, 0x07, 0x07, 0xC6, 0x02, 0x01, 0x00, 0x80,
  0x41, 0xFC, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x06, 0x03, 0xF4, 0xC3, 0xB0, 0x34, 0x02,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0, 0x36, 0x06, 0x61,
  0x47, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x01, 0xA0, 0x67, 0xF8, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x63, 0x7E, 0xE0, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x40, 0xB8, 0x0F, 0xFF, 0xFF, 0xFF, 0x10, 0xC4, 0x00, 0x00, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x17, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x06, 0xC3, 0x31, 0x8C,
  0x43, 0x30, 0xD8, 0x3E, 0x0E, 0xC3, 0x18, 0xC6, 0x30, 0xCC, 0x13, 0x06,
  0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x04, 0x27, 0xEF,
  0xEE, 0x1A, 0x1B, 0x03, 0x02, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F,
  0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0,
  0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0C, 0x06, 0x27, 0xEE, 0x0F, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x04, 0x06, 0x01, 0xFC, 0x30, 0x66, 0x06, 0x40, 0x24, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x34, 0x03, 0x40, 0x36, 0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80,
  0x06, 0x13, 0xF3, 0x83, 0x70, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x3E, 0x05, 0xE3, 0xB7, 0xE6, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x03, 0xF4, 0xC3, 0xB0, 0x34, 0x02,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0, 0x36, 0x06, 0x61,
  0x47, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x07, 0x3F,
  0xC7, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x00,
  0x1C, 0x3F, 0xD0, 0x18, 0x0C, 0x02, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x60, 0x10, 0x1E, 0x1F, 0xF8, 0x10, 0x10, 0x30, 0x30, 0xFE, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x1F, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x61, 0x4F, 0x90, 0xC0, 0x68, 0x0D, 0x81, 0x30, 0x62, 0x0C,
  0x61, 0x0C, 0x60, 0x8C, 0x11, 0x03, 0x60, 0x2C, 0x05, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0xC0, 0xD0, 0x30, 0x26, 0x0E, 0x09, 0x86, 0x86, 0x21, 0x21,
  0x88, 0x4C, 0x43, 0x33, 0x10, 0xCC, 0x4C, 0x12, 0x13, 0x04, 0x86, 0x81,
  0xE0, 0xA0, 0x70, 0x38, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xC0, 0xD8, 0x62,
  0x10, 0xCC, 0x12, 0x07, 0x80, 0xC0, 0x30, 0x1E, 0x0C, 0xC2, 0x11, 0x86,
  0xC0, 0xF0, 0x30, 0xC0, 0x68, 0x0D, 0x81, 0x30, 0x22, 0x0C, 0x61, 0x0C,
  0x20, 0x8C, 0x19, 0x01, 0x20, 0x2C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x78, 0x04, 0x00, 0xFF, 0x80, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x20, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x07, 0xFC,
  0x0F, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0xC0,
  0x30, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x18, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x0C, 0x03, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x30, 0xE0, 0x78, 0x1C, 0xF7, 0x81, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 6, 7, 10, 2, -19 },
  { 12, 14, 19, 15, 1, -19 },
  { 46, 11, 23, 14, 1, -21 },
  { 78, 18, 20, 20, 1, -20 },
  { 123, 15, 20, 17, 1, -20 },
  { 161, 1, 7, 5, 2, -19 },
  { 162, 6, 23, 7, 1, -19 },
  { 180, 5, 23, 7, 1, -19 },
  { 195, 11, 11, 13, 1, -21 },
  { 211, 12, 13, 14, 1, -16 },
  { 231, 3, 7, 6, 1, -3 },
  { 234, 6, 1, 8, 1, -8 },
  { 235, 2, 2, 6, 2, -2 },
  { 236, 9, 19, 9, 0, -19 },
  { 258, 11, 20, 14, 1, -20 },
  { 286, 6, 19, 14, 2, -19 },
  { 301, 11, 20, 14, 1, -20 },
  { 329, 11, 20, 14, 1, -20 },
  { 357, 12, 19, 14, 1, -19 },
  { 386, 10, 19, 14, 2, -19 },
  { 410, 11, 20, 14, 2, -20 },
  { 438, 11, 19, 14, 1, -19 },
  { 465, 12, 20, 14, 1, -20 },
  { 495, 11, 20, 14, 1, -20 },
  { 523, 2, 15, 6, 2, -15 },
  { 527, 3, 19, 6, 1, -15 },
  { 535, 12, 12, 14, 1, -16 },
  { 553, 12, 7, 14, 1, -13 },
  { 564, 12, 12, 14, 1, -16 },
  { 582, 8, 20, 10, 1, -20 },
  { 602, 19, 21, 21, 1, -19 },
  { 652, 14, 19, 15, 0, -19 },
  { 686, 12, 19, 15, 2, -19 },
  { 715, 12, 20, 15, 2, -20 },
  { 745, 13, 19, 17, 2, -19 },
  { 776, 10, 19, 13, 2, -19 },
  { 800, 10, 19, 12, 2, -19 },
  { 824, 14, 20, 18, 2, -20 },
  { 859, 13, 19, 17, 2, -19 },
  { 890, 6, 19, 8, 1, -19 },
  { 905, 6, 24, 6, -2, -19 },
  { 923, 12, 19, 14, 2, -19 },
  { 952, 10, 19, 12, 2, -19 },
  { 976, 17, 19, 22, 2, -19 },
  { 1017, 13, 19, 18, 2, -19 },
  { 1048, 15, 20, 18, 2, -20 },
  { 1086, 11, 19, 14, 2, -19 },
  { 1113, 15, 25, 18, 2, -20 },
  { 1160, 12, 19, 15, 2, -19 },
  { 1189, 11, 20, 13, 1, -20 },
  { 1217, 12, 19, 13, 0, -19 },
  { 1246, 13, 19, 17, 2, -19 },
  { 1277, 14, 19, 14, 0, -19 },
  { 1311, 22, 19, 22, 0, -19 },
  { 1364, 13, 19, 13, 0, -19 },
  { 1395, 13, 19, 13, 0, -19 },
  { 1426, 11, 19, 13, 1, -19 },
  { 1453, 6, 23, 9, 2, -19 },
  { 1471, 9, 19, 9, 0, -19 },
  { 1493, 5, 23, 9, 1, -19 },
  { 1508, 12, 11, 14, 1, -19 },
  { 1525, 11, 2, 11, 0, 2 },
  { 1528, 5, 5, 7, 1, -21 },
  { 1532, 10, 15, 13, 1, -15 },
  { 1551, 11, 21, 15, 2, -21 },
  { 1580, 10, 15, 11, 1, -15 },
  { 1599, 11, 21, 15, 1, -21 },
  { 1628, 11, 15, 13, 1, -15 },
  { 1649, 9, 21, 8, 0, -21 },
  { 1673, 11, 21, 15, 1, -15 },
  { 1702, 10, 21, 14, 2, -21 },
  { 1729, 2, 20, 6, 2, -20 },
  { 1734, 5, 26, 6, -1, -20 },
  { 1751, 10, 21, 12, 2, -21 },
  { 1778, 2, 21, 6, 2, -21 },
  { 1784, 18, 15, 22, 2, -15 },
  { 1818, 10, 15, 14, 2, -15 },
  { 1837, 12, 15, 14, 1, -15 },
  { 1860, 11, 21, 15, 2, -15 },
  { 1889, 11, 21, 15, 1, -15 },
  { 1918, 7, 15, 10, 2, -15 },
  { 1932, 9, 15, 11, 1, -15 },
  { 1949, 8, 18, 8, 0, -18 },
  { 1967, 10, 14, 14, 2, -14 },
  { 1985, 11, 14, 11, 0, -14 },
  { 2005, 18, 14, 18, 0, -14 },
  { 2037, 10, 14, 12, 1, -14 },
  { 2055, 11, 21, 11, 0, -14 },
  { 2084, 9, 14, 11, 1, -14 },
  { 2100, 8, 23, 10, 1, -19 },
  { 2123, 1, 28, 13, 6, -21 },
  { 2127, 8, 23, 10, 1, -19 },
  { 2150, 12, 3, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Light27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT27PT7B_H_
