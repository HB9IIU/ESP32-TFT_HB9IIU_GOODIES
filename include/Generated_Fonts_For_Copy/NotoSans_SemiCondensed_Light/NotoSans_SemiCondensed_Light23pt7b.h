#ifndef _NOTOSANS_SEMICONDENSED_LIGHT23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light23pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x0F, 0x9C, 0xE5, 0x29, 0x48, 0x08, 0xC0, 0x88,
  0x08, 0x81, 0x88, 0x10, 0x8F, 0xFF, 0x11, 0x81, 0x10, 0x11, 0x03, 0x10,
  0xFF, 0xE2, 0x10, 0x21, 0x02, 0x20, 0x22, 0x06, 0x20, 0x08, 0x0F, 0x9A,
  0x79, 0x08, 0x86, 0x41, 0x20, 0xD0, 0x1C, 0x07, 0x82, 0x61, 0x10, 0x88,
  0x46, 0x27, 0xFE, 0x08, 0x04, 0x00, 0x30, 0x00, 0x90, 0x61, 0x10, 0x84,
  0x23, 0x08, 0x44, 0x10, 0x88, 0x21, 0x20, 0x42, 0x5E, 0x45, 0x24, 0x92,
  0x84, 0xC9, 0x08, 0x12, 0x10, 0x44, 0x20, 0x88, 0x42, 0x10, 0x84, 0x12,
  0x10, 0x3C, 0x0C, 0x01, 0x98, 0x08, 0x40, 0x42, 0x02, 0x10, 0x10, 0x80,
  0xC8, 0x03, 0x80, 0x1C, 0x03, 0x20, 0x90, 0x85, 0x82, 0x68, 0x1A, 0x40,
  0x73, 0x03, 0x8C, 0x36, 0x3E, 0x18, 0xFC, 0x19, 0x08, 0x84, 0x63, 0x10,
  0x84, 0x21, 0x0C, 0x61, 0x08, 0x61, 0x04, 0x30, 0xC4, 0x22, 0x31, 0x11,
  0x11, 0x11, 0x11, 0x32, 0x24, 0x48, 0x08, 0x04, 0x22, 0x3F, 0xF0, 0x80,
  0xA0, 0xC8, 0xC6, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x69, 0x29, 0x00, 0xF8, 0xF0, 0x03, 0x02,
  0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60,
  0x40, 0xC0, 0x0C, 0x0F, 0xC6, 0x11, 0x02, 0x40, 0xB0, 0x2C, 0x0F, 0x03,
  0x80, 0xE0, 0x3C, 0x0F, 0x02, 0xC0, 0x90, 0x24, 0x18, 0x84, 0x1E, 0x00,
  0x19, 0x73, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x1C, 0x7F,
  0x90, 0x40, 0x30, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x81, 0x81, 0x81, 0x80, 0xFF, 0x80, 0x1C, 0x3B, 0xA0, 0x60, 0x10, 0x08,
  0x04, 0x04, 0x06, 0x3C, 0x01, 0x80, 0x60, 0x10, 0x08, 0x04, 0x03, 0x02,
  0xFE, 0x00, 0x00, 0x80, 0x30, 0x0E, 0x01, 0x40, 0x48, 0x09, 0x02, 0x20,
  0xC4, 0x10, 0x84, 0x11, 0x82, 0x20, 0x4F, 0xFE, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x7F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xE1, 0x0C,
  0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x80, 0x68, 0x31, 0xF8, 0x07, 0x07,
  0x63, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x7C, 0xE1, 0xB0, 0x2C, 0x0F,
  0x03, 0xC0, 0xD0, 0x34, 0x08, 0x86, 0x1F, 0x00, 0xFF, 0xC0, 0x20, 0x08,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0x0C, 0x0C, 0xC4, 0x19, 0x02, 0x40, 0x90, 0x26,
  0x10, 0xD8, 0x1C, 0x0C, 0xC4, 0x1B, 0x02, 0x80, 0xE0, 0x3C, 0x09, 0x86,
  0x3F, 0x00, 0x1C, 0x1F, 0x90, 0x58, 0x18, 0x0C, 0x06, 0x03, 0x81, 0x41,
  0xB1, 0x47, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x0C, 0x7C, 0x00, 0xE0, 0x00,
  0x0F, 0x68, 0x00, 0x00, 0x0D, 0x2D, 0x20, 0x00, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x60,
  0x60, 0x60, 0x60, 0x20, 0x00, 0x38, 0xFE, 0x03, 0x01, 0x01, 0x01, 0x02,
  0x06, 0x0C, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x10, 0x30, 0x07, 0xF0,
  0x18, 0x0C, 0x30, 0x06, 0x20, 0x02, 0x41, 0xE3, 0x42, 0x21, 0x44, 0x21,
  0x84, 0x21, 0x8C, 0x21, 0x8C, 0x21, 0x84, 0x21, 0xC4, 0x62, 0x47, 0xDE,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x18, 0x10, 0x07, 0xE0, 0x06, 0x00,
  0x70, 0x05, 0x00, 0x90, 0x09, 0x80, 0x88, 0x10, 0x81, 0x0C, 0x10, 0x43,
  0xFC, 0x20, 0x62, 0x06, 0x60, 0x24, 0x03, 0x40, 0x3C, 0x01, 0xFF, 0x20,
  0x68, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x33, 0xF8, 0x81, 0xA0, 0x38, 0x0E,
  0x01, 0x80, 0xE0, 0x28, 0x1B, 0xF8, 0x03, 0x83, 0xFC, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x08, 0x00, 0xC1, 0x0F, 0xE0, 0xFF, 0x10, 0x32, 0x03, 0x40, 0x28,
  0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x05,
  0x01, 0xA0, 0xE7, 0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x03, 0xC0, 0xFF, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x1F, 0xC0, 0x14, 0x01, 0x40, 0x16, 0x01, 0x30, 0x11, 0x81,
  0x0F, 0xF0, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x9F, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x47, 0xE0, 0x80,
  0xE0, 0x48, 0x22, 0x18, 0x8C, 0x26, 0x09, 0x02, 0xE0, 0xC8, 0x23, 0x08,
  0x62, 0x08, 0x83, 0x20, 0x48, 0x0A, 0x03, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0,
  0x0F, 0x80, 0x3A, 0x01, 0xE8, 0x05, 0x90, 0x16, 0x40, 0xD9, 0x82, 0x62,
  0x09, 0x88, 0x46, 0x31, 0x18, 0x44, 0x61, 0x21, 0x86, 0x86, 0x0E, 0x18,
  0x30, 0x60, 0xC1, 0xC0, 0x3C, 0x06, 0x80, 0xD8, 0x19, 0x03, 0x10, 0x63,
  0x0C, 0x21, 0x86, 0x30, 0x46, 0x0C, 0xC0, 0x98, 0x0B, 0x01, 0xE0, 0x1C,
  0x03, 0x07, 0x00, 0xFF, 0x0C, 0x0C, 0xC0, 0x24, 0x01, 0xA0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x80, 0x14, 0x01, 0xB0, 0x08,
  0x80, 0xC6, 0x0C, 0x0F, 0xC0, 0xFE, 0x40, 0xA0, 0x70, 0x18, 0x0C, 0x06,
  0x07, 0x06, 0xFE, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x07,
  0x80, 0xFF, 0x0C, 0x0C, 0xC0, 0x24, 0x01, 0xA0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x02, 0x80, 0x14, 0x01, 0xB0, 0x08, 0x80, 0xC6,
  0x0C, 0x0F, 0xC0, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0x20,
  0x48, 0x1A, 0x02, 0x80, 0xA0, 0x28, 0x1A, 0x0C, 0xFC, 0x21, 0x08, 0x62,
  0x08, 0x81, 0x20, 0x68, 0x0A, 0x03, 0x0E, 0x1F, 0xD0, 0x18, 0x0C, 0x06,
  0x01, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x10, 0x08, 0x04, 0x07, 0x06,
  0xFE, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x3C, 0x06, 0x80, 0x98, 0x31, 0xF8, 0xC0, 0x34,
  0x02, 0x40, 0x26, 0x06, 0x20, 0x42, 0x04, 0x30, 0xC1, 0x08, 0x10, 0x81,
  0x18, 0x19, 0x00, 0x90, 0x0B, 0x00, 0xE0, 0x06, 0x00, 0x60, 0xC0, 0x40,
  0x68, 0x1C, 0x09, 0x02, 0x83, 0x30, 0x50, 0x62, 0x1A, 0x08, 0x42, 0x61,
  0x08, 0x44, 0x61, 0x88, 0x8C, 0x13, 0x11, 0x02, 0x43, 0x20, 0x48, 0x2C,
  0x0D, 0x05, 0x80, 0xA0, 0xA0, 0x18, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x40, 0x64, 0x18, 0xC2, 0x08, 0xC1, 0x90, 0x14, 0x03, 0x80, 0x20, 0x0E,
  0x01, 0x40, 0x44, 0x08, 0xC2, 0x08, 0xC1, 0x90, 0x16, 0x03, 0xC0, 0x68,
  0x19, 0x82, 0x10, 0x43, 0x10, 0x22, 0x06, 0xC0, 0x50, 0x0E, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x08, 0x03, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0xF0, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10,
  0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x03, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x0C, 0x03, 0x01, 0x20, 0x48,
  0x21, 0x08, 0x44, 0x09, 0x02, 0x80, 0x40, 0xFF, 0xC0, 0x84, 0x21, 0x7E,
  0x01, 0x01, 0x01, 0x01, 0x3F, 0x61, 0xC1, 0x81, 0x81, 0xC3, 0x7D, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x05, 0xFB, 0x05, 0x83, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0x07, 0xC6, 0xBE, 0x00, 0x3F, 0x60, 0x40, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x61, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xCF, 0xB6, 0x1D, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x34, 0x0D, 0x87, 0x3E, 0x40, 0x3F, 0x30, 0x90, 0x38, 0x1C, 0x0F, 0xFF,
  0x01, 0x80, 0x40, 0x20, 0x18, 0x23, 0xF0, 0x06, 0x3C, 0x41, 0x83, 0x06,
  0x3F, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x3E,
  0xD8, 0x74, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD0, 0x36,
  0x1C, 0xFB, 0x00, 0xC0, 0x30, 0x0A, 0x06, 0x7F, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x05, 0xFB, 0x05, 0x82, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC7, 0xFF, 0x80, 0x11, 0x00, 0x01,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x81, 0x82, 0x84, 0x8C, 0x98, 0x90, 0xB0, 0xD8, 0x88, 0x84, 0x86,
  0x82, 0x83, 0xFF, 0xFF, 0x80, 0xBE, 0x7D, 0x87, 0x0B, 0x04, 0x1C, 0x08,
  0x38, 0x10, 0x70, 0x20, 0xE0, 0x41, 0xC0, 0x83, 0x81, 0x07, 0x02, 0x0E,
  0x04, 0x1C, 0x08, 0x30, 0xBF, 0x60, 0xB0, 0x50, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x3F, 0x18, 0x64, 0x0B, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x40, 0xD0, 0x26, 0x18, 0x7C, 0xBF, 0x60, 0xB0,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0xF8, 0xD7, 0xC8, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x00, 0x3E, 0xD8, 0x74, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xD0, 0x36, 0x1C, 0xFB, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xBF, 0x8C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x7E, 0xC0, 0x80, 0xC0, 0x60, 0x38, 0x0E, 0x02, 0x03, 0x03, 0x82, 0xFC,
  0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0xC0,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x7D,
  0xC0, 0xD0, 0x24, 0x19, 0x84, 0x21, 0x08, 0xC3, 0x20, 0x48, 0x16, 0x05,
  0x00, 0xC0, 0x30, 0xC1, 0x82, 0x83, 0x0D, 0x0A, 0x13, 0x16, 0x22, 0x24,
  0x44, 0xC9, 0x89, 0x12, 0x1A, 0x34, 0x14, 0x28, 0x38, 0x50, 0x60, 0xC0,
  0xC1, 0x80, 0x60, 0xC8, 0x43, 0x30, 0x48, 0x0E, 0x03, 0x00, 0xC0, 0x68,
  0x13, 0x08, 0x46, 0x1B, 0x03, 0xC0, 0xD0, 0x24, 0x19, 0x84, 0x21, 0x08,
  0xC3, 0x20, 0x48, 0x12, 0x07, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x40, 0xF0, 0x10, 0x00, 0xFE, 0x0C, 0x10, 0x60, 0x82, 0x0C, 0x10, 0x60,
  0x83, 0x07, 0xF0, 0x1C, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x23, 0x06, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x31, 0x84, 0x10, 0x41, 0x04, 0x10, 0xC6, 0x20,
  0xF8, 0x61, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Light23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 16, 5, 2, -16 },
  { 5, 5, 6, 8, 2, -16 },
  { 9, 12, 16, 13, 1, -16 },
  { 33, 9, 18, 12, 1, -17 },
  { 54, 15, 17, 17, 1, -17 },
  { 86, 13, 17, 14, 1, -17 },
  { 114, 1, 6, 4, 2, -16 },
  { 115, 5, 20, 6, 1, -16 },
  { 128, 4, 20, 6, 1, -16 },
  { 138, 9, 8, 11, 1, -17 },
  { 147, 10, 11, 12, 1, -14 },
  { 161, 3, 6, 5, 1, -3 },
  { 164, 5, 1, 7, 1, -7 },
  { 165, 2, 2, 5, 2, -2 },
  { 166, 8, 16, 8, 0, -16 },
  { 182, 10, 17, 12, 1, -17 },
  { 204, 5, 16, 12, 2, -16 },
  { 214, 9, 17, 12, 1, -17 },
  { 234, 9, 17, 12, 1, -17 },
  { 254, 11, 17, 12, 0, -17 },
  { 278, 10, 16, 12, 1, -16 },
  { 298, 10, 17, 12, 1, -17 },
  { 320, 10, 16, 12, 1, -16 },
  { 340, 10, 17, 12, 1, -17 },
  { 362, 9, 17, 12, 1, -17 },
  { 382, 2, 12, 5, 2, -12 },
  { 385, 3, 15, 5, 1, -12 },
  { 391, 10, 10, 12, 1, -13 },
  { 404, 10, 6, 12, 1, -11 },
  { 412, 10, 10, 12, 1, -13 },
  { 425, 8, 17, 9, 0, -17 },
  { 442, 16, 18, 18, 1, -16 },
  { 478, 12, 16, 12, 0, -16 },
  { 502, 10, 16, 13, 2, -16 },
  { 522, 11, 17, 13, 1, -17 },
  { 546, 11, 16, 15, 2, -16 },
  { 568, 8, 16, 11, 2, -16 },
  { 584, 8, 16, 10, 2, -16 },
  { 600, 12, 17, 15, 1, -17 },
  { 626, 11, 16, 15, 2, -16 },
  { 648, 5, 16, 7, 1, -16 },
  { 658, 5, 20, 5, -2, -16 },
  { 671, 10, 16, 12, 2, -16 },
  { 691, 8, 16, 11, 2, -16 },
  { 707, 14, 16, 18, 2, -16 },
  { 735, 11, 16, 15, 2, -16 },
  { 757, 13, 17, 16, 1, -17 },
  { 785, 9, 16, 12, 2, -16 },
  { 803, 13, 21, 16, 1, -17 },
  { 838, 10, 16, 12, 2, -16 },
  { 858, 9, 17, 11, 1, -17 },
  { 878, 11, 16, 11, 0, -16 },
  { 900, 11, 16, 15, 2, -16 },
  { 922, 12, 16, 12, 0, -16 },
  { 946, 19, 16, 19, 0, -16 },
  { 984, 11, 16, 11, 0, -16 },
  { 1006, 11, 16, 11, 0, -16 },
  { 1028, 10, 16, 11, 1, -16 },
  { 1048, 5, 20, 7, 2, -16 },
  { 1061, 8, 16, 8, 0, -16 },
  { 1077, 4, 20, 7, 1, -16 },
  { 1087, 10, 9, 12, 1, -16 },
  { 1099, 10, 1, 10, 0, 2 },
  { 1101, 4, 4, 6, 1, -18 },
  { 1103, 8, 12, 11, 1, -12 },
  { 1115, 9, 17, 12, 2, -17 },
  { 1135, 8, 12, 10, 1, -12 },
  { 1147, 10, 17, 12, 1, -17 },
  { 1169, 9, 12, 11, 1, -12 },
  { 1183, 7, 18, 6, 0, -18 },
  { 1199, 10, 18, 12, 1, -12 },
  { 1222, 9, 17, 12, 2, -17 },
  { 1242, 1, 17, 5, 2, -17 },
  { 1245, 4, 23, 5, -1, -17 },
  { 1257, 8, 17, 10, 2, -17 },
  { 1274, 1, 17, 5, 2, -17 },
  { 1277, 15, 12, 18, 2, -12 },
  { 1300, 9, 12, 12, 2, -12 },
  { 1314, 10, 12, 12, 1, -12 },
  { 1329, 9, 17, 12, 2, -12 },
  { 1349, 10, 17, 12, 1, -12 },
  { 1371, 6, 12, 8, 2, -12 },
  { 1380, 8, 12, 10, 1, -12 },
  { 1392, 6, 15, 7, 0, -15 },
  { 1404, 8, 12, 12, 2, -12 },
  { 1416, 10, 12, 10, 0, -12 },
  { 1431, 15, 12, 15, 0, -12 },
  { 1454, 10, 12, 10, 0, -12 },
  { 1469, 10, 18, 10, 0, -12 },
  { 1492, 7, 12, 9, 1, -12 },
  { 1503, 6, 20, 8, 1, -16 },
  { 1518, 1, 24, 11, 5, -18 },
  { 1521, 6, 20, 8, 1, -16 },
  { 1536, 10, 2, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Light23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT23PT7B_H_
