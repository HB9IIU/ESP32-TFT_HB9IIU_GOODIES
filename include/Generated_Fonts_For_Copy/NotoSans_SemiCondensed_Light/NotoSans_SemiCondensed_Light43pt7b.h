#ifndef _NOTOSANS_SEMICONDENSED_LIGHT43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light43pt7bBitmaps[] PROGMEM = {
  0x00, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x00, 0x06, 0xFF, 0xF0, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x01, 0xFF,
  0xFF, 0xF8, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x18, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xFF, 0xE1, 0xFF,
  0xF9, 0xE3, 0x0C, 0xE1, 0x80, 0x60, 0xC0, 0x70, 0x60, 0x38, 0x30, 0x1C,
  0x18, 0x06, 0x0C, 0x03, 0x86, 0x01, 0xE3, 0x00, 0x7D, 0x80, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1B, 0xC0, 0x0C, 0x70, 0x06, 0x1C, 0x03,
  0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x7C,
  0x0C, 0x77, 0xFF, 0xF1, 0xFF, 0xE0, 0x0B, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x0C, 0x03, 0xF8, 0x00, 0xC0,
  0x70, 0xC0, 0x18, 0x06, 0x0C, 0x01, 0x80, 0x60, 0x60, 0x30, 0x0E, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x06, 0x06, 0x00, 0xC0, 0x60, 0xC0,
  0x0C, 0x06, 0x0C, 0x00, 0xC0, 0x61, 0x80, 0x0C, 0x06, 0x18, 0x00, 0xC0,
  0x63, 0x8F, 0x0E, 0x06, 0x31, 0xF8, 0x60, 0x67, 0x38, 0xC6, 0x0C, 0x63,
  0x06, 0x70, 0xCE, 0x60, 0x63, 0xF8, 0xC6, 0x06, 0x1F, 0x1C, 0x60, 0x60,
  0x01, 0x86, 0x03, 0x00, 0x18, 0x60, 0x30, 0x03, 0x06, 0x03, 0x00, 0x30,
  0x60, 0x30, 0x06, 0x06, 0x03, 0x00, 0x60, 0x60, 0x70, 0x0C, 0x06, 0x06,
  0x00, 0xC0, 0x60, 0x60, 0x18, 0x07, 0x06, 0x01, 0x80, 0x30, 0xE0, 0x30,
  0x03, 0xFC, 0x03, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x0E, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x06, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0xE0, 0x02, 0x38, 0x70, 0x0C,
  0x70, 0x38, 0x0C, 0x60, 0x1C, 0x0C, 0xE0, 0x0E, 0x1C, 0xE0, 0x07, 0x18,
  0xE0, 0x03, 0xB8, 0xE0, 0x03, 0xB0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0xE0,
  0x60, 0x01, 0xF0, 0x70, 0x03, 0xB8, 0x38, 0x0F, 0x1C, 0x1F, 0xFE, 0x1E,
  0x0F, 0xF8, 0x0F, 0xFB, 0x6D, 0xB6, 0xDB, 0x00, 0x03, 0x07, 0x0E, 0x0C,
  0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0xE0, 0x38,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60,
  0x30, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E,
  0x06, 0x07, 0x07, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x04, 0x0C, 0x07, 0xC2, 0x1D, 0xFD, 0x7F, 0x1F, 0xF8,
  0x00, 0xE0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x63, 0x00, 0x61, 0xC0, 0x70,
  0x70, 0x70, 0x18, 0x08, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x39, 0x9C, 0xE7, 0x31, 0x9C, 0xC6, 0x30, 0xFF, 0xFF,
  0xFF, 0xFC, 0x6F, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xE1, 0xE0, 0x60, 0x18, 0x38, 0x07, 0x0C, 0x00, 0xC7, 0x00, 0x39, 0x80,
  0x06, 0x60, 0x01, 0x98, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x06, 0x70, 0x03, 0x8C, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x1C, 0x1C, 0x0E,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0x81, 0xC1, 0xE3, 0xF3, 0xDB, 0x8F,
  0x87, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0xF0, 0x07, 0xFF, 0x07, 0x81, 0xE1, 0x80,
  0x38, 0x40, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFE, 0x3E, 0x07, 0x9C, 0x00, 0xE4, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xEC, 0x00, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00,
  0x73, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0x83, 0x00,
  0x38, 0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00, 0x30, 0x60, 0x03,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x10, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xD0,
  0x01, 0xCC, 0x03, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x78, 0x10, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x61,
  0xF8, 0x19, 0xFF, 0x86, 0xE0, 0xF3, 0xE0, 0x0E, 0xF0, 0x03, 0xBC, 0x00,
  0x6E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D,
  0x80, 0x07, 0x70, 0x01, 0xCC, 0x00, 0x63, 0x80, 0x38, 0x60, 0x0E, 0x1C,
  0x07, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xF0, 0xE0,
  0x1C, 0x70, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x06, 0x70, 0x03,
  0x9C, 0x00, 0xE3, 0x00, 0x70, 0xE0, 0x18, 0x1E, 0x1E, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0E, 0x3C, 0x07, 0x03, 0x83, 0x80, 0x71, 0xC0,
  0x0E, 0x60, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x76, 0x00, 0x19, 0xC0, 0x0E, 0x38, 0x07, 0x07, 0xFF, 0x80,
  0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xC1, 0xE0, 0xE0, 0x38, 0x70,
  0x07, 0x18, 0x00, 0xCE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0xF6, 0x00, 0x3D,
  0xC0, 0x1F, 0x38, 0x0D, 0x87, 0xFE, 0x60, 0xFF, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0xEF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0,
  0x38, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC6, 0x38, 0xE3, 0x8C, 0x31, 0xC6, 0x18, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xC3, 0xFF, 0xCE, 0x07, 0xA0, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x07,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x38, 0xC0, 0x1F, 0xE0, 0x63, 0x01, 0xFF,
  0x81, 0x98, 0x0E, 0x06, 0x06, 0x60, 0x30, 0x18, 0x1D, 0x81, 0x80, 0x60,
  0x36, 0x06, 0x01, 0x80, 0xF8, 0x38, 0x06, 0x03, 0xC0, 0xC0, 0x18, 0x0F,
  0x03, 0x00, 0x60, 0x3C, 0x0C, 0x01, 0x80, 0xF0, 0x30, 0x0E, 0x07, 0xC0,
  0xC0, 0x38, 0x1B, 0x83, 0x80, 0xE0, 0x66, 0x06, 0x07, 0x83, 0x98, 0x1C,
  0x1B, 0x0C, 0x60, 0x3F, 0xCF, 0xE1, 0x80, 0x7E, 0x1F, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC7, 0x00, 0x03, 0x86,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE6, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0x0C, 0x0F, 0xF3, 0x00, 0x1C, 0xC0,
  0x03, 0xB0, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x07, 0x30, 0x07, 0x8F, 0xFF, 0x83,
  0xFF, 0xF0, 0xC0, 0x0F, 0x30, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3B, 0x00, 0x1E, 0xC0, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0xF8, 0x1C, 0x0E, 0x00, 0x20, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x03, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x30, 0x7F, 0x81, 0x80, 0x1F, 0x0C, 0x00, 0x3C, 0x60,
  0x00, 0xE3, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0x76, 0x00, 0x03,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0D,
  0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00,
  0x1C, 0xC0, 0x00, 0xE6, 0x00, 0x0E, 0x30, 0x00, 0xF1, 0x80, 0x0F, 0x0C,
  0x03, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF,
  0x7F, 0xFE, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC,
  0x0F, 0x80, 0xF0, 0x3C, 0x00, 0x20, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0xC0, 0x0F, 0xFD, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x01,
  0x9C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x78, 0x00, 0x18,
  0x78, 0x00, 0x30, 0x7C, 0x00, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x78, 0xF7, 0xF3, 0xE0, 0xC0, 0x01, 0xD8,
  0x00, 0x73, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0xE1, 0x80, 0x38, 0x30,
  0x0E, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x1C, 0x03, 0x07, 0x00, 0x61,
  0xC0, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x33, 0xC0, 0x06, 0xFC, 0x00, 0xFB,
  0x80, 0x1E, 0x38, 0x03, 0x83, 0x80, 0x60, 0x70, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x30, 0x0E, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0xC3, 0x00,
  0x1C, 0x60, 0x03, 0x8C, 0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x78, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFD,
  0x80, 0x00, 0x3F, 0xB0, 0x00, 0x0D, 0xF7, 0x00, 0x01, 0xBE, 0x60, 0x00,
  0x77, 0xCC, 0x00, 0x0C, 0xF9, 0xC0, 0x01, 0x9F, 0x18, 0x00, 0x73, 0xE3,
  0x80, 0x0C, 0x7C, 0x30, 0x01, 0x8F, 0x86, 0x00, 0x71, 0xF0, 0xE0, 0x0C,
  0x3E, 0x0C, 0x01, 0x87, 0xC1, 0x80, 0x70, 0xF8, 0x38, 0x0C, 0x1F, 0x03,
  0x03, 0x83, 0xE0, 0x60, 0x60, 0x7C, 0x0E, 0x0C, 0x0F, 0x80, 0xC3, 0x81,
  0xF0, 0x18, 0x60, 0x3E, 0x03, 0x8C, 0x07, 0xC0, 0x33, 0x80, 0xF8, 0x07,
  0x60, 0x1F, 0x00, 0x6C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x1C, 0x01, 0xF0, 0x03, 0x00, 0x38, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3D, 0xC0, 0x03, 0xCC, 0x00,
  0x3C, 0xE0, 0x03, 0xC6, 0x00, 0x3C, 0x70, 0x03, 0xC3, 0x80, 0x3C, 0x38,
  0x03, 0xC1, 0xC0, 0x3C, 0x0C, 0x03, 0xC0, 0xE0, 0x3C, 0x06, 0x03, 0xC0,
  0x70, 0x3C, 0x03, 0x83, 0xC0, 0x38, 0x3C, 0x01, 0xC3, 0xC0, 0x0C, 0x3C,
  0x00, 0xE3, 0xC0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x03, 0xBC, 0x00, 0x1B,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x3C, 0x01, 0xE0,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19, 0xC0, 0x00,
  0x1C, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x30, 0x7F, 0x18, 0x03, 0xCC, 0x00,
  0x76, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x39, 0x80, 0x3C,
  0xFF, 0xFC, 0x7F, 0xF8, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x60, 0x00,
  0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x00,
  0x78, 0x0F, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0xFF, 0xC0, 0x3F, 0xFE, 0x0C,
  0x3F, 0xC3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x07,
  0x30, 0x01, 0x8C, 0x00, 0xE3, 0x03, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0C,
  0x06, 0x03, 0x01, 0xC0, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x01, 0xC3, 0x00,
  0x70, 0xC0, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03,
  0xB0, 0x00, 0x6C, 0x00, 0x1C, 0x03, 0xFC, 0x07, 0xFF, 0xCF, 0x81, 0xC7,
  0x00, 0x27, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xEE, 0x01, 0xE7, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0x70, 0x00,
  0xE7, 0x00, 0x1C, 0x3C, 0x03, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xDC, 0x00, 0x06, 0x70, 0x00,
  0x38, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x70,
  0x60, 0x01, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x60, 0x07, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00, 0x06, 0x18, 0x00,
  0x1C, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x6E, 0x00, 0x1C,
  0x00, 0x1B, 0x80, 0x07, 0x80, 0x0E, 0x60, 0x03, 0x60, 0x03, 0x98, 0x00,
  0xD8, 0x00, 0xC7, 0x00, 0x36, 0x00, 0x31, 0xC0, 0x0D, 0xC0, 0x1C, 0x30,
  0x07, 0x30, 0x07, 0x0C, 0x01, 0x8C, 0x01, 0x83, 0x80, 0x63, 0x00, 0x60,
  0xE0, 0x18, 0xE0, 0x38, 0x18, 0x0E, 0x18, 0x0E, 0x06, 0x03, 0x06, 0x03,
  0x01, 0xC0, 0xC1, 0x80, 0xC0, 0x70, 0x70, 0x70, 0x70, 0x0C, 0x1C, 0x0C,
  0x1C, 0x03, 0x06, 0x03, 0x06, 0x00, 0xE1, 0x80, 0xC1, 0x80, 0x38, 0xE0,
  0x38, 0xE0, 0x06, 0x38, 0x06, 0x38, 0x01, 0x8C, 0x01, 0x8C, 0x00, 0x73,
  0x00, 0x63, 0x00, 0x1C, 0xC0, 0x1D, 0xC0, 0x03, 0x70, 0x03, 0x70, 0x00,
  0xD8, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x0D, 0x80,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x71, 0x80, 0x03, 0x0E, 0x00, 0x38, 0x30, 0x01, 0x81,
  0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x07,
  0x00, 0x1C, 0x70, 0x00, 0x63, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0,
  0x00, 0x77, 0x00, 0x03, 0x18, 0x00, 0x38, 0xE0, 0x03, 0x83, 0x00, 0x18,
  0x1C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x80, 0xE0, 0x0E, 0x06, 0x00, 0x70,
  0x70, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x3B, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xC3,
  0x80, 0x1C, 0x1C, 0x01, 0x81, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x70,
  0x06, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00, 0x39, 0xC0, 0x01, 0x98,
  0x00, 0x1D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0x98, 0x00, 0x19, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xE0, 0x06, 0x06, 0x00, 0x60, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x18, 0x01, 0x81, 0x80, 0x1C, 0x30, 0x00, 0xC3, 0x00, 0x0E, 0x60,
  0x00, 0x6E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1, 0xC1,
  0xC1, 0xC1, 0x81, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x38, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x07, 0xFF, 0x1F, 0xE7, 0x78, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x70, 0x37, 0x7F, 0xF7,
  0x1F, 0xC3, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x3F, 0x83, 0x9F, 0xF8, 0xEC, 0x0F, 0x3E, 0x00, 0xCF, 0x00, 0x3B,
  0xC0, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x06, 0xF0, 0x03, 0xBE, 0x01, 0xCE, 0xC0, 0xF3,
  0x3F, 0xF8, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x78, 0x11, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x21, 0xFF, 0xC1, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x7F, 0x1C, 0x3F, 0xF7, 0x1C, 0x0E, 0xCE, 0x01, 0xB3, 0x00, 0x3D, 0xC0,
  0x07, 0x60, 0x01, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76,
  0x00, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0xCE, 0x00, 0xB3, 0xC0, 0xEC, 0x7F,
  0xF3, 0x07, 0xF0, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00,
  0xE3, 0x00, 0x33, 0x80, 0x19, 0x80, 0x0E, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x10, 0x7F, 0xF8, 0x1F, 0xF8, 0x01, 0xF0, 0x3F, 0xC3, 0xC4, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1F, 0xF1, 0xFF,
  0x81, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0xF0, 0xC3, 0xFF, 0x31, 0xC0, 0xEC, 0xE0, 0x0B, 0x30, 0x03, 0xDC, 0x00,
  0x76, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x60,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x3C, 0xE0, 0x0B, 0x3C, 0x0F, 0xC7, 0xFF,
  0x70, 0x7F, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE3, 0x00, 0xF0, 0xFF, 0xF8, 0x1F,
  0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0xFE, 0x1C, 0xFF, 0xCE, 0xC0, 0xF7, 0xC0, 0x3B, 0xC0, 0x0D, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0xFE, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x70,
  0xE0, 0xE0, 0xE1, 0xC0, 0xE1, 0x80, 0xE3, 0x80, 0xE7, 0x00, 0xEF, 0x00,
  0xEF, 0x80, 0xF9, 0x80, 0xF1, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0, 0x70,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC3, 0xF0, 0x3F, 0x8C, 0xFF, 0xC7, 0xFC, 0xEC, 0x1C, 0xC0, 0xEF,
  0x80, 0xF8, 0x07, 0xF0, 0x07, 0x80, 0x7F, 0x00, 0x70, 0x03, 0xE0, 0x07,
  0x00, 0x3E, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x03,
  0xE0, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00, 0x3E, 0x00,
  0x70, 0x03, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00,
  0x3E, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x03, 0xE0,
  0x07, 0x00, 0x3E, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00, 0x30, 0xC3, 0xF8,
  0x63, 0xFF, 0x3B, 0x03, 0xDF, 0x00, 0xEF, 0x00, 0x37, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x3C, 0x1C, 0x01, 0xC3, 0x00, 0x18, 0xE0,
  0x03, 0x98, 0x00, 0x73, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80,
  0x03, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xB8, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x01, 0xCE, 0x00, 0x38, 0xC0, 0x06, 0x1C, 0x01, 0xC1, 0xC0,
  0x70, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0xC3, 0xF8, 0x31, 0xFF, 0x8E, 0xC0,
  0xF3, 0xE0, 0x1C, 0xF0, 0x03, 0xBC, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x6F, 0x00,
  0x3B, 0xE0, 0x1C, 0xEC, 0x0F, 0x39, 0xFF, 0x8E, 0x3F, 0x83, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0xC3,
  0xFF, 0x31, 0xC0, 0xEC, 0xE0, 0x1B, 0x70, 0x03, 0xDC, 0x00, 0x76, 0x00,
  0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x3C, 0xE0, 0x1B, 0x3C, 0x0F, 0xC7, 0xFF, 0x70, 0x7F,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0xC3, 0xFE, 0x7E, 0xEE, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F,
  0xF0, 0xFF, 0xF7, 0x01, 0xB8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0xC0, 0x3B,
  0xFF, 0xC7, 0xFE, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xFF,
  0xFF, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x3F, 0x83, 0xF0, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xD8, 0x01, 0xEE,
  0x01, 0xF7, 0x81, 0xB9, 0xFF, 0x9C, 0x7F, 0x86, 0xE0, 0x01, 0xD8, 0x00,
  0x66, 0x00, 0x19, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x80, 0x70,
  0x60, 0x18, 0x18, 0x06, 0x07, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0E,
  0x1C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x1C, 0xE0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x80, 0x3C, 0x03, 0xF0, 0x0D,
  0x80, 0x76, 0x01, 0xB0, 0x0C, 0xC0, 0x36, 0x01, 0x9C, 0x0E, 0xE0, 0x73,
  0x81, 0x8C, 0x0C, 0x30, 0x31, 0x81, 0x86, 0x06, 0x30, 0x30, 0xE1, 0xC7,
  0x0E, 0x1C, 0x30, 0x61, 0x81, 0x86, 0x0C, 0x30, 0x31, 0xC1, 0xC6, 0x07,
  0x30, 0x19, 0xC0, 0x66, 0x03, 0x30, 0x0C, 0xC0, 0x66, 0x01, 0xB8, 0x0E,
  0xC0, 0x36, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0xB8, 0x03, 0x8C, 0x01,
  0x87, 0x01, 0xC1, 0xC0, 0xC0, 0x60, 0xE0, 0x38, 0xE0, 0x0C, 0x60, 0x07,
  0x70, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1B, 0x00,
  0x1D, 0xC0, 0x1C, 0x70, 0x0C, 0x18, 0x0E, 0x0E, 0x06, 0x03, 0x07, 0x01,
  0xC7, 0x00, 0x73, 0x00, 0x1B, 0x80, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x77,
  0x00, 0x19, 0xC0, 0x0E, 0x30, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x70, 0x60,
  0x1C, 0x1C, 0x06, 0x07, 0x01, 0x80, 0xC0, 0xE0, 0x38, 0x30, 0x0E, 0x0C,
  0x01, 0x87, 0x00, 0x71, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xCC, 0x00,
  0x1B, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x3E,
  0x01, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xF0, 0x1F, 0x03, 0x80, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x07, 0xC0, 0xF8, 0x0C, 0x00, 0x08, 0x00,
  0x1F, 0xE0, 0x1F, 0xFE, 0x0F, 0x03, 0xFF, 0x80, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 31, 10, 3, -31 },
  { 17, 9, 11, 15, 3, -31 },
  { 30, 23, 31, 25, 1, -31 },
  { 120, 17, 36, 22, 2, -33 },
  { 197, 28, 31, 32, 2, -31 },
  { 306, 24, 31, 26, 2, -31 },
  { 399, 3, 11, 8, 3, -31 },
  { 404, 8, 38, 12, 2, -31 },
  { 442, 9, 38, 12, 1, -31 },
  { 485, 17, 17, 21, 2, -33 },
  { 522, 18, 20, 22, 2, -25 },
  { 567, 5, 11, 9, 2, -5 },
  { 574, 10, 3, 13, 1, -13 },
  { 578, 4, 4, 10, 3, -4 },
  { 580, 13, 31, 15, 1, -31 },
  { 631, 18, 31, 22, 2, -31 },
  { 701, 9, 31, 22, 4, -31 },
  { 736, 18, 31, 22, 2, -31 },
  { 806, 17, 31, 22, 2, -31 },
  { 872, 20, 31, 22, 1, -31 },
  { 950, 17, 31, 22, 3, -31 },
  { 1016, 18, 31, 22, 2, -31 },
  { 1086, 18, 31, 22, 2, -31 },
  { 1156, 18, 31, 22, 2, -31 },
  { 1226, 18, 31, 22, 2, -31 },
  { 1296, 4, 23, 10, 3, -23 },
  { 1308, 6, 29, 10, 1, -23 },
  { 1330, 18, 19, 22, 2, -25 },
  { 1373, 18, 11, 22, 2, -21 },
  { 1398, 18, 19, 22, 2, -25 },
  { 1441, 14, 31, 16, 1, -31 },
  { 1496, 30, 35, 34, 2, -31 },
  { 1628, 23, 31, 23, 0, -31 },
  { 1718, 18, 31, 24, 4, -31 },
  { 1788, 21, 31, 24, 2, -31 },
  { 1870, 21, 31, 27, 4, -31 },
  { 1952, 15, 31, 21, 4, -31 },
  { 2011, 15, 31, 20, 4, -31 },
  { 2070, 23, 31, 28, 2, -31 },
  { 2160, 20, 31, 28, 4, -31 },
  { 2238, 8, 31, 12, 2, -31 },
  { 2269, 9, 39, 10, -3, -31 },
  { 2313, 19, 31, 23, 4, -31 },
  { 2387, 15, 31, 20, 4, -31 },
  { 2446, 27, 31, 35, 4, -31 },
  { 2551, 20, 31, 28, 4, -31 },
  { 2629, 25, 31, 29, 2, -31 },
  { 2726, 17, 31, 23, 4, -31 },
  { 2792, 25, 38, 29, 2, -31 },
  { 2911, 18, 31, 23, 4, -31 },
  { 2981, 17, 31, 21, 2, -31 },
  { 3047, 20, 31, 20, 0, -31 },
  { 3125, 20, 31, 28, 4, -31 },
  { 3203, 22, 31, 22, 0, -31 },
  { 3289, 34, 31, 35, 1, -31 },
  { 3421, 21, 31, 21, 0, -31 },
  { 3503, 20, 31, 20, 0, -31 },
  { 3581, 19, 31, 21, 1, -31 },
  { 3655, 8, 38, 14, 4, -31 },
  { 3693, 13, 31, 15, 1, -31 },
  { 3744, 9, 38, 14, 1, -31 },
  { 3787, 20, 18, 22, 1, -31 },
  { 3832, 18, 2, 18, 0, 4 },
  { 3837, 7, 7, 11, 2, -33 },
  { 3844, 16, 23, 21, 2, -23 },
  { 3890, 18, 33, 23, 3, -33 },
  { 3965, 15, 23, 18, 2, -23 },
  { 4009, 18, 33, 23, 2, -33 },
  { 4084, 17, 23, 21, 2, -23 },
  { 4133, 13, 33, 12, 1, -33 },
  { 4187, 18, 33, 23, 2, -23 },
  { 4262, 17, 33, 23, 3, -33 },
  { 4333, 3, 31, 9, 3, -31 },
  { 4345, 8, 41, 9, -2, -31 },
  { 4386, 16, 33, 19, 3, -33 },
  { 4452, 3, 33, 9, 3, -33 },
  { 4465, 28, 23, 34, 3, -23 },
  { 4546, 17, 23, 23, 3, -23 },
  { 4595, 19, 23, 23, 2, -23 },
  { 4650, 18, 33, 23, 3, -23 },
  { 4725, 18, 33, 23, 2, -23 },
  { 4800, 12, 23, 15, 3, -23 },
  { 4835, 14, 23, 18, 2, -23 },
  { 4876, 11, 28, 13, 1, -28 },
  { 4915, 17, 23, 23, 3, -23 },
  { 4964, 18, 23, 18, 0, -23 },
  { 5016, 27, 23, 29, 1, -23 },
  { 5094, 17, 23, 19, 1, -23 },
  { 5143, 18, 33, 18, 0, -23 },
  { 5218, 15, 23, 17, 1, -23 },
  { 5262, 13, 38, 15, 1, -31 },
  { 5324, 3, 43, 21, 9, -33 },
  { 5341, 12, 38, 15, 2, -31 },
  { 5398, 18, 5, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Light43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT43PT7B_H_
