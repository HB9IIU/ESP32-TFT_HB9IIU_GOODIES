#ifndef _NOTOSANS_SEMICONDENSED_LIGHT60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light60pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9E, 0xFD, 0xF7, 0x8C, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x76, 0x03, 0xB0, 0x1D, 0x80, 0xEC, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3E, 0x18, 0x3C, 0x3C, 0x18, 0x04, 0x78, 0x18,
  0x00, 0x70, 0x18, 0x00, 0xF0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18,
  0x00, 0xE0, 0x18, 0x00, 0xF0, 0x18, 0x00, 0x70, 0x18, 0x00, 0x78, 0x18,
  0x00, 0x7C, 0x18, 0x00, 0x3E, 0x18, 0x00, 0x1F, 0x98, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x18, 0xFC, 0x00, 0x18, 0x3C, 0x00, 0x18, 0x1E, 0x00, 0x18,
  0x0E, 0x00, 0x18, 0x0F, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18,
  0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x0F, 0x00, 0x18, 0x0E, 0x00, 0x18,
  0x1E, 0xC0, 0x18, 0x3C, 0xFC, 0x18, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x00,
  0x7F, 0xC0, 0x00, 0x70, 0x03, 0xC7, 0x80, 0x01, 0xC0, 0x0E, 0x07, 0x00,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x70, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x0E, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x38, 0x7F, 0x0E, 0x00, 0xE1, 0xC3,
  0xFE, 0x1C, 0x03, 0x87, 0x1E, 0x3C, 0x70, 0x0E, 0x38, 0x70, 0x79, 0xC0,
  0x70, 0xE3, 0x80, 0xE3, 0x83, 0xC7, 0x0E, 0x01, 0x8F, 0x1E, 0x1C, 0x38,
  0x07, 0x1F, 0xF0, 0xE1, 0xC0, 0x1C, 0x3F, 0x83, 0x87, 0x00, 0x70, 0x00,
  0x1C, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x70, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x01,
  0xC0, 0x70, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x1C,
  0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x00, 0x78, 0xF0, 0x03, 0x80,
  0x00, 0xFF, 0xC0, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE3,
  0xE0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x0E, 0x1F, 0x03, 0xC0, 0x07, 0x0F,
  0x00, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x03, 0xC7, 0x00, 0x0F, 0x01, 0xC7,
  0x80, 0x07, 0xC1, 0xE3, 0xC0, 0x01, 0xE0, 0xF1, 0xC0, 0x00, 0x78, 0x70,
  0xE0, 0x00, 0x1E, 0x78, 0x70, 0x00, 0x07, 0xF8, 0x38, 0x00, 0x01, 0xFC,
  0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3F,
  0x01, 0xE0, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3C, 0xF0, 0x3E, 0x00, 0x7C,
  0x3C, 0x0F, 0xF7, 0xFC, 0x0F, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x7F, 0xF0,
  0x01, 0xF0, 0x05, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE,
  0x66, 0x66, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x38, 0x0F, 0xF8, 0x71, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x01, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x0E, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0x80, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0x87,
  0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF7,
  0x90, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80,
  0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F,
  0x07, 0xFC, 0x3E, 0xF1, 0xF3, 0xCF, 0x0F, 0xF8, 0x3D, 0xC0, 0xF6, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7E, 0x00, 0xF8, 0x78, 0x00, 0x78,
  0x20, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0xFC, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x40, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x80, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C,
  0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x07,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE7, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x20, 0x00, 0x3E, 0x70, 0x00,
  0xF8, 0xFF, 0x3F, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x04, 0x00, 0x38, 0x3F, 0xF0, 0x1C, 0x7F, 0xFC,
  0x0E, 0x7C, 0x3F, 0x0F, 0x70, 0x03, 0xC7, 0xF0, 0x00, 0xF3, 0xF0, 0x00,
  0x39, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0x78, 0x00, 0x03, 0xBC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x07, 0xF1, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xE0, 0x0F, 0x83, 0xE0,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x03,
  0xE0, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x37, 0x3E, 0x00,
  0x77, 0x1F, 0x83, 0xE7, 0x0F, 0xFF, 0xC7, 0x07, 0xFF, 0x07, 0x00, 0xFC,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x38, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0x90, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0x20, 0x1E, 0x7C, 0xF9, 0xF1, 0xE1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x38, 0x70,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x00, 0x7C, 0x40,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x01, 0xFE, 0x00, 0x71, 0xE0, 0x03,
  0xFF, 0xC0, 0x38, 0xE0, 0x07, 0xFF, 0xE0, 0x0E, 0x70, 0x07, 0xC0, 0x70,
  0x07, 0x70, 0x03, 0x80, 0x38, 0x03, 0xB8, 0x03, 0x80, 0x1C, 0x01, 0xDC,
  0x03, 0xC0, 0x0E, 0x00, 0xEE, 0x01, 0xC0, 0x07, 0x00, 0x77, 0x00, 0xE0,
  0x03, 0x80, 0x3F, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x80, 0x70, 0x00, 0xE0,
  0x0F, 0xC0, 0x38, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0xF0,
  0x0E, 0x00, 0x1C, 0x01, 0xF8, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x03, 0x80,
  0x0F, 0x00, 0x7E, 0x01, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x70, 0x03, 0xC0,
  0x3B, 0x80, 0x38, 0x01, 0xE0, 0x1C, 0xE0, 0x1C, 0x01, 0xB0, 0x0E, 0x70,
  0x07, 0x01, 0xDC, 0x0E, 0x38, 0x03, 0xE3, 0xC7, 0x1E, 0x1C, 0x00, 0xFF,
  0xC3, 0xFF, 0x07, 0x00, 0x3F, 0xC0, 0xFE, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x07, 0xF0, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0xC3, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0xC3, 0xC0, 0x00,
  0x7C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xF3, 0xC0, 0x03, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xC0, 0x0F, 0x03, 0xF0, 0x00, 0x20, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x06, 0x00,
  0xFF, 0xDF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01,
  0xE0, 0x07, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x0F, 0xC3, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x1E, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x04, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x70,
  0x00, 0x3F, 0xFF, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x07, 0x03,
  0xE0, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x3F, 0x8F, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xA0, 0xF9, 0xFF, 0x8F,
  0xF8, 0x7F, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x7F,
  0x00, 0x01, 0xEE, 0xF0, 0x00, 0x3F, 0x9E, 0x00, 0x07, 0xE1, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xEE, 0x00, 0x00, 0x01, 0xDF, 0xF8, 0x00,
  0x00, 0x07, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFD, 0xC0, 0x00, 0x00, 0xEF,
  0xF7, 0x00, 0x00, 0x03, 0xBF, 0xCE, 0x00, 0x00, 0x1E, 0xFF, 0x38, 0x00,
  0x00, 0x73, 0xFC, 0xF0, 0x00, 0x01, 0xCF, 0xF1, 0xC0, 0x00, 0x0E, 0x3F,
  0xC7, 0x00, 0x00, 0x38, 0xFF, 0x1E, 0x00, 0x00, 0xE3, 0xFC, 0x38, 0x00,
  0x07, 0x0F, 0xF0, 0xE0, 0x00, 0x1C, 0x3F, 0xC3, 0xC0, 0x00, 0xF0, 0xFF,
  0x07, 0x00, 0x03, 0x83, 0xFC, 0x1C, 0x00, 0x0E, 0x0F, 0xF0, 0x78, 0x00,
  0x78, 0x3F, 0xC0, 0xE0, 0x01, 0xC0, 0xFF, 0x03, 0xC0, 0x07, 0x03, 0xFC,
  0x07, 0x00, 0x3C, 0x0F, 0xF0, 0x1C, 0x00, 0xE0, 0x3F, 0xC0, 0x78, 0x03,
  0x80, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0x80, 0x70, 0x0F, 0xF0,
  0x0F, 0x01, 0xC0, 0x3F, 0xC0, 0x1C, 0x0E, 0x00, 0xFF, 0x00, 0x70, 0x38,
  0x03, 0xFC, 0x01, 0xE1, 0xE0, 0x0F, 0xF0, 0x03, 0x87, 0x00, 0x3F, 0xC0,
  0x0E, 0x1C, 0x00, 0xFF, 0x00, 0x3C, 0xF0, 0x03, 0xFC, 0x00, 0x73, 0x80,
  0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00,
  0xFE, 0xF0, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x3F, 0x9E, 0x00, 0x01, 0xFC,
  0xF0, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x7F, 0x0E, 0x00, 0x03, 0xF8, 0x78,
  0x00, 0x1F, 0xC1, 0xE0, 0x00, 0xFE, 0x0F, 0x00, 0x07, 0xF0, 0x3C, 0x00,
  0x3F, 0x80, 0xE0, 0x01, 0xFC, 0x07, 0x80, 0x0F, 0xE0, 0x1E, 0x00, 0x7F,
  0x00, 0xF0, 0x03, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0xFE, 0x00,
  0x78, 0x07, 0xF0, 0x01, 0xC0, 0x3F, 0x80, 0x0F, 0x01, 0xFC, 0x00, 0x3C,
  0x0F, 0xE0, 0x01, 0xE0, 0x7F, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x3C, 0x1F,
  0xC0, 0x00, 0xF0, 0xFE, 0x00, 0x03, 0x87, 0xF0, 0x00, 0x1E, 0x3F, 0x80,
  0x00, 0x79, 0xFC, 0x00, 0x03, 0xCF, 0xE0, 0x00, 0x0F, 0x7F, 0x00, 0x00,
  0x7B, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xF8, 0xF0,
  0x00, 0xFC, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x7C, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0xF0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x07, 0xFC, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0x1C, 0x3E, 0x00, 0x04, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x80, 0x00, 0x7C, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x01, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x0F, 0xFD, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3D, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x8E, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0E,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x71,
  0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xC7,
  0x00, 0x07, 0x03, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x0E,
  0x00, 0x3C, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x70,
  0x07, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x01, 0xC0,
  0x1C, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x38, 0x03, 0x80,
  0xF0, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x03,
  0x80, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x1C, 0x1E,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70,
  0x00, 0x3C, 0x78, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xE3, 0xC0,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x01, 0xEF, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x78, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38,
  0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0C, 0x03, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xF3, 0xF8, 0x38, 0x01, 0xE1, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0xFC, 0x07, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xC0, 0x39, 0xF0, 0x01, 0xDE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xF7, 0x80,
  0x3B, 0xBF, 0x07, 0x8C, 0xFF, 0xF8, 0x61, 0xFF, 0x83, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x08, 0x00, 0xE0, 0xFF, 0xC0, 0xE3, 0xFF, 0xE0,
  0xE7, 0xF7, 0xF0, 0xEF, 0x00, 0xF8, 0xEC, 0x00, 0x3C, 0xFC, 0x00, 0x1C,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3C, 0xEC, 0x00, 0x3C, 0xEE, 0x00, 0xF8, 0xE7, 0xC3, 0xF0,
  0xE3, 0xFF, 0xE0, 0xC1, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x01, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x08, 0x1F, 0xEF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x40, 0x3C, 0x07,
  0xFE, 0x1E, 0x07, 0xFF, 0x8F, 0x0F, 0xF7, 0xE7, 0x87, 0x80, 0x3B, 0xC7,
  0x80, 0x0E, 0xE7, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x7D,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x3D, 0xE0, 0x00, 0x3E, 0x70, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x8F,
  0x00, 0x1D, 0xC7, 0xC0, 0x1C, 0xE1, 0xF8, 0x3C, 0x70, 0x7F, 0xFC, 0x38,
  0x0F, 0xFC, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x07, 0xE7, 0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0x38,
  0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x0F, 0x80, 0x0C,
  0x07, 0xF0, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0x81, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xC1, 0xC1, 0xFF, 0xF0, 0xE1, 0xFE, 0xFE, 0x71, 0xF0, 0x07, 0x38,
  0xF0, 0x01, 0xDC, 0xF0, 0x00, 0x7E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0xBC, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0xCE, 0x00, 0x03, 0xE7, 0x80, 0x03, 0x71,
  0xE0, 0x03, 0xF8, 0xF8, 0x03, 0xBC, 0x3F, 0x07, 0x9E, 0x0F, 0xFF, 0x8F,
  0x01, 0xFF, 0x87, 0x80, 0x0C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x08, 0x00, 0x0F, 0x87, 0x00,
  0x0F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x01, 0x00, 0x38, 0x3F, 0xF0, 0x71, 0xFF, 0xF0, 0xE7, 0xF7, 0xF1,
  0xDE, 0x01, 0xF3, 0xB0, 0x01, 0xE7, 0xC0, 0x01, 0xEF, 0x80, 0x01, 0xDE,
  0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xC0,
  0x73, 0xFF, 0xF7, 0x10, 0x00, 0x00, 0x00, 0x07, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE0, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x1C, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE7, 0xFC, 0xFF, 0x1F, 0xC0,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x0F, 0xB8, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80,
  0x0F, 0x0E, 0x00, 0x78, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x78,
  0x0E, 0x03, 0xC0, 0x38, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0E,
  0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE7, 0xE0, 0x03, 0xBF, 0x80, 0x0E, 0xEF,
  0x00, 0x3F, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x3C, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x04, 0x01, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0x8F,
  0xFF, 0x07, 0xFF, 0xC7, 0x3F, 0x7F, 0x1F, 0x9F, 0xCE, 0xE0, 0x1E, 0x78,
  0x07, 0x9F, 0x80, 0x1E, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0x80, 0x0F, 0x7C,
  0x00, 0x3E, 0x00, 0x0E, 0xF0, 0x00, 0x7C, 0x00, 0x1D, 0xE0, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x0E,
  0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x1F,
  0xC0, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x03,
  0xF8, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x00,
  0x38, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00,
  0x0F, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0C, 0x01, 0xC1, 0xFF, 0x83,
  0x8F, 0xFF, 0x87, 0x3F, 0x3F, 0x8E, 0xF0, 0x0F, 0x9D, 0x80, 0x0F, 0x3E,
  0x00, 0x0F, 0x7C, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x1E, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0xE0,
  0xFF, 0xC0, 0xE3, 0xFF, 0xE0, 0xE7, 0xF7, 0xF0, 0xE7, 0x00, 0xF8, 0xEE,
  0x00, 0x3C, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x3C, 0xEC, 0x00, 0x3C, 0xEF,
  0x00, 0xF8, 0xE7, 0xE7, 0xF0, 0xE3, 0xFF, 0xE0, 0xE0, 0xFF, 0xC0, 0xE0,
  0x08, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC1, 0xC0,
  0xFF, 0xF0, 0xE1, 0xFE, 0xFC, 0x71, 0xF0, 0x07, 0x38, 0xF0, 0x01, 0xDC,
  0xF0, 0x00, 0x7E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xBC,
  0x00, 0x07, 0xCE, 0x00, 0x03, 0xE7, 0x80, 0x03, 0x73, 0xE0, 0x03, 0xF8,
  0xF8, 0x03, 0xBC, 0x3F, 0x0F, 0x9E, 0x0F, 0xFF, 0x8F, 0x01, 0xFF, 0x87,
  0x80, 0x08, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0xE0, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFF, 0x38, 0x0E, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0x8F, 0xE3, 0xC0, 0x06, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE8, 0x00, 0x0F,
  0x70, 0x00, 0xF3, 0xF8, 0x7F, 0x9F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x07,
  0x80, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xE3, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x30, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xF9, 0xE0, 0x03, 0x73, 0xE0, 0x0E, 0xE3, 0xF1, 0xF9,
  0xC3, 0xFF, 0xE3, 0x83, 0xFF, 0x03, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x07,
  0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x1C, 0x00,
  0x1C, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x03,
  0x80, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x3C, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3B, 0xC0,
  0x01, 0xF0, 0x00, 0x73, 0x80, 0x03, 0xE0, 0x01, 0xE7, 0x00, 0x0F, 0xC0,
  0x03, 0x8F, 0x00, 0x1D, 0xC0, 0x07, 0x1E, 0x00, 0x3B, 0x80, 0x0E, 0x1C,
  0x00, 0xF7, 0x00, 0x3C, 0x38, 0x01, 0xCE, 0x00, 0x70, 0x78, 0x03, 0x8E,
  0x00, 0xE0, 0xF0, 0x07, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x38, 0x07, 0x81,
  0xC0, 0x38, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x70, 0x1C, 0x07, 0x81, 0xE0,
  0xE0, 0x38, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x0E, 0x07, 0x01, 0xC1, 0xC0,
  0x1E, 0x0E, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x07, 0x07, 0x00, 0x38, 0x70,
  0x0E, 0x1E, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x00, 0xF3, 0xC0, 0x1C, 0x70,
  0x00, 0xE7, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x7B, 0xC0, 0x03, 0x9C,
  0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x01, 0xDC,
  0x00, 0x0F, 0xC0, 0x03, 0xB8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x07, 0x80,
  0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xE7,
  0x80, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x77, 0x00, 0x00, 0xF7,
  0x80, 0x01, 0xE3, 0x80, 0x01, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x07, 0x80,
  0xE0, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1D,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x1F, 0x80, 0x0C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xBF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF4, 0x00, 0x0F,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Light60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 44, 14, 4, -43 },
  { 34, 13, 16, 21, 4, -43 },
  { 60, 32, 43, 34, 1, -43 },
  { 232, 24, 49, 31, 3, -46 },
  { 379, 38, 44, 44, 3, -43 },
  { 588, 33, 45, 37, 3, -44 },
  { 774, 4, 16, 12, 4, -43 },
  { 782, 12, 52, 17, 3, -43 },
  { 860, 12, 52, 17, 2, -43 },
  { 938, 23, 23, 29, 3, -46 },
  { 1005, 25, 28, 31, 3, -35 },
  { 1093, 7, 15, 13, 2, -7 },
  { 1107, 14, 3, 18, 2, -18 },
  { 1113, 5, 6, 14, 4, -5 },
  { 1117, 19, 43, 21, 1, -43 },
  { 1220, 25, 45, 31, 3, -44 },
  { 1361, 14, 43, 31, 5, -43 },
  { 1437, 24, 43, 31, 3, -43 },
  { 1566, 24, 44, 31, 3, -43 },
  { 1698, 29, 43, 31, 1, -43 },
  { 1854, 23, 44, 31, 4, -43 },
  { 1981, 25, 44, 31, 3, -43 },
  { 2119, 25, 43, 31, 3, -43 },
  { 2254, 25, 44, 31, 3, -43 },
  { 2392, 24, 44, 31, 3, -43 },
  { 2524, 5, 33, 14, 4, -32 },
  { 2545, 7, 40, 14, 2, -32 },
  { 2580, 25, 27, 31, 3, -35 },
  { 2665, 25, 15, 31, 3, -29 },
  { 2712, 25, 27, 31, 3, -35 },
  { 2797, 20, 44, 23, 1, -43 },
  { 2907, 41, 49, 48, 3, -43 },
  { 3159, 32, 43, 32, 0, -43 },
  { 3331, 26, 43, 34, 5, -43 },
  { 3471, 28, 44, 33, 3, -43 },
  { 3625, 29, 43, 38, 5, -43 },
  { 3781, 21, 43, 30, 5, -43 },
  { 3894, 21, 43, 27, 5, -43 },
  { 4007, 32, 45, 39, 3, -44 },
  { 4187, 28, 43, 39, 5, -43 },
  { 4338, 12, 43, 17, 3, -43 },
  { 4403, 13, 54, 14, -4, -43 },
  { 4491, 27, 43, 31, 5, -43 },
  { 4637, 21, 43, 27, 5, -43 },
  { 4750, 38, 43, 48, 5, -43 },
  { 4955, 29, 43, 39, 5, -43 },
  { 5111, 34, 45, 41, 3, -44 },
  { 5303, 24, 43, 32, 5, -43 },
  { 5432, 34, 54, 41, 3, -44 },
  { 5662, 26, 43, 32, 5, -43 },
  { 5802, 24, 44, 30, 3, -43 },
  { 5934, 28, 43, 28, 0, -43 },
  { 6085, 28, 44, 39, 5, -43 },
  { 6239, 31, 43, 31, 0, -43 },
  { 6406, 47, 43, 49, 1, -43 },
  { 6659, 29, 43, 29, 0, -43 },
  { 6815, 28, 43, 28, 0, -43 },
  { 6966, 25, 43, 29, 2, -43 },
  { 7101, 12, 53, 19, 5, -43 },
  { 7181, 19, 43, 21, 1, -43 },
  { 7284, 12, 53, 19, 2, -43 },
  { 7364, 27, 25, 31, 2, -43 },
  { 7449, 25, 3, 25, 0, 5 },
  { 7459, 11, 10, 15, 2, -46 },
  { 7473, 21, 33, 29, 3, -32 },
  { 7560, 24, 47, 33, 5, -46 },
  { 7701, 21, 34, 25, 3, -33 },
  { 7791, 25, 47, 33, 3, -46 },
  { 7938, 24, 34, 30, 3, -33 },
  { 8040, 18, 46, 17, 1, -46 },
  { 8144, 25, 47, 32, 3, -33 },
  { 8291, 23, 46, 32, 5, -46 },
  { 8424, 5, 44, 13, 4, -44 },
  { 8452, 11, 58, 13, -2, -44 },
  { 8532, 22, 46, 27, 5, -46 },
  { 8659, 3, 46, 13, 5, -46 },
  { 8677, 39, 33, 48, 5, -33 },
  { 8838, 23, 33, 32, 5, -33 },
  { 8933, 26, 34, 32, 3, -33 },
  { 9044, 24, 47, 33, 5, -33 },
  { 9185, 25, 47, 32, 3, -33 },
  { 9332, 15, 32, 21, 5, -32 },
  { 9392, 21, 34, 25, 2, -33 },
  { 9482, 16, 40, 18, 1, -39 },
  { 9562, 23, 33, 32, 4, -32 },
  { 9657, 25, 32, 25, 0, -32 },
  { 9757, 39, 32, 40, 1, -32 },
  { 9913, 24, 32, 27, 1, -32 },
  { 10009, 25, 46, 25, 0, -32 },
  { 10153, 20, 32, 24, 2, -32 },
  { 10233, 17, 53, 21, 2, -43 },
  { 10346, 3, 61, 29, 13, -46 },
  { 10369, 17, 53, 21, 2, -43 },
  { 10482, 25, 6, 31, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_Light60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT60PT7B_H_
