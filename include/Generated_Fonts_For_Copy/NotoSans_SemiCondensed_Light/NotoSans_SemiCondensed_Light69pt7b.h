#ifndef _NOTOSANS_SEMICONDENSED_LIGHT69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light69pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x7C, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77,
  0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0,
  0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F, 0x8E, 0x1F,
  0x87, 0xC1, 0xC0, 0x61, 0xE0, 0x38, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0x00,
  0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x07,
  0x00, 0x0F, 0x80, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x0F, 0x83, 0x80, 0x00,
  0xFC, 0x70, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0x9F, 0xC0, 0x00, 0x70, 0xFC, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xC0,
  0x78, 0x00, 0x38, 0x0F, 0x80, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00,
  0x1C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x01,
  0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x03, 0xEC, 0x00,
  0xE0, 0xF9, 0xF0, 0x1C, 0x7E, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x3C, 0x3E, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x70, 0x03, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x1E, 0x0F,
  0xE0, 0x38, 0x01, 0xE0, 0xE0, 0xFF, 0xC1, 0xC0, 0x0F, 0x0F, 0x0F, 0xFF,
  0x0F, 0x00, 0x70, 0x70, 0xF0, 0x78, 0x38, 0x03, 0x87, 0x87, 0x01, 0xE1,
  0xC0, 0x3C, 0x38, 0x78, 0x07, 0x0F, 0x03, 0xC3, 0xC3, 0x80, 0x3C, 0x3C,
  0x3E, 0x1C, 0x1C, 0x01, 0xE0, 0xFF, 0xE1, 0xE1, 0xE0, 0x07, 0x03, 0xFE,
  0x0E, 0x0F, 0x00, 0x38, 0x07, 0xC0, 0xF0, 0x70, 0x01, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x00, 0x03, 0x80,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x70,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x38, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x00, 0x7B, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0x83, 0xF0,
  0xF8, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0x03,
  0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x1F, 0x00, 0x0F, 0x80, 0x38, 0x78, 0x00,
  0x1E, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x3C,
  0x3C, 0x00, 0x01, 0xF0, 0xF0, 0xF0, 0x00, 0x03, 0xE7, 0xC3, 0xC0, 0x00,
  0x07, 0xDE, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0xC0,
  0x78, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x07, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x03, 0xF7, 0xC0,
  0xFC, 0x00, 0x1F, 0x8F, 0x81, 0xFC, 0x01, 0xF8, 0x1E, 0x03, 0xFF, 0xFF,
  0xC0, 0x7C, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0x00, 0x7C, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF8,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x60,
  0x0E, 0x00, 0xCF, 0x81, 0xC0, 0xFF, 0xFE, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x00, 0x1C, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xFF, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xF0, 0x3E, 0xE0, 0xF9, 0xC3, 0xE3, 0x8F, 0x87, 0x7E, 0x0F,
  0xF8, 0x1D, 0xC0, 0x3B, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0xF8,
  0x38, 0x00, 0x07, 0x81, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0xF0,
  0xFF, 0x00, 0x1F, 0x87, 0x80, 0x00, 0xF8, 0x70, 0x00, 0x07, 0xC2, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x80, 0x00, 0x07, 0xCE,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x87, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x88, 0x00, 0x00, 0xF8, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFC, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x10, 0x00, 0xF0, 0x3F, 0xF8, 0x0F, 0x0F, 0xFF, 0xC0,
  0xF1, 0xFF, 0xFF, 0x0F, 0x3C, 0x01, 0xF8, 0xF7, 0x00, 0x0F, 0x8F, 0xE0,
  0x00, 0x7C, 0xFC, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x01,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0x80, 0x3F, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x7C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x77, 0x1F, 0x00, 0x1E, 0xF0, 0xFC, 0x07, 0xCF, 0x07,
  0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0x0F, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x10, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78,
  0xC0, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3C,
  0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C,
  0x1E, 0x0E, 0x07, 0x07, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x83, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0x80, 0x1F, 0x84, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0x1E, 0x00, 0x1F, 0xFF, 0xC0, 0x1E, 0x38, 0x00, 0x7F, 0x1F, 0x80, 0x1C,
  0xF0, 0x01, 0xF0, 0x07, 0x00, 0x39, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x7B,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0xF7, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xFE,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x0F, 0xC0,
  0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFC, 0x01,
  0xE0, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0x00, 0x0F, 0x80, 0x1D, 0xC0, 0x0E,
  0x00, 0x1F, 0x00, 0x3B, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0xF7, 0x80, 0x3C,
  0x00, 0xFC, 0x01, 0xCF, 0x00, 0x3C, 0x03, 0x98, 0x07, 0x9E, 0x00, 0x7C,
  0x0F, 0x38, 0x1E, 0x1C, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x38, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x78, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x3F, 0xF0, 0xF0, 0x00,
  0x0F, 0xC3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x1F, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0xFF, 0x0F, 0x00, 0x00, 0x7E,
  0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0xC3, 0xC0, 0x07, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x02, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x02, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x01, 0xFC,
  0x0F, 0x00, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00,
  0x3F, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x0E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x00, 0xF0,
  0x7E, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00,
  0x0F, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7D, 0x01, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC7, 0xE0,
  0x00, 0x0F, 0x3F, 0x80, 0x00, 0x3C, 0xFF, 0x00, 0x00, 0xF7, 0xBE, 0x00,
  0x03, 0xFC, 0x78, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x3F, 0x03, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFD, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xBC, 0x00, 0x00, 0x00, 0xEF, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xFE, 0x78,
  0x00, 0x00, 0x07, 0xBF, 0xCF, 0x00, 0x00, 0x00, 0xE7, 0xF9, 0xE0, 0x00,
  0x00, 0x3C, 0xFF, 0x1E, 0x00, 0x00, 0x07, 0x1F, 0xE3, 0xC0, 0x00, 0x01,
  0xE3, 0xFC, 0x38, 0x00, 0x00, 0x3C, 0x7F, 0x87, 0x80, 0x00, 0x07, 0x0F,
  0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xFE, 0x0E, 0x00, 0x00, 0x3C, 0x3F, 0xC1,
  0xE0, 0x00, 0x07, 0x07, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0xFF, 0x03, 0xC0,
  0x00, 0x3C, 0x1F, 0xE0, 0x78, 0x00, 0x07, 0x03, 0xFC, 0x0F, 0x00, 0x01,
  0xE0, 0x7F, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xFE, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0xF8,
  0x07, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0x70, 0x01, 0xE0, 0x1F, 0xE0, 0x0F,
  0x00, 0x38, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x38, 0x01, 0xFE, 0x00, 0x78, 0x0F, 0x00,
  0x3F, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x38, 0x00, 0xFF,
  0x00, 0x1E, 0x0F, 0x00, 0x1F, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xFC, 0x00,
  0x3C, 0x78, 0x00, 0x7F, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0xF0, 0x00, 0x79,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xEF, 0x00, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x07, 0xF9,
  0xE0, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0xFF,
  0x0F, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x00, 0x3F, 0xC1, 0xE0, 0x00, 0x1F,
  0xE0, 0xF8, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x07, 0xF8, 0x0F, 0x00, 0x03,
  0xFC, 0x07, 0xC0, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0xF8, 0x00,
  0x7F, 0x80, 0x3C, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0x80,
  0x0F, 0xF0, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0x3C,
  0x01, 0xFE, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x7F, 0x80, 0x01,
  0xE0, 0x3F, 0xC0, 0x00, 0xF8, 0x1F, 0xE0, 0x00, 0x3C, 0x0F, 0xF0, 0x00,
  0x1F, 0x07, 0xF8, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x03, 0xE1, 0xFE, 0x00,
  0x00, 0xF0, 0xFF, 0x00, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0x1F, 0x1F, 0xC0,
  0x00, 0x07, 0x8F, 0xE0, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x00, 0xF3, 0xF8,
  0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0x1E, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xFF, 0x8F, 0x00, 0x03, 0xF1, 0xE0,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0xF8, 0xF0, 0x00, 0x7E, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0xFF, 0xC0, 0xF0, 0x00,
  0x3F, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xCE, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7D, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x07, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x0F, 0x1C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x0F, 0xC0, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0xF9, 0xE3, 0xF8, 0x00, 0xF3, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0xF0, 0x00, 0x77,
  0x7C, 0x00, 0x73, 0xBF, 0x00, 0x79, 0xCF, 0xFF, 0xF8, 0xE3, 0xFF, 0xF8,
  0x70, 0x7F, 0xF0, 0x38, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x07, 0xFE, 0x00, 0xE0, 0xFF, 0xF8, 0x0E, 0x3F, 0xFF, 0xE0, 0xE7, 0xC0,
  0x7F, 0x0E, 0x70, 0x01, 0xF0, 0xEE, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x7C,
  0xEE, 0x00, 0x0F, 0x8E, 0xF0, 0x01, 0xF0, 0xE7, 0x80, 0x3F, 0x0E, 0x3F,
  0xFF, 0xE0, 0xE1, 0xFF, 0xF8, 0x0E, 0x0F, 0xFF, 0x00, 0x00, 0x17, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x80,
  0xE0, 0xFC, 0x00, 0x23, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x1C, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xFC, 0x0F, 0x03,
  0xFF, 0xF0, 0xF0, 0x7F, 0xFF, 0x8F, 0x0F, 0xE0, 0x7C, 0xF1, 0xF8, 0x01,
  0xEF, 0x1F, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x7F, 0x3C, 0x00, 0x03, 0xF7,
  0x80, 0x00, 0x3F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xF1,
  0xF0, 0x00, 0xEF, 0x0F, 0x80, 0x3C, 0x70, 0xFF, 0xFF, 0x87, 0x03, 0xFF,
  0xF0, 0x70, 0x1F, 0xFE, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x81, 0xFC, 0x00, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x3F, 0xFF, 0x07, 0x07, 0xFF, 0xF8,
  0xF0, 0xFE, 0x07, 0xCF, 0x1F, 0x80, 0x0E, 0xF1, 0xE0, 0x00, 0x7F, 0x3E,
  0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x3C,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x6F, 0x1F, 0x00, 0x0E, 0xF0, 0xF8, 0x03,
  0xCF, 0x07, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0x0F, 0x01, 0xFF, 0xE0, 0xF0,
  0x03, 0xD0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC4, 0x00,
  0x00, 0x7C, 0x30, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0xFF, 0xC0, 0xE0, 0xFF, 0xF8, 0x38, 0xFF, 0xFF, 0x8E, 0x7C, 0x07,
  0xE3, 0x9C, 0x00, 0x7C, 0xEE, 0x00, 0x0F, 0x3F, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x7F, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x10,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x3E, 0x38, 0x00, 0x3E,
  0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x1F,
  0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x0F,
  0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x0F, 0x80, 0x07, 0x07, 0x80, 0x03, 0x87,
  0x80, 0x01, 0xC7, 0xE0, 0x00, 0xE7, 0xF0, 0x00, 0x77, 0xBC, 0x00, 0x3B,
  0x9F, 0x00, 0x1F, 0x87, 0x80, 0x0F, 0xC1, 0xE0, 0x07, 0xC0, 0xF8, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xE0,
  0x38, 0x00, 0xF8, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1F, 0x07, 0x00, 0x07,
  0x83, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF8, 0xE0, 0x00, 0x3C, 0x70, 0x00,
  0x0F, 0x38, 0x00, 0x07, 0xDC, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0E, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x8E, 0x7C, 0x0F, 0xC7,
  0xC0, 0xFC, 0xEF, 0x00, 0x7C, 0xF0, 0x03, 0xEE, 0xE0, 0x03, 0xEE, 0x00,
  0x1E, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x3F, 0xF0, 0x38, 0x3F, 0xFE, 0x0E, 0x3F,
  0xFF, 0xE3, 0x9F, 0x01, 0xF8, 0xE7, 0x00, 0x1F, 0x3B, 0x80, 0x03, 0xEF,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x3F, 0xE0, 0x0E, 0x0F, 0xFF, 0x80, 0xE3, 0xFF, 0xFE, 0x0E, 0x3C, 0x07,
  0xF0, 0xE7, 0x00, 0x1F, 0x0E, 0xE0, 0x00, 0xF8, 0xEC, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0x07, 0xCE,
  0xE0, 0x00, 0xF8, 0xEF, 0x00, 0x1F, 0x0E, 0x7C, 0x03, 0xF0, 0xE3, 0xFF,
  0xFE, 0x0E, 0x1F, 0xFF, 0xC0, 0xE0, 0x7F, 0xF0, 0x0E, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x3F, 0xFF, 0x07,
  0x07, 0xFF, 0xF8, 0xF0, 0xFE, 0x07, 0xCF, 0x1F, 0x80, 0x1E, 0xF1, 0xE0,
  0x00, 0x7F, 0x3E, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x3F, 0x78, 0x00, 0x03,
  0xF7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x3F, 0x3C, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x6F, 0x1F, 0x00, 0x0E,
  0xF1, 0xF8, 0x03, 0xCF, 0x0F, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0x0F, 0x01,
  0xFF, 0xC0, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7E, 0x3E, 0x78, 0x07, 0x78, 0x03,
  0xB8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xF8, 0x03, 0xE7, 0xC0, 0x00, 0x8F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0xC0, 0x00, 0x7D, 0xF0, 0x03, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x77,
  0x3E, 0x00, 0x3D, 0xCF, 0xC0, 0x3E, 0x71, 0xFF, 0xFF, 0x1C, 0x3F, 0xFF,
  0x87, 0x03, 0xFF, 0x81, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0x80, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0xC0, 0x00, 0xE7, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0x78, 0x00, 0x1D, 0xC0,
  0x01, 0xE3, 0xC0, 0x03, 0xDC, 0x00, 0x1E, 0x3C, 0x00, 0x39, 0xE0, 0x01,
  0xC3, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xE0, 0x03, 0xC1,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x81, 0xE0,
  0x07, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x70, 0x07, 0x80, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x07, 0x81, 0xC0, 0x3C, 0x0E, 0x00, 0x78, 0x3C, 0x01, 0xC1, 0xE0,
  0x03, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xE0, 0x03,
  0xC7, 0x80, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0xE3, 0xC0, 0x01, 0xC7,
  0x80, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x07,
  0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x00,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x09,
  0xFF, 0xE0, 0x00, 0x5F, 0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFA, 0x00, 0x01, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 50, 16, 5, -49 },
  { 39, 15, 18, 24, 5, -49 },
  { 73, 36, 49, 39, 2, -49 },
  { 294, 27, 56, 35, 4, -52 },
  { 483, 45, 51, 51, 3, -50 },
  { 770, 38, 51, 42, 3, -50 },
  { 1013, 4, 18, 13, 5, -49 },
  { 1022, 14, 60, 19, 3, -49 },
  { 1127, 14, 60, 19, 2, -49 },
  { 1232, 27, 26, 33, 3, -52 },
  { 1320, 29, 33, 35, 3, -41 },
  { 1440, 8, 17, 15, 3, -8 },
  { 1457, 16, 3, 21, 2, -20 },
  { 1463, 6, 7, 16, 5, -6 },
  { 1469, 22, 49, 24, 1, -49 },
  { 1604, 28, 51, 35, 4, -50 },
  { 1783, 15, 49, 35, 6, -49 },
  { 1875, 28, 50, 35, 3, -50 },
  { 2050, 28, 51, 35, 3, -50 },
  { 2229, 33, 50, 35, 1, -50 },
  { 2436, 28, 50, 35, 4, -49 },
  { 2611, 28, 51, 35, 4, -50 },
  { 2790, 29, 49, 35, 3, -49 },
  { 2968, 29, 51, 35, 3, -50 },
  { 3153, 28, 51, 35, 3, -50 },
  { 3332, 6, 38, 16, 5, -37 },
  { 3361, 9, 46, 16, 2, -37 },
  { 3413, 29, 31, 35, 3, -40 },
  { 3526, 29, 17, 35, 3, -33 },
  { 3588, 29, 31, 35, 3, -40 },
  { 3701, 23, 51, 26, 1, -50 },
  { 3848, 47, 55, 55, 4, -49 },
  { 4172, 37, 49, 37, 0, -49 },
  { 4399, 30, 49, 39, 6, -49 },
  { 4583, 32, 51, 38, 4, -50 },
  { 4787, 34, 49, 44, 6, -49 },
  { 4996, 24, 49, 34, 6, -49 },
  { 5143, 24, 49, 31, 6, -49 },
  { 5290, 36, 51, 45, 4, -50 },
  { 5520, 32, 49, 45, 6, -49 },
  { 5716, 14, 49, 20, 3, -49 },
  { 5802, 15, 62, 16, -5, -49 },
  { 5919, 30, 49, 36, 6, -49 },
  { 6103, 24, 49, 32, 6, -49 },
  { 6250, 43, 49, 55, 6, -49 },
  { 6514, 33, 49, 45, 6, -49 },
  { 6717, 39, 51, 47, 4, -50 },
  { 6966, 27, 49, 36, 6, -49 },
  { 7132, 39, 62, 47, 4, -50 },
  { 7435, 30, 49, 37, 6, -49 },
  { 7619, 28, 51, 34, 3, -50 },
  { 7798, 32, 49, 32, 0, -49 },
  { 7994, 33, 50, 44, 6, -49 },
  { 8201, 36, 49, 36, 0, -49 },
  { 8422, 55, 49, 57, 1, -49 },
  { 8759, 33, 49, 33, 0, -49 },
  { 8962, 32, 49, 32, 0, -49 },
  { 9158, 30, 49, 34, 2, -49 },
  { 9342, 14, 60, 22, 6, -49 },
  { 9447, 22, 49, 24, 1, -49 },
  { 9582, 14, 60, 22, 2, -49 },
  { 9687, 31, 28, 36, 2, -49 },
  { 9796, 29, 3, 29, 0, 6 },
  { 9807, 12, 11, 18, 3, -53 },
  { 9824, 25, 38, 33, 3, -37 },
  { 9943, 28, 53, 37, 6, -52 },
  { 10129, 23, 38, 29, 4, -37 },
  { 10239, 28, 53, 37, 4, -52 },
  { 10425, 27, 38, 34, 4, -37 },
  { 10554, 21, 53, 19, 1, -53 },
  { 10694, 28, 54, 37, 4, -37 },
  { 10883, 26, 52, 37, 6, -52 },
  { 11052, 5, 50, 15, 5, -50 },
  { 11084, 12, 67, 15, -2, -50 },
  { 11185, 25, 52, 31, 6, -52 },
  { 11348, 3, 52, 15, 6, -52 },
  { 11368, 44, 37, 55, 6, -37 },
  { 11572, 26, 37, 37, 6, -37 },
  { 11693, 29, 38, 37, 4, -37 },
  { 11831, 28, 53, 37, 6, -37 },
  { 12017, 28, 53, 37, 4, -37 },
  { 12203, 17, 37, 24, 6, -37 },
  { 12282, 23, 38, 29, 3, -37 },
  { 12392, 18, 46, 21, 1, -45 },
  { 12496, 26, 38, 37, 5, -37 },
  { 12620, 29, 37, 29, 0, -37 },
  { 12755, 44, 37, 46, 1, -37 },
  { 12959, 28, 37, 31, 1, -37 },
  { 13089, 29, 54, 29, 0, -37 },
  { 13285, 23, 37, 27, 2, -37 },
  { 13392, 20, 60, 25, 2, -49 },
  { 13542, 3, 70, 34, 15, -53 },
  { 13569, 19, 60, 25, 3, -49 },
  { 13712, 29, 7, 35, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_Light69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT69PT7B_H_
