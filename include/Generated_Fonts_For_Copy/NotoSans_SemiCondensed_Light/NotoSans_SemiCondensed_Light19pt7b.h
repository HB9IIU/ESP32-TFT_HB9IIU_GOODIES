#ifndef _NOTOSANS_SEMICONDENSED_LIGHT19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light19pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x50, 0x70, 0x99, 0x99, 0x90, 0x08, 0x82, 0x20, 0x88,
  0x24, 0x7F, 0xC4, 0x41, 0x10, 0x44, 0x11, 0x3F, 0xF2, 0x20, 0x88, 0x22,
  0x08, 0x80, 0x10, 0x7E, 0xD0, 0x90, 0x90, 0xD0, 0x70, 0x1C, 0x12, 0x12,
  0x11, 0x12, 0xFC, 0x10, 0x10, 0x60, 0x49, 0x08, 0x88, 0x88, 0x90, 0x89,
  0x08, 0xA0, 0x8A, 0xE9, 0x51, 0x65, 0x10, 0x91, 0x09, 0x11, 0x11, 0x10,
  0x93, 0x0E, 0x18, 0x09, 0x04, 0x21, 0x08, 0x64, 0x0B, 0x01, 0x81, 0xA0,
  0xCC, 0x61, 0xA8, 0x2A, 0x04, 0xC2, 0x9F, 0x10, 0xF8, 0x12, 0x44, 0xC8,
  0x88, 0x88, 0x88, 0x84, 0x42, 0x30, 0x91, 0x22, 0x49, 0x24, 0x92, 0x52,
  0x80, 0x10, 0x23, 0x59, 0xC2, 0x8C, 0x91, 0x00, 0x10, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x7A, 0xF0, 0x70, 0x04, 0x10, 0x42, 0x08,
  0x41, 0x04, 0x20, 0x82, 0x10, 0x43, 0x00, 0x38, 0x64, 0x42, 0x82, 0x83,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x42, 0x3C, 0x13, 0xD9, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x38, 0xC4, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x60, 0xC0, 0xFF, 0x38, 0xC6, 0x02, 0x02, 0x02, 0x06,
  0x3C, 0x0C, 0x02, 0x03, 0x03, 0x02, 0x82, 0xFC, 0x02, 0x01, 0x01, 0x81,
  0x40, 0xA0, 0x90, 0xC8, 0x44, 0x42, 0x21, 0x3F, 0xE0, 0x40, 0x20, 0x10,
  0x7E, 0x40, 0x40, 0x40, 0x40, 0x40, 0xFC, 0x02, 0x03, 0x01, 0x01, 0x02,
  0x86, 0xFC, 0x0E, 0x30, 0x40, 0x40, 0x80, 0x80, 0xBE, 0xC2, 0x81, 0x81,
  0x81, 0x43, 0x42, 0x3C, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x38, 0x46, 0xC2, 0x82, 0xC2, 0x46,
  0x38, 0x2C, 0x42, 0x81, 0x81, 0x81, 0xC2, 0x7C, 0x38, 0x44, 0x82, 0x82,
  0x83, 0x81, 0x83, 0x45, 0x3B, 0x02, 0x02, 0x02, 0x04, 0x78, 0xD0, 0x00,
  0x70, 0xD0, 0x00, 0x7A, 0x01, 0x06, 0x18, 0x60, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x03, 0x0C, 0x30,
  0xC0, 0x39, 0x88, 0x10, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x00, 0x02,
  0x06, 0x00, 0x03, 0x00, 0xE7, 0x08, 0x0C, 0x80, 0x24, 0x38, 0xC6, 0x46,
  0x22, 0x31, 0x11, 0x90, 0x8C, 0x44, 0x62, 0x65, 0x0C, 0xE4, 0x00, 0x30,
  0x00, 0xC1, 0x01, 0xF0, 0x04, 0x03, 0x00, 0xC0, 0x28, 0x12, 0x04, 0x81,
  0x10, 0x84, 0x3F, 0x08, 0x24, 0x09, 0x02, 0x40, 0x60, 0x10, 0xF0, 0x8E,
  0x82, 0x82, 0x82, 0x82, 0xFC, 0x86, 0x83, 0x81, 0x81, 0x83, 0x82, 0xFC,
  0x0F, 0x18, 0x58, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x00, 0xFC, 0xF0, 0x47, 0x20, 0xD0, 0x28, 0x1C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x50, 0x28, 0x67, 0xE0, 0xFE, 0x08, 0x20, 0x82,
  0x0F, 0xE0, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x3F, 0x82, 0x08, 0x20, 0x82, 0x00, 0x0F, 0x8E, 0x36, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x0F, 0x80, 0x60, 0x14, 0x05, 0x01, 0x20, 0x47, 0xF0,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0C, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xE0, 0x83, 0x82, 0x84, 0x88,
  0x90, 0xB0, 0xA0, 0xD0, 0x90, 0x88, 0x8C, 0x84, 0x82, 0x83, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0x3C, 0x03,
  0xC0, 0x5C, 0x07, 0xA0, 0xBA, 0x0B, 0xA0, 0xB9, 0x13, 0x91, 0x38, 0x93,
  0x8A, 0x38, 0xA3, 0x86, 0x38, 0x43, 0x80, 0xE0, 0x70, 0x34, 0x1A, 0x0C,
  0x86, 0x43, 0x11, 0x8C, 0xC2, 0x60, 0xB0, 0x58, 0x1C, 0x0C, 0x0E, 0x06,
  0x31, 0x83, 0x20, 0x2C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0D,
  0x01, 0x20, 0x22, 0x08, 0x3E, 0x00, 0xF1, 0x1A, 0x0C, 0x18, 0x30, 0x61,
  0xFE, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x0E, 0x06, 0x31, 0x83, 0x20,
  0x2C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0D, 0x01, 0x20, 0x22,
  0x08, 0x3E, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0xF0, 0x8C, 0x82, 0x82, 0x82,
  0x82, 0x84, 0xF8, 0x88, 0x88, 0x84, 0x84, 0x82, 0x83, 0x3C, 0xC6, 0x04,
  0x08, 0x18, 0x1C, 0x0E, 0x06, 0x04, 0x08, 0x10, 0x3F, 0x80, 0xFF, 0x84,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x2C, 0x33, 0xF0, 0x80, 0x60, 0x24, 0x09, 0x02, 0x41,
  0x88, 0x42, 0x10, 0x8C, 0x12, 0x04, 0x81, 0x20, 0x30, 0x0C, 0x03, 0x00,
  0x81, 0x02, 0x83, 0x05, 0x06, 0x0A, 0x14, 0x34, 0x28, 0x44, 0x48, 0x88,
  0x91, 0x12, 0x26, 0x24, 0x48, 0x28, 0x50, 0x50, 0xA0, 0xC1, 0xC1, 0x83,
  0x01, 0x02, 0x00, 0xC0, 0xA0, 0x88, 0x44, 0x41, 0x60, 0xA0, 0x30, 0x18,
  0x14, 0x0B, 0x08, 0x8C, 0x24, 0x14, 0x04, 0x80, 0xA0, 0x90, 0x4C, 0x42,
  0x21, 0xB0, 0x50, 0x28, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xFF,
  0x02, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80,
  0xFF, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0x81, 0x04, 0x10, 0x20,
  0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92,
  0x49, 0xE0, 0x10, 0x18, 0x28, 0x24, 0x44, 0x42, 0x42, 0x81, 0xFF, 0x99,
  0x80, 0x7C, 0x0C, 0x08, 0x13, 0xF8, 0x60, 0xC3, 0x86, 0xF4, 0x81, 0x02,
  0x04, 0x0F, 0xD0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x7F, 0x80, 0x3E,
  0x83, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x78, 0x01, 0x01, 0x01, 0x01,
  0x3D, 0x43, 0x83, 0x81, 0x81, 0x81, 0x81, 0x83, 0x43, 0x3D, 0x3C, 0x86,
  0x0C, 0x1F, 0xF0, 0x20, 0x60, 0x40, 0x7C, 0x08, 0xD2, 0x08, 0x23, 0xE2,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x7D, 0x43, 0x83, 0x81, 0x81,
  0x81, 0x81, 0x83, 0x43, 0x3D, 0x01, 0x01, 0x02, 0x46, 0x38, 0x81, 0x02,
  0x04, 0x0F, 0xD0, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xF0,
  0x55, 0x55, 0x50, 0x33, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3A,
  0x40, 0x82, 0x08, 0x20, 0x8E, 0x29, 0x28, 0xE2, 0xC9, 0x22, 0x8A, 0x10,
  0xFF, 0xFC, 0xF9, 0xE8, 0x63, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84,
  0x18, 0x41, 0x84, 0x18, 0x41, 0xFD, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x04, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0xFD, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC7, 0x7A, 0x04, 0x08, 0x10,
  0x00, 0x7D, 0x43, 0x83, 0x81, 0x81, 0x81, 0x81, 0x83, 0x43, 0x3D, 0x01,
  0x01, 0x01, 0x01, 0xFC, 0x88, 0x88, 0x88, 0x88, 0x7E, 0x08, 0x30, 0x70,
  0x60, 0x41, 0x87, 0xE0, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x43,
  0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x43, 0x7D, 0x81,
  0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18, 0x18, 0x18, 0x82, 0x1A, 0x30,
  0x91, 0x44, 0x8A, 0x24, 0x52, 0x14, 0x50, 0xA2, 0x85, 0x14, 0x30, 0xC0,
  0x82, 0x00, 0x43, 0x22, 0x24, 0x14, 0x18, 0x18, 0x14, 0x26, 0x42, 0xC1,
  0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x10, 0xA0, 0xC0, 0xFC, 0x20, 0x84, 0x30, 0x84, 0x10, 0x83, 0xF0, 0x09,
  0x88, 0x42, 0x10, 0x8C, 0xC2, 0x08, 0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF,
  0xE0, 0x83, 0x08, 0x42, 0x10, 0x84, 0x19, 0x88, 0x42, 0x10, 0x84, 0xC0,
  0x61, 0x9F,
};

const GFXglyph NotoSans_SemiCondensed_Light19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 4, 5, 7, 1, -14 },
  { 8, 10, 14, 11, 0, -14 },
  { 26, 8, 15, 10, 1, -14 },
  { 41, 12, 14, 14, 1, -14 },
  { 62, 10, 14, 12, 1, -14 },
  { 80, 1, 5, 4, 1, -14 },
  { 81, 4, 17, 5, 1, -14 },
  { 90, 3, 17, 5, 1, -14 },
  { 97, 7, 7, 9, 1, -14 },
  { 104, 8, 9, 10, 1, -11 },
  { 113, 2, 4, 4, 1, -2 },
  { 114, 4, 1, 6, 1, -6 },
  { 115, 2, 2, 4, 1, -2 },
  { 116, 6, 14, 7, 0, -14 },
  { 127, 8, 14, 10, 1, -14 },
  { 141, 4, 14, 10, 2, -14 },
  { 148, 8, 14, 10, 1, -14 },
  { 162, 8, 14, 10, 1, -14 },
  { 176, 9, 14, 10, 0, -14 },
  { 192, 8, 14, 10, 1, -14 },
  { 206, 8, 14, 10, 1, -14 },
  { 220, 8, 14, 10, 1, -14 },
  { 234, 8, 14, 10, 1, -14 },
  { 248, 8, 14, 10, 1, -14 },
  { 262, 2, 10, 4, 1, -10 },
  { 265, 2, 12, 4, 1, -10 },
  { 268, 8, 8, 10, 1, -11 },
  { 276, 8, 5, 10, 1, -9 },
  { 281, 8, 8, 10, 1, -11 },
  { 289, 7, 14, 7, 0, -14 },
  { 302, 13, 16, 15, 1, -14 },
  { 328, 10, 14, 10, 0, -14 },
  { 346, 8, 14, 11, 2, -14 },
  { 360, 9, 14, 10, 1, -14 },
  { 376, 9, 14, 12, 2, -14 },
  { 392, 6, 14, 9, 2, -14 },
  { 403, 6, 14, 9, 2, -14 },
  { 414, 10, 14, 12, 1, -14 },
  { 432, 9, 14, 12, 2, -14 },
  { 448, 4, 14, 5, 1, -14 },
  { 455, 4, 17, 4, -1, -14 },
  { 464, 8, 14, 10, 2, -14 },
  { 478, 6, 14, 9, 2, -14 },
  { 489, 12, 14, 15, 2, -14 },
  { 510, 9, 14, 13, 2, -14 },
  { 526, 11, 14, 13, 1, -14 },
  { 546, 7, 14, 10, 2, -14 },
  { 559, 11, 17, 13, 1, -14 },
  { 583, 8, 14, 10, 2, -14 },
  { 597, 7, 14, 9, 1, -14 },
  { 610, 9, 14, 9, 0, -14 },
  { 626, 9, 14, 12, 2, -14 },
  { 642, 10, 14, 10, 0, -14 },
  { 660, 15, 14, 16, 0, -14 },
  { 687, 9, 14, 9, 0, -14 },
  { 703, 9, 14, 9, 0, -14 },
  { 719, 8, 14, 9, 1, -14 },
  { 733, 3, 17, 6, 2, -14 },
  { 740, 6, 14, 7, 0, -14 },
  { 751, 3, 17, 6, 1, -14 },
  { 758, 8, 8, 10, 1, -14 },
  { 766, 8, 1, 8, 0, 2 },
  { 767, 3, 3, 5, 1, -15 },
  { 769, 7, 10, 9, 1, -10 },
  { 778, 7, 14, 10, 2, -14 },
  { 791, 7, 10, 8, 1, -10 },
  { 800, 8, 14, 10, 1, -14 },
  { 814, 7, 10, 9, 1, -10 },
  { 823, 6, 15, 5, 0, -15 },
  { 835, 8, 15, 10, 1, -10 },
  { 850, 7, 14, 10, 2, -14 },
  { 863, 2, 14, 4, 1, -14 },
  { 867, 4, 19, 4, -1, -14 },
  { 877, 6, 14, 8, 2, -14 },
  { 888, 1, 14, 4, 2, -14 },
  { 890, 12, 10, 15, 2, -10 },
  { 905, 7, 10, 10, 2, -10 },
  { 914, 8, 10, 10, 1, -10 },
  { 924, 7, 14, 10, 2, -10 },
  { 937, 8, 14, 10, 1, -10 },
  { 951, 4, 10, 7, 2, -10 },
  { 956, 6, 10, 8, 1, -10 },
  { 964, 5, 13, 6, 0, -13 },
  { 973, 8, 10, 10, 1, -10 },
  { 983, 8, 10, 8, 0, -10 },
  { 993, 13, 10, 13, 0, -10 },
  { 1010, 8, 10, 8, 0, -10 },
  { 1020, 8, 15, 8, 0, -10 },
  { 1035, 6, 10, 8, 1, -10 },
  { 1043, 5, 17, 7, 1, -14 },
  { 1054, 1, 19, 9, 4, -14 },
  { 1057, 5, 17, 7, 1, -14 },
  { 1068, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Light19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT19PT7B_H_
