#ifndef _NOTOSANS_SEMICONDENSED_LIGHT26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x04,
  0x20, 0x21, 0x03, 0x08, 0x10, 0xC0, 0x84, 0x04, 0x23, 0xFF, 0xE1, 0x08,
  0x18, 0x40, 0xC6, 0x04, 0x20, 0x21, 0x0F, 0xFF, 0x08, 0x40, 0xC2, 0x06,
  0x30, 0x21, 0x01, 0x08, 0x08, 0x40, 0x04, 0x00, 0x80, 0x7E, 0x3E, 0xE4,
  0x41, 0x88, 0x31, 0x06, 0x20, 0x64, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x4C,
  0x08, 0xC1, 0x18, 0x23, 0x04, 0x58, 0xB9, 0xFC, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x38, 0x0C, 0x36, 0x04, 0x11, 0x86, 0x18, 0x42, 0x0C, 0x23, 0x06,
  0x11, 0x03, 0x09, 0x81, 0x84, 0x80, 0x46, 0x4F, 0x23, 0x48, 0x9B, 0x24,
  0x67, 0x26, 0x10, 0x13, 0x08, 0x19, 0x84, 0x08, 0xC2, 0x0C, 0x61, 0x04,
  0x11, 0x86, 0x08, 0x82, 0x03, 0xC0, 0x0E, 0x00, 0x37, 0x00, 0xC2, 0x01,
  0x06, 0x02, 0x0C, 0x06, 0x10, 0x04, 0x60, 0x0D, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC8, 0x33, 0x18, 0x6C, 0x18, 0x98, 0x1B, 0x30, 0x1C, 0x60, 0x18,
  0x40, 0x70, 0xC3, 0xB0, 0xFE, 0x38, 0xFE, 0x08, 0xCC, 0x46, 0x31, 0x08,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0x42, 0x18, 0x43, 0x08, 0x60, 0x82, 0x18,
  0x43, 0x08, 0x43, 0x18, 0xC2, 0x10, 0x84, 0x63, 0x18, 0x8C, 0x62, 0x23,
  0x00, 0x0C, 0x01, 0x00, 0x42, 0x11, 0xF7, 0xC3, 0x80, 0xE0, 0x4C, 0x31,
  0x08, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x6D, 0x2D, 0x00, 0xFF, 0xF0,
  0xF0, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04,
  0x02, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x00, 0x0F,
  0x07, 0xF0, 0x83, 0x30, 0x24, 0x04, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x06, 0x80, 0xD0, 0x1B, 0x02, 0x60, 0xC6, 0x30,
  0x7C, 0x00, 0x04, 0x33, 0x59, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x40, 0x1E, 0x0F, 0xF1, 0x03, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x73, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x07, 0x03, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xD8, 0x39, 0xFC, 0x00, 0x00,
  0x80, 0x18, 0x03, 0x80, 0x28, 0x04, 0x80, 0xC8, 0x08, 0x81, 0x88, 0x10,
  0x82, 0x08, 0x60, 0x84, 0x08, 0x80, 0x8F, 0xFF, 0xFF, 0xF0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x7F, 0x9F, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0xFE, 0x20, 0xE0, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xA0, 0xCF, 0xE0, 0x03, 0xC1, 0xD8, 0x40, 0x18, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x10, 0x5F, 0x9E, 0x1B, 0x81, 0xE0, 0x3C, 0x02, 0x80, 0x50,
  0x1B, 0x03, 0x20, 0x46, 0x18, 0x7E, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x00, 0x0F, 0x07,
  0x71, 0x83, 0x20, 0x24, 0x04, 0x80, 0x98, 0x31, 0x8C, 0x1F, 0x01, 0xE0,
  0xC6, 0x30, 0x64, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0x40, 0x6C, 0x18, 0x7E,
  0x00, 0x1E, 0x07, 0x71, 0x83, 0x20, 0x2C, 0x05, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x6C, 0x1C, 0xC7, 0x8F, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x01,
  0x80, 0x61, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x6D, 0x00, 0x00, 0x00,
  0x36, 0x96, 0x80, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x10, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x40, 0x00, 0x7C, 0xEE,
  0x03, 0x03, 0x01, 0x03, 0x03, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xC0, 0x60,
  0x60, 0x04, 0x30, 0x00, 0x88, 0x00, 0x26, 0x1F, 0x85, 0x0C, 0x21, 0x42,
  0x08, 0x71, 0x82, 0x1C, 0x60, 0x87, 0x10, 0x61, 0xC6, 0x18, 0x51, 0x86,
  0x34, 0x22, 0x89, 0x07, 0x9C, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x10, 0x07, 0xF8, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xE0,
  0x04, 0x80, 0x12, 0x00, 0xCC, 0x02, 0x10, 0x08, 0x40, 0x61, 0x81, 0x02,
  0x07, 0xF8, 0x3F, 0xF0, 0x80, 0x42, 0x01, 0x18, 0x06, 0x40, 0x0B, 0x00,
  0x2C, 0x00, 0xC0, 0xFC, 0x1F, 0xF3, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x02, 0xC3, 0x9F, 0xF3, 0x03, 0x60, 0x3C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x3B, 0xFE, 0x00, 0x07, 0xC1, 0xFF, 0x30, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x82, 0x0F, 0xE0, 0xF8,
  0x07, 0xFC, 0x30, 0x39, 0x80, 0xCC, 0x03, 0x60, 0x0B, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0B, 0x00, 0xD8,
  0x06, 0xC0, 0x66, 0x1E, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x7F, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x7F, 0xFF, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x00, 0x07, 0xE0, 0xFF, 0xCC, 0x02, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x2C, 0x01, 0x60, 0x09, 0xC0, 0xC3, 0xFC, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x10, 0xFB, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xBE, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x2F, 0xB8, 0xC0, 0x2C, 0x06, 0xC0,
  0xCC, 0x18, 0xC3, 0x0C, 0x20, 0xC4, 0x0C, 0xC0, 0xD8, 0x0F, 0xC0, 0xEC,
  0x0C, 0x60, 0xC3, 0x0C, 0x30, 0xC1, 0x8C, 0x08, 0xC0, 0xCC, 0x06, 0xC0,
  0x30, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xE0, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFD, 0x00, 0x5E, 0x80, 0x2F,
  0x60, 0x37, 0x90, 0x13, 0xC8, 0x19, 0xE6, 0x08, 0xF1, 0x04, 0x78, 0xC6,
  0x3C, 0x62, 0x1E, 0x11, 0x0F, 0x0D, 0x87, 0x86, 0x83, 0xC1, 0x41, 0xE0,
  0xE0, 0xF0, 0x20, 0x60, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3D, 0x01,
  0xEC, 0x0F, 0x30, 0x79, 0x83, 0xC6, 0x1E, 0x10, 0xF0, 0xC7, 0x82, 0x3C,
  0x19, 0xE0, 0x6F, 0x01, 0x78, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x06, 0x07,
  0x80, 0x7F, 0x83, 0x03, 0x18, 0x06, 0xC0, 0x0B, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x90, 0x06, 0x60, 0x10, 0xE1, 0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0xF3,
  0x03, 0x60, 0x6C, 0x05, 0x80, 0xF0, 0x16, 0x02, 0xC0, 0xD8, 0x33, 0xFC,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00,
  0x07, 0x80, 0x7F, 0x83, 0x03, 0x18, 0x06, 0xC0, 0x0B, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x90, 0x06, 0x60, 0x10, 0xE1, 0xC1, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0xFC, 0x0F, 0xF8, 0xC0, 0xCC, 0x04, 0xC0,
  0x4C, 0x06, 0xC0, 0x4C, 0x04, 0xC0, 0xCC, 0x38, 0xFE, 0x0C, 0x20, 0xC3,
  0x0C, 0x10, 0xC1, 0x8C, 0x0C, 0xC0, 0xCC, 0x06, 0xC0, 0x30, 0x0F, 0x87,
  0xF9, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x38, 0x03, 0xC0,
  0x0E, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xD8, 0x33, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x48, 0x02, 0x60, 0x31, 0x83, 0x07,
  0xF0, 0xC0, 0x0E, 0x00, 0x50, 0x06, 0xC0, 0x26, 0x01, 0x10, 0x18, 0x80,
  0xC6, 0x04, 0x10, 0x60, 0x83, 0x06, 0x10, 0x11, 0x80, 0x8C, 0x06, 0x40,
  0x36, 0x00, 0xB0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0xC0, 0x20, 0x1A, 0x01,
  0x80, 0xD0, 0x1C, 0x04, 0xC0, 0xA0, 0x26, 0x05, 0x03, 0x10, 0x2C, 0x18,
  0x83, 0x20, 0x86, 0x19, 0x04, 0x30, 0x88, 0x60, 0x84, 0x63, 0x04, 0x61,
  0x10, 0x33, 0x08, 0x81, 0x90, 0x4C, 0x04, 0x83, 0x60, 0x2C, 0x0A, 0x01,
  0xE0, 0x50, 0x0E, 0x02, 0x80, 0x30, 0x1C, 0x01, 0x80, 0x40, 0x40, 0x36,
  0x03, 0x20, 0x63, 0x04, 0x10, 0xC1, 0x88, 0x09, 0x80, 0xD0, 0x07, 0x00,
  0x60, 0x07, 0x00, 0xD0, 0x09, 0x81, 0x88, 0x10, 0xC3, 0x06, 0x60, 0x64,
  0x03, 0xC0, 0x30, 0xC0, 0x14, 0x03, 0x60, 0x26, 0x06, 0x20, 0x43, 0x0C,
  0x10, 0x81, 0x98, 0x09, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0xFF, 0x80, 0xFF,
  0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0xE0, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18,
  0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60,
  0xFF, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x87, 0xE0, 0x04, 0x00, 0x60, 0x0A, 0x00, 0xB0, 0x19, 0x01, 0x18,
  0x30, 0x82, 0x0C, 0x60, 0x44, 0x06, 0xC0, 0x30, 0xFF, 0xE0, 0xC3, 0x08,
  0x30, 0x3F, 0x18, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x31, 0xFD, 0xC3, 0x40,
  0xF0, 0x3C, 0x0F, 0x07, 0x63, 0xDF, 0xB0, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x37, 0xC7, 0x8C, 0xA0, 0xD8, 0x0B, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x58, 0x1A, 0x86, 0x4F, 0x80, 0x0F,
  0x9C, 0x58, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C,
  0x03, 0x08, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x47,
  0xC9, 0x8D, 0x60, 0x68, 0x0D, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0A,
  0x03, 0x40, 0x6C, 0x0C, 0xC2, 0x8F, 0x90, 0x1F, 0x06, 0x31, 0x83, 0x20,
  0x24, 0x05, 0x80, 0xFF, 0xFE, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x03,
  0x04, 0x3F, 0x80, 0x0F, 0x1D, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F,
  0x26, 0x35, 0x81, 0xA0, 0x34, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x28,
  0x0D, 0x01, 0xB0, 0x33, 0x0A, 0x3E, 0x40, 0x08, 0x03, 0x00, 0x60, 0x09,
  0x03, 0x3F, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xF3,
  0xC6, 0xA0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x18, 0xC0, 0x00,
  0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x62,
  0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x07, 0x86, 0xC2, 0x62,
  0x33, 0x1B, 0x0B, 0x85, 0x43, 0x31, 0x8C, 0xC2, 0x61, 0xB0, 0x78, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x1E, 0x59, 0x91, 0xB0, 0x70, 0x78,
  0x18, 0x3C, 0x08, 0x1E, 0x04, 0x0F, 0x02, 0x07, 0x81, 0x03, 0xC0, 0x81,
  0xE0, 0x40, 0xF0, 0x20, 0x78, 0x10, 0x3C, 0x08, 0x1E, 0x04, 0x0C, 0x9F,
  0x2C, 0x6A, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x30, 0x1F, 0x86, 0x39, 0x81, 0x20, 0x34, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x28, 0x05, 0x01, 0xB0, 0x23, 0x0C, 0x3F,
  0x00, 0x9F, 0x16, 0x32, 0x83, 0x60, 0x2C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0x60, 0x6F, 0x19, 0xBE, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x00, 0x1F, 0x26, 0x35, 0x81, 0xA0, 0x34, 0x07,
  0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x0D, 0x01, 0xB0, 0x33, 0x0A, 0x3E,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x9F, 0x66, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x3F, 0xB0,
  0xB0, 0x18, 0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x60, 0x38,
  0x37, 0xF0, 0x10, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x1E, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x07, 0x63, 0x4F, 0x90, 0xC0,
  0x78, 0x09, 0x01, 0x30, 0x66, 0x08, 0x41, 0x0C, 0x61, 0x88, 0x11, 0x03,
  0x60, 0x68, 0x05, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0xC0, 0xA0, 0x60, 0xD0,
  0x70, 0x6C, 0x2C, 0x26, 0x16, 0x11, 0x09, 0x18, 0x8C, 0x8C, 0x64, 0x64,
  0x32, 0x12, 0x0B, 0x0B, 0x05, 0x05, 0x83, 0x83, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0xC0, 0xD0, 0x66, 0x10, 0x8C, 0x32, 0x07, 0x80, 0xC0, 0x30, 0x16,
  0x0C, 0x82, 0x31, 0x84, 0xC1, 0xA0, 0x30, 0xC0, 0x68, 0x0D, 0x01, 0x30,
  0x62, 0x0C, 0x41, 0x0C, 0x60, 0x8C, 0x11, 0x03, 0x60, 0x2C, 0x05, 0x00,
  0xE0, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x78, 0x00, 0xFF,
  0x01, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC0,
  0xFF, 0x02, 0x1C, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC7, 0x06,
  0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x81, 0xC0, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x30, 0xE3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x38, 0x00, 0x10,
  0x1F, 0xC6, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Light26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 13, 19, 15, 1, -19 },
  { 42, 11, 22, 13, 1, -20 },
  { 73, 17, 19, 19, 1, -19 },
  { 114, 15, 19, 16, 1, -19 },
  { 150, 1, 7, 5, 2, -19 },
  { 151, 5, 23, 7, 1, -19 },
  { 166, 5, 23, 7, 1, -19 },
  { 181, 10, 10, 13, 1, -20 },
  { 194, 11, 12, 13, 1, -15 },
  { 211, 3, 6, 6, 1, -3 },
  { 214, 6, 2, 8, 1, -8 },
  { 216, 2, 2, 6, 2, -2 },
  { 217, 9, 19, 9, 0, -19 },
  { 239, 11, 19, 13, 1, -19 },
  { 266, 6, 19, 13, 2, -19 },
  { 281, 11, 19, 13, 1, -19 },
  { 308, 11, 19, 13, 1, -19 },
  { 335, 12, 19, 13, 1, -19 },
  { 364, 10, 19, 13, 2, -19 },
  { 388, 11, 19, 13, 1, -19 },
  { 415, 11, 19, 13, 1, -19 },
  { 442, 11, 19, 13, 1, -19 },
  { 469, 11, 19, 13, 1, -19 },
  { 496, 2, 14, 6, 2, -14 },
  { 500, 3, 17, 6, 1, -14 },
  { 507, 11, 12, 13, 1, -15 },
  { 524, 11, 6, 13, 1, -12 },
  { 533, 11, 12, 13, 1, -15 },
  { 550, 8, 19, 10, 1, -19 },
  { 569, 18, 21, 21, 1, -19 },
  { 617, 14, 19, 14, 0, -19 },
  { 651, 11, 19, 15, 2, -19 },
  { 678, 12, 19, 14, 2, -19 },
  { 707, 13, 19, 16, 2, -19 },
  { 738, 9, 19, 13, 2, -19 },
  { 760, 9, 19, 12, 2, -19 },
  { 782, 13, 19, 17, 2, -19 },
  { 813, 12, 19, 17, 2, -19 },
  { 842, 5, 19, 8, 1, -19 },
  { 854, 6, 24, 6, -2, -19 },
  { 872, 12, 19, 14, 2, -19 },
  { 901, 9, 19, 12, 2, -19 },
  { 923, 17, 19, 21, 2, -19 },
  { 964, 13, 19, 17, 2, -19 },
  { 995, 14, 19, 18, 2, -19 },
  { 1029, 11, 19, 14, 2, -19 },
  { 1056, 14, 23, 18, 2, -19 },
  { 1097, 12, 19, 14, 2, -19 },
  { 1126, 11, 19, 13, 1, -19 },
  { 1153, 12, 19, 12, 0, -19 },
  { 1182, 13, 19, 17, 2, -19 },
  { 1213, 13, 19, 13, 0, -19 },
  { 1244, 21, 19, 21, 0, -19 },
  { 1294, 12, 19, 13, 0, -19 },
  { 1323, 12, 19, 12, 0, -19 },
  { 1352, 11, 19, 13, 1, -19 },
  { 1379, 5, 23, 8, 2, -19 },
  { 1394, 9, 19, 9, 0, -19 },
  { 1416, 5, 23, 8, 1, -19 },
  { 1431, 12, 11, 13, 1, -19 },
  { 1448, 11, 1, 11, 0, 2 },
  { 1450, 5, 4, 7, 1, -20 },
  { 1453, 10, 14, 13, 1, -14 },
  { 1471, 11, 20, 14, 2, -20 },
  { 1499, 9, 14, 11, 1, -14 },
  { 1515, 11, 20, 14, 1, -20 },
  { 1543, 11, 14, 13, 1, -14 },
  { 1563, 8, 20, 7, 0, -20 },
  { 1583, 11, 20, 14, 1, -14 },
  { 1611, 10, 20, 14, 2, -20 },
  { 1636, 2, 19, 6, 2, -19 },
  { 1641, 5, 25, 6, -1, -19 },
  { 1657, 9, 20, 12, 2, -20 },
  { 1680, 2, 20, 6, 2, -20 },
  { 1685, 17, 14, 21, 2, -14 },
  { 1715, 10, 14, 14, 2, -14 },
  { 1733, 11, 14, 14, 1, -14 },
  { 1753, 11, 20, 14, 2, -14 },
  { 1781, 11, 20, 14, 1, -14 },
  { 1809, 7, 14, 9, 2, -14 },
  { 1822, 9, 14, 11, 1, -14 },
  { 1838, 7, 17, 8, 0, -17 },
  { 1853, 10, 14, 14, 2, -14 },
  { 1871, 11, 14, 11, 0, -14 },
  { 1891, 17, 14, 17, 0, -14 },
  { 1921, 10, 14, 12, 1, -14 },
  { 1939, 11, 20, 11, 0, -14 },
  { 1967, 8, 14, 10, 1, -14 },
  { 1981, 7, 23, 9, 1, -19 },
  { 2002, 1, 26, 13, 6, -20 },
  { 2006, 7, 23, 9, 1, -19 },
  { 2027, 11, 3, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Light26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT26PT7B_H_
