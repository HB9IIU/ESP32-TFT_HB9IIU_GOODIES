#ifndef _NOTOSANS_SEMICONDENSED_LIGHT20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light20pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x50, 0x70, 0xCC, 0x63, 0x18, 0x80, 0x08, 0x81, 0x10,
  0x22, 0x04, 0x47, 0xFE, 0x22, 0x04, 0x40, 0x88, 0x11, 0x1F, 0xF8, 0x44,
  0x11, 0x02, 0x20, 0x44, 0x00, 0x10, 0x3D, 0x52, 0x90, 0x90, 0x90, 0x50,
  0x38, 0x0E, 0x13, 0x11, 0x11, 0x13, 0xFE, 0x10, 0x10, 0x70, 0x44, 0x44,
  0x22, 0x21, 0x11, 0x08, 0x90, 0x44, 0xB2, 0x2A, 0x4A, 0x51, 0x24, 0x88,
  0x24, 0x42, 0x22, 0x11, 0x11, 0x09, 0x08, 0x38, 0x08, 0x06, 0xC1, 0x88,
  0x21, 0x06, 0x20, 0x4C, 0x0F, 0x01, 0xC0, 0x68, 0x58, 0x8A, 0x09, 0x40,
  0xC8, 0x19, 0x87, 0x9F, 0x98, 0xEA, 0x80, 0x32, 0x44, 0xC8, 0x88, 0x88,
  0x88, 0xC4, 0x42, 0x30, 0x84, 0x42, 0x22, 0x31, 0x11, 0x32, 0x22, 0x44,
  0x80, 0x10, 0x10, 0x91, 0x7E, 0x18, 0x2C, 0x66, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x5A, 0x80, 0xF0, 0x70, 0x06, 0x08,
  0x10, 0x40, 0x83, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x18, 0x00, 0x08,
  0x3E, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0x43,
  0x42, 0x3C, 0x37, 0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0x7E, 0x82, 0x03,
  0x03, 0x02, 0x02, 0x06, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC0, 0xFF, 0xFE,
  0x82, 0x01, 0x01, 0x02, 0x06, 0x38, 0x06, 0x03, 0x01, 0x01, 0x01, 0x82,
  0xFC, 0x03, 0x00, 0xC0, 0x50, 0x24, 0x09, 0x04, 0x42, 0x10, 0x84, 0x41,
  0x30, 0x4F, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x7E, 0x40, 0x40, 0x40, 0x40,
  0x78, 0x46, 0x03, 0x01, 0x01, 0x01, 0x01, 0x82, 0xFC, 0x1E, 0x20, 0x40,
  0x40, 0xC0, 0x9C, 0xA2, 0xC1, 0x81, 0x81, 0x81, 0x41, 0x63, 0x3E, 0xFF,
  0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x30,
  0x20, 0x7E, 0x43, 0xC1, 0xC1, 0x42, 0x26, 0x18, 0x66, 0x43, 0x81, 0x81,
  0x81, 0x43, 0x7E, 0x7C, 0x42, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x65, 0x19,
  0x01, 0x02, 0x02, 0x04, 0x78, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xA0,
  0x01, 0x03, 0x0C, 0x30, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0x0C, 0x30, 0xC0, 0xFC,
  0x0C, 0x08, 0x10, 0x60, 0x82, 0x08, 0x10, 0x40, 0x00, 0x03, 0x06, 0x00,
  0x0F, 0xE0, 0x40, 0xC2, 0x00, 0x90, 0x02, 0x47, 0xC6, 0x21, 0x18, 0x84,
  0x62, 0x11, 0x88, 0x46, 0x23, 0x28, 0x8C, 0x91, 0xCC, 0x40, 0x00, 0x80,
  0x03, 0x04, 0x03, 0xE0, 0x04, 0x01, 0x40, 0x28, 0x05, 0x01, 0x30, 0x22,
  0x04, 0x41, 0x0C, 0x3F, 0x84, 0x11, 0x03, 0x20, 0x24, 0x05, 0x00, 0xC0,
  0xFE, 0x83, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x83, 0x81, 0x81, 0x81, 0x81,
  0x83, 0xFC, 0x1F, 0x90, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xFC, 0xFE, 0x41, 0xA0, 0x70, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x27, 0xE0, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x7E, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00,
  0x02, 0x03, 0xFC, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x83,
  0xF0, 0x07, 0x00, 0xA0, 0x16, 0x02, 0x60, 0x47, 0xF0, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x04, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xAC, 0x83, 0x41, 0x21, 0x11, 0x09, 0x05, 0x83,
  0xC1, 0xA0, 0x88, 0x46, 0x21, 0x10, 0x48, 0x34, 0x0C, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0xC0, 0x3C,
  0x03, 0xC0, 0x3A, 0x05, 0xA0, 0x5B, 0x0D, 0x90, 0x99, 0x09, 0x89, 0x18,
  0x91, 0x89, 0x18, 0x61, 0x86, 0x18, 0x61, 0xC0, 0xE0, 0x78, 0x34, 0x19,
  0x0C, 0x86, 0x23, 0x19, 0x84, 0xC3, 0x60, 0xB0, 0x38, 0x1C, 0x04, 0x04,
  0x03, 0xF0, 0x81, 0x20, 0x34, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0xA0, 0x14, 0x04, 0x41, 0x87, 0xE0, 0xFC, 0x82, 0x82, 0x83,
  0x83, 0x82, 0x86, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x04, 0x03,
  0xF0, 0x81, 0x20, 0x34, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0xA0, 0x14, 0x04, 0x41, 0x87, 0xE0, 0x08, 0x01, 0x80, 0x18, 0xFC,
  0x82, 0x83, 0x83, 0x83, 0x82, 0x86, 0xF8, 0x88, 0x84, 0x84, 0x82, 0x83,
  0x81, 0x7F, 0xC0, 0x80, 0x80, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0x01,
  0x01, 0x82, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x11, 0xF0, 0x80,
  0x50, 0x14, 0x09, 0x02, 0x20, 0x88, 0x42, 0x10, 0xC4, 0x13, 0x04, 0x81,
  0xA0, 0x38, 0x0C, 0x03, 0x00, 0xC1, 0x81, 0x41, 0x83, 0x41, 0x82, 0x41,
  0x42, 0x62, 0x42, 0x22, 0x46, 0x22, 0x44, 0x22, 0x24, 0x34, 0x24, 0x14,
  0x24, 0x14, 0x28, 0x14, 0x18, 0x18, 0x18, 0x08, 0x18, 0xC0, 0x98, 0x42,
  0x10, 0x48, 0x12, 0x03, 0x00, 0xC0, 0x30, 0x16, 0x04, 0x82, 0x31, 0x84,
  0x41, 0xB0, 0x30, 0xC0, 0xA0, 0xD8, 0x44, 0x62, 0x20, 0x90, 0x50, 0x18,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xFF, 0x02, 0x02, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x40, 0x40, 0x80, 0xFF, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0, 0x81, 0x01, 0x02, 0x06, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xC0, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xF0, 0x18, 0x0C, 0x09, 0x04, 0x84, 0x22, 0x12, 0x05,
  0x03, 0xFF, 0xC8, 0x80, 0x3C, 0x8C, 0x08, 0x10, 0x2F, 0xF0, 0xC1, 0x83,
  0x0D, 0xE8, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC6, 0x82, 0x83, 0x81, 0x81,
  0x81, 0x83, 0x82, 0xC2, 0xBC, 0x1E, 0xC5, 0x06, 0x08, 0x10, 0x20, 0x40,
  0xC0, 0x80, 0xF8, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x63, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC1, 0x43, 0x3D, 0x1C, 0x66, 0x42, 0x81, 0x81, 0xFF,
  0x80, 0x80, 0x40, 0x41, 0x3E, 0x1C, 0x82, 0x08, 0xF8, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x00, 0x3D, 0x63, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xC1, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x42, 0x3C, 0x81, 0x02, 0x04,
  0x0B, 0xD8, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x80, 0x70,
  0x55, 0x55, 0x54, 0x13, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x2E, 0x81, 0x02, 0x04, 0x08, 0x71, 0xA2, 0x48, 0xA1, 0xC2, 0x44, 0xC8,
  0x90, 0xA1, 0x80, 0xFF, 0xFE, 0xB8, 0xE6, 0x28, 0xA1, 0x85, 0x04, 0x38,
  0x21, 0xC1, 0x0E, 0x08, 0x70, 0x43, 0x82, 0x1C, 0x10, 0xE0, 0x86, 0xBD,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x1C, 0x31, 0x10,
  0x50, 0x28, 0x14, 0x0E, 0x07, 0x02, 0x41, 0x21, 0x8F, 0x80, 0xBC, 0xC6,
  0x82, 0x83, 0x81, 0x81, 0x81, 0x83, 0x82, 0xC2, 0xBC, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x3D, 0x63, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0x43,
  0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x20, 0x3D, 0x8A, 0x04, 0x0C, 0x06, 0x03, 0x02, 0x07, 0x0B, 0xE0, 0x20,
  0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x41, 0x43, 0x3D, 0x81, 0xC1, 0x43, 0x42,
  0x62, 0x22, 0x24, 0x24, 0x14, 0x18, 0x18, 0x82, 0x0A, 0x18, 0x50, 0xC2,
  0x8A, 0x24, 0x59, 0x12, 0x48, 0xA2, 0x45, 0x14, 0x28, 0x60, 0xC3, 0x04,
  0x18, 0x41, 0x63, 0x22, 0x14, 0x14, 0x08, 0x14, 0x14, 0x22, 0x63, 0xC1,
  0x81, 0xC1, 0x41, 0x42, 0x22, 0x22, 0x24, 0x14, 0x14, 0x18, 0x08, 0x08,
  0x10, 0x10, 0x30, 0xE0, 0xFC, 0x10, 0x82, 0x10, 0xC2, 0x10, 0x42, 0x0F,
  0xC0, 0x19, 0x08, 0x42, 0x10, 0x8C, 0x83, 0x08, 0x42, 0x10, 0x84, 0x18,
  0xFF, 0xFF, 0xF0, 0xC1, 0x08, 0x42, 0x10, 0x86, 0x09, 0x88, 0x42, 0x10,
  0x84, 0xC0, 0xF1, 0x8F,
};

const GFXglyph NotoSans_SemiCondensed_Light20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 14, 5, 1, -14 },
  { 5, 5, 5, 7, 1, -14 },
  { 9, 11, 14, 11, 0, -14 },
  { 29, 8, 16, 10, 1, -15 },
  { 45, 13, 14, 15, 1, -14 },
  { 68, 11, 15, 12, 1, -15 },
  { 89, 2, 5, 4, 1, -14 },
  { 91, 4, 17, 6, 1, -14 },
  { 100, 4, 17, 6, 1, -14 },
  { 109, 8, 7, 10, 1, -15 },
  { 116, 8, 10, 10, 1, -12 },
  { 126, 2, 5, 4, 1, -2 },
  { 128, 4, 1, 6, 1, -6 },
  { 129, 2, 2, 5, 1, -2 },
  { 130, 7, 14, 7, 0, -14 },
  { 143, 8, 15, 10, 1, -15 },
  { 158, 4, 14, 10, 2, -14 },
  { 165, 8, 14, 10, 1, -14 },
  { 179, 8, 14, 10, 1, -14 },
  { 193, 10, 14, 10, 0, -14 },
  { 211, 8, 14, 10, 1, -14 },
  { 225, 8, 14, 10, 1, -14 },
  { 239, 8, 14, 10, 1, -14 },
  { 253, 8, 14, 10, 1, -14 },
  { 267, 8, 14, 10, 1, -14 },
  { 281, 2, 11, 5, 1, -11 },
  { 284, 2, 14, 5, 1, -11 },
  { 288, 8, 9, 10, 1, -12 },
  { 297, 8, 5, 10, 1, -10 },
  { 302, 8, 9, 10, 1, -12 },
  { 311, 7, 14, 8, 0, -14 },
  { 324, 14, 16, 16, 1, -14 },
  { 352, 11, 14, 11, 0, -14 },
  { 372, 8, 14, 11, 2, -14 },
  { 386, 9, 14, 11, 1, -14 },
  { 402, 9, 14, 13, 2, -14 },
  { 418, 7, 14, 10, 2, -14 },
  { 431, 7, 14, 9, 2, -14 },
  { 444, 11, 15, 13, 1, -15 },
  { 465, 9, 14, 13, 2, -14 },
  { 481, 4, 14, 6, 1, -14 },
  { 488, 4, 18, 5, -1, -14 },
  { 497, 9, 14, 10, 2, -14 },
  { 513, 7, 14, 9, 2, -14 },
  { 526, 12, 14, 16, 2, -14 },
  { 547, 9, 14, 13, 2, -14 },
  { 563, 11, 15, 14, 1, -15 },
  { 584, 8, 14, 11, 2, -14 },
  { 598, 11, 18, 14, 1, -15 },
  { 623, 8, 14, 11, 2, -14 },
  { 637, 8, 14, 10, 1, -14 },
  { 651, 9, 14, 9, 0, -14 },
  { 667, 9, 14, 13, 2, -14 },
  { 683, 10, 14, 10, 0, -14 },
  { 701, 16, 14, 16, 0, -14 },
  { 729, 10, 14, 10, 0, -14 },
  { 747, 9, 14, 9, 0, -14 },
  { 763, 8, 14, 10, 1, -14 },
  { 777, 4, 17, 6, 2, -14 },
  { 786, 7, 14, 7, 0, -14 },
  { 799, 4, 17, 6, 1, -14 },
  { 808, 9, 8, 10, 1, -14 },
  { 817, 8, 1, 8, 0, 2 },
  { 818, 3, 3, 5, 1, -15 },
  { 820, 7, 11, 10, 1, -11 },
  { 830, 8, 15, 11, 2, -15 },
  { 845, 7, 11, 8, 1, -11 },
  { 855, 8, 15, 11, 1, -15 },
  { 870, 8, 11, 10, 1, -11 },
  { 881, 6, 15, 6, 0, -15 },
  { 893, 8, 16, 11, 1, -11 },
  { 909, 7, 15, 11, 2, -15 },
  { 923, 2, 15, 4, 1, -15 },
  { 927, 4, 20, 4, -1, -15 },
  { 937, 7, 15, 9, 2, -15 },
  { 951, 1, 15, 4, 2, -15 },
  { 953, 13, 11, 16, 2, -11 },
  { 971, 7, 11, 11, 2, -11 },
  { 981, 9, 11, 11, 1, -11 },
  { 994, 8, 16, 11, 2, -11 },
  { 1010, 8, 16, 11, 1, -11 },
  { 1026, 5, 11, 7, 2, -11 },
  { 1033, 7, 11, 8, 1, -11 },
  { 1043, 6, 13, 6, 0, -13 },
  { 1053, 8, 11, 11, 1, -11 },
  { 1064, 8, 11, 8, 0, -11 },
  { 1075, 13, 11, 13, 0, -11 },
  { 1093, 8, 11, 9, 0, -11 },
  { 1104, 8, 16, 8, 0, -11 },
  { 1120, 6, 11, 8, 1, -11 },
  { 1129, 5, 17, 7, 1, -14 },
  { 1140, 1, 20, 10, 4, -15 },
  { 1143, 5, 17, 7, 1, -14 },
  { 1154, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Light20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT20PT7B_H_
