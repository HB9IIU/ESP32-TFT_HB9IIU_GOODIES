#ifndef _NOTOSANS_SEMICONDENSED_LIGHT9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x37, 0xD5, 0xF5, 0x30, 0x2F, 0xA4, 0x33, 0xE2, 0x42,
  0xAB, 0x2F, 0x6C, 0xB2, 0xC0, 0x22, 0x94, 0xCA, 0xCD, 0xE0, 0xC0, 0x6A,
  0xA4, 0xD5, 0x5C, 0x2F, 0x26, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x25, 0x29,
  0x00, 0x25, 0x99, 0x99, 0x70, 0xD5, 0x50, 0x61, 0x11, 0x24, 0xF0, 0x69,
  0x16, 0x11, 0xF0, 0x33, 0x59, 0x71, 0xF3, 0x13, 0xC0, 0x34, 0x87, 0x99,
  0x70, 0xF1, 0x22, 0x24, 0x69, 0x96, 0xD9, 0x70, 0x69, 0x99, 0x71, 0x60,
  0x88, 0x8C, 0x3C, 0x61, 0xFF, 0xC3, 0x2C, 0xC4, 0x94, 0x10, 0x7C, 0xB6,
  0xAD, 0x5B, 0xC8, 0x0E, 0x00, 0x22, 0x94, 0xE8, 0xC4, 0xF9, 0xE9, 0x9E,
  0x78, 0x88, 0x88, 0xF0, 0xF9, 0x99, 0x9E, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9,
  0x00, 0x78, 0x8A, 0x99, 0x70, 0x99, 0xF9, 0x99, 0xD5, 0x70, 0x55, 0x57,
  0xBC, 0x8C, 0xA9, 0x92, 0x49, 0xC0, 0x8C, 0x77, 0xBA, 0xD4, 0x9D, 0xDB,
  0xB9, 0x64, 0xA3, 0x18, 0xC7, 0xC0, 0xF6, 0xE9, 0x00, 0x64, 0xA3, 0x18,
  0xC7, 0x44, 0x10, 0xE9, 0xAE, 0xA9, 0x78, 0x86, 0x11, 0xF0, 0xF2, 0x22,
  0x22, 0x99, 0x99, 0x9F, 0x8C, 0x94, 0xA6, 0x10, 0x93, 0x25, 0xAB, 0x66,
  0xC4, 0x80, 0x96, 0x26, 0x59, 0x95, 0x62, 0x22, 0xF2, 0x24, 0x4F, 0xEA,
  0xAC, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x65, 0x90, 0xF0, 0x90, 0x61, 0x79,
  0xF0, 0x93, 0xDB, 0x78, 0x78, 0x88, 0x70, 0x11, 0x79, 0x99, 0x70, 0x69,
  0xF8, 0x70, 0x6B, 0x24, 0x90, 0x79, 0x99, 0x71, 0xF0, 0x93, 0xDB, 0x68,
  0xBE, 0xBF, 0x80, 0x92, 0xE9, 0xA8, 0xFE, 0xDA, 0x9A, 0x69, 0xA4, 0xF6,
  0xDA, 0x79, 0x99, 0x70, 0xF6, 0xDF, 0x20, 0x79, 0x99, 0x71, 0x10, 0xEA,
  0x80, 0x71, 0x1E, 0x5E, 0x48, 0xC0, 0xB6, 0xDE, 0x99, 0x66, 0x40, 0x96,
  0xDB, 0x56, 0x48, 0x96, 0x46, 0x90, 0x99, 0x66, 0x44, 0xC0, 0xE5, 0x2E,
  0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Light9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 3, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 0, -7 },
  { 11, 6, 7, 7, 0, -7 },
  { 17, 5, 7, 6, 0, -7 },
  { 22, 1, 2, 2, 0, -6 },
  { 23, 2, 7, 3, 0, -6 },
  { 25, 2, 7, 3, 0, -6 },
  { 27, 4, 4, 4, 0, -7 },
  { 29, 4, 4, 5, 0, -5 },
  { 31, 1, 2, 2, 0, -1 },
  { 32, 2, 1, 3, 0, -3 },
  { 33, 1, 1, 2, 1, -1 },
  { 34, 3, 6, 3, 0, -6 },
  { 37, 4, 7, 5, 0, -7 },
  { 41, 2, 6, 5, 1, -6 },
  { 43, 4, 7, 5, 0, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 4, 6, 5, 0, -6 },
  { 54, 3, 6, 5, 1, -6 },
  { 57, 4, 7, 5, 0, -7 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 4, 7, 5, 0, -7 },
  { 68, 4, 7, 5, 0, -7 },
  { 72, 1, 5, 2, 1, -5 },
  { 73, 1, 6, 2, 0, -5 },
  { 74, 4, 4, 5, 0, -5 },
  { 76, 4, 2, 5, 0, -4 },
  { 77, 4, 4, 5, 0, -5 },
  { 79, 3, 7, 3, 0, -7 },
  { 82, 7, 7, 7, 0, -6 },
  { 89, 5, 6, 5, 0, -6 },
  { 93, 4, 6, 5, 1, -6 },
  { 96, 4, 7, 5, 1, -7 },
  { 100, 4, 6, 6, 1, -6 },
  { 103, 3, 6, 4, 1, -6 },
  { 106, 3, 6, 4, 1, -6 },
  { 109, 4, 7, 6, 1, -7 },
  { 113, 4, 6, 6, 1, -6 },
  { 116, 2, 6, 3, 0, -6 },
  { 118, 2, 8, 2, -1, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 3, 6, 4, 1, -6 },
  { 126, 5, 6, 7, 1, -6 },
  { 130, 4, 6, 6, 1, -6 },
  { 133, 5, 7, 6, 1, -7 },
  { 138, 3, 6, 5, 1, -6 },
  { 141, 5, 9, 6, 1, -7 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 4, 7, 4, 0, -7 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 4, 6, 6, 1, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 7, 6, 7, 0, -6 },
  { 170, 4, 6, 4, 0, -6 },
  { 173, 4, 6, 4, 0, -6 },
  { 176, 4, 6, 4, 0, -6 },
  { 179, 2, 7, 3, 1, -6 },
  { 181, 3, 6, 3, 0, -6 },
  { 184, 2, 7, 3, 0, -6 },
  { 186, 4, 3, 5, 0, -6 },
  { 188, 4, 1, 4, 0, 0 },
  { 189, 2, 2, 2, 0, -7 },
  { 190, 4, 5, 4, 0, -5 },
  { 193, 3, 7, 5, 1, -7 },
  { 196, 4, 5, 4, 0, -5 },
  { 199, 4, 7, 5, 0, -7 },
  { 203, 4, 5, 4, 0, -5 },
  { 206, 3, 7, 3, 0, -7 },
  { 209, 4, 7, 5, 0, -5 },
  { 213, 3, 7, 5, 1, -7 },
  { 216, 1, 7, 2, 0, -7 },
  { 217, 1, 9, 2, 0, -7 },
  { 219, 3, 7, 4, 1, -7 },
  { 222, 1, 7, 2, 0, -7 },
  { 223, 6, 5, 7, 1, -5 },
  { 227, 3, 5, 5, 1, -5 },
  { 229, 4, 5, 5, 0, -5 },
  { 232, 3, 7, 5, 1, -5 },
  { 235, 4, 7, 5, 0, -5 },
  { 239, 2, 5, 3, 1, -5 },
  { 241, 3, 5, 4, 0, -5 },
  { 243, 3, 6, 3, 0, -6 },
  { 246, 3, 5, 5, 1, -5 },
  { 248, 4, 5, 4, 0, -5 },
  { 251, 6, 5, 6, 0, -5 },
  { 255, 4, 5, 4, 0, -5 },
  { 258, 4, 7, 4, 0, -5 },
  { 262, 3, 5, 4, 0, -5 },
  { 264, 3, 7, 3, 0, -6 },
  { 267, 1, 9, 4, 2, -7 },
  { 269, 3, 7, 3, 0, -6 },
  { 272, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Light9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT9PT7B_H_
