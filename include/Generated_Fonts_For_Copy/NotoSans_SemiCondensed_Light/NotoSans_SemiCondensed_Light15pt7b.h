#ifndef _NOTOSANS_SEMICONDENSED_LIGHT15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0x5B, 0x24, 0x24, 0x24,
  0xFF, 0x24, 0x24, 0x48, 0x23, 0xEA, 0x28, 0xA1, 0xC2, 0x89, 0x26, 0xA7,
  0x08, 0x62, 0x51, 0x24, 0x92, 0x89, 0x55, 0x55, 0xB2, 0x29, 0x14, 0x91,
  0x48, 0xE0, 0x30, 0x48, 0x48, 0x48, 0x50, 0x60, 0x91, 0x8A, 0x86, 0x86,
  0x79, 0xF0, 0x2A, 0x49, 0x24, 0x92, 0x26, 0x91, 0x24, 0x89, 0x49, 0x28,
  0x22, 0x97, 0x94, 0x58, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xF0, 0xE0,
  0x80, 0x08, 0x44, 0x21, 0x10, 0x88, 0x42, 0x20, 0x71, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x27, 0x80, 0x17, 0x91, 0x11, 0x11, 0x11, 0x10, 0x72,
  0x20, 0x82, 0x08, 0x21, 0x08, 0x42, 0x0F, 0xC0, 0x72, 0x20, 0x42, 0x09,
  0xC0, 0x81, 0x04, 0x2F, 0x80, 0x04, 0x18, 0x50, 0xA2, 0x44, 0x91, 0x42,
  0x7E, 0x08, 0x10, 0x7A, 0x08, 0x20, 0xF2, 0x20, 0x41, 0x04, 0x2F, 0x80,
  0x39, 0x08, 0x20, 0xB3, 0x28, 0x61, 0x86, 0x17, 0x80, 0xFC, 0x10, 0x82,
  0x08, 0x41, 0x08, 0x20, 0x84, 0x00, 0x72, 0x28, 0x61, 0x48, 0xCC, 0xA1,
  0x86, 0x17, 0x80, 0x72, 0x28, 0x61, 0x86, 0x37, 0x41, 0x08, 0x2F, 0x00,
  0x81, 0x83, 0xC0, 0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F,
  0x81, 0x03, 0x81, 0x19, 0x88, 0x00, 0xF0, 0x42, 0x10, 0x88, 0x84, 0x00,
  0x08, 0x1E, 0x08, 0x64, 0x0A, 0x39, 0x92, 0x64, 0x9A, 0x26, 0x89, 0x97,
  0xA2, 0x04, 0x00, 0xF8, 0x08, 0x18, 0x18, 0x24, 0x24, 0x24, 0x7E, 0x42,
  0x42, 0x81, 0x81, 0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x21, 0x41, 0x83, 0x0B,
  0xE0, 0x1E, 0xC1, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x80, 0xF8, 0xF8,
  0x84, 0x82, 0x82, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0xFE, 0x08,
  0x20, 0x83, 0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8,
  0x20, 0x82, 0x08, 0x00, 0x1E, 0x61, 0x40, 0x80, 0x80, 0x8E, 0x81, 0x81,
  0x81, 0x41, 0x3F, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06,
  0x08, 0xE9, 0x24, 0x92, 0x4B, 0x80, 0x24, 0x92, 0x49, 0x24, 0x93, 0x80,
  0x83, 0x0A, 0x24, 0x8A, 0x1C, 0x24, 0x44, 0x89, 0x0A, 0x08, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC0, 0xF0, 0x3C, 0x0E, 0x85,
  0xA1, 0x64, 0x99, 0x26, 0x49, 0x8C, 0x63, 0x18, 0xC4, 0x81, 0xC1, 0xA1,
  0xA1, 0x91, 0x91, 0x89, 0x85, 0x85, 0x83, 0x83, 0x3C, 0x42, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xF2, 0x38, 0x61, 0x86, 0x3F,
  0x20, 0x82, 0x08, 0x00, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x42, 0x3C, 0x04, 0x02, 0x02, 0xF9, 0x0A, 0x14, 0x28, 0x5D, 0x24,
  0x44, 0x89, 0x0A, 0x08, 0x7A, 0x08, 0x20, 0xC0, 0xC0, 0x81, 0x04, 0x2F,
  0x80, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84, 0xF0, 0x81, 0x82, 0x42,
  0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x18, 0x10, 0x82, 0x18, 0x61, 0x46,
  0x14, 0x62, 0x45, 0x24, 0x92, 0x29, 0x22, 0x94, 0x28, 0xC1, 0x0C, 0x10,
  0xC0, 0x82, 0x88, 0x91, 0x41, 0x82, 0x0A, 0x14, 0x44, 0x8A, 0x08, 0x82,
  0x85, 0x12, 0x22, 0x85, 0x04, 0x08, 0x10, 0x20, 0x40, 0x7E, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x40, 0x83, 0xF8, 0xF2, 0x49, 0x24, 0x92, 0x4E,
  0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x42, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x10, 0x30, 0xA1, 0x24, 0x58, 0x40, 0xFC, 0x90, 0xF0, 0x42,
  0xF8, 0xC6, 0x3F, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0x87, 0x1B, 0x80,
  0x7C, 0x21, 0x08, 0x42, 0x0F, 0x04, 0x10, 0x5F, 0x86, 0x18, 0x61, 0x86,
  0x17, 0xC0, 0x7A, 0x28, 0x7F, 0x82, 0x08, 0x1E, 0x3A, 0x11, 0xE4, 0x21,
  0x08, 0x42, 0x10, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x18, 0x8C,
  0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x40, 0x9F, 0xE0, 0x20,
  0x12, 0x49, 0x24, 0x92, 0x70, 0x82, 0x08, 0x22, 0x92, 0x8A, 0x38, 0x92,
  0x28, 0xC0, 0xFF, 0xE0, 0xBB, 0xB3, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18,
  0x46, 0x11, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7A, 0x18, 0x61, 0x86,
  0x18, 0x5E, 0xBB, 0x18, 0x61, 0x86, 0x1C, 0x6E, 0x82, 0x08, 0x20, 0x7E,
  0x18, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x10, 0x41, 0xBC, 0x88, 0x88, 0x88,
  0xFC, 0x20, 0x83, 0x04, 0x3E, 0x44, 0xF4, 0x44, 0x44, 0x43, 0x86, 0x18,
  0x61, 0x86, 0x18, 0xDD, 0x86, 0x14, 0x92, 0x48, 0xA3, 0x04, 0x84, 0x63,
  0x14, 0xC9, 0x2A, 0x52, 0x8C, 0xA3, 0x10, 0x84, 0xC5, 0x22, 0x84, 0x30,
  0xA4, 0xB1, 0x85, 0x14, 0x52, 0x28, 0xA3, 0x04, 0x10, 0x82, 0x30, 0xF1,
  0x22, 0x44, 0x8F, 0x34, 0x44, 0x44, 0x84, 0x44, 0x44, 0x30, 0xFF, 0xFE,
  0x84, 0x44, 0x44, 0x32, 0x44, 0x44, 0xC0, 0xF4, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_Light15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 11, 4, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 8, 11, 9, 0, -11 },
  { 16, 6, 12, 8, 1, -11 },
  { 25, 9, 11, 11, 1, -11 },
  { 38, 8, 11, 9, 1, -11 },
  { 49, 1, 4, 3, 1, -11 },
  { 50, 3, 13, 4, 1, -11 },
  { 55, 3, 13, 4, 1, -11 },
  { 60, 6, 5, 7, 1, -11 },
  { 64, 6, 7, 8, 1, -9 },
  { 70, 1, 4, 3, 1, -2 },
  { 71, 3, 1, 5, 1, -5 },
  { 72, 1, 1, 3, 1, -1 },
  { 73, 5, 11, 5, 0, -11 },
  { 80, 6, 11, 8, 1, -11 },
  { 89, 4, 11, 8, 1, -11 },
  { 95, 6, 11, 8, 1, -11 },
  { 104, 6, 11, 8, 1, -11 },
  { 113, 7, 11, 8, 0, -11 },
  { 123, 6, 11, 8, 1, -11 },
  { 132, 6, 11, 8, 1, -11 },
  { 141, 6, 11, 8, 1, -11 },
  { 150, 6, 11, 8, 1, -11 },
  { 159, 6, 11, 8, 1, -11 },
  { 168, 1, 8, 3, 1, -8 },
  { 169, 1, 10, 3, 1, -8 },
  { 171, 6, 7, 8, 1, -9 },
  { 177, 6, 4, 8, 1, -7 },
  { 180, 6, 7, 8, 1, -9 },
  { 186, 5, 11, 6, 0, -11 },
  { 193, 10, 12, 12, 1, -11 },
  { 208, 8, 11, 8, 0, -11 },
  { 219, 7, 11, 8, 1, -11 },
  { 229, 7, 11, 8, 1, -11 },
  { 239, 8, 11, 9, 1, -11 },
  { 250, 6, 11, 7, 1, -11 },
  { 259, 6, 11, 7, 1, -11 },
  { 268, 8, 11, 10, 1, -11 },
  { 279, 7, 11, 10, 1, -11 },
  { 289, 3, 11, 4, 1, -11 },
  { 294, 3, 14, 4, -1, -11 },
  { 300, 7, 11, 8, 1, -11 },
  { 310, 6, 11, 7, 1, -11 },
  { 319, 10, 11, 12, 1, -11 },
  { 333, 8, 11, 10, 1, -11 },
  { 344, 8, 11, 10, 1, -11 },
  { 355, 6, 11, 8, 1, -11 },
  { 364, 8, 14, 10, 1, -11 },
  { 378, 7, 11, 8, 1, -11 },
  { 388, 6, 11, 7, 1, -11 },
  { 397, 7, 11, 7, 0, -11 },
  { 407, 7, 11, 10, 1, -11 },
  { 417, 8, 11, 8, 0, -11 },
  { 428, 12, 11, 12, 0, -11 },
  { 445, 7, 11, 7, 0, -11 },
  { 455, 7, 11, 7, 0, -11 },
  { 465, 7, 11, 7, 0, -11 },
  { 475, 3, 13, 5, 1, -11 },
  { 480, 5, 11, 5, 0, -11 },
  { 487, 4, 13, 5, 0, -11 },
  { 494, 7, 6, 8, 0, -11 },
  { 500, 6, 1, 6, 0, 1 },
  { 501, 2, 2, 4, 1, -11 },
  { 502, 5, 8, 7, 1, -8 },
  { 507, 6, 11, 8, 1, -11 },
  { 516, 5, 8, 6, 1, -8 },
  { 521, 6, 11, 8, 1, -11 },
  { 530, 6, 8, 7, 1, -8 },
  { 536, 5, 11, 4, 0, -11 },
  { 543, 6, 12, 8, 1, -8 },
  { 552, 6, 11, 8, 1, -11 },
  { 561, 1, 11, 3, 1, -11 },
  { 563, 3, 15, 3, -1, -11 },
  { 569, 6, 11, 7, 1, -11 },
  { 578, 1, 11, 3, 1, -11 },
  { 580, 10, 8, 12, 1, -8 },
  { 590, 6, 8, 8, 1, -8 },
  { 596, 6, 8, 8, 1, -8 },
  { 602, 6, 12, 8, 1, -8 },
  { 611, 6, 12, 8, 1, -8 },
  { 620, 4, 8, 5, 1, -8 },
  { 624, 5, 8, 6, 1, -8 },
  { 629, 4, 10, 5, 0, -10 },
  { 634, 6, 8, 8, 1, -8 },
  { 640, 6, 8, 6, 0, -8 },
  { 646, 10, 8, 10, 0, -8 },
  { 656, 6, 8, 7, 0, -8 },
  { 662, 6, 12, 6, 0, -8 },
  { 671, 4, 8, 6, 1, -8 },
  { 675, 4, 13, 5, 1, -11 },
  { 682, 1, 15, 7, 3, -11 },
  { 684, 4, 13, 5, 1, -11 },
  { 691, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Light15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT15PT7B_H_
