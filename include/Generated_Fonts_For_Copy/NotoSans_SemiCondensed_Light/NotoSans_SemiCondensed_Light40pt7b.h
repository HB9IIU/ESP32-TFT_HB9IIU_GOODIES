#ifndef _NOTOSANS_SEMICONDENSED_LIGHT40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x0B, 0xFE,
  0xC3, 0xE1, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0xB0,
  0xC0, 0x00, 0xC0, 0xC0, 0x06, 0x04, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x03,
  0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x81, 0x00, 0x08, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x02, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x1F, 0xFC, 0x3F, 0xFE, 0x71, 0x82, 0x61, 0x80, 0xC1, 0x80, 0xC1, 0x80,
  0xC1, 0x80, 0xC1, 0x80, 0x61, 0x80, 0x71, 0x80, 0x3D, 0x80, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x01, 0xBC, 0x01, 0x8E, 0x01, 0x87, 0x01, 0x83,
  0x01, 0x83, 0x01, 0x83, 0x01, 0x83, 0x01, 0x87, 0x81, 0x8E, 0xF9, 0xFC,
  0xFF, 0xF8, 0x07, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x00,
  0x18, 0x0F, 0xC0, 0x0C, 0x06, 0x18, 0x03, 0x01, 0x83, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x30, 0x30, 0x0C, 0x0C, 0x0C, 0x03, 0x03, 0x06, 0x00,
  0xC0, 0xC1, 0x80, 0x30, 0x30, 0xC0, 0x0C, 0x0C, 0x30, 0x03, 0x03, 0x18,
  0x20, 0xC0, 0xC6, 0x3E, 0x30, 0x33, 0x18, 0xC6, 0x0C, 0xCC, 0x19, 0x86,
  0x63, 0x06, 0x3F, 0x18, 0xC1, 0x87, 0x8E, 0x60, 0x20, 0x03, 0x18, 0x0C,
  0x00, 0xC6, 0x03, 0x00, 0x61, 0x80, 0xC0, 0x18, 0x60, 0x30, 0x0C, 0x18,
  0x0C, 0x03, 0x06, 0x06, 0x01, 0x80, 0xC1, 0x80, 0x60, 0x30, 0x60, 0x30,
  0x0C, 0x18, 0x0C, 0x01, 0xDC, 0x06, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xE0, 0x01, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x60,
  0x00, 0xC3, 0x80, 0x03, 0x9C, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0x30, 0x00, 0x38, 0x60, 0x39, 0xC1, 0xC0, 0xCE, 0x03,
  0x83, 0x38, 0x07, 0x0C, 0xC0, 0x0E, 0x63, 0x00, 0x1D, 0x8C, 0x00, 0x3C,
  0x30, 0x00, 0x70, 0xE0, 0x03, 0xC1, 0x80, 0x1F, 0x87, 0x80, 0xE7, 0x0F,
  0xFF, 0x0E, 0x0F, 0xF0, 0x1C, 0xFF, 0xFF, 0xFC, 0x07, 0x06, 0x0C, 0x1C,
  0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x70,
  0x30, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x07, 0xE0, 0x60, 0x30, 0x38, 0x18,
  0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x38, 0x30, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x08, 0x10, 0x3E, 0x21, 0xFF, 0xFF, 0x87, 0xF0, 0x03, 0x80, 0x0D,
  0x80, 0x39, 0x80, 0x63, 0x81, 0x83, 0x07, 0x07, 0x02, 0x04, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x37, 0x77, 0x66, 0xEC, 0xCC, 0xFF, 0xFF, 0xF0,
  0x5F, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xE0,
  0x0F, 0xF8, 0x1C, 0x3C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07,
  0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x06, 0x30, 0x06,
  0x38, 0x0E, 0x1C, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0x81, 0xC1, 0xE1,
  0xF1, 0xDB, 0x8F, 0x86, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x07, 0xE0, 0x3F, 0xF0, 0xF8, 0x3C, 0x60,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0xF0, 0x3C, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0xC0, 0x1C, 0xFF, 0xF8, 0x7F,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x07, 0x01,
  0x80, 0xC0, 0x30, 0x30, 0x06, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xF0,
  0x7F, 0xFC, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0xC0, 0x1C, 0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0xFE, 0x01, 0xFF,
  0x01, 0xC0, 0x81, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x3C, 0x0E, 0x7F, 0x87,
  0x71, 0xE3, 0x60, 0x39, 0xE0, 0x0E, 0xE0, 0x03, 0x70, 0x01, 0xB8, 0x00,
  0xDC, 0x00, 0x7E, 0x00, 0x3B, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x30,
  0x07, 0x1C, 0x03, 0x07, 0x03, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x0F, 0xFC,
  0x0F, 0x07, 0x06, 0x01, 0xC6, 0x00, 0x63, 0x00, 0x39, 0x80, 0x1C, 0xC0,
  0x0E, 0x60, 0x06, 0x38, 0x03, 0x0E, 0x03, 0x03, 0x83, 0x80, 0xF7, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x3C, 0xF0, 0x38, 0x1C, 0x38, 0x07, 0x18, 0x01,
  0xDC, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x06, 0xE0,
  0x03, 0x30, 0x03, 0x9C, 0x03, 0x87, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xE0,
  0x1F, 0xF0, 0x3C, 0x38, 0x70, 0x1C, 0x60, 0x0E, 0xE0, 0x06, 0xC0, 0x06,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0x70, 0x0F, 0x38, 0x1B, 0x3F, 0xF3, 0x0F, 0xE3, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x7F, 0xE0, 0x7F, 0xC0, 0x5F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x7F, 0xC0, 0x11, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xCE, 0x73, 0x18, 0xCE, 0x63, 0x30, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0x87, 0xFF, 0x38, 0x3C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x03, 0x80, 0xE3, 0x01, 0xFF,
  0x06, 0x60, 0x38, 0x30, 0x66, 0x06, 0x03, 0x06, 0x60, 0xE0, 0x70, 0x2C,
  0x0C, 0x06, 0x03, 0xC0, 0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x03, 0xC1, 0xC0,
  0x60, 0x3C, 0x18, 0x06, 0x06, 0xC1, 0xC0, 0x60, 0x6C, 0x0C, 0x06, 0x06,
  0xC0, 0xC0, 0xE0, 0x6C, 0x0C, 0x0B, 0x0C, 0x60, 0x61, 0xB1, 0xC6, 0x03,
  0xF1, 0xF8, 0x60, 0x08, 0x04, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00,
  0x66, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8E, 0x00, 0x0C, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x0E, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x18,
  0x0E, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x38, 0x01, 0x81, 0x80, 0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00,
  0x0E, 0x30, 0x00, 0x33, 0x80, 0x01, 0x98, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0x80, 0xFE, 0x00, 0x7F, 0xFC, 0x30, 0x7F, 0x18, 0x01, 0xCC,
  0x00, 0x66, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03,
  0xB0, 0x01, 0x98, 0x01, 0xCC, 0x01, 0xC7, 0xFF, 0x83, 0xFF, 0xE1, 0x80,
  0x3C, 0xC0, 0x06, 0x60, 0x03, 0xB0, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x03, 0xB0, 0x07,
  0x9F, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0x03,
  0x87, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0x0F, 0xF0, 0x60, 0x0F, 0x0C,
  0x00, 0x71, 0x80, 0x07, 0x30, 0x00, 0x66, 0x00, 0x0E, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x1C, 0xC0,
  0x07, 0x18, 0x01, 0xC3, 0x00, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xEF,
  0xFF, 0xB0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x81, 0xF0,
  0x1E, 0x1E, 0x00, 0x21, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x37, 0x00, 0x01,
  0xB8, 0x00, 0x0C, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x1C, 0x00, 0x18, 0x70,
  0x00, 0xC3, 0xE0, 0x06, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFE, 0xFF, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x03, 0xBF,
  0x9F, 0x80, 0xC0, 0x03, 0xE0, 0x03, 0xB0, 0x03, 0x98, 0x03, 0x8C, 0x01,
  0x86, 0x01, 0xC3, 0x01, 0xC1, 0x81, 0xC0, 0xC1, 0xC0, 0x60, 0xC0, 0x30,
  0xC0, 0x18, 0xE0, 0x0C, 0xE0, 0x06, 0xF0, 0x03, 0x7C, 0x01, 0xE6, 0x00,
  0xE3, 0x80, 0x60, 0xE0, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x07, 0x06, 0x03,
  0x83, 0x00, 0xE1, 0x80, 0x30, 0xC0, 0x1C, 0x60, 0x07, 0x30, 0x01, 0x98,
  0x00, 0xEC, 0x00, 0x38, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0xC0, 0x00, 0xDF, 0x60,
  0x00, 0x6F, 0xB8, 0x00, 0x37, 0xCC, 0x00, 0x33, 0xE6, 0x00, 0x19, 0xF3,
  0x80, 0x0C, 0xF8, 0xC0, 0x0C, 0x7C, 0x60, 0x06, 0x3E, 0x38, 0x07, 0x1F,
  0x0C, 0x03, 0x0F, 0x86, 0x01, 0x87, 0xC1, 0x81, 0xC3, 0xE0, 0xC0, 0xC1,
  0xF0, 0x60, 0x60, 0xF8, 0x18, 0x60, 0x7C, 0x0C, 0x30, 0x3E, 0x07, 0x18,
  0x1F, 0x01, 0x98, 0x0F, 0x80, 0xCC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0x80, 0x38, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xB0,
  0x00, 0xF7, 0x00, 0x1E, 0x60, 0x03, 0xCE, 0x00, 0x78, 0xC0, 0x0F, 0x1C,
  0x01, 0xE1, 0xC0, 0x3C, 0x18, 0x07, 0x83, 0x80, 0xF0, 0x30, 0x1E, 0x07,
  0x03, 0xC0, 0x60, 0x78, 0x06, 0x0F, 0x00, 0xE1, 0xE0, 0x0C, 0x3C, 0x01,
  0xC7, 0x80, 0x18, 0xF0, 0x03, 0x9E, 0x00, 0x3B, 0xC0, 0x03, 0x78, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x3E, 0x0F, 0x80, 0x70, 0x07, 0x81, 0xC0, 0x03, 0x07, 0x00,
  0x07, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D,
  0x80, 0x00, 0x3B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x8C,
  0x00, 0x07, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x3C,
  0x03, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xC3,
  0x0F, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xB0, 0x0E,
  0x7F, 0xF8, 0xFF, 0xE1, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x0F, 0x80,
  0x70, 0x07, 0x81, 0xC0, 0x03, 0x07, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x1C, 0x00, 0x0C,
  0x18, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x3F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0xFE,
  0x00, 0x7F, 0xF8, 0x30, 0xFE, 0x18, 0x03, 0x8C, 0x00, 0xE6, 0x00, 0x73,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01,
  0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x03, 0xE1, 0xFF, 0xC0, 0xFF, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x18, 0x0E, 0x0C, 0x03, 0x06, 0x01, 0xC3, 0x00, 0x61,
  0x80, 0x38, 0xC0, 0x0C, 0x60, 0x07, 0x30, 0x01, 0x98, 0x00, 0xEC, 0x00,
  0x38, 0x07, 0xF8, 0x1F, 0xFE, 0x3C, 0x0E, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0xC0, 0x1C, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x07, 0x70, 0x00, 0xC7, 0x00, 0x38, 0xF0, 0x0E, 0x0F, 0xFF, 0x80,
  0x7F, 0xC0, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0xE7, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x87, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x0E, 0x07, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x38, 0x0C, 0x00, 0xC0, 0xE0, 0x06, 0x07, 0x00, 0x38,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x38, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x70, 0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x66, 0x00,
  0x7C, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0x98, 0x01, 0xB0, 0x07, 0x38, 0x07,
  0x60, 0x0C, 0x30, 0x0C, 0xE0, 0x18, 0x60, 0x18, 0xC0, 0x30, 0xC0, 0x31,
  0x80, 0xE1, 0xC0, 0xE3, 0x01, 0x81, 0x81, 0x87, 0x03, 0x03, 0x03, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0x1C, 0x0E, 0x1C, 0x18, 0x30, 0x0C, 0x30, 0x38,
  0x60, 0x18, 0x60, 0x30, 0xC0, 0x30, 0xC0, 0x63, 0x80, 0x73, 0x80, 0xC6,
  0x00, 0x66, 0x01, 0xCC, 0x00, 0xCC, 0x01, 0x98, 0x01, 0x98, 0x03, 0x70,
  0x03, 0xF0, 0x06, 0xC0, 0x03, 0xC0, 0x0D, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE6, 0x00, 0x18, 0xE0, 0x06, 0x0C, 0x01, 0xC1, 0xC0, 0x30,
  0x18, 0x0E, 0x03, 0x81, 0x80, 0x30, 0x70, 0x07, 0x0C, 0x00, 0x63, 0x80,
  0x0E, 0x60, 0x00, 0xDC, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x01, 0xB0, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x03, 0x86, 0x00,
  0x60, 0xE0, 0x1C, 0x0C, 0x03, 0x01, 0xC0, 0xE0, 0x18, 0x18, 0x03, 0x87,
  0x00, 0x30, 0xC0, 0x07, 0x30, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEC,
  0x00, 0x19, 0x80, 0x07, 0x38, 0x00, 0xC3, 0x00, 0x38, 0x70, 0x06, 0x06,
  0x01, 0xC0, 0xE0, 0x30, 0x0C, 0x06, 0x01, 0xC1, 0xC0, 0x18, 0x30, 0x03,
  0x8E, 0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xE0,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0xFF, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x18,
  0x30, 0x0E, 0x0C, 0x03, 0x01, 0x81, 0xC0, 0x60, 0x60, 0x1C, 0x38, 0x03,
  0x0C, 0x00, 0xE7, 0x00, 0x19, 0x80, 0x07, 0xE0, 0x00, 0xC0, 0xFF, 0xFF,
  0x80, 0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0x80, 0x01, 0x80, 0x7F, 0xC3,
  0xC7, 0x88, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0xFF, 0xCF, 0xC3, 0x70, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0x7F, 0xEC, 0xFE, 0x10, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC1, 0xE0, 0x63, 0xFC, 0x33, 0x8F, 0x1B, 0x01,
  0xCF, 0x00, 0x67, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0x60,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1B, 0x80, 0x0D,
  0xC0, 0x06, 0xE0, 0x03, 0x70, 0x03, 0xBC, 0x03, 0x9B, 0x03, 0xCC, 0xFF,
  0xC6, 0x3F, 0x80, 0x00, 0xE0, 0x1F, 0xF1, 0xF1, 0x8E, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0F, 0x01, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x03, 0xC3,
  0x0F, 0xF3, 0x1E, 0x3B, 0x38, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x60, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x07, 0x70, 0x07,
  0x38, 0x0F, 0x1F, 0xF9, 0x0F, 0xF1, 0x01, 0xC0, 0x0F, 0xF0, 0x1E, 0x38,
  0x38, 0x0C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x3C, 0x02, 0x1F, 0xFE,
  0x07, 0xFC, 0x00, 0xE0, 0x1F, 0xC1, 0xE6, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x3F, 0xF9, 0xFF, 0xC0, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x0F, 0xF1, 0x1E, 0x3B, 0x38,
  0x0F, 0x70, 0x07, 0x60, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0x60, 0x03, 0x60, 0x07, 0x70, 0x07, 0x38, 0x0F, 0x1F, 0xFB, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x40, 0x0E, 0x7C, 0x7C, 0x3F, 0xF8, 0x01, 0xC0, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC1, 0xE1, 0x8F, 0xF3, 0x38, 0xF6, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0xFF, 0x80, 0x00, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x6B, 0xDF, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x3B, 0x00,
  0xE6, 0x03, 0x8C, 0x0E, 0x18, 0x18, 0x30, 0x60, 0x61, 0xC0, 0xC7, 0x01,
  0x9C, 0x03, 0x3C, 0x06, 0xD8, 0x0F, 0x38, 0x1C, 0x30, 0x30, 0x30, 0x60,
  0x70, 0xC0, 0x61, 0x80, 0xE3, 0x00, 0xE6, 0x00, 0xCC, 0x01, 0xD8, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x18,
  0x33, 0xFC, 0x3F, 0xCD, 0xC7, 0x9E, 0x7B, 0x60, 0x6C, 0x06, 0xF0, 0x1E,
  0x01, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xE0, 0x0F, 0x80, 0x30, 0x03, 0xC0,
  0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30,
  0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00,
  0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x30, 0x01, 0xC1, 0x8F,
  0xF3, 0x38, 0xF6, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC7,
  0x00, 0x73, 0x00, 0x19, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0,
  0x07, 0x60, 0x03, 0x38, 0x01, 0x8C, 0x01, 0xC7, 0x01, 0xC1, 0xFF, 0xC0,
  0x3F, 0x80, 0x01, 0xE0, 0x63, 0xFC, 0x33, 0x8F, 0x1B, 0x01, 0xCD, 0x00,
  0x67, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x06,
  0xE0, 0x03, 0x78, 0x03, 0xB4, 0x03, 0x9B, 0x03, 0xCC, 0xFF, 0xC6, 0x3F,
  0x83, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xF1,
  0x1E, 0x3B, 0x38, 0x0F, 0x70, 0x07, 0x60, 0x07, 0x60, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x07, 0x70, 0x07, 0x38, 0x0F,
  0x1F, 0xFB, 0x0F, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x01, 0xF8,
  0xFB, 0x3F, 0x6C, 0x0D, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x81, 0xFF, 0xDE, 0x1D, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F,
  0x00, 0xEF, 0xFF, 0x3F, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x3F,
  0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1F,
  0xC3, 0xF0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x0E, 0xC0, 0x3D,
  0xC0, 0xD9, 0xFF, 0xB1, 0xFC, 0x60, 0xE0, 0x03, 0xB0, 0x01, 0x98, 0x01,
  0xCE, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xE0, 0x30, 0x30, 0x18, 0x18,
  0x1C, 0x0E, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xE3, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xD8, 0x03, 0x80, 0x36, 0x00, 0xB0,
  0x1D, 0xC0, 0x6C, 0x06, 0x30, 0x1B, 0x01, 0x8C, 0x06, 0xC0, 0x63, 0x03,
  0x98, 0x38, 0x60, 0xC6, 0x0C, 0x18, 0x31, 0x83, 0x06, 0x0C, 0x60, 0xC1,
  0x86, 0x0C, 0x70, 0x31, 0x83, 0x18, 0x0C, 0x60, 0xC6, 0x03, 0x38, 0x39,
  0x80, 0xCC, 0x06, 0xE0, 0x1B, 0x01, 0xB0, 0x06, 0xC0, 0x6C, 0x01, 0xA0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00,
  0xE0, 0x07, 0x70, 0x0E, 0x30, 0x1C, 0x38, 0x18, 0x1C, 0x38, 0x0C, 0x30,
  0x0E, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0,
  0x06, 0xE0, 0x0E, 0x60, 0x0C, 0x30, 0x1C, 0x38, 0x18, 0x18, 0x30, 0x1C,
  0x70, 0x0C, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0x98, 0x00,
  0xCE, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x30, 0x60, 0x38, 0x30, 0x18, 0x18,
  0x0C, 0x06, 0x0E, 0x03, 0x06, 0x01, 0x83, 0x00, 0x63, 0x80, 0x31, 0x80,
  0x18, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x09, 0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x10, 0x1F, 0x03, 0xE0, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x1C,
  0x0F, 0x80, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x3F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x3C, 0x0F, 0x83, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x1F,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xE0, 0x7F, 0xD0, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 9, 11, 14, 3, -29 },
  { 25, 21, 29, 23, 1, -29 },
  { 102, 16, 32, 21, 2, -30 },
  { 166, 26, 29, 30, 2, -29 },
  { 261, 22, 29, 24, 2, -29 },
  { 341, 2, 11, 8, 3, -29 },
  { 344, 8, 35, 11, 2, -29 },
  { 379, 8, 35, 11, 1, -29 },
  { 414, 15, 15, 19, 2, -30 },
  { 443, 17, 19, 21, 2, -24 },
  { 484, 4, 10, 9, 2, -5 },
  { 489, 10, 2, 12, 1, -12 },
  { 492, 3, 4, 9, 3, -4 },
  { 494, 12, 29, 14, 1, -29 },
  { 538, 16, 29, 21, 2, -29 },
  { 596, 9, 29, 21, 3, -29 },
  { 629, 16, 29, 21, 2, -29 },
  { 687, 16, 29, 21, 2, -29 },
  { 745, 19, 29, 21, 1, -29 },
  { 814, 16, 29, 21, 2, -29 },
  { 872, 17, 29, 21, 2, -29 },
  { 934, 16, 29, 21, 2, -29 },
  { 992, 17, 29, 21, 2, -29 },
  { 1054, 16, 29, 21, 2, -29 },
  { 1112, 3, 22, 9, 3, -22 },
  { 1121, 5, 27, 9, 1, -22 },
  { 1138, 17, 18, 21, 2, -23 },
  { 1177, 17, 10, 21, 2, -19 },
  { 1199, 17, 18, 21, 2, -23 },
  { 1238, 13, 29, 15, 1, -29 },
  { 1286, 28, 33, 32, 2, -29 },
  { 1402, 21, 29, 21, 0, -29 },
  { 1479, 17, 29, 23, 4, -29 },
  { 1541, 19, 29, 22, 2, -29 },
  { 1610, 19, 29, 25, 4, -29 },
  { 1679, 14, 29, 20, 4, -29 },
  { 1730, 14, 29, 18, 4, -29 },
  { 1781, 21, 29, 26, 2, -29 },
  { 1858, 18, 29, 26, 4, -29 },
  { 1924, 8, 29, 12, 2, -29 },
  { 1953, 9, 36, 9, -3, -29 },
  { 1994, 17, 29, 21, 4, -29 },
  { 2056, 13, 29, 18, 4, -29 },
  { 2104, 25, 29, 32, 4, -29 },
  { 2195, 19, 29, 26, 4, -29 },
  { 2264, 23, 29, 27, 2, -29 },
  { 2348, 15, 29, 21, 4, -29 },
  { 2403, 23, 36, 27, 2, -29 },
  { 2507, 17, 29, 22, 4, -29 },
  { 2569, 16, 29, 20, 2, -29 },
  { 2627, 18, 29, 19, 0, -29 },
  { 2693, 19, 29, 26, 3, -29 },
  { 2762, 21, 29, 21, 0, -29 },
  { 2839, 31, 29, 33, 1, -29 },
  { 2952, 19, 29, 19, 0, -29 },
  { 3021, 19, 29, 19, 0, -29 },
  { 3090, 17, 29, 20, 1, -29 },
  { 3152, 9, 35, 13, 3, -29 },
  { 3192, 12, 29, 14, 1, -29 },
  { 3236, 8, 35, 13, 1, -29 },
  { 3271, 18, 17, 21, 1, -29 },
  { 3310, 17, 1, 17, 0, 4 },
  { 3313, 7, 7, 10, 2, -31 },
  { 3320, 14, 22, 19, 2, -22 },
  { 3359, 17, 30, 22, 3, -30 },
  { 3423, 14, 22, 17, 2, -22 },
  { 3462, 16, 30, 22, 2, -30 },
  { 3522, 16, 22, 20, 2, -22 },
  { 3566, 13, 31, 11, 0, -31 },
  { 3617, 16, 32, 22, 2, -22 },
  { 3681, 15, 30, 21, 3, -30 },
  { 3738, 3, 29, 9, 3, -29 },
  { 3749, 7, 39, 9, -1, -29 },
  { 3784, 15, 30, 18, 3, -30 },
  { 3841, 2, 30, 9, 3, -30 },
  { 3849, 26, 22, 32, 3, -22 },
  { 3921, 15, 22, 21, 3, -22 },
  { 3963, 17, 22, 21, 2, -22 },
  { 4010, 17, 31, 22, 3, -22 },
  { 4076, 16, 31, 22, 2, -22 },
  { 4138, 11, 22, 14, 3, -22 },
  { 4169, 13, 22, 17, 2, -22 },
  { 4205, 10, 26, 12, 1, -26 },
  { 4238, 15, 21, 21, 3, -21 },
  { 4278, 17, 21, 17, 0, -21 },
  { 4323, 26, 21, 27, 0, -21 },
  { 4392, 16, 21, 18, 1, -21 },
  { 4434, 17, 31, 17, 0, -21 },
  { 4500, 13, 21, 16, 1, -21 },
  { 4535, 12, 35, 14, 1, -29 },
  { 4588, 2, 40, 19, 9, -30 },
  { 4598, 11, 35, 14, 2, -29 },
  { 4647, 17, 4, 21, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_Light40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT40PT7B_H_
