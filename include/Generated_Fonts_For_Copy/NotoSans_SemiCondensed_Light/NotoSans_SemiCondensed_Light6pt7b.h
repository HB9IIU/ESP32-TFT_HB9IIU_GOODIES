#ifndef _NOTOSANS_SEMICONDENSED_LIGHT6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7B, 0xD0, 0x5D, 0x3C, 0xEB, 0x77, 0xE4, 0xAF, 0x80,
  0xF8, 0xF8, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xF6, 0xF0,
  0xF0, 0xE5, 0x70, 0xEC, 0xF0, 0x4B, 0x90, 0xD8, 0xF0, 0xFA, 0xF0, 0xE9,
  0x20, 0xEA, 0xF0, 0xF5, 0xB0, 0xA0, 0xB0, 0x39, 0x80, 0xFC, 0x8F, 0x00,
  0xDA, 0x7F, 0xDA, 0x60, 0x49, 0xD0, 0xFF, 0xF2, 0x30, 0xFF, 0xFB, 0xFA,
  0xEA, 0x97, 0xFF, 0xF0, 0xF8, 0xEB, 0xAB, 0xB7, 0xF0, 0xFF, 0xF9, 0x97,
  0xFA, 0xF9, 0x95, 0x20, 0xFB, 0xF8, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0xB5,
  0x20, 0xAF, 0x74, 0xA0, 0xA9, 0x50, 0xA9, 0x20, 0xE9, 0x70, 0xEA, 0xC0,
  0xA5, 0xF8, 0x54, 0xE0, 0x80, 0x7C, 0x9A, 0xDE, 0xEC, 0x2E, 0xDE, 0xFB,
  0x80, 0x7A, 0x80, 0xF6, 0xF0, 0x9A, 0xDA, 0xF0, 0xF8, 0x97, 0x6A, 0xF8,
  0xFB, 0xB0, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC,
  0xEB, 0xB7, 0x80, 0xB9, 0x00, 0xD7, 0xA0, 0xEA, 0x80, 0xB9, 0x60, 0xDC,
  0x59, 0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Light6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 4, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 1, 5, 2, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 3, 3, 3, 0, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 4, 3, 1, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 1, 3, 1, 0, -3 },
  { 42, 1, 4, 1, 0, -3 },
  { 43, 3, 3, 3, 0, -4 },
  { 45, 3, 2, 3, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 2, 4, 2, 0, -4 },
  { 49, 4, 5, 5, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 2, 4, 3, 1, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 2, 4, 4, 1, -4 },
  { 58, 2, 4, 3, 1, -4 },
  { 59, 2, 4, 3, 1, -4 },
  { 60, 4, 4, 4, 0, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 1, 4, 2, 0, -4 },
  { 64, 1, 5, 1, 0, -4 },
  { 65, 2, 4, 3, 1, -4 },
  { 66, 2, 4, 3, 1, -4 },
  { 67, 3, 4, 5, 1, -4 },
  { 69, 2, 4, 4, 1, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 2, 4, 3, 1, -4 },
  { 73, 4, 5, 4, 0, -4 },
  { 76, 2, 4, 3, 1, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 5, 4, 5, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 2, 5, 2, 0, -4 },
  { 96, 2, 4, 2, 0, -4 },
  { 97, 1, 5, 2, 0, -4 },
  { 98, 3, 2, 3, 0, -4 },
  { 99, 3, 1, 3, 0, 0 },
  { 100, 1, 1, 2, 0, -5 },
  { 101, 2, 3, 3, 0, -3 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 2, 3, 3, 0, -3 },
  { 105, 3, 5, 3, 0, -5 },
  { 107, 3, 3, 3, 0, -3 },
  { 109, 2, 5, 2, 0, -5 },
  { 111, 3, 4, 3, 0, -3 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 1, 4, 1, 0, -4 },
  { 116, 1, 5, 1, 0, -4 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 1, 5, 1, 0, -5 },
  { 120, 4, 3, 5, 0, -3 },
  { 122, 3, 3, 3, 0, -3 },
  { 124, 3, 3, 3, 0, -3 },
  { 126, 3, 4, 3, 0, -3 },
  { 128, 3, 4, 3, 0, -3 },
  { 130, 2, 3, 2, 0, -3 },
  { 131, 2, 3, 3, 0, -3 },
  { 132, 2, 4, 2, 0, -4 },
  { 133, 3, 3, 3, 0, -3 },
  { 135, 3, 3, 3, 0, -3 },
  { 137, 4, 3, 4, 0, -3 },
  { 139, 3, 3, 3, 0, -3 },
  { 141, 3, 4, 3, 0, -3 },
  { 143, 2, 3, 2, 0, -3 },
  { 144, 2, 5, 2, 0, -4 },
  { 146, 1, 6, 3, 1, -5 },
  { 147, 2, 5, 2, 0, -4 },
  { 149, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Light6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT6PT7B_H_
