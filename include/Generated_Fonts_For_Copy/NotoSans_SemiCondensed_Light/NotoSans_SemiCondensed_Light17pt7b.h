#ifndef _NOTOSANS_SEMICONDENSED_LIGHT17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xAA, 0x8B, 0x99, 0x99, 0x09, 0x08, 0x84, 0x4F, 0xF1, 0x20,
  0x90, 0x49, 0xFF, 0x22, 0x12, 0x09, 0x04, 0x80, 0x10, 0x73, 0x54, 0x89,
  0x12, 0x1C, 0x0E, 0x14, 0x24, 0x4E, 0xE3, 0x02, 0x00, 0x71, 0x92, 0x22,
  0x48, 0x49, 0x09, 0x49, 0x2A, 0x9D, 0x88, 0x51, 0x0A, 0x22, 0x44, 0x44,
  0x90, 0xE0, 0x78, 0x22, 0x11, 0x08, 0x82, 0x81, 0x81, 0x63, 0x12, 0x85,
  0x41, 0xA1, 0xCF, 0x90, 0xF0, 0x29, 0x49, 0x24, 0x92, 0x44, 0x88, 0x89,
  0x22, 0x49, 0x24, 0xA5, 0x20, 0x10, 0x49, 0x5E, 0x31, 0x24, 0x80, 0x10,
  0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0xEA, 0xF0, 0xB0, 0x0C, 0x20, 0x84,
  0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x78, 0x8A, 0x14, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x09, 0x13, 0xC0, 0x17, 0xD1, 0x11, 0x11, 0x11, 0x11, 0x79,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x08, 0x20, 0x83, 0x07, 0xF0, 0xFD, 0x08,
  0x10, 0x20, 0x4F, 0x03, 0x03, 0x02, 0x04, 0x17, 0xC0, 0x06, 0x06, 0x0A,
  0x12, 0x12, 0x22, 0x42, 0x42, 0xFF, 0x02, 0x02, 0x02, 0x7C, 0x82, 0x04,
  0x08, 0x1F, 0x81, 0x01, 0x02, 0x04, 0x17, 0xC0, 0x3C, 0x81, 0x04, 0x09,
  0x9C, 0xA0, 0xC1, 0x83, 0x05, 0x11, 0xE0, 0xFE, 0x04, 0x10, 0x20, 0x81,
  0x02, 0x08, 0x10, 0x40, 0x83, 0x00, 0x7D, 0x0A, 0x0C, 0x24, 0xC6, 0x13,
  0x43, 0x83, 0x06, 0x1B, 0xE0, 0x79, 0x0A, 0x14, 0x18, 0x30, 0xDE, 0x81,
  0x04, 0x08, 0x27, 0x80, 0xE0, 0x02, 0xC0, 0xE0, 0x03, 0xA8, 0x02, 0x18,
  0xC6, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60,
  0x30, 0x47, 0x10, 0x40, 0xF8, 0x10, 0x41, 0x08, 0x43, 0x08, 0x20, 0x02,
  0x08, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x72, 0x89, 0x19, 0x11, 0x91, 0x19,
  0x11, 0x91, 0x28, 0xEE, 0x80, 0x04, 0x00, 0x31, 0x80, 0x60, 0x08, 0x0A,
  0x05, 0x02, 0x82, 0x21, 0x10, 0x88, 0x7E, 0x41, 0x20, 0x90, 0x30, 0x10,
  0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x21, 0x41, 0x83, 0x06, 0x17, 0xC0, 0x3F,
  0x60, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x60, 0x3F, 0xF8,
  0x86, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0xFC,
  0x21, 0x08, 0x7E, 0x10, 0x84, 0x21, 0xF0, 0xFC, 0x21, 0x08, 0x43, 0xF0,
  0x84, 0x21, 0x00, 0x3F, 0xB0, 0x10, 0x10, 0x08, 0x04, 0x02, 0x1F, 0x01,
  0x80, 0xA0, 0x58, 0x23, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x10, 0xE9, 0x24, 0x92, 0x49, 0x70, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x12, 0xE0, 0x87, 0x12, 0x64, 0x8A, 0x1C, 0x28, 0x48,
  0x89, 0x12, 0x14, 0x30, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0,
  0x80, 0xF0, 0x3C, 0x0F, 0x05, 0xA1, 0x68, 0x5A, 0x26, 0x49, 0x92, 0x65,
  0x18, 0xC6, 0x21, 0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x85,
  0x85, 0x83, 0x83, 0x3F, 0x10, 0x44, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06,
  0x02, 0x80, 0x90, 0x26, 0x10, 0xF8, 0xFA, 0x18, 0x61, 0x86, 0x3F, 0xA0,
  0x82, 0x08, 0x20, 0x3F, 0x10, 0x44, 0x0A, 0x02, 0x80, 0xE0, 0x18, 0x06,
  0x02, 0x80, 0x90, 0x26, 0x10, 0xF8, 0x02, 0x00, 0x80, 0x18, 0xF9, 0x0A,
  0x14, 0x28, 0x51, 0x3C, 0x48, 0x89, 0x12, 0x14, 0x30, 0x7D, 0x02, 0x04,
  0x0C, 0x0E, 0x03, 0x02, 0x02, 0x04, 0x17, 0xC0, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3E, 0x80, 0xA0, 0x90, 0x48,
  0x24, 0x21, 0x10, 0x88, 0x48, 0x14, 0x0A, 0x06, 0x01, 0x00, 0x83, 0x05,
  0x0C, 0x24, 0x30, 0x91, 0x42, 0x44, 0x88, 0x92, 0x42, 0x49, 0x0A, 0x24,
  0x28, 0x50, 0x61, 0x81, 0x86, 0x04, 0x18, 0xC1, 0x42, 0x24, 0x24, 0x18,
  0x18, 0x18, 0x14, 0x24, 0x42, 0x42, 0x81, 0x81, 0x42, 0x42, 0x24, 0x24,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x08, 0x30, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x07, 0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x10, 0x50, 0xA2, 0x24, 0x50,
  0x60, 0x80, 0xFE, 0x88, 0x80, 0x78, 0x10, 0x41, 0x7E, 0x18, 0x63, 0xF4,
  0x81, 0x02, 0x04, 0x0B, 0xD8, 0x70, 0xC1, 0x83, 0x07, 0x0E, 0x1B, 0xC0,
  0x7D, 0x08, 0x20, 0x82, 0x08, 0x10, 0x7C, 0x02, 0x04, 0x08, 0x17, 0xB8,
  0xE0, 0xC1, 0x83, 0x06, 0x0E, 0x37, 0xA0, 0x78, 0x8A, 0x14, 0x1F, 0xF0,
  0x20, 0x20, 0x7C, 0x3C, 0x82, 0x08, 0xF0, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x7B, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0x7A, 0x04, 0x08, 0x2F,
  0xC0, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x20, 0xC2, 0xAA, 0xAA, 0x30, 0x02, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2E,
  0x81, 0x02, 0x04, 0x08, 0x51, 0x24, 0x50, 0xD1, 0xA2, 0x24, 0x68, 0x60,
  0xFF, 0xF8, 0xBD, 0xF8, 0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C,
  0x21, 0x84, 0x20, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x7C,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xA2, 0x7C, 0xBD, 0x87, 0x0C, 0x18, 0x30,
  0x70, 0xE1, 0xBD, 0x02, 0x04, 0x08, 0x00, 0x7B, 0x8E, 0x0C, 0x18, 0x30,
  0x60, 0xE3, 0x7A, 0x04, 0x08, 0x10, 0x20, 0xBE, 0x31, 0x08, 0x42, 0x10,
  0x80, 0xFC, 0x21, 0x83, 0x04, 0x21, 0xF8, 0x42, 0x3E, 0x84, 0x21, 0x08,
  0x42, 0x0E, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0x7A, 0x82, 0x85,
  0x12, 0x22, 0x45, 0x0A, 0x14, 0x10, 0x84, 0x28, 0xC5, 0x28, 0xA5, 0x24,
  0x94, 0x52, 0x8C, 0x51, 0x8C, 0x30, 0x80, 0xC2, 0x88, 0xB0, 0xC1, 0x03,
  0x09, 0x22, 0xC2, 0x82, 0x85, 0x12, 0x22, 0x45, 0x0A, 0x0C, 0x10, 0x20,
  0x41, 0x0E, 0x00, 0xF8, 0x44, 0x42, 0x21, 0x10, 0xF8, 0x32, 0x44, 0x44,
  0x4C, 0x44, 0x44, 0x42, 0x10, 0xFF, 0xFF, 0x80, 0xC6, 0x22, 0x22, 0x21,
  0x22, 0x22, 0x24, 0x80, 0xE3, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_Light17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 4, 4, 6, 1, -12 },
  { 6, 9, 12, 10, 0, -12 },
  { 20, 7, 14, 9, 1, -13 },
  { 33, 11, 12, 13, 1, -12 },
  { 50, 9, 12, 10, 1, -12 },
  { 64, 1, 4, 3, 1, -12 },
  { 65, 3, 15, 5, 1, -12 },
  { 71, 3, 15, 5, 1, -12 },
  { 77, 6, 7, 8, 1, -13 },
  { 83, 7, 8, 9, 1, -10 },
  { 90, 2, 4, 4, 1, -2 },
  { 91, 4, 1, 5, 1, -5 },
  { 92, 2, 2, 4, 1, -2 },
  { 93, 6, 12, 6, 0, -12 },
  { 102, 7, 12, 9, 1, -12 },
  { 113, 4, 12, 9, 1, -12 },
  { 119, 7, 12, 9, 1, -12 },
  { 130, 7, 12, 9, 1, -12 },
  { 141, 8, 12, 9, 0, -12 },
  { 153, 7, 12, 9, 1, -12 },
  { 164, 7, 12, 9, 1, -12 },
  { 175, 7, 12, 9, 1, -12 },
  { 186, 7, 12, 9, 1, -12 },
  { 197, 7, 12, 9, 1, -12 },
  { 208, 2, 9, 4, 1, -9 },
  { 211, 2, 11, 4, 1, -9 },
  { 214, 7, 8, 9, 1, -10 },
  { 221, 7, 4, 9, 1, -8 },
  { 225, 7, 8, 9, 1, -10 },
  { 232, 6, 12, 6, 0, -12 },
  { 241, 12, 14, 13, 1, -12 },
  { 262, 9, 12, 9, 0, -12 },
  { 276, 7, 12, 10, 2, -12 },
  { 287, 8, 12, 9, 1, -12 },
  { 299, 8, 12, 11, 2, -12 },
  { 311, 5, 12, 8, 2, -12 },
  { 319, 5, 12, 8, 2, -12 },
  { 327, 9, 12, 11, 1, -12 },
  { 341, 7, 12, 11, 2, -12 },
  { 352, 3, 12, 5, 1, -12 },
  { 357, 4, 15, 4, -1, -12 },
  { 365, 7, 12, 9, 2, -12 },
  { 376, 5, 12, 8, 2, -12 },
  { 384, 10, 12, 14, 2, -12 },
  { 399, 8, 12, 11, 2, -12 },
  { 411, 10, 12, 12, 1, -12 },
  { 426, 6, 12, 9, 2, -12 },
  { 435, 10, 15, 12, 1, -12 },
  { 454, 7, 12, 9, 2, -12 },
  { 465, 7, 12, 8, 1, -12 },
  { 476, 8, 12, 8, 0, -12 },
  { 488, 8, 12, 11, 1, -12 },
  { 500, 9, 12, 9, 0, -12 },
  { 514, 14, 12, 14, 0, -12 },
  { 535, 8, 12, 8, 0, -12 },
  { 547, 8, 12, 8, 0, -12 },
  { 559, 7, 12, 8, 1, -12 },
  { 570, 4, 15, 5, 1, -12 },
  { 578, 6, 12, 6, 0, -12 },
  { 587, 4, 15, 5, 0, -12 },
  { 595, 7, 7, 9, 1, -12 },
  { 602, 7, 1, 7, 0, 1 },
  { 603, 3, 3, 4, 1, -13 },
  { 605, 6, 9, 8, 1, -9 },
  { 612, 7, 13, 9, 1, -13 },
  { 624, 6, 9, 7, 1, -9 },
  { 631, 7, 13, 9, 1, -13 },
  { 643, 7, 9, 8, 1, -9 },
  { 651, 6, 13, 5, 0, -13 },
  { 661, 7, 13, 9, 1, -9 },
  { 673, 7, 13, 9, 1, -13 },
  { 685, 2, 12, 4, 1, -12 },
  { 688, 4, 16, 4, -1, -12 },
  { 696, 7, 13, 8, 1, -13 },
  { 708, 1, 13, 4, 1, -13 },
  { 710, 11, 9, 14, 1, -9 },
  { 723, 7, 9, 9, 1, -9 },
  { 731, 7, 9, 9, 1, -9 },
  { 739, 7, 13, 9, 1, -9 },
  { 751, 7, 13, 9, 1, -9 },
  { 763, 5, 9, 6, 1, -9 },
  { 769, 5, 9, 7, 1, -9 },
  { 775, 5, 11, 5, 0, -11 },
  { 782, 7, 9, 9, 1, -9 },
  { 790, 7, 9, 7, 0, -9 },
  { 798, 11, 9, 11, 0, -9 },
  { 811, 7, 9, 8, 0, -9 },
  { 819, 7, 13, 7, 0, -9 },
  { 831, 5, 9, 7, 1, -9 },
  { 837, 4, 15, 6, 1, -12 },
  { 845, 1, 17, 8, 4, -13 },
  { 848, 4, 15, 6, 1, -12 },
  { 856, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Light17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT17PT7B_H_
