#ifndef _NOTOSANS_SEMICONDENSED_LIGHT58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light58pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x71, 0x8C, 0x63, 0x18, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x79, 0x80, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x01, 0xB8, 0x0D, 0xC0, 0x6E,
  0x03, 0x70, 0x19, 0x80, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x01, 0xC0, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x38, 0x03, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x1F, 0x1C, 0x3C, 0x7C, 0x38, 0x08, 0xE0, 0x70,
  0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x70, 0x01,
  0xE0, 0xE0, 0x01, 0xF1, 0xC0, 0x01, 0xFB, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x77, 0xE0, 0x00,
  0xE3, 0xE0, 0x01, 0xC1, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0xC0, 0x0E,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xD0, 0x07, 0x0F, 0xBE, 0x0E, 0x3E,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x04, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x0F, 0xBC, 0x00,
  0x0E, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x18,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x70, 0x00,
  0x70, 0x07, 0x03, 0x80, 0x03, 0x80, 0x38, 0x38, 0x00, 0x1C, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0x07, 0x00, 0x70, 0xE1, 0xFC, 0x38,
  0x03, 0x0E, 0x1F, 0xF0, 0xC0, 0x38, 0x71, 0xE3, 0xC7, 0x01, 0xC7, 0x0E,
  0x0E, 0x38, 0x0E, 0x38, 0xE0, 0x38, 0xE0, 0xE3, 0x87, 0x01, 0xC7, 0xFE,
  0x1C, 0x30, 0x06, 0x1F, 0xF1, 0xC3, 0x80, 0x38, 0x3E, 0x0E, 0x1C, 0x01,
  0xC0, 0x00, 0x60, 0xE0, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x70, 0x00, 0x38,
  0x38, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x70, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x03, 0x83,
  0xC0, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x0E, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x3C, 0x07, 0x80, 0x1C, 0x78,
  0x03, 0xC0, 0x3C, 0x70, 0x01, 0xE0, 0x38, 0xF0, 0x01, 0xE0, 0x38, 0xE0,
  0x00, 0xF0, 0x78, 0xE0, 0x00, 0x78, 0x70, 0xE0, 0x00, 0x3C, 0xF0, 0xE0,
  0x00, 0x1E, 0xE0, 0xE0, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0xE0, 0x78,
  0x00, 0x3E, 0xF0, 0x3E, 0x00, 0xFC, 0x78, 0x1F, 0xCF, 0xF0, 0x3C, 0x0F,
  0xFF, 0xE0, 0x3E, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xD8, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x30, 0x0C, 0x03, 0xF8, 0x30, 0xFF, 0xFE, 0xDF, 0xF3, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0xF3,
  0xC0, 0x03, 0x87, 0x00, 0x1C, 0x0E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78,
  0x0E, 0x01, 0xC0, 0x10, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x71,
  0xC3, 0x87, 0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF,
  0xF7, 0x90, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xE7, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x7E, 0x0F, 0xF0, 0xFB, 0x8F, 0x9C, 0xF0, 0xEF, 0x07, 0xF0, 0x3B, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x83,
  0xF0, 0x1F, 0x0F, 0x80, 0x0F, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x87, 0xF0, 0x0F, 0x8F, 0x00, 0x0F, 0x8C, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xD0, 0x00, 0x0F, 0x38, 0x00, 0x3E, 0x7F, 0x07, 0xF8, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x77, 0xFE, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC8, 0x00, 0x0F, 0x18, 0x00, 0x7C,
  0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x04,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x70, 0xFF, 0xC0, 0xF3, 0xFF, 0xF0, 0xF7, 0xC1, 0xF8,
  0xEF, 0x00, 0x7C, 0xEC, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1E,
  0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x07, 0xE3, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C,
  0x78, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xC7, 0xE0, 0x1F, 0x01, 0xF0,
  0x3E, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E,
  0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x83, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xF8, 0x1F, 0x03, 0xC0, 0x0F, 0x07,
  0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xE7, 0x00, 0x0F,
  0xCF, 0x80, 0x7B, 0x8F, 0xE7, 0xE7, 0x0F, 0xFF, 0x8E, 0x07, 0xFC, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x18, 0x1F, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFD, 0xE4, 0x1E, 0x7C, 0xF9,
  0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8E,
  0x1C, 0x38, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3C, 0x07, 0xC4, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x1F, 0xC0, 0x0C,
  0x38, 0x00, 0xFF, 0xF0, 0x0E, 0x38, 0x01, 0xFF, 0xF0, 0x0E, 0x70, 0x03,
  0xC0, 0x70, 0x0E, 0x70, 0x07, 0x80, 0x70, 0x07, 0x70, 0x0F, 0x00, 0x70,
  0x07, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x60, 0x0E, 0x00, 0x70, 0x07, 0xE0,
  0x1C, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00,
  0x70, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0xE0, 0x1C, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0xE0, 0x1C,
  0x00, 0xF0, 0x06, 0xE0, 0x1C, 0x00, 0xF0, 0x0E, 0xE0, 0x1C, 0x00, 0xF0,
  0x0E, 0xE0, 0x1E, 0x01, 0xB0, 0x1C, 0x60, 0x0E, 0x01, 0xB8, 0x1C, 0x70,
  0x0F, 0x07, 0x38, 0x38, 0x70, 0x07, 0xFF, 0x1F, 0xF0, 0x70, 0x03, 0xFE,
  0x0F, 0xE0, 0x38, 0x00, 0x60, 0x01, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3C, 0x07, 0xFE, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x38, 0xF0,
  0x00, 0x7C, 0x78, 0x00, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x07, 0x80, 0x07, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x03, 0xEF, 0x00, 0x03, 0xE7, 0x80, 0x07, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xF0, 0x3F, 0x00, 0x04, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x0F, 0xF8, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x7E, 0x0F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0x7C, 0x00,
  0x01, 0xC0, 0x7E, 0x00, 0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0xC7, 0xFF, 0xFF,
  0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0xE7, 0xE7, 0xFE, 0x3F, 0xE0,
  0x30, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0,
  0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF8,
  0x00, 0x1E, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF3, 0xC0, 0x03, 0xF0,
  0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xEE, 0x00, 0x00, 0x03, 0xFE, 0xE0, 0x00, 0x00, 0x77, 0xEF, 0x00, 0x00,
  0x07, 0x7E, 0x70, 0x00, 0x00, 0x77, 0xE7, 0x00, 0x00, 0x0E, 0x7E, 0x78,
  0x00, 0x00, 0xE7, 0xE3, 0x80, 0x00, 0x0E, 0x7E, 0x38, 0x00, 0x01, 0xC7,
  0xE1, 0xC0, 0x00, 0x1C, 0x7E, 0x1C, 0x00, 0x03, 0xC7, 0xE1, 0xE0, 0x00,
  0x38, 0x7E, 0x0E, 0x00, 0x03, 0x87, 0xE0, 0xE0, 0x00, 0x70, 0x7E, 0x0F,
  0x00, 0x07, 0x07, 0xE0, 0x70, 0x00, 0x70, 0x7E, 0x07, 0x00, 0x0E, 0x07,
  0xE0, 0x78, 0x00, 0xE0, 0x7E, 0x03, 0x80, 0x0E, 0x07, 0xE0, 0x38, 0x01,
  0xC0, 0x7E, 0x01, 0xC0, 0x1C, 0x07, 0xE0, 0x1C, 0x01, 0xC0, 0x7E, 0x01,
  0xC0, 0x38, 0x07, 0xE0, 0x0E, 0x03, 0x80, 0x7E, 0x00, 0xE0, 0x78, 0x07,
  0xE0, 0x0F, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x70, 0x07, 0xE0, 0x07, 0x0E,
  0x00, 0x7E, 0x00, 0x78, 0xE0, 0x07, 0xE0, 0x03, 0x8E, 0x00, 0x7E, 0x00,
  0x39, 0xC0, 0x07, 0xE0, 0x03, 0xDC, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x70, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7E, 0xE0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x7E,
  0x78, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xE1, 0xC0,
  0x00, 0x7E, 0x1E, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x07,
  0xE0, 0x78, 0x00, 0x7E, 0x03, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0x7E, 0x01,
  0xC0, 0x07, 0xE0, 0x1E, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00,
  0x7E, 0x00, 0x78, 0x07, 0xE0, 0x03, 0x80, 0x7E, 0x00, 0x3C, 0x07, 0xE0,
  0x01, 0xC0, 0x7E, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x0F,
  0x07, 0xE0, 0x00, 0x78, 0x7E, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x3C, 0x7E,
  0x00, 0x01, 0xC7, 0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x00, 0xF7, 0xE0, 0x00,
  0x0F, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x83, 0xC1, 0xFF, 0xC7, 0x80, 0x0F, 0xCF, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x3F, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x3F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x7E, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1C,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0x70, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0xFC, 0x03, 0xE3, 0xE0, 0x00, 0x8F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xD0, 0x00, 0x0F, 0x38, 0x00, 0x7C, 0x7F, 0xCF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xA0, 0x00,
  0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0xC0, 0x00, 0x71, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xDC,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0xE0,
  0x00, 0xE0, 0xF0, 0x00, 0x73, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x8E, 0x00,
  0x0E, 0x07, 0x00, 0x0E, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x70, 0x01,
  0xC0, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x1E,
  0x07, 0x80, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x70, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x0F, 0x0F,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0,
  0x03, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x07, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xC0, 0x01,
  0xCF, 0x00, 0x00, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xEE,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0,
  0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x38,
  0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x0E,
  0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x3C,
  0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFC,
  0x7F, 0x03, 0x80, 0x3C, 0x08, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0x8F, 0x1F, 0x80, 0x3C, 0xF8, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x70, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70,
  0x00, 0x7D, 0xC0, 0x01, 0xF7, 0x80, 0x0D, 0xDF, 0x00, 0x67, 0x3E, 0x07,
  0x9C, 0x7F, 0xFC, 0x70, 0xFF, 0xC1, 0xC0, 0x70, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x1F,
  0xF0, 0x38, 0xFF, 0xF0, 0x73, 0xF3, 0xF8, 0xEE, 0x00, 0xF1, 0xF8, 0x00,
  0xF3, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xDE, 0x00, 0x07, 0xBE, 0x00,
  0x0F, 0x7E, 0x00, 0x3C, 0xEE, 0x00, 0xF1, 0x8F, 0x07, 0xC3, 0x0F, 0xFF,
  0x06, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xF8, 0x02, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x01, 0x0F, 0xE3, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x01, 0xFF, 0x07, 0x07, 0xFF, 0xC7,
  0x0F, 0xE7, 0xE7, 0x1F, 0x00, 0xF7, 0x1E, 0x00, 0x37, 0x3C, 0x00, 0x3F,
  0x38, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x38, 0x00, 0x1F,
  0x3C, 0x00, 0x37, 0x1E, 0x00, 0x77, 0x0F, 0xC3, 0xE7, 0x07, 0xFF, 0xC7,
  0x03, 0xFF, 0x07, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0x1F, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0E,
  0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x60, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xB8, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x07, 0x07, 0xFF, 0xC7, 0x0F,
  0xE7, 0xE7, 0x1F, 0x00, 0xF7, 0x1E, 0x00, 0x37, 0x3C, 0x00, 0x1F, 0x38,
  0x00, 0x1F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x3C,
  0x00, 0x37, 0x1E, 0x00, 0x67, 0x0F, 0xC3, 0xE7, 0x07, 0xFF, 0xC7, 0x03,
  0xFF, 0x07, 0x00, 0x30, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x7C, 0x3C, 0x01, 0xF8, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x83, 0xFE, 0x0E, 0x3F,
  0xFC, 0x39, 0xF9, 0xF8, 0xEE, 0x00, 0xF3, 0xF0, 0x01, 0xEF, 0x80, 0x07,
  0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x77, 0xFF, 0xE7,
  0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80,
  0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x79, 0xFF, 0x3F, 0xC7, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x7B, 0x80, 0x07, 0x9C, 0x00, 0x78, 0xE0,
  0x07, 0x87, 0x00, 0x38, 0x38, 0x03, 0x81, 0xC0, 0x3C, 0x0E, 0x03, 0xC0,
  0x70, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x1E,
  0x00, 0x39, 0xF0, 0x01, 0xCF, 0x80, 0x0E, 0xFE, 0x00, 0x7E, 0x78, 0x03,
  0xE1, 0xC0, 0x1E, 0x0F, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x78, 0xE0, 0x01, 0xC7, 0x00, 0x0F, 0x38, 0x00, 0x3D, 0xC0, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xFF, 0x00, 0xFF, 0x86, 0x1F,
  0xFC, 0x1F, 0xFE, 0x31, 0xF3, 0xF1, 0xFB, 0xF9, 0xDC, 0x07, 0xDE, 0x03,
  0xEF, 0x80, 0x1E, 0xE0, 0x0F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x03,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80,
  0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F,
  0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00,
  0x1F, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0xC0, 0xFF, 0x83, 0x0F, 0xFF, 0x0C,
  0x7E, 0x7E, 0x3B, 0x80, 0x3C, 0xFC, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x00,
  0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x03, 0xF9, 0xFC, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x00,
  0xFE, 0x3F, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0xFF, 0x81, 0x87, 0xFF, 0x83, 0x1F, 0x9F, 0xC7, 0x70, 0x07, 0x8E,
  0xC0, 0x07, 0x9F, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x7B, 0xF0, 0x01, 0xE7, 0x70, 0x07, 0x8E, 0x7C, 0x7F, 0x1C,
  0x7F, 0xFC, 0x38, 0x7F, 0xE0, 0x70, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x07, 0x07, 0xFF, 0xC7, 0x0F, 0xE7, 0xE7, 0x1F, 0x00, 0xF7, 0x1E, 0x00,
  0x37, 0x3C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x38, 0x00, 0x37, 0x3C, 0x00, 0x37, 0x1E, 0x00, 0xE7, 0x0F, 0x83,
  0xE7, 0x07, 0xFF, 0xCF, 0x03, 0xFF, 0x0F, 0x00, 0x30, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xF7, 0x78, 0x0E, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xC0, 0x04, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x80, 0x01, 0xEE, 0x00, 0x3E, 0xFC, 0x1F,
  0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3E, 0x10, 0x3F, 0xE0, 0x3F, 0xC0, 0x0C, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0x80, 0x0F,
  0xCF, 0x00, 0x77, 0x3F, 0x0F, 0x8C, 0x7F, 0xFC, 0x30, 0x7F, 0xE0, 0xC0,
  0x18, 0x00, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x1E, 0xE0, 0x01, 0xF0, 0x00, 0xE7, 0x00, 0x0D, 0xC0, 0x07, 0x38, 0x00,
  0xEE, 0x00, 0x39, 0xE0, 0x07, 0x70, 0x03, 0xC7, 0x00, 0x3B, 0x80, 0x1C,
  0x38, 0x01, 0xCE, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x07, 0x0F, 0x00, 0xE3,
  0x80, 0x78, 0x38, 0x07, 0x1E, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x1C, 0x0E,
  0x03, 0x83, 0x80, 0xE0, 0x78, 0x1C, 0x1C, 0x0F, 0x01, 0xC0, 0xE0, 0x70,
  0x70, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x1C, 0x03, 0xC3,
  0x80, 0xE1, 0xE0, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x07, 0xBC, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x00,
  0x6E, 0x00, 0x1B, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x1E,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x03,
  0x83, 0xC0, 0x03, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xE7, 0x00, 0x01,
  0xC3, 0x80, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03,
  0x81, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0xC0, 0x00,
  0xE3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x77, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xF0,
  0xFF, 0x0F, 0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_Light58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 42, 14, 4, -41 },
  { 28, 13, 15, 21, 4, -41 },
  { 53, 31, 41, 33, 1, -41 },
  { 212, 23, 47, 30, 3, -44 },
  { 348, 37, 43, 43, 3, -42 },
  { 547, 32, 43, 36, 3, -42 },
  { 719, 3, 15, 11, 4, -41 },
  { 725, 11, 50, 16, 3, -41 },
  { 794, 12, 50, 16, 2, -41 },
  { 869, 22, 22, 28, 3, -44 },
  { 930, 24, 27, 30, 3, -34 },
  { 1011, 7, 15, 13, 2, -7 },
  { 1025, 13, 3, 18, 2, -17 },
  { 1030, 5, 6, 13, 4, -5 },
  { 1034, 18, 41, 20, 1, -41 },
  { 1127, 24, 43, 30, 3, -42 },
  { 1256, 13, 41, 30, 5, -41 },
  { 1323, 23, 42, 30, 3, -42 },
  { 1444, 23, 43, 30, 3, -42 },
  { 1568, 28, 42, 30, 1, -42 },
  { 1715, 23, 42, 30, 4, -41 },
  { 1836, 24, 43, 30, 3, -42 },
  { 1965, 24, 41, 30, 3, -41 },
  { 2088, 24, 43, 30, 3, -42 },
  { 2217, 23, 43, 30, 3, -42 },
  { 2341, 5, 32, 13, 4, -31 },
  { 2361, 7, 39, 13, 2, -31 },
  { 2396, 24, 26, 30, 3, -34 },
  { 2474, 24, 15, 30, 3, -28 },
  { 2519, 24, 26, 30, 3, -34 },
  { 2597, 19, 43, 22, 1, -42 },
  { 2700, 40, 46, 46, 3, -41 },
  { 2930, 31, 42, 31, 0, -42 },
  { 3093, 25, 41, 33, 5, -41 },
  { 3222, 27, 43, 32, 3, -42 },
  { 3368, 28, 41, 37, 5, -41 },
  { 3512, 20, 41, 29, 5, -41 },
  { 3615, 20, 41, 26, 5, -41 },
  { 3718, 31, 43, 38, 3, -42 },
  { 3885, 27, 41, 37, 5, -41 },
  { 4024, 11, 41, 17, 3, -41 },
  { 4081, 13, 52, 14, -4, -41 },
  { 4166, 25, 41, 30, 5, -41 },
  { 4295, 20, 41, 27, 5, -41 },
  { 4398, 36, 41, 47, 5, -41 },
  { 4583, 28, 41, 38, 5, -41 },
  { 4727, 33, 43, 40, 3, -42 },
  { 4905, 23, 41, 31, 5, -41 },
  { 5023, 33, 52, 40, 3, -42 },
  { 5238, 25, 41, 31, 5, -41 },
  { 5367, 23, 43, 29, 3, -42 },
  { 5491, 27, 41, 27, 0, -41 },
  { 5630, 27, 42, 37, 5, -41 },
  { 5772, 30, 41, 30, 0, -41 },
  { 5926, 46, 41, 48, 1, -41 },
  { 6162, 28, 41, 28, 0, -41 },
  { 6306, 27, 41, 27, 0, -41 },
  { 6445, 25, 41, 28, 2, -41 },
  { 6574, 12, 50, 18, 5, -41 },
  { 6649, 18, 41, 20, 1, -41 },
  { 6742, 12, 50, 18, 2, -41 },
  { 6817, 26, 24, 30, 2, -42 },
  { 6895, 24, 3, 24, 0, 5 },
  { 6904, 11, 9, 15, 2, -44 },
  { 6917, 22, 32, 28, 2, -31 },
  { 7005, 23, 45, 31, 5, -44 },
  { 7135, 20, 32, 24, 3, -31 },
  { 7215, 24, 45, 31, 3, -44 },
  { 7350, 23, 32, 29, 3, -31 },
  { 7442, 18, 44, 16, 1, -44 },
  { 7541, 24, 45, 31, 3, -31 },
  { 7676, 22, 44, 31, 5, -44 },
  { 7797, 5, 42, 13, 4, -42 },
  { 7824, 11, 56, 13, -2, -42 },
  { 7901, 21, 44, 26, 5, -44 },
  { 8017, 3, 44, 13, 5, -44 },
  { 8034, 37, 31, 47, 5, -31 },
  { 8178, 22, 31, 31, 5, -31 },
  { 8264, 25, 32, 31, 3, -31 },
  { 8364, 23, 45, 31, 5, -31 },
  { 8494, 24, 45, 31, 3, -31 },
  { 8629, 15, 31, 20, 5, -31 },
  { 8688, 20, 32, 24, 2, -31 },
  { 8768, 15, 39, 17, 1, -38 },
  { 8842, 22, 32, 31, 4, -31 },
  { 8930, 24, 31, 24, 0, -31 },
  { 9023, 37, 31, 39, 1, -31 },
  { 9167, 24, 31, 26, 1, -31 },
  { 9260, 24, 45, 25, 0, -31 },
  { 9395, 19, 31, 23, 2, -31 },
  { 9469, 16, 50, 21, 2, -41 },
  { 9569, 3, 58, 28, 13, -44 },
  { 9591, 17, 50, 21, 2, -41 },
  { 9698, 24, 7, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_Light58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT58PT7B_H_
