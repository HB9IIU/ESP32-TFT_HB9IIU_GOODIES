#ifndef _NOTOSANS_SEMICONDENSED_LIGHT70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light70pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xF3, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0E, 0xE0, 0x0D,
  0xC0, 0x18, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x1F, 0xEE, 0x7F, 0x83, 0xE0, 0xE0, 0x38, 0x7C, 0x0E,
  0x00, 0x87, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF8, 0x0E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x7E, 0x0E, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x1F,
  0xCE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0xFF, 0x00,
  0x00, 0xE3, 0xF8, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0xE0, 0x7C, 0x00, 0x0E,
  0x03, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x3E, 0x00, 0x0E, 0x03,
  0xCC, 0x00, 0xE0, 0xF8, 0xFC, 0x0E, 0x3F, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x0F, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0x07,
  0x00, 0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0xF0, 0x7F, 0x81, 0xC0,
  0x07, 0x07, 0x07, 0xFF, 0x0F, 0x00, 0x78, 0x78, 0x7C, 0x7C, 0x38, 0x03,
  0xC3, 0x87, 0x81, 0xE1, 0xC0, 0x1C, 0x3C, 0x3C, 0x07, 0x8F, 0x01, 0xE1,
  0xC1, 0xC0, 0x1C, 0x3C, 0x1E, 0x1E, 0x1E, 0x00, 0xE1, 0xF1, 0xF0, 0xF0,
  0xE0, 0x07, 0x87, 0xFF, 0x07, 0x07, 0x00, 0x3C, 0x1F, 0xF0, 0x78, 0x38,
  0x00, 0xE0, 0x1C, 0x03, 0x83, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x70, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x00,
  0x38, 0x03, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x3C, 0x00, 0x3C, 0x00, 0x03, 0xE7, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x1F,
  0x00, 0x0F, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x00, 0x78,
  0x7C, 0x00, 0x3E, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x01, 0xE1, 0xE0, 0x00,
  0x3E, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x78, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x78, 0x00,
  0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0x00, 0x7E,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xC0,
  0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0xF8, 0x07, 0xC0, 0x01, 0xF8,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x40, 0x0E, 0x00, 0x2F, 0x01, 0xC0, 0x3D, 0xFC, 0x18, 0x7F, 0xFF, 0xF3,
  0x7F, 0xF1, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x01,
  0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x60, 0x01,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE3,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xEF, 0x0F, 0xCF, 0x1F,
  0x8F, 0x3E, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F, 0x70, 0x0F, 0x20, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xE0,
  0x00, 0x1E, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x1F, 0x04, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x40, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x39, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xF0, 0x0F, 0xF0,
  0x10, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x80, 0x00,
  0x0F, 0x8E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x07, 0xFF, 0xC0, 0xF1, 0xFF, 0xFE, 0x0F, 0x3F, 0xC7, 0xF0, 0xF7,
  0xC0, 0x0F, 0x8F, 0x70, 0x00, 0x7C, 0xFE, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x78, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0xC7, 0x80,
  0x01, 0xDE, 0x3F, 0x00, 0x3C, 0xF0, 0xFE, 0x0F, 0xC7, 0x83, 0xFF, 0xFC,
  0x3C, 0x07, 0xFF, 0xC1, 0xC0, 0x0F, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x02, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x31, 0xFF, 0xFF,
  0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE3, 0x00, 0x06, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x87, 0xC0, 0x1F, 0x86, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xFE, 0x00, 0x1C, 0x3C, 0x00, 0x1F, 0xFF, 0xC0, 0x1C, 0x3C, 0x00,
  0x3F, 0xFF, 0xC0, 0x1E, 0x38, 0x00, 0x7C, 0x03, 0xC0, 0x0E, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0x80, 0x03, 0xC0, 0x0F, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x07,
  0x80, 0x03, 0x80, 0x0F, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x0F, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x0F, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x07,
  0x00, 0x07, 0x80, 0x0E, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x0E, 0xE0, 0x07,
  0x00, 0x07, 0x80, 0x0E, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0xE0, 0x07,
  0x80, 0x0F, 0x80, 0x1E, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1C, 0xF0, 0x03,
  0x80, 0x1D, 0xC0, 0x3C, 0xF0, 0x03, 0xC0, 0x1D, 0xC0, 0x78, 0x70, 0x01,
  0xE0, 0x78, 0xE0, 0xF8, 0x70, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x78, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x78, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x00,
  0xFE, 0x3C, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3F,
  0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0xE0,
  0x3C, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x03,
  0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x00, 0x00, 0x80, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x00, 0x3C, 0x07,
  0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xFA, 0x03,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF0,
  0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x7E,
  0x00, 0x00, 0x79, 0xFE, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x01, 0xEF, 0x7C,
  0x00, 0x03, 0xFC, 0x7C, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0x80, 0x00,
  0x00, 0x0E, 0xFF, 0x78, 0x00, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0x00,
  0x1E, 0xFF, 0x3C, 0x00, 0x00, 0x01, 0xCF, 0xF3, 0xC0, 0x00, 0x00, 0x3C,
  0xFF, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0xF1, 0xE0, 0x00, 0x00, 0x38, 0xFF,
  0x1E, 0x00, 0x00, 0x07, 0x8F, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xFF, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xFF, 0x07, 0x80,
  0x00, 0x0E, 0x0F, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0xF0, 0x3C, 0x00, 0x01, 0xC0, 0xFF, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x00, 0x38, 0x0F,
  0xF0, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x07,
  0x00, 0x0E, 0x00, 0xFF, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xFF, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x3C,
  0x00, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x38, 0x00,
  0xFF, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xFF,
  0x00, 0x0F, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0x9E, 0x00, 0x0F, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0x0F, 0xF7, 0xC0, 0x00,
  0x03, 0xFC, 0xF0, 0x00, 0x00, 0xFF, 0x1E, 0x00, 0x00, 0x3F, 0xC7, 0xC0,
  0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x03, 0xFC, 0x3E, 0x00, 0x00, 0xFF, 0x07,
  0x80, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x03, 0xFC,
  0x07, 0x80, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x0F,
  0xF0, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7C, 0x00,
  0x3F, 0xC0, 0x0F, 0x00, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x00,
  0x78, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xC0,
  0x00, 0x78, 0x0F, 0xF0, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0xFF,
  0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x03, 0xC3,
  0xFC, 0x00, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0x1E, 0x3F, 0xC0, 0x00, 0x07,
  0xCF, 0xF0, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x00, 0x3E, 0xFF, 0x00, 0x00,
  0x07, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x8F, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x3F,
  0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0x0C, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xF8, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x9C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xC1, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x38, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0x80, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x7C,
  0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x1C,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x78,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0x3F, 0xC0, 0xF0, 0x03, 0xF0, 0x60, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x71, 0xFC, 0x00, 0x39, 0xF8, 0x00, 0x1D,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x1B, 0xBE, 0x00,
  0x3D, 0xCF, 0x80, 0x3C, 0xE7, 0xFF, 0xFC, 0x71, 0xFF, 0xFC, 0x38, 0x3F,
  0xF8, 0x1C, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xFC,
  0x00, 0xF0, 0x7F, 0xF8, 0x0E, 0x1F, 0xFF, 0xC0, 0xE3, 0xFF, 0xFF, 0x0E,
  0x78, 0x01, 0xF0, 0xEF, 0x00, 0x0F, 0x8E, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3C, 0xFC, 0x00,
  0x07, 0xCE, 0xE0, 0x00, 0x78, 0xEF, 0x00, 0x0F, 0x8E, 0x7C, 0x03, 0xF0,
  0xE3, 0xFF, 0xFE, 0x0E, 0x1F, 0xFF, 0xC0, 0xE0, 0x7F, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xE0, 0x06, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x0F, 0xE0, 0x0E, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0x01, 0xFF, 0xF0, 0xF0, 0x3F,
  0xFF, 0x8F, 0x07, 0xFF, 0xFC, 0x70, 0xFC, 0x01, 0xE7, 0x1F, 0x00, 0x0F,
  0x73, 0xE0, 0x00, 0x77, 0x3C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x77, 0x1F,
  0x00, 0x0E, 0x70, 0xFC, 0x03, 0xE7, 0x07, 0xFF, 0xFC, 0x70, 0x3F, 0xFF,
  0x87, 0x01, 0xFF, 0xE0, 0x70, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0xFC, 0x03,
  0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x18, 0x3F, 0x80, 0x1F, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xF8, 0x08, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x07, 0x03, 0xFF, 0xF8, 0x70,
  0x7F, 0xFF, 0xC7, 0x0F, 0xC0, 0x1E, 0x71, 0xF0, 0x00, 0xF7, 0x3E, 0x00,
  0x07, 0xF3, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xF3, 0xC0, 0x00, 0x37, 0x3E, 0x00, 0x07, 0x71, 0xF0, 0x00, 0xEF,
  0x0F, 0xC0, 0x3E, 0xF0, 0x7F, 0xFF, 0xCF, 0x03, 0xFF, 0xF8, 0xF0, 0x0F,
  0xFE, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC3, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x83,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0xF0, 0x7F, 0xF8, 0x3C, 0x7F, 0xFF,
  0x0E, 0x3F, 0xFF, 0xE3, 0x9E, 0x00, 0xFC, 0xEF, 0x00, 0x0F, 0xBB, 0x80,
  0x01, 0xEF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x77, 0xFF, 0xFF, 0xB8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0xFF,
  0xE7, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0xC0,
  0x07, 0x07, 0xC0, 0x03, 0x87, 0xC0, 0x01, 0xC3, 0xE0, 0x00, 0xE3, 0xF0,
  0x00, 0x73, 0xFC, 0x00, 0x3B, 0xDE, 0x00, 0x1D, 0xC7, 0x80, 0x0F, 0xC3,
  0xE0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x38, 0x7F, 0xFE, 0x07, 0xFF, 0xE1,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8E, 0x78, 0x07, 0xC7, 0x80, 0x7E, 0x77,
  0x00, 0x1F, 0x78, 0x00, 0xFB, 0xB0, 0x00, 0x7B, 0x80, 0x07, 0xDF, 0x80,
  0x03, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x38, 0x1F, 0xFE, 0x0E,
  0x1F, 0xFF, 0xC3, 0x8F, 0xFF, 0xF8, 0xE7, 0x80, 0x3F, 0x3B, 0xC0, 0x03,
  0xEE, 0xE0, 0x00, 0x7B, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0E, 0x07,
  0xFF, 0x80, 0xE1, 0xFF, 0xFE, 0x0E, 0x3F, 0xFF, 0xF0, 0xE7, 0x80, 0x1F,
  0x0E, 0x70, 0x00, 0xF8, 0xEE, 0x00, 0x07, 0xCE, 0xC0, 0x00, 0x3C, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x7C, 0xEE,
  0x00, 0x07, 0x8E, 0x70, 0x01, 0xF8, 0xE7, 0xC0, 0x3F, 0x0E, 0x3F, 0xFF,
  0xE0, 0xE1, 0xFF, 0xFC, 0x0F, 0x07, 0xFF, 0x00, 0xF0, 0x0F, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFF, 0x07, 0x03, 0xFF, 0xF8, 0x70, 0x7F, 0xFF, 0xC7, 0x0F, 0xC0,
  0x1E, 0x71, 0xF0, 0x00, 0xF7, 0x3E, 0x00, 0x07, 0x73, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x37,
  0x3E, 0x00, 0x07, 0x71, 0xF0, 0x00, 0xEF, 0x0F, 0xC0, 0x3C, 0xF0, 0x7F,
  0xFF, 0xCF, 0x03, 0xFF, 0xF0, 0xF0, 0x1F, 0xFE, 0x0F, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xB8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFE, 0xE7, 0xC0, 0x39, 0xC0, 0x0E, 0xE0,
  0x03, 0xB0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0x9F, 0xE3, 0xE0,
  0x01, 0xCF, 0x80, 0x00, 0x9E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xFB, 0xE0, 0x07, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x81, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00,
  0x0F, 0xDE, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x7F, 0x3E, 0x00, 0x3D, 0xE7,
  0xE0, 0x0F, 0x3C, 0x7F, 0xFF, 0xC7, 0x87, 0xFF, 0xF0, 0x70, 0x3F, 0xF8,
  0x0E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0x3C, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x77, 0x80, 0x03, 0x87,
  0x80, 0x07, 0xBC, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0xE0, 0x01, 0xE1, 0xE0,
  0x01, 0xE7, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x3C, 0x00, 0x70, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x0F, 0x00, 0x38,
  0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC1, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x38, 0x1E,
  0x00, 0x78, 0x1C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x01, 0xC3, 0xC0, 0x03,
  0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0x79,
  0xE0, 0x03, 0xC7, 0x00, 0x03, 0xCE, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x70,
  0x00, 0x7B, 0xC0, 0x00, 0x77, 0x80, 0x03, 0xDE, 0x00, 0x03, 0xBC, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xC0, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x37, 0xFF, 0xF8, 0x01, 0xFE,
  0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFA, 0x00, 0x03, 0xFF, 0xC8, 0x00,
  0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Light70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 51, 16, 5, -50 },
  { 40, 15, 18, 25, 5, -50 },
  { 74, 36, 50, 40, 2, -50 },
  { 299, 28, 57, 36, 4, -53 },
  { 499, 45, 52, 52, 3, -51 },
  { 792, 39, 52, 43, 3, -51 },
  { 1046, 4, 18, 14, 5, -50 },
  { 1055, 14, 61, 19, 3, -50 },
  { 1162, 14, 61, 19, 2, -50 },
  { 1269, 27, 26, 34, 3, -53 },
  { 1357, 30, 33, 36, 3, -41 },
  { 1481, 8, 17, 15, 3, -8 },
  { 1498, 17, 4, 21, 2, -21 },
  { 1507, 6, 7, 16, 5, -6 },
  { 1513, 22, 50, 24, 1, -50 },
  { 1651, 28, 52, 36, 4, -51 },
  { 1833, 16, 50, 36, 6, -50 },
  { 1933, 29, 51, 36, 3, -51 },
  { 2118, 29, 52, 36, 3, -51 },
  { 2307, 34, 50, 36, 1, -50 },
  { 2520, 28, 51, 36, 4, -50 },
  { 2699, 28, 52, 36, 4, -51 },
  { 2881, 29, 50, 36, 3, -50 },
  { 3063, 29, 52, 36, 3, -51 },
  { 3252, 29, 52, 36, 3, -51 },
  { 3441, 6, 39, 16, 5, -38 },
  { 3471, 9, 47, 16, 2, -38 },
  { 3524, 30, 32, 36, 3, -41 },
  { 3644, 30, 18, 36, 3, -34 },
  { 3712, 30, 32, 36, 3, -41 },
  { 3832, 23, 52, 26, 1, -51 },
  { 3982, 48, 56, 56, 4, -50 },
  { 4318, 38, 50, 38, 0, -50 },
  { 4556, 30, 50, 40, 6, -50 },
  { 4744, 33, 52, 39, 4, -51 },
  { 4959, 34, 50, 44, 6, -50 },
  { 5172, 25, 50, 35, 6, -50 },
  { 5329, 25, 50, 32, 6, -50 },
  { 5486, 37, 52, 46, 4, -51 },
  { 5727, 33, 50, 45, 6, -50 },
  { 5934, 14, 50, 20, 3, -50 },
  { 6022, 15, 63, 16, -5, -50 },
  { 6141, 31, 50, 37, 6, -50 },
  { 6335, 25, 50, 32, 6, -50 },
  { 6492, 44, 50, 56, 6, -50 },
  { 6767, 34, 50, 46, 6, -50 },
  { 6980, 40, 52, 48, 4, -51 },
  { 7240, 28, 50, 37, 6, -50 },
  { 7415, 40, 63, 48, 4, -51 },
  { 7730, 30, 50, 38, 6, -50 },
  { 7918, 28, 52, 35, 3, -51 },
  { 8100, 32, 50, 33, 0, -50 },
  { 8300, 33, 51, 45, 6, -50 },
  { 8511, 36, 50, 36, 0, -50 },
  { 8736, 55, 50, 57, 1, -50 },
  { 9080, 33, 50, 34, 0, -50 },
  { 9287, 33, 50, 33, 0, -50 },
  { 9494, 30, 50, 34, 2, -50 },
  { 9682, 14, 61, 22, 6, -50 },
  { 9789, 22, 50, 24, 1, -50 },
  { 9927, 14, 61, 22, 2, -50 },
  { 10034, 32, 29, 36, 2, -50 },
  { 10150, 29, 3, 29, 0, 6 },
  { 10161, 12, 12, 18, 3, -54 },
  { 10179, 25, 39, 34, 3, -38 },
  { 10301, 28, 54, 38, 6, -53 },
  { 10490, 24, 39, 30, 4, -38 },
  { 10607, 28, 54, 38, 4, -53 },
  { 10796, 27, 39, 35, 4, -38 },
  { 10928, 22, 54, 20, 1, -54 },
  { 11077, 28, 55, 38, 4, -38 },
  { 11270, 26, 53, 38, 6, -53 },
  { 11443, 5, 51, 15, 5, -51 },
  { 11475, 13, 68, 15, -3, -51 },
  { 11586, 25, 53, 31, 6, -53 },
  { 11752, 4, 53, 15, 6, -53 },
  { 11779, 45, 38, 56, 6, -38 },
  { 11993, 26, 38, 38, 6, -38 },
  { 12117, 29, 39, 37, 4, -38 },
  { 12259, 28, 55, 38, 6, -38 },
  { 12452, 28, 55, 38, 4, -38 },
  { 12645, 18, 38, 25, 6, -38 },
  { 12731, 23, 39, 29, 3, -38 },
  { 12844, 19, 47, 21, 1, -46 },
  { 12956, 27, 38, 38, 5, -37 },
  { 13085, 29, 37, 29, 0, -37 },
  { 13220, 45, 37, 47, 1, -37 },
  { 13429, 29, 37, 31, 1, -37 },
  { 13564, 29, 54, 30, 0, -37 },
  { 13760, 23, 37, 28, 2, -37 },
  { 13867, 20, 61, 25, 2, -50 },
  { 14020, 4, 70, 34, 15, -53 },
  { 14055, 20, 61, 25, 3, -50 },
  { 14208, 30, 7, 36, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_Light70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT70PT7B_H_
