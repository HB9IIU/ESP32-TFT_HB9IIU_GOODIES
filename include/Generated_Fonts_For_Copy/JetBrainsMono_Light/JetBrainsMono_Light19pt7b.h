#ifndef _JETBRAINSMONO_LIGHT19PT7B_H_
#define _JETBRAINSMONO_LIGHT19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light19pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x92, 0x48, 0x0E, 0xC0, 0xCE, 0x73, 0x98, 0xC4, 0x11,
  0x84, 0x61, 0x10, 0x44, 0xFF, 0xC8, 0x42, 0x30, 0x88, 0x22, 0x3F, 0xE4,
  0x21, 0x18, 0x44, 0x11, 0x00, 0x08, 0x04, 0x02, 0x07, 0xC7, 0xB3, 0x4D,
  0x26, 0xD0, 0x68, 0x1E, 0x03, 0xC1, 0x30, 0x9E, 0x4D, 0x26, 0xD6, 0x3E,
  0x04, 0x02, 0x01, 0x00, 0x78, 0x29, 0x0B, 0x32, 0x66, 0x4C, 0x90, 0xF4,
  0x01, 0x80, 0x20, 0x0B, 0xC3, 0x44, 0x48, 0x91, 0x16, 0x27, 0x83, 0x80,
  0x3C, 0x19, 0x84, 0x31, 0x00, 0x60, 0x0C, 0x07, 0x03, 0x63, 0xCD, 0xB1,
  0x4C, 0x73, 0x0C, 0xC7, 0x9E, 0x30, 0xFC, 0x09, 0xD8, 0x8C, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x63, 0x0C, 0x30, 0xC0, 0xC3, 0x83, 0x06, 0x08, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x84, 0x73, 0x00, 0x08, 0x02, 0x00,
  0x82, 0x22, 0xEB, 0xC7, 0x81, 0xC0, 0xD8, 0x33, 0x18, 0x40, 0x08, 0x04,
  0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x36, 0x66, 0x4C,
  0xFC, 0x7F, 0x80, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x30, 0x20, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x7C, 0xE6, 0x83,
  0x83, 0x83, 0x83, 0x9B, 0x9B, 0x83, 0x83, 0x83, 0x83, 0xC6, 0x7C, 0x18,
  0x68, 0xC8, 0x88, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x3E, 0x31, 0x90, 0x78, 0x30, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06,
  0x06, 0x06, 0x06, 0x03, 0xFC, 0x7F, 0x3F, 0x80, 0x80, 0x80, 0x80, 0xE0,
  0x7C, 0x02, 0x01, 0x80, 0xF0, 0x68, 0x26, 0x31, 0xF0, 0x06, 0x18, 0x20,
  0xC3, 0x04, 0x18, 0xE1, 0x83, 0x07, 0xF8, 0x10, 0x20, 0x40, 0xFE, 0xFE,
  0xC0, 0xC0, 0xC0, 0xBC, 0xE6, 0xC3, 0x03, 0x03, 0x03, 0x83, 0xC6, 0x7C,
  0x06, 0x06, 0x02, 0x03, 0x03, 0x01, 0x21, 0xFC, 0xC3, 0x41, 0xE0, 0x70,
  0x68, 0x36, 0x31, 0xF0, 0xFF, 0xFF, 0x83, 0x82, 0x06, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x18, 0x10, 0x30, 0x20, 0x7C, 0xC6, 0xC2, 0x83, 0xC2, 0x46,
  0x3C, 0x7C, 0xC6, 0x83, 0x83, 0x83, 0xC6, 0x7C, 0x3E, 0x39, 0x90, 0x78,
  0x3C, 0x0E, 0x0D, 0x86, 0xFE, 0x1B, 0x03, 0x01, 0x81, 0x80, 0x80, 0xC0,
  0x5F, 0x80, 0x00, 0x5F, 0x80, 0x37, 0x70, 0x00, 0x00, 0x37, 0x66, 0x4C,
  0x03, 0x0E, 0x38, 0xE0, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x07, 0x1C, 0x70,
  0xC0, 0x80, 0xF3, 0xE0, 0xC1, 0x04, 0x11, 0xDE, 0x61, 0x80, 0x00, 0x61,
  0x80, 0x3E, 0x18, 0x64, 0x0B, 0x02, 0x80, 0xE3, 0xF8, 0x8E, 0x23, 0x88,
  0xE2, 0x38, 0x8E, 0x23, 0x87, 0xF0, 0x0C, 0x01, 0x80, 0x3E, 0x00, 0x0C,
  0x0E, 0x05, 0x02, 0xC1, 0x61, 0x90, 0x88, 0x46, 0x23, 0x3F, 0x90, 0x48,
  0x3C, 0x1E, 0x04, 0xFC, 0xFE, 0x83, 0x83, 0x83, 0x82, 0xFC, 0x8E, 0x83,
  0x83, 0x83, 0x83, 0x86, 0xFC, 0x3C, 0xE6, 0xC3, 0x83, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x83, 0x83, 0xC6, 0x7C, 0xF8, 0x9E, 0x82, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x82, 0x8E, 0xFC, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0xFE, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x3C, 0xE6, 0xC3, 0x83, 0x80, 0x80, 0x80, 0x9F, 0x83, 0x83, 0x83,
  0x83, 0xC6, 0x7C, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xFF, 0xFF, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x1F, 0xC0, 0x1F, 0x1F, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0xC1, 0xC1, 0x63, 0x3E, 0x81, 0x41, 0xA1, 0x90,
  0xC8, 0xC4, 0x63, 0xE1, 0x10, 0x8C, 0x42, 0x21, 0x90, 0x48, 0x34, 0x0C,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xC3, 0xC7, 0xC5, 0xE5, 0xAD, 0xAB, 0xBB, 0x9B, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0xC3, 0xC3, 0xE3, 0xA3, 0xA3, 0xB3, 0x93, 0x9B,
  0x8B, 0x8B, 0x8F, 0x87, 0x87, 0x87, 0x7C, 0xE6, 0xC2, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x82, 0xC6, 0x7C, 0xFC, 0xFE, 0x83, 0x81,
  0x81, 0x81, 0x83, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0xE6,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC6, 0x7C,
  0x0C, 0x06, 0x03, 0xFC, 0xFE, 0x83, 0x81, 0x81, 0x83, 0x86, 0xFC, 0x8C,
  0x8C, 0x86, 0x86, 0x83, 0x83, 0x3E, 0x39, 0x98, 0x68, 0x36, 0x03, 0x00,
  0xF0, 0x1E, 0x01, 0x80, 0xF0, 0x68, 0x36, 0x31, 0xF0, 0xFF, 0xFF, 0xC2,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0xC2, 0xC6, 0x7C, 0xC0, 0xE0, 0xD0, 0x68, 0x26, 0x13, 0x18, 0x8C, 0x64,
  0x32, 0x1B, 0x05, 0x82, 0x81, 0xC0, 0x60, 0x8C, 0xE3, 0x38, 0xCE, 0x52,
  0x94, 0xB5, 0x2D, 0x4B, 0x52, 0x52, 0x94, 0xE5, 0x39, 0x8C, 0x63, 0x18,
  0xC0, 0xC1, 0x98, 0x66, 0x30, 0xC8, 0x16, 0x07, 0x00, 0xC0, 0x30, 0x16,
  0x0D, 0x82, 0x31, 0x84, 0x41, 0xB0, 0x30, 0x80, 0xF0, 0x64, 0x19, 0x8C,
  0x23, 0x0C, 0x81, 0x60, 0x70, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xFF, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0x40,
  0xC0, 0x80, 0xFF, 0xFF, 0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x87, 0xC0, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10,
  0x18, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x03, 0xFF, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x18, 0x38, 0x2C, 0x64, 0x44, 0x46,
  0xC2, 0x83, 0xFF, 0xFF, 0xC0, 0xC8, 0x80, 0x0C, 0x1F, 0x98, 0x40, 0x30,
  0x19, 0xFD, 0x87, 0x83, 0xC1, 0xB1, 0xDF, 0x60, 0x80, 0x80, 0x80, 0x98,
  0xBE, 0xC2, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC6, 0xBC, 0x18, 0x7E,
  0xC2, 0x83, 0x80, 0x80, 0x80, 0x80, 0x83, 0xC6, 0x7C, 0x03, 0x03, 0x03,
  0x33, 0x7F, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC7, 0x7B, 0x38,
  0x7E, 0xC2, 0x83, 0x83, 0xFF, 0x80, 0x80, 0x83, 0xC6, 0x7C, 0x0F, 0x87,
  0xC6, 0x03, 0x01, 0x87, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x30, 0x7F, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC7, 0x7B,
  0x03, 0x03, 0x02, 0x7E, 0x80, 0x80, 0x80, 0x98, 0xBE, 0xC2, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x18, 0x18, 0x18, 0x00, 0x00, 0xF8,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x04, 0x1C, 0x10,
  0x00, 0x1F, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0D,
  0xF0, 0x80, 0x80, 0x80, 0x80, 0x83, 0x86, 0x84, 0x8C, 0xF8, 0x8C, 0x8C,
  0x86, 0x82, 0x83, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x7C, 0x13, 0x7F, 0xF2, 0x39, 0x1C,
  0x8E, 0x47, 0x23, 0x91, 0xC8, 0xE4, 0x72, 0x20, 0x18, 0xBE, 0xC2, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x18, 0x7E, 0xC2, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0xC6, 0x7C, 0x18, 0xBE, 0xC2, 0x83, 0x83, 0x83,
  0x83, 0x83, 0xC3, 0xC6, 0xBC, 0x80, 0x80, 0x80, 0x30, 0x7F, 0xC3, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0xC7, 0x7B, 0x03, 0x03, 0x03, 0x1C, 0xFE,
  0xC3, 0xC3, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x38, 0x7E, 0xC3,
  0xC0, 0xC0, 0x7C, 0x06, 0x03, 0x83, 0xC3, 0x7E, 0x18, 0x0C, 0x06, 0x1F,
  0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xF8, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC2, 0xC6, 0x7C, 0xC1, 0xA0, 0xD8,
  0x4C, 0x62, 0x31, 0x90, 0x58, 0x2C, 0x1C, 0x06, 0x00, 0x8C, 0xE3, 0x2D,
  0x4B, 0x52, 0x54, 0x95, 0x65, 0x31, 0x4C, 0x63, 0x18, 0xC0, 0xE1, 0x91,
  0x8D, 0x83, 0x80, 0xC0, 0xE0, 0xD8, 0x46, 0x61, 0x60, 0xC0, 0xC1, 0xB0,
  0xD8, 0x44, 0x63, 0x20, 0x90, 0x58, 0x38, 0x0C, 0x06, 0x02, 0x03, 0x03,
  0x00, 0xFE, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x40, 0x80, 0xFF, 0x07,
  0x0F, 0x08, 0x18, 0x08, 0x08, 0x08, 0x08, 0xF8, 0xF0, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x0C, 0x07, 0xFF, 0xFF, 0xC0, 0xC0, 0xF0, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x1F, 0x1F, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0xE0, 0x20, 0xBC, 0x73, 0x38, 0xE0,
};

const GFXglyph JetBrainsMono_Light19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 5, 6, 11, 3, -14 },
  { 11, 10, 14, 11, 1, -14 },
  { 29, 9, 20, 11, 1, -17 },
  { 52, 11, 14, 11, 0, -14 },
  { 72, 10, 14, 11, 1, -14 },
  { 90, 1, 6, 11, 5, -14 },
  { 91, 5, 18, 11, 4, -16 },
  { 103, 6, 18, 11, 2, -16 },
  { 117, 10, 10, 11, 1, -12 },
  { 130, 9, 9, 11, 1, -11 },
  { 141, 4, 6, 11, 3, -3 },
  { 144, 6, 1, 11, 3, -7 },
  { 145, 3, 3, 11, 4, -3 },
  { 147, 8, 18, 11, 2, -16 },
  { 165, 8, 14, 11, 2, -14 },
  { 179, 8, 14, 11, 2, -14 },
  { 193, 9, 14, 11, 1, -14 },
  { 209, 9, 14, 11, 1, -14 },
  { 225, 7, 14, 11, 2, -14 },
  { 238, 8, 14, 11, 2, -14 },
  { 252, 9, 14, 11, 1, -14 },
  { 268, 8, 14, 11, 2, -14 },
  { 282, 8, 14, 11, 2, -14 },
  { 296, 9, 14, 11, 1, -14 },
  { 312, 3, 11, 11, 4, -11 },
  { 317, 4, 14, 11, 3, -11 },
  { 324, 8, 10, 11, 2, -11 },
  { 334, 8, 6, 11, 2, -9 },
  { 340, 8, 10, 11, 2, -11 },
  { 350, 6, 14, 11, 3, -14 },
  { 361, 10, 17, 11, 1, -14 },
  { 383, 9, 14, 11, 1, -14 },
  { 399, 8, 14, 11, 2, -14 },
  { 413, 8, 14, 11, 2, -14 },
  { 427, 8, 14, 11, 2, -14 },
  { 441, 8, 14, 11, 2, -14 },
  { 455, 8, 14, 11, 2, -14 },
  { 469, 8, 14, 11, 2, -14 },
  { 483, 8, 14, 11, 2, -14 },
  { 497, 7, 14, 11, 2, -14 },
  { 510, 8, 14, 11, 1, -14 },
  { 524, 9, 14, 11, 2, -14 },
  { 540, 8, 14, 11, 2, -14 },
  { 554, 8, 14, 11, 2, -14 },
  { 568, 8, 14, 11, 2, -14 },
  { 582, 8, 14, 11, 2, -14 },
  { 596, 8, 14, 11, 2, -14 },
  { 610, 8, 17, 11, 2, -14 },
  { 627, 8, 14, 11, 2, -14 },
  { 641, 9, 14, 11, 1, -14 },
  { 657, 9, 14, 11, 1, -14 },
  { 673, 8, 14, 11, 2, -14 },
  { 687, 9, 14, 11, 1, -14 },
  { 703, 10, 14, 11, 1, -14 },
  { 721, 10, 14, 11, 1, -14 },
  { 739, 10, 14, 11, 1, -14 },
  { 757, 8, 14, 11, 2, -14 },
  { 771, 5, 18, 11, 4, -16 },
  { 783, 8, 18, 11, 2, -16 },
  { 801, 4, 18, 11, 3, -16 },
  { 810, 8, 8, 11, 2, -14 },
  { 818, 9, 2, 11, 1, 0 },
  { 821, 3, 3, 11, 4, -15 },
  { 823, 9, 11, 11, 1, -11 },
  { 836, 8, 14, 11, 2, -14 },
  { 850, 8, 11, 11, 2, -11 },
  { 861, 8, 14, 11, 2, -14 },
  { 875, 8, 11, 11, 2, -11 },
  { 886, 9, 14, 11, 1, -14 },
  { 902, 8, 14, 11, 2, -11 },
  { 916, 8, 14, 11, 2, -14 },
  { 930, 8, 15, 11, 2, -15 },
  { 945, 7, 18, 11, 2, -15 },
  { 961, 8, 14, 11, 2, -14 },
  { 975, 9, 14, 11, 1, -14 },
  { 991, 9, 11, 11, 1, -11 },
  { 1004, 8, 11, 11, 2, -11 },
  { 1015, 8, 11, 11, 2, -11 },
  { 1026, 8, 14, 11, 2, -11 },
  { 1040, 8, 14, 11, 2, -11 },
  { 1054, 8, 11, 11, 2, -11 },
  { 1065, 8, 11, 11, 2, -11 },
  { 1076, 9, 13, 11, 1, -13 },
  { 1091, 8, 10, 11, 2, -10 },
  { 1101, 9, 10, 11, 1, -10 },
  { 1113, 10, 10, 11, 1, -10 },
  { 1126, 9, 10, 11, 1, -10 },
  { 1138, 9, 13, 11, 1, -10 },
  { 1153, 8, 10, 11, 2, -10 },
  { 1163, 8, 18, 11, 2, -16 },
  { 1181, 1, 18, 11, 5, -16 },
  { 1184, 8, 18, 11, 2, -16 },
  { 1202, 9, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_Light19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_LIGHT19PT7B_H_
