#ifndef _JETBRAINSMONO_LIGHT65PT7B_H_
#define _JETBRAINSMONO_LIGHT65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light65pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F,
  0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x1E, 0x3F,
  0x87, 0xF0, 0xF0, 0xFC, 0x3F, 0x07, 0x83, 0xF1, 0xF0, 0x3C, 0x1F, 0x9F,
  0x81, 0xE0, 0x7C, 0xF8, 0x0F, 0x03, 0xE7, 0xC0, 0x78, 0x1F, 0x3E, 0x03,
  0xC0, 0xF9, 0xF8, 0x1E, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7E, 0x07, 0x80,
  0x01, 0xF8, 0x3C, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x3F, 0x0F, 0x00, 0x01,
  0xFE, 0x78, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7B, 0xFC, 0x00, 0x03, 0xC7, 0xF0,
  0x00, 0x1E, 0x1F, 0xC0, 0x00, 0xF0, 0x7E, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x3C, 0x0F, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78,
  0x0F, 0xFC, 0x03, 0xC0, 0x7F, 0xE0, 0x1E, 0x03, 0xFF, 0x00, 0xF0, 0x1F,
  0xFC, 0x07, 0x81, 0xFB, 0xE0, 0x3C, 0x0F, 0x9F, 0x81, 0xE0, 0xFC, 0x7F,
  0x0F, 0x0F, 0xC3, 0xFE, 0x79, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x08, 0x7F,
  0xE0, 0x00, 0x07, 0x87, 0xFF, 0xC0, 0x00, 0x7C, 0x7F, 0xFE, 0x00, 0x03,
  0xC7, 0xE1, 0xF8, 0x00, 0x3C, 0x3E, 0x03, 0xC0, 0x03, 0xE1, 0xE0, 0x1F,
  0x00, 0x1E, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0x1E, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x07, 0x80,
  0xF0, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x78, 0x03, 0xE0,
  0x0F, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x07, 0xC3, 0xC0,
  0x03, 0xF0, 0x7C, 0x3C, 0x00, 0x0F, 0xFF, 0xE3, 0xE0, 0x00, 0x3F, 0xFE,
  0x1E, 0x00, 0x00, 0xFF, 0xE1, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x83, 0xFE, 0x00, 0x00, 0x7C, 0x3F, 0xFC, 0x00, 0x03, 0xC3, 0xFF,
  0xF0, 0x00, 0x3C, 0x3F, 0xFF, 0xC0, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0x1E,
  0x1F, 0x00, 0xF0, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0x7C, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x1F, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x07, 0xC3, 0xC0, 0x07, 0xC0,
  0x3C, 0x3C, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x00, 0xFF, 0xFE, 0x1E, 0x00,
  0x03, 0xFF, 0xF1, 0xE0, 0x00, 0x0F, 0xFF, 0x1F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xBF,
  0x07, 0xE0, 0x0F, 0x9F, 0x01, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0x07, 0xC7,
  0xC0, 0x3F, 0x07, 0xE3, 0xE0, 0x0F, 0xC3, 0xE1, 0xF0, 0x03, 0xF3, 0xE0,
  0xF8, 0x00, 0xF9, 0xF0, 0x7C, 0x00, 0x7F, 0xF0, 0x3E, 0x00, 0x1F, 0xF8,
  0x1F, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F,
  0xE0, 0x7E, 0x00, 0x3F, 0xF8, 0x1F, 0x80, 0x3F, 0x7E, 0x0F, 0xE0, 0x7F,
  0x1F, 0x03, 0xFF, 0xFF, 0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0xFF,
  0x00, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x07, 0xC0, 0x06, 0x3F, 0x00, 0xF8, 0x07, 0xE7, 0xFC,
  0x0E, 0x07, 0xFC, 0xFF, 0xE1, 0xC3, 0xFF, 0xBF, 0xFF, 0x39, 0xFF, 0xF8,
  0xFF, 0xF7, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xC7,
  0xF0, 0x10, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xDF, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x60,
  0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0x83, 0xF8, 0x3F,
  0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8,
  0x0E, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x7C,
  0x00, 0x0F, 0xF3, 0xE0, 0x00, 0xFF, 0x1F, 0x00, 0x1F, 0xE0, 0xF8, 0x00,
  0xFE, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xC0,
  0x0F, 0x80, 0x08, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xDF, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07,
  0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0xF0, 0x0F, 0x8F,
  0xFF, 0x81, 0xF7, 0xFF, 0xF8, 0x3E, 0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0xF8,
  0xFF, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7C, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF0, 0xFF,
  0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF3, 0xFE, 0x00, 0x3F, 0x7F, 0xFC, 0x01, 0xF7, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xDF, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7E,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xDF, 0x80, 0x1F, 0xFC, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xF3,
  0xFE, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF9, 0xFF, 0x1F, 0xC0, 0xC0, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x04, 0x0F, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0x00,
  0x3F, 0xFE, 0xFF, 0x80, 0x3F, 0x87, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0xE0,
  0x1F, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x1F, 0xF8, 0x07, 0x80, 0x0F, 0xFC,
  0x03, 0xC0, 0x07, 0xFE, 0x01, 0xE0, 0x03, 0xFF, 0x00, 0xF0, 0x01, 0xFF,
  0x80, 0x78, 0x00, 0xFF, 0xC0, 0x3C, 0x00, 0x7F, 0xE0, 0x1E, 0x00, 0x3F,
  0xF0, 0x0F, 0x00, 0x1F, 0xF8, 0x07, 0x80, 0x0F, 0xFC, 0x03, 0xC0, 0x07,
  0xFE, 0x01, 0xE0, 0x03, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x7C, 0x00,
  0xFF, 0xC0, 0x3E, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0xC0,
  0x3F, 0xF8, 0x03, 0xFC, 0xF7, 0xFC, 0x00, 0xFF, 0xFB, 0xFE, 0x00, 0x3F,
  0xF9, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x01, 0xFC,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x03, 0xF8, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x0F, 0xEF, 0x80, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x1F, 0xF1, 0xF0, 0x00, 0xFF,
  0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFE, 0xF8, 0x00, 0x3F, 0x9F, 0x00,
  0x0F, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x78, 0x00, 0xFF, 0xFB, 0xC0, 0x07, 0xBF,
  0xDE, 0x00, 0x3D, 0xFE, 0x78, 0x03, 0xEF, 0xF3, 0xC0, 0x1E, 0x7F, 0x9E,
  0x00, 0xF3, 0xFE, 0x78, 0x0F, 0x9F, 0xF3, 0xC0, 0x79, 0xFF, 0x9E, 0x03,
  0xCF, 0xFC, 0x78, 0x3E, 0x7F, 0xE3, 0xC1, 0xE3, 0xFF, 0x1E, 0x0F, 0x1F,
  0xF8, 0x78, 0xF8, 0xFF, 0xC3, 0xC7, 0x87, 0xFE, 0x1E, 0x3C, 0x3F, 0xF0,
  0x7B, 0xE1, 0xFF, 0x83, 0xDE, 0x0F, 0xFC, 0x1E, 0xF0, 0x7F, 0xE0, 0x7F,
  0x83, 0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0x7E, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xC0, 0x03, 0xFF,
  0x7C, 0x00, 0x7F, 0xE7, 0x80, 0x0F, 0xFC, 0xF0, 0x01, 0xFF, 0x9F, 0x00,
  0x3F, 0xF1, 0xE0, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0xC7, 0xC0, 0x1F, 0xF8,
  0x78, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xE1, 0xF0, 0x0F, 0xFC, 0x1E, 0x01,
  0xFF, 0x83, 0xE0, 0x3F, 0xF0, 0x3C, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0,
  0xF8, 0x1F, 0xF8, 0x0F, 0x03, 0xFF, 0x01, 0xF0, 0x7F, 0xE0, 0x3E, 0x0F,
  0xFC, 0x03, 0xC1, 0xFF, 0x80, 0x7C, 0x3F, 0xF0, 0x0F, 0x87, 0xFE, 0x00,
  0xF0, 0xFF, 0xC0, 0x1F, 0x1F, 0xF8, 0x01, 0xE3, 0xFF, 0x00, 0x3E, 0x7F,
  0xE0, 0x07, 0xCF, 0xFC, 0x00, 0x79, 0xFF, 0x80, 0x0F, 0xBF, 0xF0, 0x01,
  0xF7, 0xFE, 0x00, 0x1E, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x03, 0xFE,
  0x7C, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F, 0x7C, 0x00,
  0x07, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xFC, 0x7C, 0x00, 0x0F,
  0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFE, 0x7C, 0x00, 0x3F, 0xE3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x7C, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3E,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFF, 0x01, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x01,
  0xFF, 0x80, 0x3B, 0x80, 0x3E, 0xF0, 0x07, 0x70, 0x07, 0x9F, 0x00, 0xEE,
  0x00, 0xF3, 0xE0, 0x1D, 0xC0, 0x1E, 0x7C, 0x03, 0xB8, 0x07, 0xCF, 0x80,
  0x77, 0x80, 0xF9, 0xF0, 0x1E, 0xF0, 0x1F, 0x3E, 0x03, 0xCE, 0x03, 0xE7,
  0xC0, 0x79, 0xC0, 0x7C, 0x78, 0x0E, 0x38, 0x0F, 0x0F, 0x01, 0xC7, 0x01,
  0xE1, 0xF0, 0x38, 0xE0, 0x3C, 0x3E, 0x07, 0x1C, 0x07, 0x87, 0xC0, 0xE3,
  0xC1, 0xF0, 0xF8, 0x3C, 0x78, 0x3E, 0x1F, 0x07, 0x87, 0x07, 0xC3, 0xE0,
  0xF0, 0xE0, 0xF8, 0x7C, 0x1C, 0x1C, 0x1F, 0x07, 0x83, 0x83, 0x83, 0xC0,
  0xF0, 0x70, 0x70, 0x78, 0x1E, 0x0E, 0x0E, 0x0F, 0x03, 0xE1, 0xC1, 0xE1,
  0xE0, 0x7C, 0x78, 0x3C, 0x7C, 0x0F, 0x8F, 0x03, 0x8F, 0x81, 0xF1, 0xC0,
  0x71, 0xF0, 0x3E, 0x38, 0x0E, 0x3E, 0x03, 0xC7, 0x01, 0xC7, 0x80, 0x78,
  0xE0, 0x38, 0xF0, 0x0F, 0x1C, 0x07, 0x1E, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x3E, 0xF0, 0x1E, 0x78, 0x07, 0xDE, 0x03, 0xDF, 0x00, 0xFB, 0x80, 0x3B,
  0xE0, 0x1F, 0x70, 0x07, 0x7C, 0x03, 0xEE, 0x00, 0xEF, 0x00, 0x3D, 0xC0,
  0x1D, 0xE0, 0x07, 0xB8, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x03, 0xDF,
  0x3F, 0xFF, 0xFD, 0xF3, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF, 0xF1, 0xF0, 0x7F,
  0xFC, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0x87,
  0xFF, 0xC1, 0xF1, 0xFF, 0xFC, 0x3E, 0x7F, 0xFF, 0xC7, 0xDF, 0x07, 0xFC,
  0xFB, 0x80, 0x1F, 0xDF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x7E, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0xFE, 0x00, 0x0F,
  0xDF, 0x60, 0x03, 0xFB, 0xEF, 0x01, 0xFE, 0x7C, 0xFF, 0xFF, 0x8F, 0x9F,
  0xFF, 0xE1, 0xF1, 0xFF, 0xF8, 0x3E, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xFE, 0x03, 0xFC,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xC1, 0xF0, 0x7F, 0xFC,
  0x3E, 0x1F, 0xFF, 0xC7, 0xC7, 0xFF, 0xFC, 0xF9, 0xFE, 0x07, 0xDF, 0x7F,
  0x00, 0x3B, 0xEF, 0xC0, 0x03, 0xFD, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF,
  0xE0, 0x03, 0x7C, 0xFF, 0x01, 0xEF, 0x8F, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF,
  0x3E, 0x0F, 0xFF, 0xC7, 0xC0, 0xFF, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFC, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xE0,
  0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xE0, 0xFF,
  0xF8, 0x7C, 0x3F, 0xFF, 0xCF, 0x8F, 0xFF, 0xF9, 0xF3, 0xFE, 0x0F, 0xBE,
  0x7E, 0x00, 0x77, 0xDF, 0x80, 0x07, 0xFB, 0xF0, 0x00, 0x7F, 0x7C, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x0D, 0xF3, 0xFC, 0x07, 0xBE, 0x3F, 0xFF, 0xE7,
  0xC3, 0xFF, 0xFC, 0xF8, 0x3F, 0xFF, 0x1F, 0x03, 0xFF, 0x83, 0xE0, 0x07,
  0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x1F, 0xF8, 0x0F, 0x87, 0xFF, 0xC1, 0xF3, 0xFF, 0xFC,
  0x3E, 0x7F, 0xFF, 0xC7, 0xDE, 0x03, 0xFC, 0xFB, 0x80, 0x1F, 0x9F, 0xE0,
  0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0xF8,
  0xFE, 0x0F, 0xE1, 0xF3, 0xFE, 0x3F, 0xE3, 0xEF, 0xFC, 0xFF, 0xE7, 0xDF,
  0xFD, 0xFF, 0xCF, 0xE0, 0xFA, 0x0F, 0xDF, 0x80, 0xF8, 0x0F, 0xBF, 0x01,
  0xF0, 0x1F, 0x7C, 0x03, 0xE0, 0x1E, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F,
  0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C,
  0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0,
  0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00,
  0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07,
  0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F,
  0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF,
  0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC,
  0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0,
  0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x3F, 0xF0, 0x1F, 0x0F,
  0xFF, 0x83, 0xE7, 0xFF, 0xF8, 0x7C, 0xFF, 0xFF, 0x8F, 0xBE, 0x0F, 0xF9,
  0xF7, 0x00, 0x3F, 0x3F, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0xF8, 0x3F, 0xF0, 0x1F, 0x0F, 0xFF, 0x83, 0xE3, 0xFF, 0xF8,
  0x7C, 0xFF, 0xFF, 0x8F, 0xBE, 0x07, 0xF9, 0xF7, 0x00, 0x3F, 0xBF, 0xC0,
  0x03, 0xF7, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7D, 0xFC, 0x00, 0x1F, 0xBE, 0xC0, 0x07, 0xF7, 0xDE,
  0x03, 0xFC, 0xF9, 0xFF, 0xFF, 0x1F, 0x3F, 0xFF, 0xC3, 0xE3, 0xFF, 0xF0,
  0x7C, 0x1F, 0xFC, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xE0,
  0xFF, 0xF8, 0x7C, 0x3F, 0xFF, 0x8F, 0x8F, 0xFF, 0xF9, 0xF3, 0xFE, 0x0F,
  0xBE, 0x7E, 0x00, 0x77, 0xDF, 0x80, 0x07, 0xFB, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x1F, 0xDF, 0xC0, 0x06, 0xF9, 0xFE, 0x03, 0xDF, 0x1F, 0xFF, 0xF3, 0xE1,
  0xFF, 0xFE, 0x7C, 0x1F, 0xFF, 0x8F, 0x81, 0xFF, 0xC1, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0x8F, 0xFF, 0x83, 0xF3, 0xFF, 0xF8,
  0x7E, 0xFF, 0xFF, 0x8F, 0xFE, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xF8, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x77, 0x00, 0xFF, 0xC0, 0x3B, 0x80, 0x7D, 0xE0, 0x1D, 0xC0,
  0x3C, 0xF0, 0x0E, 0xE0, 0x1E, 0x78, 0x07, 0x70, 0x0F, 0x3E, 0x07, 0xBC,
  0x07, 0x9F, 0x03, 0xCE, 0x07, 0xCF, 0x81, 0xC7, 0x03, 0xE3, 0xC0, 0xE3,
  0x81, 0xE1, 0xE0, 0x71, 0xC0, 0xF0, 0xF0, 0x38, 0xE0, 0x78, 0x78, 0x3C,
  0x78, 0x3C, 0x3E, 0x1E, 0x3C, 0x1E, 0x1F, 0x0E, 0x0E, 0x1F, 0x0F, 0x87,
  0x07, 0x0F, 0x03, 0xC3, 0x83, 0x87, 0x81, 0xE1, 0xC1, 0xC3, 0xC0, 0xF1,
  0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x3E, 0x70, 0x1C, 0xF8, 0x1F,
  0x38, 0x0E, 0x78, 0x07, 0x9C, 0x07, 0x3C, 0x03, 0xCE, 0x03, 0x9E, 0x01,
  0xEF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF7, 0x80, 0x7B, 0x80, 0x3B, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x79, 0xFF, 0xC0, 0x03, 0xDF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xC3, 0xF0, 0x07, 0xFC, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F,
  0x03, 0xFE, 0x00, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xBC, 0x00, 0x3F, 0xF9, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00,
};

const GFXglyph JetBrainsMono_Light65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 9, 47, 39, 15, -47 },
  { 54, 19, 19, 39, 10, -47 },
  { 100, 35, 47, 39, 2, -47 },
  { 306, 29, 66, 39, 5, -57 },
  { 546, 37, 48, 39, 1, -48 },
  { 768, 33, 49, 39, 4, -48 },
  { 971, 6, 19, 39, 16, -47 },
  { 986, 20, 63, 39, 12, -55 },
  { 1144, 20, 63, 39, 7, -55 },
  { 1302, 35, 34, 39, 2, -40 },
  { 1451, 31, 31, 39, 4, -37 },
  { 1572, 13, 20, 39, 11, -10 },
  { 1605, 21, 5, 39, 9, -24 },
  { 1619, 11, 11, 39, 14, -10 },
  { 1635, 29, 61, 39, 5, -54 },
  { 1857, 29, 49, 39, 5, -48 },
  { 2035, 29, 47, 39, 6, -47 },
  { 2206, 29, 48, 39, 5, -48 },
  { 2380, 28, 48, 39, 5, -47 },
  { 2548, 26, 47, 39, 6, -47 },
  { 2701, 27, 48, 39, 6, -47 },
  { 2863, 29, 48, 39, 5, -47 },
  { 3037, 30, 47, 39, 5, -47 },
  { 3214, 29, 49, 39, 5, -48 },
  { 3392, 29, 48, 39, 5, -48 },
  { 3566, 11, 37, 39, 14, -36 },
  { 3617, 14, 46, 39, 11, -36 },
  { 3698, 27, 34, 39, 6, -38 },
  { 3813, 27, 20, 39, 6, -31 },
  { 3881, 27, 34, 39, 6, -38 },
  { 3996, 23, 47, 39, 9, -47 },
  { 4132, 33, 60, 39, 3, -48 },
  { 4380, 31, 47, 39, 4, -47 },
  { 4563, 28, 47, 39, 6, -47 },
  { 4728, 28, 49, 39, 6, -48 },
  { 4900, 27, 47, 39, 6, -47 },
  { 5059, 27, 47, 39, 7, -47 },
  { 5218, 28, 48, 39, 6, -48 },
  { 5386, 28, 49, 39, 6, -48 },
  { 5558, 27, 47, 39, 6, -47 },
  { 5717, 25, 47, 39, 7, -47 },
  { 5864, 29, 48, 39, 3, -47 },
  { 6038, 30, 47, 39, 6, -47 },
  { 6215, 27, 47, 39, 8, -47 },
  { 6374, 29, 47, 39, 5, -47 },
  { 6545, 27, 47, 39, 6, -47 },
  { 6704, 27, 49, 39, 6, -48 },
  { 6870, 29, 47, 39, 6, -47 },
  { 7041, 28, 60, 39, 6, -48 },
  { 7251, 29, 47, 39, 6, -47 },
  { 7422, 29, 49, 39, 5, -48 },
  { 7600, 31, 48, 39, 4, -48 },
  { 7786, 27, 48, 39, 6, -47 },
  { 7948, 31, 47, 39, 4, -47 },
  { 8131, 35, 47, 39, 2, -47 },
  { 8337, 33, 47, 39, 3, -47 },
  { 8531, 33, 47, 39, 3, -47 },
  { 8725, 27, 47, 39, 6, -47 },
  { 8884, 15, 61, 39, 14, -54 },
  { 8999, 29, 61, 39, 5, -54 },
  { 9221, 15, 61, 39, 10, -54 },
  { 9336, 27, 25, 39, 6, -47 },
  { 9421, 31, 4, 39, 4, 2 },
  { 9437, 13, 9, 39, 12, -51 },
  { 9452, 28, 37, 39, 5, -36 },
  { 9582, 27, 48, 39, 6, -47 },
  { 9744, 27, 37, 39, 6, -36 },
  { 9869, 27, 48, 39, 6, -47 },
  { 10031, 27, 37, 39, 6, -36 },
  { 10156, 31, 47, 39, 4, -47 },
  { 10339, 27, 48, 39, 6, -36 },
  { 10501, 27, 47, 39, 6, -47 },
  { 10660, 30, 50, 39, 6, -50 },
  { 10848, 24, 62, 39, 6, -50 },
  { 11034, 30, 47, 39, 6, -47 },
  { 11211, 34, 47, 39, 2, -47 },
  { 11411, 31, 36, 39, 4, -36 },
  { 11551, 27, 36, 39, 6, -36 },
  { 11673, 27, 37, 39, 6, -36 },
  { 11798, 27, 48, 39, 6, -36 },
  { 11960, 27, 48, 39, 6, -36 },
  { 12122, 27, 36, 39, 7, -36 },
  { 12244, 28, 37, 39, 6, -36 },
  { 12374, 30, 46, 39, 4, -46 },
  { 12547, 27, 37, 39, 6, -36 },
  { 12672, 31, 36, 39, 4, -36 },
  { 12812, 33, 36, 39, 3, -36 },
  { 12961, 31, 36, 39, 4, -36 },
  { 13101, 31, 48, 39, 4, -36 },
  { 13287, 27, 36, 39, 6, -36 },
  { 13409, 27, 61, 39, 6, -54 },
  { 13615, 5, 61, 39, 17, -54 },
  { 13654, 27, 61, 39, 6, -54 },
  { 13860, 29, 13, 39, 5, -29 },
};

const GFXfont JetBrainsMono_Light65pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light65pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _JETBRAINSMONO_LIGHT65PT7B_H_
