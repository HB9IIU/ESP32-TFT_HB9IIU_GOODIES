#ifndef _JETBRAINSMONO_LIGHT56PT7B_H_
#define _JETBRAINSMONO_LIGHT56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x0E, 0xF0, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x03, 0x80,
  0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0xF0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xF8, 0xE7, 0xE1, 0xF0, 0x70, 0xF8, 0xF8, 0x38,
  0x7C, 0x78, 0x1C, 0x1F, 0x7C, 0x0E, 0x0F, 0xBE, 0x07, 0x07, 0xDF, 0x03,
  0x80, 0x0F, 0x81, 0xC0, 0x07, 0xC0, 0xE0, 0x01, 0xF0, 0x70, 0x00, 0xF8,
  0x38, 0x00, 0x7E, 0x1C, 0x00, 0x1F, 0xCE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1D, 0xFC, 0x00, 0x0E, 0x3F, 0x00, 0x07, 0x0F,
  0x80, 0x03, 0x83, 0xE0, 0x01, 0xC1, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x70,
  0x3F, 0xE0, 0x38, 0x1F, 0xF0, 0x1C, 0x0F, 0xF8, 0x0E, 0x07, 0xBC, 0x07,
  0x07, 0xDF, 0x03, 0x83, 0xEF, 0xC1, 0xC3, 0xE3, 0xF0, 0xE3, 0xF0, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0x1E, 0x3F, 0xFC, 0x00,
  0x3C, 0x7C, 0x7E, 0x00, 0x38, 0x78, 0x1E, 0x00, 0x78, 0xF0, 0x1E, 0x00,
  0xF0, 0xF0, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x01, 0xE0, 0xF0, 0x0E, 0x03,
  0xC0, 0xF0, 0x0E, 0x03, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0xF0, 0x0E, 0x0F,
  0x00, 0xF0, 0x0E, 0x1E, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x78, 0x3E, 0x3C,
  0x00, 0x7F, 0xFC, 0x78, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0x1F, 0xF0, 0xF0,
  0x00, 0x01, 0x81, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x0F,
  0xF0, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x1C, 0x7F, 0xFC, 0x00, 0x3C, 0x78,
  0x3E, 0x00, 0x78, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x0E, 0x00, 0xF0, 0xF0,
  0x0E, 0x01, 0xE0, 0xF0, 0x0E, 0x03, 0xC0, 0xF0, 0x0E, 0x03, 0x80, 0xF0,
  0x0E, 0x07, 0x80, 0xF0, 0x0E, 0x0F, 0x00, 0xF0, 0x0E, 0x0E, 0x00, 0xF0,
  0x1E, 0x1E, 0x00, 0x78, 0x1E, 0x3C, 0x00, 0x7C, 0x3E, 0x38, 0x00, 0x3F,
  0xFC, 0x78, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0,
  0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0xF8, 0x07, 0x9F, 0x03, 0xE0, 0x7C,
  0xF8, 0x0F, 0x83, 0xC7, 0xC0, 0x7C, 0x3E, 0x3E, 0x01, 0xF1, 0xE1, 0xF0,
  0x07, 0xDF, 0x0F, 0x80, 0x1F, 0xF0, 0x7C, 0x00, 0xFF, 0x03, 0xE0, 0x03,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x3F, 0xC0, 0xF8, 0x03, 0xFF, 0x07, 0xE0, 0x3E, 0xF8, 0x3F,
  0xFF, 0xE3, 0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xFF, 0xE0, 0x3E, 0x07, 0xFC,
  0x01, 0xF8, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xEF, 0x78, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x60, 0x07, 0x80, 0x31, 0xF0, 0x1E,
  0x03, 0xE7, 0xF8, 0x70, 0x7F, 0xBF, 0xF1, 0xC7, 0xFE, 0x7F, 0xF3, 0x7F,
  0xF4, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x08, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x38, 0x0F,
  0xF0, 0x7C, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F,
  0xF0, 0x7C, 0x0F, 0xF0, 0x18, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x3F, 0xC3, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0x7C, 0x01, 0xFC, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x30, 0x07, 0xC0, 0x10, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x3F, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3F,
  0x00, 0x7C, 0x1F, 0xE7, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x28, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8,
  0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x3F, 0x80,
  0x78, 0xFF, 0xE0, 0x79, 0xFF, 0xF0, 0x7B, 0xFF, 0xF8, 0x7F, 0x81, 0xFC,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x9F, 0xE0, 0x07, 0xDF, 0xFE, 0x01, 0xEF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x07, 0xFC, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7D,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78,
  0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F,
  0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0xFC, 0x3F, 0xEF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0x80, 0x7E,
  0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF8, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFE, 0xF8, 0x01, 0xFE, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x10, 0x0F, 0xC3,
  0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x1F,
  0x80, 0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0xF8, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x37,
  0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xE0, 0x0F, 0xF0, 0x1E, 0x00, 0xFF, 0x03,
  0xE0, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0x03, 0xE0, 0x0F, 0xF0, 0x3E, 0x00,
  0xFF, 0x03, 0xE0, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0x03, 0xE0, 0x0F, 0xF0,
  0x3E, 0x00, 0xFF, 0x03, 0xE0, 0x0F, 0xF0, 0x1E, 0x00, 0xFF, 0x01, 0xE0,
  0x0F, 0xF0, 0x1E, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0xCF, 0x7F,
  0x00, 0xFF, 0xE7, 0xF0, 0x07, 0xFE, 0x7F, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78,
  0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3C, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xFC, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8,
  0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x01, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F,
  0x00, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x80, 0x7F, 0x9F, 0x00, 0x1F, 0xBE, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0xEF, 0x80, 0x3F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F,
  0x00, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07,
  0xC3, 0xF0, 0x07, 0xE1, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xBF, 0xB8, 0x03, 0xDF, 0xDE, 0x01, 0xEF, 0xEF,
  0x00, 0xE7, 0xF3, 0x80, 0xF3, 0xF9, 0xE0, 0x7B, 0xFC, 0xF0, 0x39, 0xFE,
  0x38, 0x3C, 0xFF, 0x1E, 0x1E, 0x7F, 0x8F, 0x0E, 0x3F, 0xE3, 0x87, 0x1F,
  0xF1, 0xE7, 0x8F, 0xF8, 0xF3, 0x87, 0xFC, 0x39, 0xC3, 0xFE, 0x1F, 0xE1,
  0xFF, 0x0F, 0xE0, 0xFF, 0x83, 0xF0, 0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0xF8,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFD, 0xE0, 0x07, 0xFB, 0xC0, 0x0F, 0xF7, 0x80, 0x1F,
  0xE7, 0x80, 0x3F, 0xCF, 0x00, 0x7F, 0xCE, 0x00, 0xFF, 0x9E, 0x01, 0xFF,
  0x3C, 0x03, 0xFE, 0x3C, 0x07, 0xFC, 0x78, 0x0F, 0xF8, 0xF0, 0x1F, 0xF0,
  0xF0, 0x3F, 0xE1, 0xE0, 0x7F, 0xC3, 0xC0, 0xFF, 0x83, 0xC1, 0xFF, 0x07,
  0x83, 0xFE, 0x07, 0x87, 0xFC, 0x0F, 0x0F, 0xF8, 0x1E, 0x1F, 0xF0, 0x1E,
  0x3F, 0xE0, 0x3C, 0x7F, 0xC0, 0x78, 0xFF, 0x80, 0x79, 0xFF, 0x00, 0xF3,
  0xFE, 0x01, 0xE7, 0xFC, 0x01, 0xEF, 0xF8, 0x03, 0xDF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x0F, 0x9F, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xFD, 0xFF, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0xFE, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0,
  0x03, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x3F,
  0x00, 0xFC, 0x3F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x1F, 0xE7,
  0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xF0,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x01,
  0xF1, 0xF8, 0x01, 0xF8, 0x7F, 0xCF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x03, 0xE3, 0xF0,
  0x0F, 0xC3, 0xFC, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x7C,
  0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x7C,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x3F, 0xC0, 0x3E, 0x00, 0xFF,
  0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x7B, 0xC0,
  0x3F, 0x01, 0xEF, 0x80, 0xFC, 0x07, 0xBE, 0x03, 0x70, 0x1E, 0x78, 0x1D,
  0xC0, 0x79, 0xE0, 0x73, 0x01, 0xE7, 0x81, 0xCE, 0x07, 0x9E, 0x07, 0x38,
  0x1E, 0x78, 0x1C, 0xE0, 0x79, 0xE0, 0x73, 0x83, 0xC7, 0x81, 0xCE, 0x0F,
  0x1F, 0x06, 0x38, 0x3C, 0x3C, 0x38, 0xE0, 0xF0, 0xF0, 0xE1, 0x83, 0xC3,
  0xC3, 0x87, 0x0F, 0x0F, 0x0E, 0x1C, 0x3C, 0x3C, 0x38, 0x70, 0xF0, 0xF0,
  0xE1, 0xC3, 0x83, 0xC3, 0x87, 0x1E, 0x0F, 0x0C, 0x1C, 0x78, 0x3C, 0x70,
  0x71, 0xE0, 0x79, 0xC0, 0xC7, 0x81, 0xE7, 0x03, 0x1E, 0x07, 0x9C, 0x0E,
  0x78, 0x1E, 0x70, 0x39, 0xE0, 0x79, 0xC0, 0xE7, 0x01, 0xE6, 0x03, 0x9C,
  0x07, 0xB8, 0x0E, 0x70, 0x1E, 0xE0, 0x3B, 0xC0, 0x3B, 0x80, 0xEF, 0x00,
  0xFE, 0x01, 0xBC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1E, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x00,
  0x01, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x7C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3C,
  0x00, 0x1F, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7E, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7F,
  0x01, 0xEF, 0x3F, 0xFF, 0xCF, 0x1F, 0xFF, 0x8F, 0x07, 0xFF, 0x0F, 0x00,
  0x60, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0xF9,
  0xFF, 0xE0, 0xFB, 0xFF, 0xF8, 0xFB, 0xFF, 0xF8, 0xFF, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFE,
  0x00, 0x7E, 0xFF, 0x00, 0xFC, 0xFB, 0xC3, 0xFC, 0xFB, 0xFF, 0xF8, 0xF9,
  0xFF, 0xF0, 0xF8, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x3F, 0xEF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0xF8, 0x78, 0x7F, 0xF8, 0xF1, 0xFF, 0xF9, 0xE7, 0xFF, 0xFB,
  0xCF, 0xC0, 0x37, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x0D, 0xE7, 0xF8, 0x7B, 0xC7, 0xFF, 0xE7,
  0x87, 0xFF, 0xCF, 0x03, 0xFE, 0x1E, 0x00, 0x60, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC7, 0xF8, 0x3E, 0x00, 0xFC,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xFE, 0x1E, 0x1F, 0xFE, 0x3C, 0x7F, 0xFE, 0x79, 0xFF, 0xFE, 0xF3, 0xF0,
  0x0D, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xEF,
  0x00, 0x07, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x7F, 0x3F, 0x01, 0xDE, 0x3F,
  0xFF, 0xBC, 0x3F, 0xFE, 0x78, 0x3F, 0xF8, 0xF0, 0x1F, 0xC1, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE1, 0xFF, 0x07, 0xCF, 0xFF, 0x0F, 0xBF, 0xFF, 0x9F, 0x7C,
  0xFF, 0x3F, 0xC0, 0x3F, 0x7F, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xE7, 0x80, 0x03, 0xE3,
  0xC0, 0x03, 0xF1, 0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF0,
  0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x7C, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0xC0, 0xF0, 0x03, 0xE0, 0x78,
  0x00, 0xF8, 0x3C, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7,
  0x80, 0x03, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0x80, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0xF3, 0xF0, 0x7E, 0x3D, 0xFE, 0x3F,
  0xCF, 0xFF, 0xDF, 0xFB, 0xF1, 0xF6, 0x3E, 0xF8, 0x3E, 0x07, 0xBC, 0x07,
  0x81, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC,
  0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03,
  0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0,
  0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3C, 0xF8,
  0x7F, 0xC1, 0xF3, 0xFF, 0xC3, 0xEF, 0xFF, 0xE7, 0xDF, 0xFF, 0xCF, 0xF0,
  0x0F, 0xDF, 0xC0, 0x0F, 0xBF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x3F, 0xEF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0xF8, 0x7F, 0xC0, 0xF9, 0xFF, 0xE0, 0xFB,
  0xFF, 0xF8, 0xFB, 0xFF, 0xF8, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7E, 0xFF,
  0x00, 0xFC, 0xFB, 0xC3, 0xFC, 0xFB, 0xFF, 0xF8, 0xF9, 0xFF, 0xF0, 0xF8,
  0x7F, 0xC0, 0xF8, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x1E, 0x1F,
  0xFE, 0x3C, 0x7F, 0xFE, 0x79, 0xFF, 0xFE, 0xF3, 0xF0, 0x0D, 0xEF, 0x80,
  0x0F, 0xDF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0xF8,
  0x03, 0x79, 0xFE, 0x1E, 0xF1, 0xFF, 0xF9, 0xE1, 0xFF, 0xE3, 0xC1, 0xFF,
  0x87, 0x80, 0x18, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0xF8, 0x7F, 0xC0, 0xF9, 0xFF, 0xE0,
  0xFB, 0xFF, 0xF8, 0xFB, 0xE7, 0xF8, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3E,
  0x3F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0x80, 0x7C, 0x03, 0xDE, 0x03,
  0xE0, 0x1E, 0xF0, 0x1F, 0x00, 0xF7, 0x80, 0xFC, 0x07, 0xBC, 0x07, 0xE0,
  0x3D, 0xE0, 0x37, 0x01, 0xCF, 0x03, 0xB8, 0x1E, 0x38, 0x1C, 0xC0, 0xF1,
  0xE0, 0xE7, 0x07, 0x8F, 0x07, 0x38, 0x3C, 0x78, 0x39, 0xC1, 0xE3, 0xC1,
  0x8E, 0x0E, 0x1E, 0x1C, 0x70, 0x70, 0xF0, 0xE1, 0x87, 0x83, 0x87, 0x0E,
  0x3C, 0x1E, 0x38, 0x71, 0xE0, 0xF1, 0xC3, 0x8F, 0x07, 0x8C, 0x1C, 0x70,
  0x3C, 0xE0, 0xE3, 0x81, 0xE7, 0x07, 0x1C, 0x07, 0x38, 0x1D, 0xE0, 0x39,
  0xC0, 0xEF, 0x01, 0xEE, 0x07, 0x70, 0x0F, 0x60, 0x3B, 0x80, 0x7F, 0x01,
  0xDC, 0x03, 0xF8, 0x0E, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x01,
  0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x01,
  0xE0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3D, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x78,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xCF,
  0xFC, 0x01, 0xF7, 0xFF, 0x80, 0x7F, 0xF3, 0xF0, 0x1F, 0xF8, 0x7E, 0x07,
  0xFC, 0x0F, 0xC1, 0xFF, 0x01, 0xF8, 0x7B, 0xC0, 0x3F, 0xFE, 0xF0, 0x07,
  0xFF, 0x3C, 0x00, 0xFF, 0x8F, 0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_Light56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 8, 41, 34, 13, -41 },
  { 42, 16, 17, 34, 9, -41 },
  { 76, 30, 41, 34, 2, -41 },
  { 230, 25, 57, 34, 4, -49 },
  { 409, 32, 41, 34, 1, -41 },
  { 573, 29, 42, 34, 3, -41 },
  { 726, 5, 17, 34, 14, -41 },
  { 737, 16, 54, 34, 11, -47 },
  { 845, 17, 54, 34, 6, -47 },
  { 960, 30, 29, 34, 2, -34 },
  { 1069, 26, 27, 34, 4, -32 },
  { 1157, 11, 17, 34, 10, -8 },
  { 1181, 18, 3, 34, 8, -20 },
  { 1188, 9, 9, 34, 12, -8 },
  { 1199, 25, 52, 34, 4, -46 },
  { 1362, 24, 42, 34, 5, -41 },
  { 1488, 25, 41, 34, 5, -41 },
  { 1617, 26, 41, 34, 4, -41 },
  { 1751, 24, 42, 34, 4, -41 },
  { 1877, 23, 41, 34, 5, -41 },
  { 1995, 24, 42, 34, 5, -41 },
  { 2121, 26, 42, 34, 4, -41 },
  { 2258, 25, 41, 34, 5, -41 },
  { 2387, 24, 43, 34, 5, -42 },
  { 2516, 26, 41, 34, 4, -41 },
  { 2650, 9, 32, 34, 12, -31 },
  { 2686, 11, 40, 34, 10, -31 },
  { 2741, 24, 29, 34, 5, -33 },
  { 2828, 24, 17, 34, 5, -27 },
  { 2879, 24, 29, 34, 5, -33 },
  { 2966, 20, 41, 34, 8, -41 },
  { 3069, 28, 51, 34, 3, -41 },
  { 3248, 28, 41, 34, 3, -41 },
  { 3392, 24, 41, 34, 5, -41 },
  { 3515, 24, 42, 34, 5, -41 },
  { 3641, 23, 41, 34, 5, -41 },
  { 3759, 23, 41, 34, 6, -41 },
  { 3877, 23, 41, 34, 6, -41 },
  { 3995, 24, 42, 34, 5, -41 },
  { 4121, 23, 41, 34, 5, -41 },
  { 4239, 22, 41, 34, 6, -41 },
  { 4352, 25, 42, 34, 3, -41 },
  { 4484, 26, 41, 34, 5, -41 },
  { 4618, 24, 41, 34, 6, -41 },
  { 4741, 25, 41, 34, 4, -41 },
  { 4870, 23, 41, 34, 5, -41 },
  { 4988, 23, 42, 34, 5, -41 },
  { 5109, 26, 41, 34, 5, -41 },
  { 5243, 24, 51, 34, 5, -41 },
  { 5396, 25, 41, 34, 5, -41 },
  { 5525, 25, 43, 34, 4, -42 },
  { 5660, 27, 41, 34, 3, -41 },
  { 5799, 23, 42, 34, 5, -41 },
  { 5920, 28, 41, 34, 3, -41 },
  { 6064, 30, 41, 34, 2, -41 },
  { 6218, 29, 41, 34, 2, -41 },
  { 6367, 29, 41, 34, 2, -41 },
  { 6516, 24, 41, 34, 5, -41 },
  { 6639, 13, 52, 34, 12, -46 },
  { 6724, 25, 52, 34, 4, -46 },
  { 6887, 14, 52, 34, 8, -46 },
  { 6978, 24, 22, 34, 5, -41 },
  { 7044, 27, 4, 34, 3, 1 },
  { 7058, 12, 8, 34, 10, -44 },
  { 7070, 24, 32, 34, 4, -31 },
  { 7166, 24, 42, 34, 5, -41 },
  { 7292, 24, 32, 34, 5, -31 },
  { 7388, 23, 42, 34, 5, -41 },
  { 7509, 24, 32, 34, 5, -31 },
  { 7605, 26, 41, 34, 4, -41 },
  { 7739, 23, 41, 34, 5, -31 },
  { 7857, 23, 41, 34, 5, -41 },
  { 7975, 26, 43, 34, 5, -43 },
  { 8115, 20, 53, 34, 5, -43 },
  { 8248, 25, 41, 34, 6, -41 },
  { 8377, 29, 41, 34, 2, -41 },
  { 8526, 26, 31, 34, 4, -31 },
  { 8627, 23, 31, 34, 5, -31 },
  { 8717, 24, 32, 34, 5, -31 },
  { 8813, 24, 41, 34, 5, -31 },
  { 8936, 23, 41, 34, 5, -31 },
  { 9054, 24, 31, 34, 6, -31 },
  { 9147, 24, 32, 34, 5, -31 },
  { 9243, 26, 39, 34, 3, -39 },
  { 9370, 23, 32, 34, 5, -31 },
  { 9462, 27, 31, 34, 3, -31 },
  { 9567, 29, 31, 34, 2, -31 },
  { 9680, 27, 31, 34, 3, -31 },
  { 9785, 27, 41, 34, 3, -31 },
  { 9924, 23, 31, 34, 5, -31 },
  { 10014, 24, 52, 34, 5, -46 },
  { 10170, 4, 52, 34, 15, -46 },
  { 10196, 24, 52, 34, 5, -46 },
  { 10352, 26, 11, 34, 4, -25 },
};

const GFXfont JetBrainsMono_Light56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_LIGHT56PT7B_H_
