#ifndef _JETBRAINSMONO_LIGHT36PT7B_H_
#define _JETBRAINSMONO_LIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light36pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x18, 0xC6, 0x31,
  0x80, 0x00, 0x01, 0xFF, 0xFB, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1C, 0x01, 0x81, 0xC0, 0x30,
  0x30, 0x0E, 0x06, 0x01, 0xC0, 0xC0, 0x30, 0x38, 0x06, 0x06, 0x00, 0xC0,
  0xC1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0xC0, 0xE0, 0x18, 0x1C, 0x03, 0x03,
  0x00, 0x60, 0x60, 0x1C, 0x0C, 0x03, 0x83, 0x80, 0x60, 0x70, 0x0C, 0x0C,
  0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x0E, 0x06, 0x01, 0x81, 0xC0, 0x30, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0xC0, 0x38, 0x18, 0x06, 0x07, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x0F, 0xF0, 0x3F, 0xFC,
  0x79, 0x9E, 0x71, 0x8E, 0x71, 0x8E, 0xE1, 0x87, 0xE1, 0x80, 0xF1, 0x80,
  0x71, 0x80, 0x79, 0x80, 0x3D, 0x80, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0x9E, 0x01, 0x8E, 0x01, 0x87, 0x01, 0x87, 0xE1, 0x87,
  0xE1, 0x87, 0xE1, 0x87, 0xF1, 0x8E, 0x7D, 0xBE, 0x3F, 0xFC, 0x0F, 0xF0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0x00,
  0x7F, 0xF8, 0x0E, 0xE1, 0x80, 0xCC, 0x18, 0x18, 0xC1, 0xC3, 0x8C, 0x1C,
  0x30, 0xC1, 0xC6, 0x0C, 0x18, 0xE0, 0xE1, 0x8C, 0x0F, 0xF9, 0x80, 0x7F,
  0x38, 0x00, 0x83, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC7, 0x80,
  0x19, 0xFE, 0x03, 0x9C, 0xE0, 0x73, 0x87, 0x06, 0x30, 0x70, 0xC3, 0x07,
  0x1C, 0x30, 0x71, 0x83, 0x07, 0x30, 0x38, 0x77, 0x03, 0x86, 0x60, 0x1F,
  0xEC, 0x00, 0xFC, 0x03, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xF0, 0xF0,
  0x38, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0x38,
  0x1F, 0x87, 0x0E, 0xE1, 0xE3, 0xB8, 0x39, 0xCE, 0x07, 0x73, 0x80, 0xF8,
  0xE0, 0x3E, 0x38, 0x07, 0x0E, 0x03, 0xE3, 0xC1, 0xFC, 0x78, 0xF7, 0x9F,
  0xF8, 0xE1, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0xF0,
  0x7C, 0x3C, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xF0,
  0x1F, 0x03, 0xC0, 0x30, 0xC0, 0x1E, 0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x87, 0xE0,
  0xF8, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x80, 0xC0, 0x9E, 0x18, 0x7F, 0xF3, 0x3F, 0x3F, 0xDF,
  0xC0, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0xD8, 0x00, 0x3B, 0x80, 0x0F, 0x38,
  0x01, 0xC7, 0x80, 0x70, 0x78, 0x1E, 0x07, 0x81, 0x80, 0xE0, 0x10, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x1E, 0x7C, 0xF1, 0xE3, 0x8F, 0x1C, 0x38, 0x71, 0xC3, 0x80,
  0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x78, 0x3C, 0x70,
  0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE3, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE1, 0x87, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xF0,
  0x0E, 0x70, 0x1E, 0x7C, 0x3C, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1E, 0xC0, 0x7C, 0xC0, 0xF0, 0xC0, 0xE0, 0xC0, 0xC0, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x78, 0x3C, 0xF0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF8, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x07, 0x3E, 0x3E, 0x3F, 0xF8, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x73, 0x80, 0xEF, 0x01, 0xDC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x7F, 0xFE, 0xFF,
  0xFD, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xEF, 0xE1, 0xFF, 0xE3, 0xE3, 0xE7, 0x81, 0xEE, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xDC, 0x07, 0xBE, 0x1E, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3B, 0xF0, 0x77, 0xFC, 0x7C, 0x3C,
  0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x1E, 0x7C, 0x7C, 0x3F, 0xF8,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC,
  0x78, 0x3C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x60, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x38, 0x1C, 0x1C, 0x78, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0,
  0x3C, 0x38, 0x78, 0x1C, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x7C, 0x3C, 0x3F, 0xF8, 0x0F, 0xF0,
  0x01, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x78, 0x3C, 0x70, 0x0E, 0xE0, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0E, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xBC, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0xDE, 0x1E, 0x3F, 0x3F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x60, 0xE0, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0xFF, 0x87, 0xFE, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE1, 0xFE, 0x0F, 0xE0, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xF0, 0x1C, 0x78, 0x03, 0x9C, 0x00, 0x6E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xCF, 0x07, 0xFB, 0xC1, 0xC1,
  0xF0, 0x60, 0x7C, 0x18, 0x1F, 0x06, 0x07, 0xC1, 0x81, 0xF0, 0x60, 0x7C,
  0x18, 0x1F, 0x06, 0x07, 0xC1, 0x81, 0xF0, 0x70, 0x7C, 0x1E, 0x3F, 0x03,
  0xFB, 0xC0, 0x7C, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0x70, 0x01, 0xCC, 0x00,
  0x73, 0x00, 0x1C, 0xE0, 0x06, 0x38, 0x03, 0x86, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x0C, 0x1C, 0x07, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0xC7,
  0x00, 0x39, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0xFF, 0xE1, 0xFF,
  0xE3, 0x03, 0xE6, 0x01, 0xEC, 0x01, 0xD8, 0x03, 0xB0, 0x07, 0x60, 0x0E,
  0xC0, 0x1D, 0x80, 0x3B, 0x01, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFF, 0x30,
  0x0F, 0x60, 0x0E, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xB0, 0x0F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x80, 0x01, 0x80,
  0x0F, 0xF0, 0x3F, 0xFC, 0x78, 0x3C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x06,
  0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x3C, 0x3C,
  0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0x83, 0xF7, 0x00, 0xEE,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0x7F,
  0xFC, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x3F,
  0xFC, 0x78, 0x3C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1,
  0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F,
  0xF0, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x70, 0x1E, 0x7C, 0x3C, 0x3F, 0xF8, 0x0F,
  0xF0, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38,
  0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0x83, 0x81, 0xC1, 0xE0, 0xE0,
  0x70, 0x70, 0x3C, 0x38, 0x0E, 0x1C, 0x07, 0x8E, 0x01, 0xC7, 0x00, 0xF3,
  0x80, 0x39, 0xC0, 0x1E, 0xE0, 0x07, 0x70, 0x03, 0xC0, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1B, 0xD8, 0x1B, 0xD8, 0x3F, 0xDC, 0x37, 0xCC, 0x37,
  0xCC, 0x77, 0xCE, 0x67, 0xE6, 0x67, 0xE6, 0xE7, 0xE7, 0xC7, 0xE3, 0xC7,
  0xE3, 0xC7, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFD,
  0x81, 0xFB, 0x83, 0xF3, 0x07, 0xE6, 0x0F, 0xCE, 0x1F, 0x8C, 0x3F, 0x1C,
  0x7E, 0x38, 0xFC, 0x31, 0xF8, 0x73, 0xF0, 0xE7, 0xE0, 0xCF, 0xC1, 0xDF,
  0x81, 0xBF, 0x03, 0xBE, 0x07, 0x7C, 0x06, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01,
  0xEE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xDC, 0x03, 0xB8, 0x0F,
  0x3C, 0x3C, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x38, 0x0F,
  0x9C, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3,
  0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x78, 0x3C, 0x70, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06,
  0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06,
  0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0x70, 0x0E,
  0x70, 0x1E, 0x3C, 0x3C, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFC,
  0xE0, 0x3E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07,
  0x03, 0x80, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E,
  0xE0, 0x06, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0E,
  0x7C, 0x3E, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x76, 0x00, 0xEE, 0x01, 0xDC, 0x07,
  0x1E, 0x1E, 0x3F, 0xF8, 0x1F, 0xE0, 0xE0, 0x01, 0xF8, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x0E, 0x70, 0x07, 0x0C, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C,
  0x38, 0x0E, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x03,
  0x07, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0E, 0x38, 0x01, 0x8E, 0x00, 0x73,
  0x80, 0x1C, 0xC0, 0x07, 0x70, 0x00, 0xDC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x06, 0xE0, 0xF0,
  0x6E, 0x0F, 0x0E, 0x60, 0xF0, 0xE6, 0x0B, 0x0E, 0x61, 0xB0, 0xE7, 0x19,
  0x0E, 0x71, 0x90, 0xE7, 0x19, 0x8C, 0x71, 0x98, 0xC7, 0x19, 0x8C, 0x31,
  0x98, 0xC3, 0x11, 0x9C, 0x33, 0x19, 0xC3, 0x31, 0x9C, 0x3B, 0x09, 0xC3,
  0xB0, 0xD8, 0x3B, 0x0D, 0x83, 0xB0, 0xD8, 0x3B, 0x0D, 0x81, 0xA0, 0xD8,
  0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0xF0, 0x03,
  0xDC, 0x01, 0xE3, 0x80, 0x70, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x00,
  0xE1, 0xC0, 0x38, 0xE0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0D, 0xC0, 0x07, 0x38,
  0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x0E, 0x0E, 0x03, 0xC3,
  0x80, 0x71, 0xC0, 0x1E, 0xF0, 0x03, 0xB8, 0x00, 0x70, 0xF0, 0x00, 0xEE,
  0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x30, 0x07, 0x0E, 0x00, 0xE1, 0x80, 0x0E, 0x70, 0x01,
  0xCC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0x60, 0x0C, 0x70, 0x1C, 0x30, 0x1C,
  0x38, 0x38, 0x18, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x0E, 0x60, 0x0E, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xF9, 0xF3, 0x80, 0xF7, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x7F, 0xFD, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x7D, 0xFF, 0xB9, 0xFE,
  0x70, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0xFC, 0x77, 0xFC, 0xEE, 0x7D, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xF6, 0x1E, 0xEF, 0xF9,
  0xCF, 0xE0, 0x0F, 0xE0, 0x3F, 0xF0, 0xF9, 0xF3, 0xC0, 0xF7, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xB8, 0x07, 0x70, 0x1E, 0x78, 0x78,
  0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC3, 0xF3, 0x9F, 0xF7, 0x7E, 0x7E, 0xE0, 0x3D, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xBE,
  0x1F, 0x3F, 0xEE, 0x3F, 0x9C, 0x0F, 0xE0, 0x3F, 0xF0, 0xF1, 0xF3, 0x80,
  0xE7, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x07, 0x70,
  0x0E, 0x78, 0x78, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x0F, 0xCE, 0x7F, 0xDC, 0xF9, 0xFB, 0xC0, 0xF7, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xBC, 0x1F, 0x3F, 0xFE, 0x3F,
  0xDC, 0x1C, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x1F, 0xFC, 0x3F, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0xFC, 0x77, 0xFC, 0xEC, 0x7D, 0xF0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x00, 0xF0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x3C, 0xFF, 0xC7, 0xFC,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x0F, 0xC0, 0x1E, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x78, 0xC0,
  0x70, 0xC0, 0xE0, 0xC1, 0xE0, 0xC1, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xC1,
  0xC0, 0xC0, 0xE0, 0xC0, 0xF0, 0xC0, 0x70, 0xC0, 0x78, 0xC0, 0x3C, 0xC0,
  0x1C, 0xC0, 0x1E, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0xEF, 0x9E, 0x77, 0xDF, 0xBC,
  0x78, 0xFC, 0x38, 0x7E, 0x0C, 0x3F, 0x06, 0x1F, 0x83, 0x0F, 0xC1, 0x87,
  0xE0, 0xC3, 0xF0, 0x61, 0xF8, 0x30, 0xFC, 0x18, 0x7E, 0x0C, 0x3F, 0x06,
  0x1F, 0x83, 0x0F, 0xC1, 0x87, 0xE0, 0xC3, 0xF0, 0x61, 0xF8, 0x30, 0xFC,
  0x18, 0x70, 0xE3, 0xF1, 0xDF, 0xF3, 0xB9, 0xF7, 0xC0, 0xFF, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x70, 0x0F, 0xE0, 0x3F, 0xF0, 0xFB, 0xF3, 0xC0, 0xE7,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x07, 0x70, 0x1E,
  0x78, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0xE3, 0xF1, 0xDF, 0xF3, 0xB9, 0xF7,
  0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0xD8, 0x7B, 0xBF, 0xE7, 0x3F, 0x8E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0xCE, 0x7F, 0xDC, 0xF9,
  0xFB, 0x80, 0xF7, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8,
  0x07, 0x70, 0x1E, 0xF8, 0x7C, 0xFF, 0xB8, 0xFE, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0xE7, 0xE1, 0xDF, 0xF3,
  0xF1, 0xF7, 0x80, 0xEF, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0xFC, 0x7E, 0x7E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xD8, 0x03,
  0xB8, 0x07, 0x70, 0x1C, 0x78, 0x78, 0x7F, 0xE0, 0x7F, 0x80, 0xE0, 0x03,
  0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0,
  0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0xE1, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x03, 0x70, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0xE0, 0xE0, 0x6C, 0x1C, 0x0D, 0x83, 0xC3,
  0xB0, 0x78, 0x77, 0x0B, 0x0C, 0xE1, 0x61, 0x9C, 0x6C, 0x31, 0x8C, 0x86,
  0x31, 0x99, 0xC6, 0x33, 0x38, 0xC4, 0x66, 0x1C, 0x8C, 0xC3, 0xB1, 0x98,
  0x36, 0x13, 0x06, 0xC3, 0x60, 0xD8, 0x7C, 0x1A, 0x0F, 0x03, 0x41, 0xE0,
  0x78, 0x3C, 0x07, 0x03, 0x80, 0xF0, 0x03, 0x9E, 0x01, 0xC3, 0x80, 0xF0,
  0x70, 0x38, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0x73, 0x80, 0x1F, 0xC0, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x01, 0xCE,
  0x00, 0xE1, 0xC0, 0x70, 0x70, 0x3C, 0x0E, 0x0E, 0x01, 0xC7, 0x00, 0x7B,
  0xC0, 0x0F, 0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x1C, 0x07, 0x0E, 0x03,
  0x87, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xFF,
  0x07, 0xE7, 0x87, 0xC3, 0xC7, 0xC1, 0xFF, 0xC0, 0xFE, 0xC0, 0x3C,
};

const GFXglyph JetBrainsMono_Light36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 5, 26, 22, 8, -26 },
  { 18, 10, 11, 22, 6, -26 },
  { 32, 19, 26, 22, 1, -26 },
  { 94, 16, 36, 22, 3, -31 },
  { 166, 20, 26, 22, 1, -26 },
  { 231, 18, 27, 22, 2, -27 },
  { 292, 3, 11, 22, 9, -26 },
  { 297, 10, 34, 22, 7, -30 },
  { 340, 11, 34, 22, 4, -30 },
  { 387, 19, 19, 22, 1, -22 },
  { 433, 17, 17, 22, 2, -20 },
  { 470, 7, 11, 22, 6, -5 },
  { 480, 12, 2, 22, 5, -13 },
  { 483, 6, 5, 22, 8, -5 },
  { 487, 16, 34, 22, 3, -30 },
  { 555, 16, 27, 22, 3, -27 },
  { 609, 16, 26, 22, 3, -26 },
  { 661, 16, 27, 22, 3, -27 },
  { 715, 15, 26, 22, 3, -26 },
  { 764, 15, 26, 22, 3, -26 },
  { 813, 15, 26, 22, 3, -26 },
  { 862, 16, 26, 22, 3, -26 },
  { 914, 16, 26, 22, 3, -26 },
  { 966, 16, 27, 22, 3, -27 },
  { 1020, 16, 27, 22, 3, -27 },
  { 1074, 6, 20, 22, 8, -20 },
  { 1089, 8, 26, 22, 6, -20 },
  { 1115, 16, 19, 22, 3, -21 },
  { 1153, 15, 11, 22, 3, -17 },
  { 1174, 16, 19, 22, 3, -21 },
  { 1212, 13, 26, 22, 5, -26 },
  { 1255, 18, 33, 22, 2, -27 },
  { 1330, 18, 26, 22, 2, -26 },
  { 1389, 15, 26, 22, 4, -26 },
  { 1438, 16, 27, 22, 3, -27 },
  { 1492, 15, 26, 22, 3, -26 },
  { 1541, 15, 26, 22, 4, -26 },
  { 1590, 15, 26, 22, 4, -26 },
  { 1639, 16, 27, 22, 3, -27 },
  { 1693, 14, 26, 22, 4, -26 },
  { 1739, 14, 26, 22, 4, -26 },
  { 1785, 16, 26, 22, 2, -26 },
  { 1837, 17, 26, 22, 3, -26 },
  { 1893, 15, 26, 22, 4, -26 },
  { 1942, 16, 26, 22, 3, -26 },
  { 1994, 15, 26, 22, 3, -26 },
  { 2043, 15, 27, 22, 3, -27 },
  { 2094, 17, 26, 22, 3, -26 },
  { 2150, 16, 33, 22, 3, -27 },
  { 2216, 16, 26, 22, 3, -26 },
  { 2268, 16, 27, 22, 3, -27 },
  { 2322, 18, 26, 22, 2, -26 },
  { 2381, 15, 26, 22, 3, -26 },
  { 2430, 18, 26, 22, 2, -26 },
  { 2489, 20, 26, 22, 1, -26 },
  { 2554, 18, 26, 22, 2, -26 },
  { 2613, 19, 26, 22, 1, -26 },
  { 2675, 15, 26, 22, 3, -26 },
  { 2724, 8, 34, 22, 8, -30 },
  { 2758, 16, 34, 22, 3, -30 },
  { 2826, 9, 34, 22, 5, -30 },
  { 2865, 16, 14, 22, 3, -26 },
  { 2893, 17, 2, 22, 2, 1 },
  { 2898, 7, 5, 22, 7, -28 },
  { 2903, 15, 20, 22, 3, -20 },
  { 2941, 15, 26, 22, 3, -26 },
  { 2990, 15, 20, 22, 3, -20 },
  { 3028, 15, 26, 22, 3, -26 },
  { 3077, 15, 20, 22, 3, -20 },
  { 3115, 17, 26, 22, 2, -26 },
  { 3171, 15, 26, 22, 3, -20 },
  { 3220, 15, 26, 22, 3, -26 },
  { 3269, 17, 28, 22, 3, -28 },
  { 3329, 13, 34, 22, 3, -28 },
  { 3385, 16, 26, 22, 4, -26 },
  { 3437, 19, 26, 22, 1, -26 },
  { 3499, 17, 20, 22, 2, -20 },
  { 3542, 15, 20, 22, 3, -20 },
  { 3580, 15, 20, 22, 3, -20 },
  { 3618, 15, 26, 22, 3, -20 },
  { 3667, 15, 26, 22, 3, -20 },
  { 3716, 15, 20, 22, 4, -20 },
  { 3754, 16, 20, 22, 3, -20 },
  { 3794, 17, 25, 22, 2, -25 },
  { 3848, 15, 20, 22, 3, -20 },
  { 3886, 17, 20, 22, 2, -20 },
  { 3929, 19, 20, 22, 1, -20 },
  { 3977, 18, 20, 22, 2, -20 },
  { 4022, 17, 26, 22, 2, -20 },
  { 4078, 15, 20, 22, 3, -20 },
  { 4116, 15, 34, 22, 3, -30 },
  { 4180, 3, 34, 22, 9, -30 },
  { 4193, 15, 34, 22, 3, -30 },
  { 4257, 16, 7, 22, 3, -16 },
};

const GFXfont JetBrainsMono_Light36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_LIGHT36PT7B_H_
