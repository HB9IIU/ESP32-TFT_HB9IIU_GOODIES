#ifndef _JETBRAINSMONO_LIGHT9PT7B_H_
#define _JETBRAINSMONO_LIGHT9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x29, 0x5E, 0xAF, 0xA9, 0x40, 0x46, 0xDC, 0x65,
  0xDE, 0x40, 0x4D, 0x6C, 0xC3, 0xAE, 0x60, 0x4A, 0x8C, 0xDA, 0xD0, 0xE0,
  0x5A, 0xAA, 0x40, 0x88, 0x92, 0x4A, 0x80, 0x27, 0xC8, 0xA0, 0x44, 0xF4,
  0xC0, 0xE0, 0x80, 0x32, 0x24, 0x44, 0x88, 0x69, 0x9D, 0x99, 0xE0, 0x4C,
  0x44, 0x44, 0xF0, 0x69, 0x12, 0x44, 0xF0, 0xE2, 0x42, 0x19, 0xE0, 0x25,
  0x5B, 0xC8, 0xE8, 0x8E, 0x11, 0xE0, 0x24, 0x8E, 0x99, 0xE0, 0xF9, 0x22,
  0x24, 0x40, 0x69, 0x96, 0xB9, 0xE0, 0x69, 0x99, 0x62, 0x40, 0x88, 0x8C,
  0x3C, 0xC3, 0xFF, 0xC2, 0x3C, 0xC4, 0x94, 0x10, 0x32, 0x67, 0x5A, 0xD6,
  0x48, 0x30, 0x21, 0x0C, 0xA7, 0x26, 0x20, 0xE9, 0x9E, 0x99, 0xE0, 0x69,
  0x88, 0x89, 0xE0, 0xCA, 0x99, 0x99, 0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8,
  0x8E, 0x88, 0x80, 0x69, 0x88, 0xB9, 0xE0, 0x99, 0x9F, 0x99, 0x90, 0xE9,
  0x24, 0xB8, 0x31, 0x11, 0x19, 0x70, 0x9A, 0xAC, 0xAA, 0x90, 0x88, 0x88,
  0x88, 0xF0, 0x9B, 0xBD, 0x99, 0x90, 0x99, 0xDD, 0xDB, 0xB0, 0x69, 0x99,
  0x99, 0xE0, 0xE9, 0x9F, 0x88, 0x80, 0x69, 0x99, 0x99, 0xE2, 0x10, 0xE9,
  0x9E, 0xAA, 0x90, 0x69, 0x86, 0x19, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x80,
  0x99, 0x99, 0x99, 0xE0, 0x8A, 0x52, 0xA5, 0x18, 0x80, 0xAD, 0x6B, 0x55,
  0xAD, 0x40, 0x8A, 0x8C, 0x43, 0x2B, 0x20, 0x8A, 0x54, 0x62, 0x10, 0x80,
  0xF2, 0x24, 0x48, 0xF0, 0xEA, 0xAB, 0x88, 0x44, 0x42, 0x21, 0xE4, 0x92,
  0x4F, 0x46, 0xA9, 0xF0, 0x80, 0xE1, 0xF9, 0xF0, 0x88, 0xE9, 0x99, 0xE0,
  0xE9, 0x89, 0xE0, 0x11, 0xF9, 0x99, 0xF0, 0xE9, 0xF9, 0xE0, 0x34, 0xF4,
  0x44, 0x40, 0xF9, 0x99, 0x71, 0xE0, 0x88, 0xE9, 0x99, 0x90, 0x40, 0xC4,
  0x44, 0xF0, 0x23, 0x92, 0x49, 0xC0, 0x88, 0x9A, 0xCA, 0x90, 0xE1, 0x08,
  0x42, 0x10, 0xE0, 0xFD, 0xDD, 0xD0, 0xE9, 0x99, 0x90, 0xE9, 0x99, 0xE0,
  0xE9, 0x99, 0xE8, 0x80, 0xF9, 0x99, 0xF1, 0x10, 0xE9, 0x88, 0x80, 0xE9,
  0x61, 0xE0, 0x4F, 0x44, 0x47, 0x99, 0x99, 0xE0, 0x9A, 0xA6, 0x40, 0xAD,
  0x56, 0xA5, 0x00, 0x9A, 0x4A, 0x90, 0x9A, 0xA6, 0x44, 0x40, 0xE2, 0x48,
  0xF0, 0x34, 0x2C, 0x22, 0x43, 0xFF, 0xC4, 0x47, 0x44, 0x4C, 0xDA,
};

const GFXglyph JetBrainsMono_Light9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 7, 5, 2, -7 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 5, 1, -8 },
  { 14, 5, 7, 5, 0, -7 },
  { 19, 4, 7, 5, 1, -7 },
  { 23, 1, 3, 5, 2, -7 },
  { 24, 2, 9, 5, 2, -8 },
  { 27, 3, 9, 5, 1, -8 },
  { 31, 5, 4, 5, 0, -5 },
  { 34, 4, 4, 5, 1, -5 },
  { 36, 1, 2, 5, 2, -1 },
  { 37, 3, 1, 5, 1, -3 },
  { 38, 1, 1, 5, 2, -1 },
  { 39, 4, 8, 5, 1, -7 },
  { 43, 4, 7, 5, 1, -7 },
  { 47, 4, 7, 5, 1, -7 },
  { 51, 4, 7, 5, 1, -7 },
  { 55, 4, 7, 5, 1, -7 },
  { 59, 3, 7, 5, 1, -7 },
  { 62, 4, 7, 5, 1, -7 },
  { 66, 4, 7, 5, 1, -7 },
  { 70, 4, 7, 5, 1, -7 },
  { 74, 4, 7, 5, 1, -7 },
  { 78, 4, 7, 5, 1, -7 },
  { 82, 1, 5, 5, 2, -5 },
  { 83, 1, 6, 5, 2, -5 },
  { 84, 4, 4, 5, 1, -5 },
  { 86, 4, 2, 5, 1, -4 },
  { 87, 4, 4, 5, 1, -5 },
  { 89, 3, 7, 5, 1, -7 },
  { 92, 5, 9, 5, 0, -7 },
  { 98, 5, 7, 5, 0, -7 },
  { 103, 4, 7, 5, 1, -7 },
  { 107, 4, 7, 5, 1, -7 },
  { 111, 4, 7, 5, 1, -7 },
  { 115, 4, 7, 5, 1, -7 },
  { 119, 4, 7, 5, 1, -7 },
  { 123, 4, 7, 5, 1, -7 },
  { 127, 4, 7, 5, 1, -7 },
  { 131, 3, 7, 5, 1, -7 },
  { 134, 4, 7, 5, 0, -7 },
  { 138, 4, 7, 5, 1, -7 },
  { 142, 4, 7, 5, 1, -7 },
  { 146, 4, 7, 5, 1, -7 },
  { 150, 4, 7, 5, 1, -7 },
  { 154, 4, 7, 5, 1, -7 },
  { 158, 4, 7, 5, 1, -7 },
  { 162, 4, 9, 5, 1, -7 },
  { 167, 4, 7, 5, 1, -7 },
  { 171, 4, 7, 5, 1, -7 },
  { 175, 5, 7, 5, 0, -7 },
  { 180, 4, 7, 5, 1, -7 },
  { 184, 5, 7, 5, 0, -7 },
  { 189, 5, 7, 5, 0, -7 },
  { 194, 5, 7, 5, 0, -7 },
  { 199, 5, 7, 5, 0, -7 },
  { 204, 4, 7, 5, 1, -7 },
  { 208, 2, 8, 5, 2, -7 },
  { 210, 4, 8, 5, 1, -7 },
  { 214, 3, 8, 5, 1, -7 },
  { 217, 4, 4, 5, 1, -7 },
  { 219, 4, 1, 5, 1, 0 },
  { 220, 1, 1, 5, 2, -7 },
  { 221, 4, 5, 5, 1, -5 },
  { 224, 4, 7, 5, 1, -7 },
  { 228, 4, 5, 5, 1, -5 },
  { 231, 4, 7, 5, 1, -7 },
  { 235, 4, 5, 5, 1, -5 },
  { 238, 4, 7, 5, 1, -7 },
  { 242, 4, 7, 5, 1, -5 },
  { 246, 4, 7, 5, 1, -7 },
  { 250, 4, 7, 5, 1, -7 },
  { 254, 3, 9, 5, 1, -7 },
  { 258, 4, 7, 5, 1, -7 },
  { 262, 5, 7, 5, 0, -7 },
  { 267, 4, 5, 5, 1, -5 },
  { 270, 4, 5, 5, 1, -5 },
  { 273, 4, 5, 5, 1, -5 },
  { 276, 4, 7, 5, 1, -5 },
  { 280, 4, 7, 5, 1, -5 },
  { 284, 4, 5, 5, 1, -5 },
  { 287, 4, 5, 5, 1, -5 },
  { 290, 4, 6, 5, 1, -6 },
  { 293, 4, 5, 5, 1, -5 },
  { 296, 4, 5, 5, 1, -5 },
  { 299, 5, 5, 5, 0, -5 },
  { 303, 4, 5, 5, 1, -5 },
  { 306, 4, 7, 5, 1, -5 },
  { 310, 4, 5, 5, 1, -5 },
  { 313, 4, 8, 5, 1, -7 },
  { 317, 1, 8, 5, 2, -7 },
  { 318, 4, 8, 5, 1, -7 },
  { 322, 4, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_Light9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_LIGHT9PT7B_H_
