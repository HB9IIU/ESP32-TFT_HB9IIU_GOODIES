#ifndef _JETBRAINSMONO_LIGHT25PT7B_H_
#define _JETBRAINSMONO_LIGHT25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDA, 0x49, 0x24, 0x07, 0xFC, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0x80, 0x0C, 0x30, 0x61, 0x83, 0x08, 0x10, 0x40, 0x86, 0x3F,
  0xFC, 0x61, 0x83, 0x08, 0x18, 0x40, 0x86, 0x04, 0x31, 0xFF, 0xEF, 0xFF,
  0x18, 0x40, 0x82, 0x04, 0x30, 0x61, 0x83, 0x0C, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x03, 0xF8, 0xEB, 0x99, 0x3E, 0x23, 0xC4, 0x0C, 0x81, 0x90,
  0x3E, 0x01, 0xF0, 0x0F, 0x81, 0x30, 0x23, 0x04, 0x78, 0x8F, 0x11, 0xF2,
  0x77, 0xFC, 0x7F, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x7C, 0x0E, 0xCC,
  0x11, 0x08, 0x62, 0x11, 0x84, 0x22, 0x08, 0x4C, 0x1F, 0xB0, 0x1E, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x09, 0xE0, 0x36, 0x60, 0xC8, 0x43, 0x10, 0x84,
  0x21, 0x18, 0x42, 0x60, 0xFD, 0x80, 0xF0, 0x04, 0x00, 0xFC, 0x0E, 0x70,
  0x61, 0x83, 0x06, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x03, 0xE0, 0x19,
  0x87, 0x8E, 0x6C, 0x33, 0x60, 0xF3, 0x03, 0x18, 0x1C, 0x61, 0xE3, 0xF9,
  0x8F, 0x86, 0xFF, 0xFD, 0x90, 0x02, 0x1C, 0x71, 0x86, 0x0C, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x83, 0x03, 0x07,
  0x83, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0x61, 0x8F, 0x38, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x81, 0x04, 0x1F, 0x27, 0xBD, 0x78, 0x3E, 0x00, 0xA0,
  0x0D, 0x80, 0xEE, 0x0E, 0x30, 0x60, 0xC1, 0x04, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x41, 0xFF, 0xFF, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x39, 0xCC, 0xE7, 0x31, 0x98, 0xFF, 0xFF, 0xC0, 0x73, 0xBE,
  0xE0, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x04, 0x07,
  0xF1, 0xC7, 0x70, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC4, 0x79, 0xCF,
  0x39, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x60, 0xCF, 0xF8, 0xFE,
  0x00, 0x0E, 0x07, 0xC1, 0xD8, 0x73, 0x08, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF,
  0xFF, 0xFC, 0x04, 0x07, 0xF1, 0xC7, 0x70, 0x6C, 0x07, 0x80, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x03, 0x00, 0x7C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x80,
  0xF0, 0x37, 0x06, 0x7F, 0x87, 0xE0, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0xE3, 0x30, 0xD8, 0x3E, 0x0F, 0x03, 0xFF, 0xFF, 0xF0,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x7F, 0xCF, 0xF9, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1B, 0xC3, 0xFE, 0x60, 0xCC, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xF0, 0x1B, 0x06, 0x7F, 0xC7, 0xE0, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x7C, 0x7B, 0xDC, 0x1F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1B, 0x06, 0x7F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x3C, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x04, 0x07, 0xF1, 0xC7,
  0x30, 0x6C, 0x07, 0x80, 0xD8, 0x33, 0x06, 0x3B, 0x81, 0xC0, 0xEE, 0x30,
  0xEE, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xEF, 0xF8, 0xFE, 0x00, 0x04,
  0x07, 0xF1, 0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x6C,
  0x1D, 0xFF, 0x1F, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x00, 0x77, 0xDC, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xB8, 0x39,
  0xF3, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x31, 0xC7, 0x18, 0x63,
  0x00, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x30, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x18, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x0C, 0x00,
  0xFC, 0xFE, 0x07, 0x03, 0x03, 0x03, 0x03, 0x07, 0x7E, 0x7C, 0x60, 0x60,
  0x60, 0x00, 0x00, 0x70, 0x70, 0x70, 0x02, 0x00, 0xFE, 0x0E, 0x1C, 0xC0,
  0x66, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x7B, 0xC7, 0x3E, 0x30, 0xF1, 0x87,
  0x8C, 0x3C, 0x61, 0xE3, 0x0F, 0x18, 0x78, 0xC3, 0xC3, 0xFE, 0x04, 0x10,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x07, 0x00, 0x28,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x63, 0x03, 0x18, 0x18, 0xC0,
  0xC6, 0x0C, 0x18, 0x7F, 0xC3, 0xFE, 0x18, 0x31, 0x80, 0xCC, 0x06, 0x60,
  0x37, 0x01, 0xC0, 0xFF, 0x9F, 0xFB, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0,
  0x36, 0x0E, 0xFF, 0x18, 0x7B, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xFF, 0xDF, 0xE0, 0x04, 0x07, 0xF1, 0xC7, 0x30, 0x7C, 0x07, 0x80,
  0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x1F, 0x03, 0x60, 0xCF, 0xF8, 0x7E, 0x00, 0xFF, 0x1F, 0xF3, 0x03, 0x60,
  0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x36, 0x0E, 0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x04, 0x07, 0xF1, 0xC7,
  0x30, 0x7C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x1F, 0xE3,
  0xFC, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0x60, 0xCF, 0xF8, 0x7E, 0x00, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0C,
  0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0xFC,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x07, 0x80, 0xF8, 0x1B, 0x07, 0x7F, 0xC3, 0xF0, 0xC0, 0x7C,
  0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18, 0xC3, 0x0C, 0x70, 0xFE, 0x0C,
  0x70, 0xC3, 0x0C, 0x38, 0xC1, 0x8C, 0x1C, 0xC0, 0xCC, 0x0E, 0xC0, 0x6C,
  0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0,
  0xE0, 0xF4, 0x17, 0xC7, 0xF8, 0xFD, 0x17, 0xB6, 0xF6, 0xDE, 0x53, 0xCE,
  0x79, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0C, 0xE0, 0x7E, 0x0F, 0xC1, 0xE8, 0x3D, 0x87, 0xB0, 0xF3, 0x1E, 0x63,
  0xCC, 0x78, 0xCF, 0x19, 0xE1, 0x3C, 0x37, 0x86, 0xF0, 0x5E, 0x0F, 0xC1,
  0xF8, 0x1C, 0x04, 0x07, 0xF1, 0xC7, 0x30, 0x6C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0x60, 0xCF, 0xF8, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0xC0, 0x6C, 0x06, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC3, 0xEF, 0xF8, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x07, 0xF1, 0xC7,
  0x30, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x60, 0xCF, 0xF8, 0xFC, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0xFF, 0x8F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF8, 0xC3, 0x0C, 0x30, 0xC1,
  0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0xEC, 0x07, 0x04, 0x07, 0xF1, 0xC7,
  0x30, 0x7C, 0x07, 0x80, 0x18, 0x03, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x60, 0x06, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0xEF, 0xF8, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x33, 0x06, 0x7F, 0xC7, 0xE0, 0xE0, 0x3B, 0x01, 0x98, 0x0C, 0xC0,
  0x63, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x18, 0xC0, 0xC6, 0x06, 0x30,
  0x31, 0x80, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xA0, 0x07, 0x00, 0x38, 0x00,
  0xC7, 0x1E, 0x38, 0xF1, 0x47, 0x8A, 0x3C, 0x51, 0xE2, 0x8D, 0x14, 0x49,
  0xB2, 0x6D, 0xB3, 0x65, 0x9A, 0x2C, 0xD1, 0x66, 0x8B, 0x34, 0x59, 0xA2,
  0xC7, 0x1C, 0x38, 0xE1, 0x87, 0x00, 0xE0, 0x3B, 0x83, 0x8C, 0x18, 0x71,
  0x81, 0x8C, 0x06, 0xC0, 0x36, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x60,
  0x1B, 0x01, 0x8C, 0x0C, 0x60, 0xC1, 0x8E, 0x0E, 0x60, 0x37, 0x01, 0xC0,
  0xC0, 0x1B, 0x01, 0x98, 0x0C, 0x60, 0xC3, 0x06, 0x0C, 0x60, 0x63, 0x01,
  0xB0, 0x0D, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F,
  0xFF, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x3F, 0xFF, 0x0E, 0x01, 0xC0, 0x6C, 0x0D, 0x83, 0x18, 0x63,
  0x18, 0x33, 0x06, 0x40, 0x58, 0x0C, 0xFF, 0xF8, 0xC3, 0x1C, 0x70, 0x1F,
  0x07, 0xF9, 0x83, 0x70, 0x70, 0x06, 0x00, 0xCF, 0xFB, 0xFF, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7F, 0x36, 0xFC, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0xF1, 0xBF, 0xB8, 0x37, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF8, 0x1F, 0x06, 0xDB, 0xD9, 0xF0, 0x1F, 0x07, 0xF9, 0x83,
  0x70, 0x3C, 0x07, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x0F, 0x01, 0xB0,
  0x67, 0xFC, 0x3F, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x31, 0xE6, 0xFE,
  0xD8, 0x3F, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3B, 0x07, 0x7B, 0x67, 0xCC, 0x1F, 0x07, 0xF1, 0x83, 0x60, 0x7C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0xB0, 0x67, 0xBC, 0x3F,
  0x00, 0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xF8, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x1E, 0x6F, 0xED, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x1D, 0x83, 0xBF, 0xB3, 0xE6, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0xC7, 0xF0, 0xF8, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0xF1,
  0xBF, 0xB8, 0x37, 0x06, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0C, 0x0E, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0x81, 0xC0, 0x40, 0x00, 0x03, 0xFD, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x3B,
  0xF9, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x7C, 0x0E, 0xC0,
  0xCC, 0x18, 0xC3, 0x8C, 0x30, 0xFE, 0x0F, 0xF0, 0xC3, 0x0C, 0x38, 0xC1,
  0x8C, 0x0C, 0xC0, 0xEC, 0x07, 0xFC, 0x07, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0xB9,
  0xD7, 0xFF, 0x31, 0xE2, 0x3C, 0x47, 0x88, 0xF1, 0x1E, 0x23, 0xC4, 0x78,
  0x8F, 0x11, 0xE2, 0x3C, 0x47, 0x88, 0xC0, 0xCF, 0x1B, 0xFB, 0x83, 0x70,
  0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xC0, 0x1F, 0x07, 0xF1, 0x83, 0x70, 0x7C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x67, 0xFC, 0x3E, 0x00, 0xCF,
  0x1B, 0xFB, 0x83, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x81, 0xF0, 0x6D, 0xBD, 0x9F, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x00, 0x1E, 0x6F, 0xED, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xB0, 0x77, 0xB6, 0x7C, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0xDF, 0x3F, 0xEE, 0x1F, 0x03, 0xC0, 0xF0,
  0x3C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F,
  0x8F, 0xF9, 0x83, 0xB0, 0x06, 0x00, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xE0,
  0x0C, 0x01, 0xF0, 0x37, 0xFC, 0x7F, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D,
  0x83, 0x30, 0x67, 0xFC, 0x3E, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x66,
  0x0C, 0xC1, 0x8C, 0x61, 0x8C, 0x31, 0x83, 0x60, 0x6C, 0x0D, 0x80, 0xE0,
  0x1C, 0x00, 0xC7, 0x1E, 0x38, 0xF1, 0x47, 0x8A, 0x24, 0x51, 0x32, 0x89,
  0xB6, 0xCD, 0xB6, 0x68, 0xB3, 0x45, 0x0A, 0x28, 0x51, 0x43, 0x8E, 0x1C,
  0x70, 0x60, 0x31, 0x83, 0x0E, 0x18, 0x31, 0x80, 0xD8, 0x06, 0xC0, 0x1C,
  0x00, 0xE0, 0x0D, 0x80, 0x6C, 0x06, 0x30, 0x60, 0xC7, 0x07, 0x70, 0x1C,
  0xC0, 0x78, 0x0F, 0x81, 0xB0, 0x66, 0x0C, 0x63, 0x8C, 0x61, 0x8C, 0x1B,
  0x03, 0x60, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x7C, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x7E, 0x0F, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x70, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0xF0, 0x7E, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x3E,
  0x07, 0x00, 0x78, 0x7F, 0x8F, 0x19, 0xE3, 0xFC, 0x18,
};

const GFXglyph JetBrainsMono_Light25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 18, 15, 6, -18 },
  { 8, 7, 7, 15, 4, -18 },
  { 15, 13, 18, 15, 1, -18 },
  { 45, 11, 26, 15, 2, -22 },
  { 81, 15, 18, 15, 0, -18 },
  { 115, 13, 19, 15, 1, -19 },
  { 146, 3, 7, 15, 6, -18 },
  { 149, 7, 24, 15, 5, -21 },
  { 170, 7, 24, 15, 3, -21 },
  { 191, 13, 13, 15, 1, -15 },
  { 213, 11, 12, 15, 2, -14 },
  { 230, 5, 8, 15, 4, -4 },
  { 235, 9, 2, 15, 3, -9 },
  { 238, 5, 4, 15, 5, -4 },
  { 241, 11, 24, 15, 2, -21 },
  { 274, 11, 19, 15, 2, -19 },
  { 301, 11, 18, 15, 2, -18 },
  { 326, 11, 19, 15, 2, -19 },
  { 353, 11, 18, 15, 2, -18 },
  { 378, 10, 18, 15, 2, -18 },
  { 401, 11, 18, 15, 2, -18 },
  { 426, 11, 18, 15, 2, -18 },
  { 451, 11, 18, 15, 2, -18 },
  { 476, 11, 19, 15, 2, -19 },
  { 503, 11, 19, 15, 2, -19 },
  { 530, 5, 14, 15, 5, -14 },
  { 539, 6, 18, 15, 4, -14 },
  { 553, 11, 13, 15, 2, -15 },
  { 571, 11, 8, 15, 2, -12 },
  { 582, 11, 13, 15, 2, -15 },
  { 600, 8, 18, 15, 4, -18 },
  { 618, 13, 24, 15, 1, -19 },
  { 657, 13, 18, 15, 1, -18 },
  { 687, 11, 18, 15, 2, -18 },
  { 712, 11, 19, 15, 2, -19 },
  { 739, 11, 18, 15, 2, -18 },
  { 764, 10, 18, 15, 3, -18 },
  { 787, 11, 18, 15, 2, -18 },
  { 812, 11, 19, 15, 2, -19 },
  { 839, 11, 18, 15, 2, -18 },
  { 864, 9, 18, 15, 3, -18 },
  { 885, 11, 18, 15, 1, -18 },
  { 910, 12, 18, 15, 2, -18 },
  { 937, 10, 18, 15, 3, -18 },
  { 960, 11, 18, 15, 2, -18 },
  { 985, 11, 18, 15, 2, -18 },
  { 1010, 11, 19, 15, 2, -19 },
  { 1037, 12, 18, 15, 2, -18 },
  { 1064, 11, 24, 15, 2, -19 },
  { 1097, 12, 18, 15, 2, -18 },
  { 1124, 11, 19, 15, 2, -19 },
  { 1151, 13, 18, 15, 1, -18 },
  { 1181, 11, 18, 15, 2, -18 },
  { 1206, 13, 18, 15, 1, -18 },
  { 1236, 13, 18, 15, 1, -18 },
  { 1266, 13, 18, 15, 1, -18 },
  { 1296, 13, 18, 15, 1, -18 },
  { 1326, 11, 18, 15, 2, -18 },
  { 1351, 6, 24, 15, 5, -21 },
  { 1369, 11, 24, 15, 2, -21 },
  { 1402, 6, 24, 15, 4, -21 },
  { 1420, 11, 10, 15, 2, -18 },
  { 1434, 13, 1, 15, 1, 1 },
  { 1436, 5, 4, 15, 5, -20 },
  { 1439, 11, 14, 15, 2, -14 },
  { 1459, 11, 18, 15, 2, -18 },
  { 1484, 11, 14, 15, 2, -14 },
  { 1504, 11, 18, 15, 2, -18 },
  { 1529, 11, 14, 15, 2, -14 },
  { 1549, 11, 18, 15, 2, -18 },
  { 1574, 11, 19, 15, 2, -14 },
  { 1601, 11, 18, 15, 2, -18 },
  { 1626, 12, 19, 15, 2, -19 },
  { 1655, 9, 24, 15, 2, -19 },
  { 1682, 12, 18, 15, 2, -18 },
  { 1709, 13, 18, 15, 1, -18 },
  { 1739, 11, 14, 15, 2, -14 },
  { 1759, 11, 14, 15, 2, -14 },
  { 1779, 11, 14, 15, 2, -14 },
  { 1799, 11, 19, 15, 2, -14 },
  { 1826, 11, 19, 15, 2, -14 },
  { 1853, 10, 14, 15, 3, -14 },
  { 1871, 11, 14, 15, 2, -14 },
  { 1891, 12, 18, 15, 1, -18 },
  { 1918, 11, 14, 15, 2, -14 },
  { 1938, 11, 14, 15, 2, -14 },
  { 1958, 13, 14, 15, 1, -14 },
  { 1981, 13, 14, 15, 1, -14 },
  { 2004, 11, 19, 15, 2, -14 },
  { 2031, 11, 14, 15, 2, -14 },
  { 2051, 11, 24, 15, 2, -21 },
  { 2084, 3, 24, 15, 6, -21 },
  { 2093, 11, 24, 15, 2, -21 },
  { 2126, 11, 5, 15, 2, -11 },
};

const GFXfont JetBrainsMono_Light25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_LIGHT25PT7B_H_
