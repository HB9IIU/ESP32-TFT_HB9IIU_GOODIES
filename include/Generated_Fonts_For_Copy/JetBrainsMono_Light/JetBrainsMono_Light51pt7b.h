#ifndef _JETBRAINSMONO_LIGHT51PT7B_H_
#define _JETBRAINSMONO_LIGHT51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0xFD, 0xFF, 0xFF, 0xF7, 0xC0, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0x77, 0x80, 0xEF, 0x01, 0xDE, 0x03,
  0xBC, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0,
  0x3C, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x3C, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x78,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00,
  0xF0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0xFC, 0xE7, 0xE1, 0xF1, 0xC7, 0xC7, 0xC3, 0x87, 0xCF, 0x07, 0x07,
  0x9E, 0x0E, 0x0F, 0x3C, 0x1C, 0x1E, 0x78, 0x38, 0x00, 0xF0, 0x70, 0x01,
  0xE0, 0xE0, 0x03, 0xE1, 0xC0, 0x03, 0xE3, 0x80, 0x07, 0xE7, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0x9F, 0x80, 0x07, 0x0F, 0x80, 0x0E,
  0x1F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x3F, 0xC0, 0xE0,
  0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x83, 0xFF, 0x07, 0x07, 0x9E, 0x0E, 0x1F,
  0x3E, 0x1C, 0x7E, 0x3F, 0xBB, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x79, 0xFF, 0x80, 0x07, 0x9F, 0xFE, 0x00, 0x38, 0xE0, 0x70,
  0x03, 0x8F, 0x03, 0xC0, 0x3C, 0x70, 0x1E, 0x03, 0xC3, 0x80, 0x70, 0x1C,
  0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x1E, 0x07, 0x00, 0xE0, 0xE0, 0x38,
  0x0F, 0x0E, 0x01, 0xE0, 0x78, 0xF0, 0x0F, 0x03, 0x87, 0x00, 0x3F, 0xFC,
  0x70, 0x00, 0xFF, 0xC7, 0x80, 0x03, 0xFC, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x3F, 0xE0, 0x00, 0xE3, 0xFF, 0x80, 0x0E,
  0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0xF0, 0x07, 0x0E, 0x03, 0x80, 0x70, 0x70,
  0x1E, 0x07, 0x83, 0x80, 0xF0, 0x38, 0x1C, 0x07, 0x83, 0x80, 0xE0, 0x3C,
  0x3C, 0x07, 0x01, 0xE1, 0xC0, 0x38, 0x0E, 0x1C, 0x01, 0xC0, 0x71, 0xE0,
  0x0F, 0x07, 0x8E, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0xFF, 0xCF, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x78, 0xF8, 0x07, 0xBC, 0x1F,
  0x03, 0xCF, 0x03, 0xC0, 0xF3, 0xC0, 0x78, 0x78, 0xF0, 0x1F, 0x1E, 0x3C,
  0x03, 0xEF, 0x0F, 0x00, 0x7F, 0xC3, 0xC0, 0x0F, 0xE0, 0xF0, 0x03, 0xF8,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xE0, 0xF0, 0x03,
  0xFC, 0x3E, 0x01, 0xFF, 0x87, 0xE1, 0xF9, 0xE0, 0xFF, 0xFC, 0x7C, 0x3F,
  0xFE, 0x0F, 0x83, 0xFE, 0x01, 0xF0, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x0F,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x00,
  0x06, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x02, 0x00, 0xF0, 0x02,
  0x78, 0x0E, 0x03, 0xDF, 0xC1, 0xC3, 0xFB, 0xFE, 0x39, 0xFF, 0xBF, 0xF6,
  0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x3C, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7E, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x03,
  0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x30, 0x3F, 0xC1, 0xF0, 0xFF, 0x0F, 0xC3,
  0xFC, 0x3F, 0x0F, 0xF0, 0x7C, 0x3F, 0xC1, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1F,
  0x7C, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x3C, 0x01, 0xF8, 0xF0,
  0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x3C, 0x02, 0x00, 0xF0, 0x08,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xF0, 0x3F, 0x0F, 0x80, 0x1F, 0x1E, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xEF, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xFC,
  0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0xF8, 0x03,
  0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0xFF, 0x83, 0xCF, 0xFF, 0x1E, 0xFF, 0xFC, 0xFF, 0x07, 0xE7,
  0xE0, 0x0F, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0x1E, 0x7C, 0x01, 0xF3, 0xF0, 0x3F, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xCF, 0xC0, 0x0F, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7F, 0x9F, 0xE1, 0xF8,
  0x07, 0xE3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7F, 0x07, 0xE0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x03,
  0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE1, 0xE0,
  0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0xCF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x7E, 0x0F, 0x83, 0xE0, 0x1F, 0x0F,
  0x00, 0x3E, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x7D, 0xF8, 0x03, 0xE3, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0xF9,
  0xF0, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01,
  0xFF, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x08, 0x7E,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x08, 0x07, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1,
  0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x7E, 0x1F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x0E,
  0x78, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1E, 0x1F, 0x80, 0x3F, 0xCF, 0xC0, 0x3F,
  0xF7, 0xE0, 0x3F, 0x1F, 0xF0, 0x1E, 0x03, 0xF8, 0x0E, 0x01, 0xFC, 0x0F,
  0x00, 0x7E, 0x07, 0x80, 0x3F, 0x03, 0xC0, 0x1F, 0x81, 0xE0, 0x0F, 0xC0,
  0xF0, 0x07, 0xE0, 0x78, 0x03, 0xF0, 0x3C, 0x01, 0xF8, 0x1E, 0x00, 0xFC,
  0x0F, 0x00, 0x7E, 0x07, 0x80, 0x3F, 0x03, 0xC0, 0x3F, 0x80, 0xF0, 0x1F,
  0xC0, 0x7C, 0x1F, 0xE0, 0x1F, 0xFB, 0xF0, 0x0F, 0xFD, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x38, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x78, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3C, 0x07, 0xF8, 0xF0, 0x03, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x1F, 0x3C, 0x01, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x3C, 0x07, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC,
  0x00, 0x3E, 0xF0, 0x03, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xE0, 0x3F, 0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x8F, 0xC1, 0xF8,
  0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xE0, 0x7F, 0x8F, 0x00, 0x3E,
  0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0,
  0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x3F, 0x3E, 0x00,
  0xFB, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF3,
  0xE0, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0x9E,
  0x00, 0x3E, 0x7C, 0x01, 0xF8, 0xFC, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFB, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3E,
  0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x83,
  0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0x78, 0x1F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x1F,
  0x07, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C,
  0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0x7E, 0xE0, 0x0E, 0xFD, 0xC0,
  0x3F, 0xFB, 0xC0, 0x77, 0xF3, 0x80, 0xEF, 0xE7, 0x03, 0xDF, 0xEF, 0x07,
  0x3F, 0xCE, 0x0E, 0x7F, 0x9C, 0x3C, 0xFF, 0x3C, 0x71, 0xFE, 0x38, 0xE3,
  0xFC, 0x73, 0xC7, 0xF8, 0xF7, 0x0F, 0xF0, 0xEE, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF7, 0x00, 0x3F, 0xFC,
  0x01, 0xFE, 0xE0, 0x0F, 0xF7, 0x00, 0x7F, 0xBC, 0x03, 0xFC, 0xE0, 0x1F,
  0xE7, 0x80, 0xFF, 0x3C, 0x07, 0xF8, 0xE0, 0x3F, 0xC7, 0x81, 0xFE, 0x3C,
  0x0F, 0xF0, 0xE0, 0x7F, 0x87, 0x83, 0xFC, 0x1C, 0x1F, 0xE0, 0xF0, 0xFF,
  0x07, 0x87, 0xF8, 0x1C, 0x3F, 0xC0, 0xF1, 0xFE, 0x07, 0x8F, 0xF0, 0x1C,
  0x7F, 0x80, 0xF3, 0xFC, 0x07, 0x9F, 0xE0, 0x1C, 0xFF, 0x00, 0xF7, 0xF8,
  0x03, 0xBF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xE0, 0x7E, 0x3E, 0x00,
  0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0xF3,
  0xE0, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC7, 0x80, 0x7F, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xBC, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78,
  0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0, 0x0F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x1E, 0x3C,
  0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01,
  0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x7C,
  0x00, 0x78, 0x7C, 0x01, 0xF0, 0xFE, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x05, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0x80, 0x7F, 0x8F, 0x00, 0x1F, 0x9E, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC,
  0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x01, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1F, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xEF, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F,
  0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF8, 0x01, 0xF8, 0xFE, 0x0F, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xF8, 0x3F,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0xF7, 0x00,
  0xF8, 0x0F, 0x78, 0x0F, 0x80, 0xF7, 0x80, 0xD8, 0x0F, 0x78, 0x0D, 0x80,
  0xF7, 0x80, 0xD8, 0x0E, 0x78, 0x1D, 0x80, 0xE7, 0x81, 0xDC, 0x0E, 0x38,
  0x1D, 0xC1, 0xE3, 0x81, 0xDC, 0x1E, 0x38, 0x19, 0xC1, 0xE3, 0xC1, 0x9C,
  0x1E, 0x3C, 0x18, 0xC1, 0xE3, 0xC3, 0x8C, 0x1C, 0x3C, 0x38, 0xC1, 0xC3,
  0xC3, 0x8C, 0x1C, 0x3C, 0x38, 0xE1, 0xC1, 0xC3, 0x8E, 0x3C, 0x1C, 0x30,
  0xE3, 0xC1, 0xC3, 0x0E, 0x3C, 0x1E, 0x30, 0x63, 0xC1, 0xE7, 0x06, 0x3C,
  0x1E, 0x70, 0x63, 0x81, 0xE7, 0x06, 0x38, 0x1E, 0x70, 0x73, 0x80, 0xE7,
  0x07, 0x38, 0x0E, 0x60, 0x73, 0x80, 0xE6, 0x07, 0x78, 0x0E, 0x60, 0x77,
  0x80, 0xFE, 0x03, 0x78, 0x0F, 0xE0, 0x37, 0x00, 0xFE, 0x03, 0x70, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF8,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF3, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xCF, 0x80, 0x01,
  0xF1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x01, 0xE0,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0x78, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xEE,
  0x00, 0x07, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xE0, 0x07, 0x83, 0x80,
  0x1E, 0x0F, 0x00, 0x70, 0x3C, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xE0, 0x78,
  0x03, 0x81, 0xC0, 0x0F, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x79, 0xE0, 0x00,
  0xE7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x7C, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFD, 0xF0, 0x0E, 0xF7, 0xFF, 0xFB, 0xCF, 0xFF, 0xCF, 0x0F, 0xFC, 0x3C,
  0x01, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x10, 0x07, 0x8F, 0xF8, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0xF0,
  0x7E, 0x7E, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1E, 0xFC, 0x01, 0xF7, 0xF8, 0x3F, 0x3D, 0xFF, 0xF9, 0xE7,
  0xFF, 0x8F, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7E, 0x3E, 0x00, 0xFB, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1E, 0x7C, 0x01,
  0xF1, 0xF8, 0x3F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x80, 0x78, 0x7F, 0xC3, 0xC7, 0xFF, 0x9E, 0x7F, 0xFE, 0xF7, 0xE0, 0x77,
  0xBE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x3B, 0xCF, 0xFF, 0xDE, 0x3F, 0xFC,
  0xF0, 0xFF, 0x87, 0x80, 0x60, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xE0, 0x3E, 0x3E, 0x00, 0xFB, 0xE0, 0x03,
  0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x01, 0xF1,
  0xF0, 0x1F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xE3, 0xC7, 0xFF, 0x9E,
  0x7F, 0xFE, 0xF7, 0xE0, 0x77, 0xBE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBC,
  0x00, 0xFD, 0xF0, 0x0D, 0xE7, 0xF3, 0xEF, 0x3F, 0xFE, 0x78, 0xFF, 0xE3,
  0xC1, 0xFE, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x30, 0x07, 0x8F, 0xF8, 0x3C, 0xFF,
  0xF1, 0xEF, 0xFF, 0xCF, 0xE0, 0x7E, 0x7E, 0x00, 0xFB, 0xE0, 0x03, 0xDF,
  0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0xCF,
  0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF0,
  0x07, 0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x03,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xF0, 0x3E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0x7C,
  0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xF1,
  0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xEF, 0x00, 0x03, 0xE0,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0x00, 0x41, 0xCF, 0xC7, 0xF3, 0xBF, 0xCF, 0xF7, 0x7F, 0xBF,
  0xEF, 0x07, 0xC3, 0xFE, 0x0F, 0x03, 0xF8, 0x0E, 0x07, 0xF0, 0x1C, 0x0F,
  0xE0, 0x38, 0x1F, 0xC0, 0x70, 0x3F, 0x80, 0xE0, 0x7F, 0x01, 0xC0, 0xFE,
  0x03, 0x81, 0xFC, 0x07, 0x03, 0xF8, 0x0E, 0x07, 0xF0, 0x1C, 0x0F, 0xE0,
  0x38, 0x1F, 0xC0, 0x70, 0x3F, 0x80, 0xE0, 0x7F, 0x01, 0xC0, 0xFE, 0x03,
  0x81, 0xFC, 0x07, 0x03, 0xF8, 0x0E, 0x07, 0xF0, 0x1C, 0x0F, 0xE0, 0x38,
  0x1F, 0xC0, 0x70, 0x3F, 0x80, 0xE0, 0x7F, 0x01, 0xC0, 0xFE, 0x03, 0x81,
  0xE0, 0x00, 0x30, 0x07, 0x8F, 0xF8, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF,
  0xF0, 0x7E, 0x7E, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF0, 0x7E, 0x3E, 0x00, 0xFB, 0xE0, 0x03,
  0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1E, 0x7C, 0x01, 0xF1,
  0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x10, 0x07, 0x8F, 0xF8, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0xF0, 0x7E,
  0x7E, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1E, 0xFC, 0x01, 0xF7, 0xF8, 0x3F, 0x3D, 0xFF, 0xF9, 0xE7, 0xFF,
  0x8F, 0x1F, 0xF0, 0x78, 0x08, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xC3, 0xC7, 0xFF, 0x9E, 0x7F,
  0xFE, 0xF7, 0xE0, 0x77, 0xBE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x3B, 0xCF,
  0xFF, 0xDE, 0x3F, 0xFC, 0xF0, 0xFF, 0x87, 0x80, 0x60, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x10, 0x07, 0x8F, 0xF8,
  0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0xE0, 0x3E, 0x7E, 0x00, 0xFB, 0xE0,
  0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xE0,
  0x3F, 0x3C, 0x00, 0x7B, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xF0, 0x1F, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x79, 0xE0,
  0x07, 0xCF, 0x80, 0x3C, 0x3F, 0x07, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0,
  0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0x80,
  0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0,
  0x3B, 0xC0, 0x7C, 0x07, 0x38, 0x0F, 0x80, 0xE7, 0x01, 0xF0, 0x3C, 0xE0,
  0x76, 0x07, 0x9E, 0x0E, 0xC0, 0xF3, 0xC1, 0xDC, 0x1C, 0x78, 0x33, 0x83,
  0x87, 0x06, 0x70, 0x70, 0xE0, 0xCE, 0x0E, 0x1C, 0x38, 0xC3, 0xC3, 0x87,
  0x18, 0x78, 0x78, 0xE3, 0x8E, 0x0F, 0x18, 0x71, 0xC0, 0xE3, 0x0E, 0x38,
  0x1C, 0x61, 0xC7, 0x03, 0x9C, 0x19, 0xE0, 0x73, 0x83, 0x38, 0x0F, 0x70,
  0x77, 0x01, 0xEC, 0x0E, 0xE0, 0x3D, 0x81, 0xDC, 0x03, 0xB0, 0x3B, 0x80,
  0x7E, 0x03, 0x70, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xE3, 0xC0, 0x00, 0xF3, 0xE0,
  0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB,
  0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xE3, 0xC0,
  0x01, 0xE3, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x03,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0x80, 0x1E, 0xFF, 0x80, 0x3D, 0xFF, 0x80, 0x7F, 0xCF,
  0x80, 0xFF, 0x0F, 0x81, 0xFC, 0x0F, 0x83, 0xF8, 0x0F, 0xCF, 0xF0, 0x0F,
  0xFE, 0xE0, 0x0F, 0xF9, 0xC0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_Light51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 37, 31, 12, -37 },
  { 34, 15, 15, 31, 8, -37 },
  { 63, 27, 37, 31, 2, -37 },
  { 188, 23, 51, 31, 4, -44 },
  { 335, 29, 37, 31, 1, -37 },
  { 470, 26, 39, 31, 3, -38 },
  { 597, 4, 15, 31, 13, -37 },
  { 605, 15, 49, 31, 10, -43 },
  { 697, 15, 49, 31, 6, -43 },
  { 789, 27, 26, 31, 2, -31 },
  { 877, 24, 24, 31, 3, -29 },
  { 949, 10, 16, 31, 9, -8 },
  { 969, 16, 4, 31, 7, -19 },
  { 977, 8, 9, 31, 11, -8 },
  { 986, 23, 48, 31, 4, -42 },
  { 1124, 22, 39, 31, 4, -38 },
  { 1232, 22, 37, 31, 5, -37 },
  { 1334, 23, 38, 31, 4, -38 },
  { 1444, 22, 38, 31, 4, -37 },
  { 1549, 21, 37, 31, 4, -37 },
  { 1647, 21, 38, 31, 5, -37 },
  { 1747, 23, 38, 31, 4, -37 },
  { 1857, 23, 37, 31, 4, -37 },
  { 1964, 22, 39, 31, 4, -38 },
  { 2072, 23, 38, 31, 4, -38 },
  { 2182, 8, 30, 31, 11, -29 },
  { 2212, 10, 37, 31, 9, -29 },
  { 2259, 22, 26, 31, 4, -30 },
  { 2331, 22, 16, 31, 4, -25 },
  { 2375, 22, 26, 31, 4, -30 },
  { 2447, 18, 37, 31, 7, -37 },
  { 2531, 25, 47, 31, 3, -38 },
  { 2678, 25, 37, 31, 3, -37 },
  { 2794, 22, 37, 31, 5, -37 },
  { 2896, 21, 39, 31, 5, -38 },
  { 2999, 21, 37, 31, 5, -37 },
  { 3097, 21, 37, 31, 5, -37 },
  { 3195, 22, 37, 31, 5, -37 },
  { 3297, 21, 39, 31, 5, -38 },
  { 3400, 21, 37, 31, 5, -37 },
  { 3498, 19, 37, 31, 6, -37 },
  { 3586, 22, 38, 31, 3, -37 },
  { 3691, 23, 37, 31, 5, -37 },
  { 3798, 21, 37, 31, 6, -37 },
  { 3896, 23, 37, 31, 4, -37 },
  { 4003, 21, 37, 31, 5, -37 },
  { 4101, 21, 39, 31, 5, -38 },
  { 4204, 23, 37, 31, 5, -37 },
  { 4311, 23, 47, 31, 4, -38 },
  { 4447, 23, 37, 31, 5, -37 },
  { 4554, 23, 39, 31, 4, -38 },
  { 4667, 25, 37, 31, 3, -37 },
  { 4783, 21, 38, 31, 5, -37 },
  { 4883, 25, 37, 31, 3, -37 },
  { 4999, 28, 37, 31, 1, -37 },
  { 5129, 26, 37, 31, 2, -37 },
  { 5250, 27, 37, 31, 2, -37 },
  { 5375, 22, 37, 31, 4, -37 },
  { 5477, 12, 48, 31, 11, -42 },
  { 5549, 23, 48, 31, 4, -42 },
  { 5687, 12, 48, 31, 8, -42 },
  { 5759, 22, 20, 31, 4, -37 },
  { 5814, 25, 4, 31, 3, 1 },
  { 5827, 10, 7, 31, 10, -40 },
  { 5836, 22, 30, 31, 4, -29 },
  { 5919, 21, 38, 31, 5, -37 },
  { 6019, 21, 30, 31, 5, -29 },
  { 6098, 21, 38, 31, 5, -37 },
  { 6198, 21, 30, 31, 5, -29 },
  { 6277, 24, 37, 31, 3, -37 },
  { 6388, 21, 38, 31, 5, -29 },
  { 6488, 21, 37, 31, 5, -37 },
  { 6586, 24, 39, 31, 4, -39 },
  { 6703, 19, 48, 31, 4, -39 },
  { 6817, 23, 37, 31, 5, -37 },
  { 6924, 26, 37, 31, 2, -37 },
  { 7045, 23, 29, 31, 4, -29 },
  { 7129, 21, 29, 31, 5, -29 },
  { 7206, 21, 29, 31, 5, -29 },
  { 7283, 21, 38, 31, 5, -29 },
  { 7383, 21, 38, 31, 5, -29 },
  { 7483, 21, 29, 31, 6, -29 },
  { 7560, 21, 29, 31, 5, -29 },
  { 7637, 23, 36, 31, 3, -36 },
  { 7741, 21, 29, 31, 5, -28 },
  { 7818, 24, 28, 31, 3, -28 },
  { 7902, 27, 28, 31, 2, -28 },
  { 7997, 25, 28, 31, 3, -28 },
  { 8085, 24, 37, 31, 3, -28 },
  { 8196, 21, 28, 31, 5, -28 },
  { 8270, 21, 48, 31, 5, -42 },
  { 8396, 4, 48, 31, 13, -42 },
  { 8420, 21, 48, 31, 5, -42 },
  { 8546, 23, 10, 31, 4, -23 },
};

const GFXfont JetBrainsMono_Light51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_LIGHT51PT7B_H_
