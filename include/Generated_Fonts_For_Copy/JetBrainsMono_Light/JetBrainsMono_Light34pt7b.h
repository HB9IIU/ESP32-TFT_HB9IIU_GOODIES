#ifndef _JETBRAINSMONO_LIGHT34PT7B_H_
#define _JETBRAINSMONO_LIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light34pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0x31, 0x8C, 0x63,
  0x00, 0x00, 0x3B, 0xFF, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0x61, 0xD8, 0x70, 0x03, 0x83, 0x80, 0xC0, 0xC0, 0x30,
  0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x70, 0x61, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC1, 0x81, 0x80, 0x60, 0xE0, 0x38, 0x30, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0x81,
  0x80, 0x60, 0x60, 0x18, 0x18, 0x06, 0x0E, 0x03, 0x83, 0x00, 0xC0, 0xC0,
  0x30, 0x30, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xBC, 0x73, 0x1D, 0xC6, 0x3B, 0x8C, 0x37,
  0x18, 0x1E, 0x30, 0x0E, 0x60, 0x1C, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xE0, 0x19, 0xE0, 0x31, 0xC0, 0x61, 0xC0, 0xC3, 0x81, 0x87,
  0xC3, 0x0F, 0xC6, 0x1F, 0x8C, 0x73, 0xD9, 0xE3, 0xFF, 0x83, 0xFC, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xEF,
  0xE0, 0x1B, 0x8E, 0x06, 0x60, 0xC1, 0xCC, 0x18, 0x31, 0x83, 0x0C, 0x30,
  0x63, 0x86, 0x0C, 0x60, 0xC3, 0x98, 0x1F, 0xE6, 0x01, 0xF8, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x67, 0xE0, 0x19, 0xFE, 0x07,
  0x30, 0xC0, 0xCE, 0x1C, 0x31, 0xC3, 0x8E, 0x38, 0x71, 0x87, 0x0E, 0x60,
  0x61, 0xDC, 0x0C, 0x33, 0x01, 0xFE, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F,
  0xF8, 0x0F, 0x1E, 0x07, 0x07, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xF0,
  0x07, 0x1C, 0x1F, 0x8F, 0x1D, 0xC3, 0x8C, 0xE0, 0xEE, 0x70, 0x3E, 0x38,
  0x1F, 0x1C, 0x07, 0x0E, 0x03, 0xC7, 0x03, 0xF1, 0xC3, 0xB8, 0xFF, 0x8E,
  0x3F, 0x83, 0x80, 0xFF, 0xFF, 0xFE, 0xD8, 0x00, 0x40, 0x30, 0x3C, 0x1E,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x00,
  0x40, 0x80, 0x38, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x0E, 0x0F, 0x0F, 0x83, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x10, 0x30, 0x27, 0x8C, 0x7F, 0xFB,
  0x3F, 0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x07, 0x38,
  0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x78, 0x38, 0x1C, 0x0F, 0x02, 0x01, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3E, 0x78, 0xE1, 0xC7,
  0x8E, 0x1C, 0x30, 0xE1, 0xC0, 0xFF, 0xFF, 0xFC, 0x79, 0xFF, 0xDF, 0x78,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x0F, 0xE0, 0x7F, 0xE1, 0xF1, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xB8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x3C, 0x7E, 0x78,
  0xFC, 0xF1, 0xF8, 0x43, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x6E, 0x01, 0xCE, 0x03, 0x9E, 0x1E, 0x1F, 0xF8, 0x1F, 0xE0, 0x03,
  0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xEE, 0x0F, 0x1C, 0x1C, 0x38, 0x30, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0,
  0x7F, 0xE1, 0xE1, 0xE7, 0x81, 0xEE, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xF7,
  0x87, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x07, 0x38, 0x1D, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xD8, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x9F, 0x86, 0xFF, 0x9E, 0x1E, 0x70, 0x1D,
  0x80, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xF8, 0x03,
  0xE0, 0x1D, 0x80, 0x77, 0x87, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3B, 0xF0, 0x3F, 0xFC, 0x7C, 0x1E, 0x78,
  0x0E, 0x70, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60,
  0x07, 0x70, 0x0E, 0x78, 0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xDC, 0x03, 0xB8, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x0F, 0xE0,
  0x7F, 0xE1, 0xE1, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x30,
  0x0E, 0x70, 0x1C, 0xF0, 0x70, 0xF3, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xDE,
  0x1E, 0x0E, 0x38, 0x0E, 0xE0, 0x1D, 0xC0, 0x1B, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xDC, 0x03, 0x9E, 0x1F, 0x1F, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x1F,
  0xF8, 0x3E, 0x3C, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x38, 0x1E, 0x3F,
  0xFE, 0x0F, 0xDC, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x79,
  0xFF, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1F, 0xFD,
  0xF7, 0x80, 0x3C, 0x7D, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x9E, 0x3C, 0x71, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x00, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3C, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xFE, 0x0F, 0xF8,
  0xFF, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x1E, 0x3F, 0xC3, 0xF0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x00, 0xE6, 0x00, 0x37, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0xF0, 0x7B, 0x78, 0x70,
  0x7C, 0x38, 0x3E, 0x1C, 0x1F, 0x0E, 0x0F, 0x87, 0x07, 0xC3, 0x83, 0xE1,
  0xC1, 0xF0, 0xE0, 0xF8, 0x70, 0x7C, 0x1C, 0x7E, 0x0F, 0xEF, 0x03, 0xE7,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x76, 0x00, 0x3B, 0x00, 0x19, 0xC0, 0x1C, 0xE0, 0x0E, 0x30,
  0x07, 0x18, 0x03, 0x0E, 0x03, 0x87, 0x01, 0xC1, 0x80, 0xE0, 0xE0, 0x60,
  0x70, 0x70, 0x38, 0x3F, 0xFC, 0x1F, 0xFF, 0x0C, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0x63, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0x80, 0xFF,
  0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x03,
  0x70, 0x06, 0xE0, 0x1D, 0xC0, 0x3B, 0x81, 0xE7, 0xFF, 0x8F, 0xFF, 0x1C,
  0x0F, 0x38, 0x07, 0x70, 0x06, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xB8, 0x3F, 0x7F, 0xFC, 0xFF, 0xE0, 0x0F, 0xE0,
  0x7F, 0xE1, 0xF1, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3F, 0x00, 0x6E,
  0x01, 0xCE, 0x03, 0x9E, 0x1E, 0x1F, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x38, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xEE,
  0x1F, 0xBF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x3F, 0xFC, 0xFF, 0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0xE1, 0xF1, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xB8,
  0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x6E, 0x01, 0xCE, 0x03, 0x9E, 0x1E, 0x1F, 0xFC, 0x0F, 0xE0, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x01, 0xDE, 0x03, 0x9E, 0x1E, 0x1F, 0xFC, 0x1F, 0xE0, 0xE0,
  0x0F, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x81, 0xBD, 0x83, 0x7B, 0x0F, 0xF6, 0x1B, 0xE6, 0x37,
  0xCC, 0xEF, 0x99, 0x9F, 0x1B, 0x3E, 0x3E, 0x7C, 0x78, 0xF8, 0x71, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0E, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3E, 0xC0, 0xFB, 0x83, 0xEE, 0x0F,
  0x98, 0x3E, 0x70, 0xF8, 0xC3, 0xE3, 0x0F, 0x8E, 0x3E, 0x18, 0xF8, 0x63,
  0xE1, 0xCF, 0x83, 0x3E, 0x0E, 0xF8, 0x1B, 0xE0, 0x6F, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0xFF, 0xC7, 0xC7, 0x9C, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x87, 0x8F, 0xFC, 0x1F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xF1, 0xE3, 0x81, 0xEE, 0x01, 0xDC,
  0x01, 0xB8, 0x03, 0x70, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x80, 0x37, 0x00,
  0x6E, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x06, 0xE0, 0x0D, 0xC0, 0x1B,
  0x80, 0x37, 0x00, 0x6E, 0x01, 0xCE, 0x03, 0x9E, 0x1E, 0x1F, 0xF8, 0x1F,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x00, 0xEE, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x01, 0xEF,
  0xFF, 0x9F, 0xFC, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE1, 0xC0, 0xE3, 0x81,
  0xC7, 0x01, 0xCE, 0x03, 0x9C, 0x03, 0xB8, 0x07, 0x70, 0x07, 0xE0, 0x0E,
  0x0F, 0xE0, 0x7F, 0xE1, 0xF1, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xB8,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0x9E, 0x0F, 0x1F, 0xFC, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x87, 0x8F, 0xFC, 0x1F,
  0xE0, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x63,
  0x80, 0x70, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x0C, 0x1C, 0x0E, 0x06, 0x07,
  0x03, 0x83, 0x81, 0xC1, 0x80, 0xE1, 0xC0, 0x30, 0xE0, 0x1C, 0x70, 0x0E,
  0x30, 0x07, 0x38, 0x01, 0x9C, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x3B, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0xE0, 0xF8, 0x38, 0x3E,
  0x0E, 0x0F, 0x87, 0x83, 0xE1, 0xA1, 0xD8, 0x68, 0x76, 0x1A, 0x1D, 0x86,
  0xC7, 0x61, 0xB1, 0x9C, 0x4C, 0x67, 0x33, 0x19, 0xCC, 0xC6, 0x73, 0x31,
  0x8C, 0xC4, 0xE3, 0x31, 0x38, 0xCC, 0x6E, 0x32, 0x1B, 0x0C, 0x86, 0xC3,
  0xE1, 0xB0, 0xF8, 0x6C, 0x3E, 0x1B, 0x0F, 0x82, 0xC1, 0xE0, 0xB0, 0x78,
  0x3C, 0x1C, 0x0F, 0x00, 0x70, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x70, 0x70,
  0x1C, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x1C, 0x60, 0x03, 0x38,
  0x00, 0xEC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0E, 0xE0, 0x07, 0x38, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x30,
  0x38, 0x1C, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x79, 0xC0, 0x0E, 0xF0, 0x01,
  0xC0, 0xE0, 0x01, 0xDC, 0x00, 0x67, 0x00, 0x38, 0xE0, 0x0C, 0x38, 0x07,
  0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x76, 0x00, 0xCC, 0x01, 0x8C, 0x07, 0x18, 0x0C,
  0x38, 0x38, 0x30, 0x60, 0x71, 0xC0, 0x63, 0x00, 0xEE, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xF0, 0x3F, 0xF0,
  0xF9, 0xF1, 0xC0, 0xF7, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07,
  0xFE, 0x7F, 0xFD, 0xE0, 0x3B, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xB8, 0x07, 0x78, 0x36, 0x7F, 0xEC, 0x7F, 0x18, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x7E, 0x3B, 0xFC, 0xFC, 0xFB,
  0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x87,
  0xBB, 0xFE, 0xE7, 0xE0, 0x0F, 0xC0, 0xFF, 0xC7, 0xEF, 0x9C, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x3E, 0x01, 0xDC, 0x07, 0x78, 0x78, 0xFF, 0xE1,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0xF9, 0xCF, 0xF7, 0x7C, 0xFD, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1D, 0xC0, 0xF7, 0x87, 0xCF, 0xFF, 0x1F, 0x9C, 0x0F, 0xC0,
  0xFF, 0xC7, 0xC7, 0x9C, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0xDC, 0x07, 0x78, 0x38, 0xFF, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0F, 0x9C,
  0xFF, 0x77, 0xCF, 0xDC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03,
  0xCF, 0xFF, 0x3F, 0xDC, 0x1C, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x87, 0xFE, 0x1F, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x7E, 0x3B, 0xFC, 0xFC, 0x7B, 0xC0, 0xFF,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1C, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x7C, 0xFF, 0x8F, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1C,
  0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xEF, 0x3C, 0xFF, 0xBE, 0xF3, 0xC7, 0xE1,
  0xC7, 0xE1, 0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE1,
  0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE1,
  0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE7, 0xE3, 0xBF, 0xCF, 0xCF,
  0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x0F, 0xC0, 0xFF, 0xC7, 0xEF, 0x9C, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xDC, 0x07, 0x78, 0x78, 0xFF,
  0xC1, 0xFE, 0x00, 0xE7, 0xE3, 0xBF, 0xCF, 0xCF, 0xBC, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x7B, 0xBF, 0xEE, 0x7E,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0F,
  0x9C, 0xFF, 0x77, 0xCF, 0xDC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xDC, 0x0F, 0x78, 0x7C, 0xFF, 0xF1, 0xF9, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xE7, 0xC3, 0xBF, 0xCF, 0x87,
  0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xF1, 0xF3, 0x80,
  0xE6, 0x00, 0xCC, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x0E, 0x78,
  0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x03, 0xFE, 0x00, 0xFE, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x0F, 0x78, 0x78, 0xFF,
  0xC1, 0xFE, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70,
  0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x0C,
  0x38, 0x0E, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x07, 0x70, 0x07, 0x60, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xE0, 0xE0, 0xD8, 0x38, 0x36, 0x0E, 0x1D,
  0x87, 0x87, 0x61, 0xA1, 0x9C, 0x68, 0x67, 0x1B, 0x19, 0xC4, 0xC6, 0x31,
  0x33, 0x8C, 0xCC, 0xE3, 0x33, 0x30, 0xCC, 0x4C, 0x3B, 0x1B, 0x0E, 0x86,
  0xC1, 0xA1, 0xB0, 0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x83, 0x81, 0xE0, 0xE0,
  0xF0, 0x07, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x38,
  0x07, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0,
  0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x70, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x38, 0x0E,
  0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x06, 0x70, 0x07, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xF0, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0x7F, 0x03, 0xFC, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x03, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x3E, 0x07, 0x7F, 0x07, 0x63, 0x87,
  0xE1, 0xC7, 0xE0, 0xFE, 0xE0, 0x7E,
};

const GFXglyph JetBrainsMono_Light34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 25, 20, 8, -25 },
  { 17, 10, 10, 20, 5, -25 },
  { 30, 18, 25, 20, 1, -25 },
  { 87, 15, 35, 20, 3, -30 },
  { 153, 19, 25, 20, 1, -25 },
  { 213, 17, 25, 20, 2, -25 },
  { 267, 3, 10, 20, 9, -25 },
  { 271, 10, 33, 20, 6, -29 },
  { 313, 10, 33, 20, 4, -29 },
  { 355, 18, 18, 20, 1, -21 },
  { 396, 16, 16, 20, 2, -19 },
  { 428, 7, 10, 20, 6, -5 },
  { 437, 11, 2, 20, 5, -12 },
  { 440, 6, 5, 20, 7, -5 },
  { 444, 15, 32, 20, 3, -28 },
  { 504, 15, 25, 20, 3, -25 },
  { 551, 15, 25, 20, 3, -25 },
  { 598, 15, 25, 20, 3, -25 },
  { 645, 14, 25, 20, 3, -25 },
  { 689, 14, 25, 20, 3, -25 },
  { 733, 14, 25, 20, 3, -25 },
  { 777, 16, 25, 20, 2, -25 },
  { 827, 15, 25, 20, 3, -25 },
  { 874, 15, 25, 20, 3, -25 },
  { 921, 16, 25, 20, 2, -25 },
  { 971, 6, 19, 20, 7, -19 },
  { 986, 7, 24, 20, 6, -19 },
  { 1007, 14, 18, 20, 3, -20 },
  { 1039, 14, 10, 20, 3, -16 },
  { 1057, 14, 18, 20, 3, -20 },
  { 1089, 12, 25, 20, 5, -25 },
  { 1127, 17, 31, 20, 2, -25 },
  { 1193, 17, 25, 20, 2, -25 },
  { 1247, 15, 25, 20, 3, -25 },
  { 1294, 15, 25, 20, 3, -25 },
  { 1341, 14, 25, 20, 3, -25 },
  { 1385, 14, 25, 20, 4, -25 },
  { 1429, 15, 25, 20, 3, -25 },
  { 1476, 15, 25, 20, 3, -25 },
  { 1523, 14, 25, 20, 3, -25 },
  { 1567, 13, 25, 20, 4, -25 },
  { 1608, 15, 25, 20, 2, -25 },
  { 1655, 16, 25, 20, 3, -25 },
  { 1705, 14, 25, 20, 4, -25 },
  { 1749, 15, 25, 20, 3, -25 },
  { 1796, 14, 25, 20, 3, -25 },
  { 1840, 14, 25, 20, 3, -25 },
  { 1884, 16, 25, 20, 3, -25 },
  { 1934, 15, 31, 20, 3, -25 },
  { 1993, 15, 25, 20, 3, -25 },
  { 2040, 15, 25, 20, 3, -25 },
  { 2087, 17, 25, 20, 2, -25 },
  { 2141, 14, 25, 20, 3, -25 },
  { 2185, 17, 25, 20, 2, -25 },
  { 2239, 18, 25, 20, 1, -25 },
  { 2296, 18, 25, 20, 1, -25 },
  { 2353, 18, 25, 20, 1, -25 },
  { 2410, 14, 25, 20, 3, -25 },
  { 2454, 8, 32, 20, 7, -28 },
  { 2486, 15, 32, 20, 3, -28 },
  { 2546, 8, 32, 20, 5, -28 },
  { 2578, 15, 13, 20, 3, -25 },
  { 2603, 16, 2, 20, 2, 1 },
  { 2607, 7, 5, 20, 6, -27 },
  { 2612, 15, 19, 20, 2, -19 },
  { 2648, 14, 25, 20, 3, -25 },
  { 2692, 14, 19, 20, 3, -19 },
  { 2726, 14, 25, 20, 3, -25 },
  { 2770, 14, 19, 20, 3, -19 },
  { 2804, 16, 25, 20, 2, -25 },
  { 2854, 14, 25, 20, 3, -19 },
  { 2898, 14, 25, 20, 3, -25 },
  { 2942, 16, 26, 20, 3, -26 },
  { 2994, 12, 32, 20, 3, -26 },
  { 3042, 16, 25, 20, 3, -25 },
  { 3092, 18, 25, 20, 1, -25 },
  { 3149, 16, 19, 20, 2, -19 },
  { 3187, 14, 19, 20, 3, -19 },
  { 3221, 14, 19, 20, 3, -19 },
  { 3255, 14, 25, 20, 3, -19 },
  { 3299, 14, 25, 20, 3, -19 },
  { 3343, 14, 19, 20, 4, -19 },
  { 3377, 15, 19, 20, 3, -19 },
  { 3413, 16, 24, 20, 2, -24 },
  { 3461, 14, 19, 20, 3, -19 },
  { 3495, 16, 19, 20, 2, -19 },
  { 3533, 18, 19, 20, 1, -19 },
  { 3576, 16, 19, 20, 2, -19 },
  { 3614, 16, 25, 20, 2, -19 },
  { 3664, 14, 19, 20, 3, -19 },
  { 3698, 14, 32, 20, 3, -28 },
  { 3754, 3, 32, 20, 9, -28 },
  { 3766, 14, 32, 20, 3, -28 },
  { 3822, 16, 6, 20, 2, -15 },
};

const GFXfont JetBrainsMono_Light34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_LIGHT34PT7B_H_
