#ifndef _JETBRAINSMONO_LIGHT47PT7B_H_
#define _JETBRAINSMONO_LIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light47pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFD, 0xF0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x03, 0xDC, 0x0F,
  0x70, 0x3D, 0xC0, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x1C, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x3F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x0E, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x0E,
  0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x0E, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0x9C, 0xF8, 0xF0, 0xE3, 0xC7, 0x87,
  0x0F, 0x38, 0x38, 0x7B, 0xC1, 0xC3, 0xDE, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF8, 0xE0, 0x03, 0xF7, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1D, 0xF8, 0x00, 0xE3, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC1,
  0xE0, 0x0E, 0x0F, 0xE0, 0x70, 0x7F, 0x03, 0x83, 0xFC, 0x1C, 0x1D, 0xE0,
  0xE1, 0xE7, 0x87, 0x1F, 0x3F, 0x39, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x77, 0xFE, 0x00, 0x39, 0xE7, 0xC0, 0x1E, 0xF0, 0x70,
  0x07, 0x38, 0x1E, 0x03, 0x8E, 0x03, 0x81, 0xC3, 0x80, 0xE0, 0x70, 0xE0,
  0x38, 0x38, 0x38, 0x0E, 0x1C, 0x0E, 0x03, 0x87, 0x03, 0x81, 0xE3, 0x80,
  0xF0, 0x71, 0xC0, 0x1F, 0xFC, 0x70, 0x03, 0xFE, 0x38, 0x00, 0x7F, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x60, 0x00, 0x38, 0xFF, 0x00, 0x1C, 0x7F, 0xE0, 0x0E, 0x3E, 0x78,
  0x03, 0x8E, 0x07, 0x01, 0xC3, 0x81, 0xC0, 0xE1, 0xE0, 0x70, 0x38, 0x78,
  0x1C, 0x1C, 0x1E, 0x07, 0x0E, 0x07, 0x81, 0xC3, 0x81, 0xE0, 0x71, 0xC0,
  0x38, 0x1C, 0xE0, 0x0E, 0x0F, 0x78, 0x03, 0xFF, 0x9C, 0x00, 0x7F, 0xEE,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x3E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xF9, 0xE0, 0x1E,
  0xF0, 0xF0, 0x1C, 0xF0, 0x78, 0x3C, 0xE0, 0x3C, 0x78, 0xE0, 0x3C, 0x78,
  0xE0, 0x1E, 0xF0, 0xE0, 0x0F, 0xF0, 0xE0, 0x0F, 0xE0, 0xE0, 0x07, 0xE0,
  0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xE0, 0xF0, 0x07, 0xF0, 0xF0, 0x0F, 0xF0,
  0xF8, 0x3E, 0x78, 0x7F, 0xFE, 0x3C, 0x3F, 0xF8, 0x3C, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x01, 0xF0, 0x1F,
  0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0x00, 0x04, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0,
  0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3C, 0x02, 0xF8, 0x1C, 0x1F,
  0xFE, 0x18, 0x7F, 0xFF, 0x99, 0xFF, 0x3F, 0xFB, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x81, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x06, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x8F,
  0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07,
  0x07, 0x83, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0x07, 0xF0, 0xF8,
  0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x0F, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xE3,
  0xE0, 0x7E, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x70, 0x03, 0xF3, 0x80, 0x3E,
  0x1C, 0x03, 0xE0, 0xE0, 0x1E, 0x07, 0x00, 0xC0, 0x38, 0x04, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xC0, 0x3E, 0x3C, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00,
  0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01,
  0xE7, 0x80, 0x3E, 0x7C, 0x07, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x38, 0xF0, 0x07, 0x3E, 0x00, 0xE7, 0x80, 0x1D, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x81, 0x80, 0x79, 0xFF, 0x07, 0xBF, 0xF8, 0x7F, 0xFF, 0xC7,
  0xE0, 0x7E, 0x7C, 0x01, 0xE7, 0x80, 0x1F, 0x78, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x3E, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3D,
  0xFC, 0x01, 0xEF, 0xFC, 0x0F, 0x7F, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x03,
  0xC7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x80,
  0x03, 0x9E, 0x00, 0x1E, 0x7C, 0x00, 0x78, 0xF0, 0x03, 0xC1, 0xF0, 0x3F,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1C, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3C, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x0F, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x3C, 0x1F, 0x0F, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x01, 0xF8, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x1E, 0x78, 0x01,
  0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0xE0, 0x7E, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x80, 0x07,
  0x9E, 0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xE1, 0xF8, 0x7F, 0x07,
  0xFF, 0xBC, 0x07, 0xFD, 0xE0, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0xFF, 0xFF,
  0x7F, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x1F, 0x87,
  0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0x3C,
  0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xC7,
  0xF0, 0x0F, 0xF7, 0xF0, 0x1F, 0xF7, 0xF0, 0x3C, 0x1F, 0xF0, 0x38, 0x0F,
  0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07,
  0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07,
  0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x38, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3F, 0x3F, 0xF0, 0x1F, 0xF7, 0xF0, 0x0F, 0xE7, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x8E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x70, 0x01, 0xC0,
  0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x38, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3C, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8E, 0x00, 0xFC, 0xE0, 0x07, 0xCE, 0x00, 0x3C, 0xE0,
  0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE,
  0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xE0, 0x3F, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xE0, 0x07, 0xCE, 0x00, 0x3C, 0xE0, 0x01,
  0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x3E, 0xE0,
  0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x03, 0xE7, 0xC0, 0x1E,
  0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x7C, 0x01, 0xE3, 0xE0, 0x7E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x0F, 0xCE, 0x00,
  0x79, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEE, 0x00, 0x7D, 0xC0, 0x1F,
  0x38, 0x1F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x03, 0xE7, 0xC0, 0x1E, 0x78,
  0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C,
  0x01, 0xE3, 0xE0, 0x7E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00,
  0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x1E, 0x00, 0xF8, 0xFC, 0x0F, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xB8, 0x00, 0x79, 0xC0, 0x03, 0xCE, 0x00, 0x3C, 0x70, 0x01, 0xE3,
  0x80, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x0F, 0x07, 0x00, 0xF8, 0x38, 0x07,
  0x81, 0xC0, 0x7C, 0x0E, 0x03, 0xC0, 0x70, 0x3E, 0x03, 0x81, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x38, 0x1E, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0x80, 0x78, 0x1C, 0x01, 0xE0, 0xE0,
  0x0F, 0x07, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x3C,
  0x70, 0x00, 0xF3, 0x80, 0x07, 0x9C, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xDC, 0x03, 0xFF, 0xC0,
  0x3B, 0xFC, 0x03, 0xBE, 0xE0, 0x3B, 0xEE, 0x07, 0x7E, 0xE0, 0x77, 0xE7,
  0x07, 0x7E, 0x70, 0xE7, 0xE7, 0x0E, 0x7E, 0x38, 0xE7, 0xE3, 0x9C, 0x7E,
  0x39, 0xC7, 0xE1, 0xDC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x87,
  0xE0, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xF7, 0x00, 0xFF, 0x70, 0x0F,
  0xF7, 0x80, 0xFF, 0x38, 0x0F, 0xF3, 0x80, 0xFF, 0x3C, 0x0F, 0xF1, 0xC0,
  0xFF, 0x1E, 0x0F, 0xF0, 0xE0, 0xFF, 0x0E, 0x0F, 0xF0, 0xF0, 0xFF, 0x07,
  0x0F, 0xF0, 0x70, 0xFF, 0x07, 0x8F, 0xF0, 0x38, 0xFF, 0x03, 0x8F, 0xF0,
  0x3C, 0xFF, 0x01, 0xCF, 0xF0, 0x1E, 0xFF, 0x00, 0xEF, 0xF0, 0x0E, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3E, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x1E, 0x7C, 0x01, 0xE3, 0xE0,
  0x7C, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xC0, 0x0F, 0xCE, 0x00, 0x1E, 0x70, 0x00,
  0x7B, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x07,
  0xDC, 0x00, 0x7C, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xE0, 0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0xF1, 0xF0, 0x07,
  0x87, 0xC0, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8E, 0x00, 0xFC, 0xE0, 0x03, 0xEE, 0x00, 0x1E, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1E, 0xE0, 0x03, 0xEE, 0x00, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0E, 0x07, 0x80, 0xE0, 0x3C,
  0x0E, 0x03, 0xC0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0xE0, 0x0F, 0x0E, 0x00,
  0xF0, 0xE0, 0x07, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0xCE, 0x00, 0x3C, 0xE0,
  0x03, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0x01, 0xF8, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xE0, 0x3E, 0x3C, 0x00,
  0xF1, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0x78, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0xC0, 0x7C, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x70, 0x00, 0xF7, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xF3, 0x80, 0x01, 0xE7, 0x80, 0x03, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xE0, 0x0E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xF0, 0x00,
  0xE1, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x9E, 0x00, 0x07,
  0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x1E,
  0x03, 0xDC, 0x07, 0x80, 0xF7, 0x01, 0xF0, 0x3D, 0xC0, 0x7C, 0x0E, 0x70,
  0x1F, 0x03, 0x9E, 0x0E, 0xC0, 0xE7, 0x83, 0xB0, 0x39, 0xE0, 0xEC, 0x0E,
  0x78, 0x33, 0x07, 0x8E, 0x0C, 0xC1, 0xE3, 0x83, 0x38, 0x78, 0xE0, 0xCE,
  0x1C, 0x38, 0x33, 0x87, 0x0E, 0x1C, 0x61, 0xC3, 0xC7, 0x18, 0x70, 0xF1,
  0xC6, 0x1C, 0x3C, 0x61, 0x87, 0x0F, 0x18, 0x63, 0xC1, 0xC6, 0x18, 0xF0,
  0x71, 0x87, 0x38, 0x1C, 0x61, 0xCE, 0x07, 0x38, 0x73, 0x81, 0xCE, 0x0C,
  0xE0, 0x73, 0x83, 0x38, 0x1E, 0xC0, 0xCE, 0x07, 0xB0, 0x33, 0x80, 0xEC,
  0x0C, 0xE0, 0x3B, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x81,
  0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xE7,
  0x80, 0x00, 0xF7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0xF0, 0x07, 0x81, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xC3,
  0xC0, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xE0, 0x07, 0x8E, 0x00,
  0x70, 0xE0, 0x0F, 0x07, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xC0, 0x38,
  0x1C, 0x03, 0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x01, 0xFF, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x0F, 0x1E, 0x00, 0x78,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x7D, 0xF0, 0x0F, 0xE7, 0xFF, 0xEF, 0x1F,
  0xFE, 0x78, 0x7F, 0xE3, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE1, 0xFC, 0x1C, 0xFF, 0xE3, 0xBF, 0xFE, 0x76, 0x07, 0xEF, 0x80, 0x7D,
  0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3D, 0xF0, 0x07, 0xBB, 0x03, 0xF7, 0x7F, 0xFC, 0xE7, 0xFF, 0x1C,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xE0, 0x7E,
  0x7C, 0x01, 0xE7, 0x80, 0x1F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x1E, 0x3E, 0x07, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x07, 0xF8, 0xF1, 0xFF, 0xCF, 0x3F, 0xFE, 0xF3, 0xE0,
  0x7F, 0x7C, 0x03, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x3E, 0x07,
  0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0x7F, 0x8F, 0x03, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x70,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x1E, 0x3E, 0x03, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xF8, 0xF1, 0xFF, 0xCF, 0x3F, 0xFE, 0xF3, 0xE0, 0x7F, 0x7C, 0x03, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0,
  0x3F, 0x3E, 0x07, 0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0x7F, 0x8F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE3, 0xFC, 0x1C, 0xFF, 0xE3,
  0xBF, 0xFE, 0x76, 0x07, 0xCF, 0x80, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xB8, 0x00, 0x79, 0xC0, 0x07, 0x8E, 0x00, 0x7C, 0x70, 0x03, 0xC3, 0x80,
  0x3C, 0x1C, 0x03, 0xE0, 0xE0, 0x3E, 0x07, 0x01, 0xE0, 0x38, 0x1E, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0x81, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x3E, 0x07, 0x00, 0xF0, 0x38, 0x03, 0xC1, 0xC0, 0x1F, 0x0E,
  0x00, 0x78, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x9C, 0x00, 0x3C, 0xE0, 0x01,
  0xF7, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF7, 0xE3,
  0xF3, 0xFF, 0xDF, 0xEF, 0xFF, 0x7F, 0xBE, 0x1F, 0x0F, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x03, 0x83, 0xFC, 0x0E, 0x0F, 0xF0, 0x38, 0x3F, 0xC0,
  0xE0, 0xFF, 0x03, 0x83, 0xFC, 0x0E, 0x0F, 0xF0, 0x38, 0x3F, 0xC0, 0xE0,
  0xFF, 0x03, 0x83, 0xFC, 0x0E, 0x0F, 0xF0, 0x38, 0x3F, 0xC0, 0xE0, 0xFF,
  0x03, 0x83, 0xFC, 0x0E, 0x0F, 0xF0, 0x38, 0x3F, 0xC0, 0xE0, 0xFF, 0x03,
  0x83, 0xFC, 0x0E, 0x0F, 0xF0, 0x38, 0x3F, 0xC0, 0xE0, 0xF0, 0xE3, 0xFC,
  0x1C, 0xFF, 0xE3, 0xBF, 0xFE, 0x76, 0x07, 0xCF, 0x80, 0x7D, 0xE0, 0x07,
  0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3C,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0x7C, 0x7C, 0x03,
  0xE7, 0x80, 0x1E, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7,
  0x00, 0x0F, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x3E, 0x07, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xE1, 0xFC, 0x1C, 0xFF, 0xE3, 0xBF, 0xFE,
  0x77, 0x07, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xF0, 0x07, 0xBB, 0x03, 0xF7,
  0x7F, 0xFC, 0xE7, 0xFF, 0x1C, 0x7F, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xF8, 0xF1, 0xFF, 0xCF, 0x3F, 0xFE, 0xF3, 0xE0, 0x7F,
  0x7C, 0x03, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x00, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x3E, 0x07, 0xF3,
  0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0x7F, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x0F, 0x3F, 0xF8, 0xF7, 0xFF, 0xCF, 0xE0,
  0x7C, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xE0, 0x3E, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0x7C, 0x03, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3E,
  0x07, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xE0,
  0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x78, 0x03,
  0x81, 0xE0, 0x1E, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x3C, 0x0F, 0x00,
  0x70, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x3C,
  0x70, 0x00, 0xF3, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x3C, 0x07,
  0xE0, 0x3C, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x3C, 0x07, 0x70, 0x3E, 0x0F,
  0x70, 0x7E, 0x0E, 0x70, 0x76, 0x0E, 0x70, 0x66, 0x0E, 0x70, 0x66, 0x0E,
  0x78, 0x66, 0x0E, 0x38, 0x67, 0x0E, 0x38, 0xE7, 0x1C, 0x38, 0xE3, 0x1C,
  0x38, 0xC3, 0x1C, 0x38, 0xC3, 0x1C, 0x38, 0xC3, 0x1C, 0x3C, 0xC3, 0x9C,
  0x1D, 0xC3, 0x98, 0x1D, 0xC1, 0xB8, 0x1D, 0x81, 0xB8, 0x1D, 0x81, 0xB8,
  0x1D, 0x81, 0xB8, 0x1D, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0xF0, 0xF0, 0x03, 0xC0,
  0xF0, 0x0F, 0x81, 0xE0, 0x1E, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x03,
  0xC3, 0xC0, 0x03, 0xCF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xCF, 0x00, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x1E,
  0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x3C,
  0x78, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x38, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x3C, 0xFF, 0x80, 0xF7, 0xFF, 0x03, 0xDE, 0x3C, 0x0F, 0xF0, 0x78,
  0x3F, 0xC0, 0xF0, 0xFF, 0x01, 0xFF, 0xBC, 0x03, 0xFC, 0xF0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_Light47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 6, 34, 28, 11, -34 },
  { 27, 14, 14, 28, 7, -34 },
  { 52, 25, 34, 28, 2, -34 },
  { 159, 21, 48, 28, 4, -41 },
  { 285, 26, 35, 28, 1, -35 },
  { 399, 24, 35, 28, 3, -35 },
  { 504, 4, 14, 28, 12, -34 },
  { 511, 14, 45, 28, 9, -39 },
  { 590, 14, 45, 28, 5, -39 },
  { 669, 24, 24, 28, 2, -29 },
  { 741, 22, 22, 28, 3, -27 },
  { 802, 9, 15, 28, 8, -7 },
  { 819, 15, 3, 28, 7, -17 },
  { 825, 8, 7, 28, 10, -7 },
  { 832, 20, 44, 28, 4, -39 },
  { 942, 20, 35, 28, 4, -35 },
  { 1030, 21, 34, 28, 4, -34 },
  { 1120, 21, 35, 28, 4, -35 },
  { 1212, 20, 34, 28, 4, -34 },
  { 1297, 19, 34, 28, 4, -34 },
  { 1378, 20, 34, 28, 4, -34 },
  { 1463, 22, 34, 28, 3, -34 },
  { 1557, 21, 34, 28, 4, -34 },
  { 1647, 20, 35, 28, 4, -35 },
  { 1735, 22, 35, 28, 3, -35 },
  { 1832, 8, 26, 28, 10, -26 },
  { 1858, 10, 34, 28, 8, -26 },
  { 1901, 20, 25, 28, 4, -28 },
  { 1964, 20, 15, 28, 4, -23 },
  { 2002, 20, 25, 28, 4, -28 },
  { 2065, 16, 34, 28, 7, -34 },
  { 2133, 24, 43, 28, 2, -35 },
  { 2262, 23, 34, 28, 3, -34 },
  { 2360, 20, 34, 28, 5, -34 },
  { 2445, 20, 35, 28, 4, -35 },
  { 2533, 19, 34, 28, 5, -34 },
  { 2614, 19, 34, 28, 5, -34 },
  { 2695, 20, 34, 28, 5, -34 },
  { 2780, 20, 35, 28, 4, -35 },
  { 2868, 19, 34, 28, 5, -34 },
  { 2949, 18, 34, 28, 5, -34 },
  { 3026, 21, 34, 28, 2, -34 },
  { 3116, 21, 34, 28, 5, -34 },
  { 3206, 20, 34, 28, 5, -34 },
  { 3291, 20, 34, 28, 4, -34 },
  { 3376, 20, 34, 28, 4, -34 },
  { 3461, 20, 35, 28, 4, -35 },
  { 3549, 21, 34, 28, 5, -34 },
  { 3639, 21, 43, 28, 4, -35 },
  { 3752, 20, 34, 28, 5, -34 },
  { 3837, 21, 35, 28, 4, -35 },
  { 3929, 23, 34, 28, 3, -34 },
  { 4027, 20, 34, 28, 4, -34 },
  { 4112, 23, 34, 28, 3, -34 },
  { 4210, 26, 34, 28, 1, -34 },
  { 4321, 24, 34, 28, 2, -34 },
  { 4423, 24, 34, 28, 2, -34 },
  { 4525, 20, 34, 28, 4, -34 },
  { 4610, 11, 44, 28, 10, -39 },
  { 4671, 20, 44, 28, 4, -39 },
  { 4781, 11, 44, 28, 7, -39 },
  { 4842, 20, 18, 28, 4, -34 },
  { 4887, 22, 3, 28, 3, 1 },
  { 4896, 9, 7, 28, 9, -37 },
  { 4904, 21, 26, 28, 3, -26 },
  { 4973, 19, 34, 28, 5, -34 },
  { 5054, 20, 26, 28, 4, -26 },
  { 5119, 20, 34, 28, 4, -34 },
  { 5204, 20, 26, 28, 4, -26 },
  { 5269, 22, 34, 28, 3, -34 },
  { 5363, 20, 34, 28, 4, -26 },
  { 5448, 19, 34, 28, 5, -34 },
  { 5529, 22, 36, 28, 4, -36 },
  { 5628, 17, 44, 28, 4, -36 },
  { 5722, 21, 34, 28, 5, -34 },
  { 5812, 24, 34, 28, 2, -34 },
  { 5914, 22, 26, 28, 3, -26 },
  { 5986, 19, 26, 28, 5, -26 },
  { 6048, 20, 26, 28, 4, -26 },
  { 6113, 19, 34, 28, 5, -26 },
  { 6194, 20, 34, 28, 4, -26 },
  { 6279, 20, 26, 28, 5, -26 },
  { 6344, 20, 26, 28, 4, -26 },
  { 6409, 21, 33, 28, 3, -33 },
  { 6496, 20, 26, 28, 4, -26 },
  { 6561, 22, 26, 28, 3, -26 },
  { 6633, 24, 26, 28, 2, -26 },
  { 6711, 23, 26, 28, 3, -26 },
  { 6786, 22, 34, 28, 3, -26 },
  { 6880, 20, 26, 28, 4, -26 },
  { 6945, 20, 44, 28, 4, -39 },
  { 7055, 4, 44, 28, 12, -39 },
  { 7077, 20, 44, 28, 4, -39 },
  { 7187, 22, 9, 28, 3, -21 },
};

const GFXfont JetBrainsMono_Light47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_LIGHT47PT7B_H_
