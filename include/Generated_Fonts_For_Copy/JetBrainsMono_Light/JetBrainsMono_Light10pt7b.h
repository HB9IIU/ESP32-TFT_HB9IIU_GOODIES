#ifndef _JETBRAINSMONO_LIGHT10PT7B_H_
#define _JETBRAINSMONO_LIGHT10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light10pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x8C, 0xFC, 0x28, 0xA5, 0xD2, 0xF9, 0x45, 0x00, 0x22, 0xFB,
  0xA7, 0x3B, 0xF2, 0xEE, 0xAF, 0x08, 0x3D, 0x59, 0xC0, 0xF4, 0x21, 0x9B,
  0x4B, 0xE0, 0xE0, 0x72, 0x49, 0x24, 0x60, 0xC4, 0x92, 0x49, 0xC0, 0x22,
  0x97, 0x8C, 0x48, 0x44, 0xF4, 0x40, 0xEA, 0xF0, 0xB0, 0x11, 0x22, 0x44,
  0x48, 0x80, 0xF9, 0x9F, 0x99, 0xF0, 0x6A, 0x22, 0x22, 0xF0, 0xF9, 0x12,
  0x24, 0xF0, 0xF2, 0x61, 0x19, 0xE0, 0x34, 0x49, 0x97, 0x10, 0xF8, 0xE9,
  0x19, 0xF0, 0x24, 0xE9, 0x99, 0xF0, 0xF9, 0x12, 0x24, 0x40, 0xF9, 0x96,
  0x99, 0xF0, 0xF9, 0x9F, 0x22, 0x40, 0xB0, 0x30, 0xB0, 0x6A, 0x16, 0x84,
  0x30, 0xF0, 0xF0, 0x86, 0x12, 0xC0, 0xF1, 0x16, 0x40, 0x40, 0x7A, 0x19,
  0xE9, 0xA6, 0xB9, 0x10, 0x30, 0x66, 0x69, 0xF9, 0x90, 0xF9, 0x9F, 0x99,
  0xF0, 0xF9, 0x88, 0x89, 0xF0, 0xF9, 0x99, 0x99, 0xE0, 0xF8, 0x8F, 0x88,
  0xF0, 0xF8, 0x8F, 0x88, 0x80, 0xF9, 0x8B, 0x99, 0xF0, 0x99, 0x9F, 0x99,
  0x90, 0xF4, 0x44, 0x44, 0xF0, 0x71, 0x11, 0x19, 0xE0, 0x94, 0xA9, 0xCA,
  0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0x9B, 0xFF, 0x99, 0x90, 0x9D, 0xDB,
  0xBB, 0x90, 0xF9, 0x99, 0x99, 0xF0, 0xF9, 0x9F, 0x88, 0x80, 0xF9, 0x99,
  0x99, 0xF2, 0x10, 0xF9, 0x9E, 0xA9, 0x90, 0xF9, 0x87, 0x19, 0xF0, 0xF2,
  0x22, 0x22, 0x20, 0x99, 0x99, 0x99, 0xF0, 0x99, 0x99, 0x66, 0x60, 0xB6,
  0xDB, 0x5E, 0x49, 0x24, 0x80, 0x49, 0x23, 0x0C, 0x31, 0x2C, 0xC0, 0xCD,
  0x23, 0x0C, 0x20, 0x82, 0x00, 0xF1, 0x24, 0x48, 0xF0, 0xEA, 0xAA, 0xC0,
  0x88, 0x44, 0x22, 0x21, 0x10, 0xD5, 0x55, 0xC0, 0x66, 0x99, 0xF0, 0x90,
  0x69, 0x1F, 0x9F, 0x8E, 0x99, 0x99, 0xF0, 0x69, 0x88, 0x9F, 0x17, 0x99,
  0x99, 0xF0, 0x69, 0x9E, 0x8F, 0x74, 0xF4, 0x44, 0x40, 0x79, 0x99, 0x97,
  0x16, 0x8E, 0x99, 0x99, 0x90, 0x60, 0x38, 0x42, 0x10, 0x9F, 0x30, 0xE2,
  0x22, 0x22, 0x2C, 0x84, 0xA5, 0x4E, 0x4A, 0x60, 0xE1, 0x08, 0x42, 0x10,
  0x60, 0xFD, 0xDD, 0xDD, 0xE9, 0x99, 0x99, 0x69, 0x99, 0x9F, 0xE9, 0x99,
  0x9F, 0x88, 0x79, 0x99, 0x9F, 0x11, 0xE9, 0x98, 0x88, 0x69, 0x87, 0x1F,
  0x4F, 0x44, 0x44, 0x70, 0x99, 0x99, 0x9F, 0x99, 0x96, 0x66, 0xA6, 0xD7,
  0x9E, 0x49, 0x20, 0x99, 0x66, 0x69, 0x99, 0x96, 0x62, 0x44, 0xF1, 0x24,
  0x8F, 0x32, 0x22, 0xC2, 0x22, 0x30, 0xFF, 0x80, 0xC4, 0x44, 0x34, 0x44,
  0xC0, 0x8F,
};

const GFXglyph JetBrainsMono_Light10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 2, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 4, 10, 6, 1, -9 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 5, 7, 6, 1, -7 },
  { 26, 1, 3, 6, 2, -7 },
  { 27, 3, 9, 6, 2, -8 },
  { 31, 3, 9, 6, 1, -8 },
  { 35, 6, 5, 6, 0, -6 },
  { 39, 4, 5, 6, 1, -6 },
  { 42, 2, 4, 6, 2, -2 },
  { 43, 4, 1, 6, 1, -4 },
  { 44, 2, 2, 6, 2, -2 },
  { 45, 4, 9, 6, 1, -8 },
  { 50, 4, 7, 6, 1, -7 },
  { 54, 4, 7, 6, 1, -7 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 4, 7, 6, 1, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 4, 7, 6, 1, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 4, 7, 6, 1, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 2, 6, 6, 2, -6 },
  { 92, 2, 8, 6, 2, -6 },
  { 94, 4, 5, 6, 1, -6 },
  { 97, 4, 3, 6, 1, -5 },
  { 99, 4, 5, 6, 1, -6 },
  { 102, 4, 7, 6, 1, -7 },
  { 106, 6, 9, 6, 0, -7 },
  { 113, 4, 7, 6, 1, -7 },
  { 117, 4, 7, 6, 1, -7 },
  { 121, 4, 7, 6, 1, -7 },
  { 125, 4, 7, 6, 1, -7 },
  { 129, 4, 7, 6, 1, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 4, 7, 6, 1, -7 },
  { 141, 4, 7, 6, 1, -7 },
  { 145, 4, 7, 6, 1, -7 },
  { 149, 4, 7, 6, 1, -7 },
  { 153, 5, 7, 6, 1, -7 },
  { 158, 4, 7, 6, 1, -7 },
  { 162, 4, 7, 6, 1, -7 },
  { 166, 4, 7, 6, 1, -7 },
  { 170, 4, 7, 6, 1, -7 },
  { 174, 4, 7, 6, 1, -7 },
  { 178, 4, 9, 6, 1, -7 },
  { 183, 4, 7, 6, 1, -7 },
  { 187, 4, 7, 6, 1, -7 },
  { 191, 4, 7, 6, 1, -7 },
  { 195, 4, 7, 6, 1, -7 },
  { 199, 4, 7, 6, 1, -7 },
  { 203, 6, 7, 6, 0, -7 },
  { 209, 6, 7, 6, 0, -7 },
  { 215, 6, 7, 6, 0, -7 },
  { 221, 4, 7, 6, 1, -7 },
  { 225, 2, 9, 6, 2, -8 },
  { 228, 4, 9, 6, 1, -8 },
  { 233, 2, 9, 6, 2, -8 },
  { 236, 4, 4, 6, 1, -7 },
  { 238, 4, 1, 6, 1, 0 },
  { 239, 2, 2, 6, 2, -8 },
  { 240, 4, 6, 6, 1, -6 },
  { 243, 4, 7, 6, 1, -7 },
  { 247, 4, 6, 6, 1, -6 },
  { 250, 4, 7, 6, 1, -7 },
  { 254, 4, 6, 6, 1, -6 },
  { 257, 4, 7, 6, 1, -7 },
  { 261, 4, 8, 6, 1, -6 },
  { 265, 4, 7, 6, 1, -7 },
  { 269, 5, 8, 6, 1, -8 },
  { 274, 4, 10, 6, 1, -8 },
  { 279, 5, 7, 6, 1, -7 },
  { 284, 5, 7, 6, 0, -7 },
  { 289, 4, 6, 6, 1, -6 },
  { 292, 4, 6, 6, 1, -6 },
  { 295, 4, 6, 6, 1, -6 },
  { 298, 4, 8, 6, 1, -6 },
  { 302, 4, 8, 6, 1, -6 },
  { 306, 4, 6, 6, 1, -6 },
  { 309, 4, 6, 6, 1, -6 },
  { 312, 4, 7, 6, 1, -7 },
  { 316, 4, 6, 6, 1, -6 },
  { 319, 4, 6, 6, 1, -6 },
  { 322, 6, 6, 6, 0, -6 },
  { 327, 4, 6, 6, 1, -6 },
  { 330, 4, 8, 6, 1, -6 },
  { 334, 4, 6, 6, 1, -6 },
  { 337, 4, 9, 6, 1, -8 },
  { 342, 1, 9, 6, 3, -8 },
  { 344, 4, 9, 6, 1, -8 },
  { 349, 4, 2, 6, 1, -5 },
};

const GFXfont JetBrainsMono_Light10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_LIGHT10PT7B_H_
