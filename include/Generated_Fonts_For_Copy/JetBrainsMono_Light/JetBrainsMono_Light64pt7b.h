#ifndef _JETBRAINSMONO_LIGHT64PT7B_H_
#define _JETBRAINSMONO_LIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light64pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0x80,
  0x7C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFB, 0xBF, 0xE0,
  0x7E, 0x1C, 0x3F, 0x07, 0xE0, 0xE0, 0xFC, 0x3E, 0x07, 0x03, 0xE3, 0xF0,
  0x38, 0x1F, 0x9F, 0x01, 0xC0, 0x7C, 0xF8, 0x0E, 0x03, 0xE7, 0xC0, 0x70,
  0x1F, 0x3E, 0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x0F, 0xC0, 0xE0, 0x00,
  0x3E, 0x07, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x3F,
  0x8E, 0x00, 0x01, 0xFF, 0x70, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0xFF, 0x80, 0x00, 0x71, 0xFC, 0x00,
  0x03, 0x83, 0xF0, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0xE0, 0x7E, 0x00, 0x07,
  0x01, 0xF0, 0x00, 0x38, 0x0F, 0x80, 0x01, 0xC0, 0x7E, 0x00, 0x0E, 0x03,
  0xFF, 0x80, 0x70, 0x1F, 0xFC, 0x03, 0x80, 0xFF, 0xE0, 0x1C, 0x07, 0xDF,
  0x80, 0xE0, 0x3E, 0x7C, 0x07, 0x03, 0xF3, 0xF0, 0x38, 0x1F, 0x0F, 0xC1,
  0xC3, 0xF8, 0x7F, 0x8E, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0xFF, 0xC0,
  0x00, 0x1F, 0x3F, 0xFF, 0x00, 0x01, 0xE3, 0xFF, 0xF0, 0x00, 0x3C, 0x7C,
  0x0F, 0x80, 0x07, 0x87, 0x80, 0x78, 0x00, 0x78, 0xF8, 0x07, 0xC0, 0x0F,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0xF0, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x07, 0xC3, 0xE0,
  0x07, 0x80, 0x78, 0x3C, 0x00, 0x7C, 0x0F, 0x87, 0x80, 0x07, 0xFF, 0xF8,
  0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x01, 0xFF, 0xE1, 0xE0, 0x00, 0x07,
  0xF8, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x00, 0x7C, 0x3F, 0xF8, 0x00,
  0x07, 0x87, 0xFF, 0xC0, 0x00, 0xF0, 0xFF, 0xFE, 0x00, 0x1F, 0x1F, 0x83,
  0xE0, 0x01, 0xE1, 0xF0, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x07, 0xC1,
  0xE0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0xF0, 0x01,
  0xF0, 0x1F, 0x1E, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x00, 0xFF, 0xFE, 0x3C,
  0x00, 0x07, 0xFF, 0xC7, 0x80, 0x00, 0x3F, 0xF8, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x3E, 0xF8, 0x1F, 0x80,
  0x7C, 0xF8, 0x0F, 0xC0, 0xFC, 0xF8, 0x07, 0xE0, 0xF8, 0xF8, 0x03, 0xE1,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0xF8, 0x01, 0xFB, 0xF0, 0xF8, 0x00, 0xFF,
  0xE0, 0xF8, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F,
  0xC0, 0xF8, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x7F, 0xE0, 0xFC, 0x01, 0xFF,
  0xF0, 0x7F, 0x03, 0xF9, 0xF8, 0x7F, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7C, 0x1F, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x40, 0x80, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x08, 0x00, 0x7C, 0x00, 0x43, 0xC0, 0x1E, 0x00, 0x79, 0xFE,
  0x07, 0x80, 0xFE, 0x7F, 0xE1, 0xE1, 0xFF, 0xFF, 0xFE, 0x38, 0xFF, 0xF3,
  0xFF, 0xCE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x0F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xE0, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0x83, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F,
  0xC1, 0xFF, 0x81, 0xFC, 0x1F, 0xF8, 0x1F, 0xC1, 0xFF, 0x81, 0xF8, 0x1F,
  0xF8, 0x0F, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFE,
  0x7C, 0x00, 0x1F, 0xC7, 0xC0, 0x07, 0xF8, 0x7C, 0x00, 0xFE, 0x07, 0xC0,
  0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xC0,
  0x07, 0xC0, 0x08, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xC7,
  0xE0, 0x03, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0xC0,
  0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE7,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x8F, 0xFF, 0x01, 0xF3, 0xFF, 0xF0, 0x3E, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7C,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF0,
  0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x3F, 0xF8, 0x01, 0xF7, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x0F, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x7F, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x7E, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0x70, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7C, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xFF, 0xBE, 0x03, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0x9F, 0x00, 0x0F,
  0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0x83, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFC, 0xFE, 0x0C, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x0F, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x7F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0xC0,
  0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0x00, 0x1F, 0xF8,
  0x0F, 0x80, 0x0F, 0xFC, 0x07, 0xC0, 0x07, 0xFE, 0x03, 0xE0, 0x03, 0xFF,
  0x01, 0xF0, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x7F,
  0xE0, 0x3E, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x1F, 0xF8, 0x0F, 0x80, 0x0F,
  0xFC, 0x07, 0xC0, 0x07, 0xFE, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0xF0, 0x01,
  0xFF, 0x80, 0x78, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x80,
  0xFF, 0xF0, 0x07, 0xF1, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFC, 0x00, 0xFF,
  0xF7, 0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x2F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xF8,
  0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xF0, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xF8, 0xF8, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x0F, 0xCF, 0x80, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF3,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFF, 0x01,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3E, 0x00,
  0x3F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0xCF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC,
  0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0x7F, 0x78, 0x00, 0xF7, 0xF7, 0x80, 0x1F, 0xFF, 0x78, 0x01,
  0xEF, 0xF3, 0xC0, 0x1E, 0xFF, 0x3C, 0x03, 0xEF, 0xF3, 0xC0, 0x3C, 0xFF,
  0x1E, 0x03, 0xCF, 0xF1, 0xE0, 0x3C, 0xFF, 0x9E, 0x07, 0x8F, 0xF8, 0xF0,
  0x78, 0xFF, 0x8F, 0x07, 0x8F, 0xF8, 0xF0, 0xF0, 0xFF, 0x87, 0x8F, 0x0F,
  0xF8, 0x78, 0xF0, 0xFF, 0x87, 0x9E, 0x1F, 0xF8, 0x3D, 0xE1, 0xFF, 0x83,
  0xDE, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x81, 0xFC, 0x1F, 0xF8, 0x1F, 0xC1,
  0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFE,
  0xF0, 0x01, 0xFF, 0xBE, 0x00, 0x7F, 0xE7, 0x80, 0x1F, 0xF9, 0xE0, 0x07,
  0xFE, 0x7C, 0x01, 0xFF, 0x8F, 0x00, 0x7F, 0xE3, 0xC0, 0x1F, 0xF8, 0xF8,
  0x07, 0xFE, 0x1E, 0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8,
  0x3C, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F,
  0xF8, 0x1F, 0x07, 0xFE, 0x03, 0xC1, 0xFF, 0x80, 0xF8, 0x7F, 0xE0, 0x3E,
  0x1F, 0xF8, 0x07, 0x87, 0xFE, 0x01, 0xF1, 0xFF, 0x80, 0x7C, 0x7F, 0xE0,
  0x0F, 0x1F, 0xF8, 0x03, 0xE7, 0xFE, 0x00, 0x79, 0xFF, 0x80, 0x1E, 0x3F,
  0xE0, 0x07, 0xCF, 0xF8, 0x00, 0xF3, 0xFE, 0x00, 0x3E, 0xFF, 0x80, 0x0F,
  0xBF, 0xE0, 0x01, 0xEF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xC0, 0x0F, 0xE7, 0xE0,
  0x01, 0xF9, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xFC, 0x07, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0x1F,
  0xE3, 0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xF3, 0xE0,
  0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xCF, 0xE0, 0x03, 0xF0, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7C, 0x00, 0x1F, 0xE3,
  0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0xE3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x3E, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xFC, 0x07, 0xF0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x7E,
  0x00, 0x7B, 0xE0, 0x0F, 0xC0, 0x0F, 0x7C, 0x01, 0xF8, 0x01, 0xEF, 0x80,
  0x3F, 0x80, 0x7D, 0xF0, 0x07, 0x70, 0x0F, 0x9E, 0x00, 0xEE, 0x01, 0xF3,
  0xC0, 0x1D, 0xC0, 0x3E, 0x7C, 0x03, 0xB8, 0x07, 0xCF, 0x80, 0xF7, 0x00,
  0xF1, 0xF0, 0x1E, 0xE0, 0x1E, 0x3E, 0x03, 0x9C, 0x03, 0xC7, 0xC0, 0x73,
  0xC0, 0x78, 0xF8, 0x0E, 0x78, 0x1F, 0x0F, 0x01, 0xC7, 0x03, 0xE1, 0xE0,
  0x38, 0xE0, 0x7C, 0x3C, 0x07, 0x1C, 0x0F, 0x87, 0xC1, 0xE3, 0x81, 0xF0,
  0xF8, 0x3C, 0x70, 0x3C, 0x1F, 0x07, 0x0E, 0x07, 0x83, 0xE0, 0xE1, 0xE0,
  0xF0, 0x7C, 0x1C, 0x3C, 0x1E, 0x0F, 0x83, 0x83, 0x87, 0xC0, 0xF0, 0x70,
  0x70, 0xF8, 0x1E, 0x1E, 0x0E, 0x1F, 0x03, 0xC3, 0xC1, 0xC3, 0xE0, 0x7C,
  0x78, 0x38, 0x78, 0x0F, 0x8E, 0x07, 0x0F, 0x01, 0xF1, 0xC0, 0xE1, 0xE0,
  0x3E, 0x38, 0x1E, 0x3C, 0x07, 0xC7, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x39,
  0xF0, 0x0F, 0x3C, 0x07, 0x3E, 0x01, 0xE7, 0x80, 0xE7, 0xC0, 0x3C, 0xE0,
  0x1C, 0xF0, 0x07, 0x9C, 0x03, 0x9E, 0x00, 0xFB, 0x80, 0x73, 0xC0, 0x1F,
  0x70, 0x0F, 0x78, 0x03, 0xEE, 0x01, 0xEF, 0x00, 0x7D, 0xC0, 0x1D, 0xE0,
  0x07, 0xF8, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xF3, 0xF8, 0x01, 0xFF, 0x3F, 0xFB,
  0xFD, 0xF1, 0xFF, 0xFF, 0x9F, 0x07, 0xFF, 0xF1, 0xF0, 0x3F, 0xFC, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x87, 0xFF, 0x81,
  0xF1, 0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0x87, 0xDF, 0xFF, 0xF8, 0xFB, 0x80,
  0x7F, 0x9F, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xE0,
  0x03, 0xF3, 0xEF, 0x01, 0xFE, 0x7D, 0xFF, 0xFF, 0x8F, 0x9F, 0xFF, 0xE1,
  0xF1, 0xFF, 0xF8, 0x3E, 0x0F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0x03, 0xFF, 0x87, 0xC3, 0xFF, 0xF9,
  0xF1, 0xFF, 0xFE, 0x7C, 0xFF, 0xFF, 0xDF, 0x3F, 0x80, 0x7F, 0xDF, 0x80,
  0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0xFF,
  0xFF, 0xDF, 0x1F, 0xFF, 0xE7, 0xC3, 0xFF, 0xF1, 0xF0, 0x3F, 0xF8, 0x7C,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x7F, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE1,
  0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xF0,
  0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0xDF, 0x3F, 0xFF, 0xF7, 0xCF, 0xE0, 0x1F,
  0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0xFF,
  0x3F, 0x80, 0x7F, 0xC7, 0xFF, 0xFD, 0xF1, 0xFF, 0xFE, 0x7C, 0x3F, 0xFF,
  0x1F, 0x03, 0xFF, 0x87, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x7F, 0xF8, 0x3E,
  0x3F, 0xFF, 0x0F, 0x9F, 0xFF, 0xE3, 0xEF, 0xEF, 0xFC, 0xFB, 0x80, 0x3F,
  0xBF, 0xC0, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0x3E, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x01,
  0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x3E,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x7C, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x78, 0x07, 0x83,
  0xE7, 0xF8, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0x3E, 0xFF, 0xCF, 0xFE, 0xFE,
  0x1F, 0xF1, 0xFB, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x01,
  0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78,
  0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01,
  0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F,
  0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8,
  0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01,
  0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78,
  0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01,
  0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F,
  0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0x00,
  0x0F, 0xC0, 0x3E, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF, 0xC3, 0xE7, 0xFF, 0xF8,
  0xFB, 0xFF, 0xFF, 0x3E, 0xE0, 0x1F, 0xEF, 0xF0, 0x01, 0xFB, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x1F, 0xC0, 0x07, 0xE1, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x0F, 0xFF, 0x03, 0xE3, 0xFF, 0xF0, 0x7C,
  0xFF, 0xFF, 0x0F, 0xBF, 0xFF, 0xF1, 0xF7, 0x00, 0x7F, 0x3F, 0xC0, 0x07,
  0xE7, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0xC0, 0x07, 0xE7, 0xDE, 0x03,
  0xFC, 0xFB, 0xFF, 0xFF, 0x1F, 0x3F, 0xFF, 0xC3, 0xE3, 0xFF, 0xF0, 0x7C,
  0x1F, 0xF8, 0x0F, 0x80, 0x70, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xE1, 0xF0, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0xDF, 0x3F, 0xFF, 0xF7, 0xCF,
  0xE0, 0x1F, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x03, 0xFC,
  0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0xF7, 0xC7, 0xFF, 0xF9, 0xF0, 0xFF, 0xFC,
  0x7C, 0x0F, 0xFE, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x0F,
  0xFF, 0x03, 0xE3, 0xFF, 0xF0, 0x7C, 0xFF, 0xFF, 0x0F, 0xBF, 0xBF, 0xF1,
  0xF7, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xFC, 0x01, 0xFE, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3,
  0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xDE, 0x00, 0xFC, 0x01, 0xF7, 0x80, 0x3F, 0x00, 0x79,
  0xF0, 0x0F, 0xC0, 0x1E, 0x7C, 0x03, 0xF0, 0x07, 0x9F, 0x00, 0xFE, 0x01,
  0xE3, 0xC0, 0x3B, 0x80, 0x78, 0xF0, 0x1E, 0xE0, 0x3E, 0x3C, 0x07, 0x38,
  0x0F, 0x0F, 0x01, 0xCE, 0x03, 0xC3, 0xE0, 0x73, 0x80, 0xF0, 0xF8, 0x1C,
  0xF0, 0x3C, 0x1E, 0x07, 0x1C, 0x0F, 0x07, 0x83, 0xC7, 0x07, 0xC1, 0xE0,
  0xE1, 0xC1, 0xE0, 0x78, 0x38, 0x70, 0x78, 0x1F, 0x0E, 0x1C, 0x1E, 0x07,
  0xC3, 0x87, 0x87, 0x80, 0xF0, 0xE0, 0xE1, 0xE0, 0x3C, 0x78, 0x38, 0x78,
  0x0F, 0x1C, 0x0E, 0x3C, 0x03, 0xC7, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0xE3,
  0xC0, 0x3E, 0x70, 0x3C, 0xF0, 0x0F, 0x9C, 0x07, 0x3C, 0x01, 0xEF, 0x01,
  0xCF, 0x00, 0x7B, 0x80, 0x77, 0x80, 0x1E, 0xE0, 0x1D, 0xE0, 0x07, 0xB8,
  0x07, 0x78, 0x01, 0xEE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3F, 0xE0, 0x01,
  0xF3, 0xFF, 0xE0, 0x07, 0xCF, 0xFF, 0xC0, 0x1F, 0x7E, 0x3F, 0x80, 0x7D,
  0xF0, 0x7E, 0x01, 0xF7, 0x80, 0xFC, 0x07, 0xFE, 0x01, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0xFB, 0xE0, 0x07, 0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0x3E, 0x00,
  0x1F, 0xF8, 0xF8, 0x00, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_Light64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 9, 47, 38, 15, -47 },
  { 54, 18, 19, 38, 10, -47 },
  { 97, 34, 47, 38, 2, -47 },
  { 297, 29, 65, 38, 5, -56 },
  { 533, 36, 47, 38, 1, -47 },
  { 745, 32, 48, 38, 4, -47 },
  { 937, 6, 19, 38, 16, -47 },
  { 952, 19, 62, 38, 12, -54 },
  { 1100, 19, 62, 38, 7, -54 },
  { 1248, 34, 33, 38, 2, -39 },
  { 1389, 30, 30, 38, 4, -36 },
  { 1502, 13, 20, 38, 11, -10 },
  { 1535, 20, 4, 38, 9, -23 },
  { 1545, 10, 11, 38, 14, -10 },
  { 1559, 28, 60, 38, 5, -53 },
  { 1769, 28, 48, 38, 5, -47 },
  { 1937, 28, 47, 38, 6, -47 },
  { 2102, 29, 47, 38, 5, -47 },
  { 2273, 27, 48, 38, 5, -47 },
  { 2435, 27, 47, 38, 5, -47 },
  { 2594, 27, 48, 38, 6, -47 },
  { 2756, 29, 48, 38, 5, -47 },
  { 2930, 29, 47, 38, 5, -47 },
  { 3101, 28, 48, 38, 5, -47 },
  { 3269, 29, 47, 38, 5, -47 },
  { 3440, 10, 37, 38, 14, -36 },
  { 3487, 13, 46, 38, 11, -36 },
  { 3562, 28, 34, 38, 5, -38 },
  { 3681, 27, 20, 38, 6, -31 },
  { 3749, 28, 34, 38, 5, -38 },
  { 3868, 23, 47, 38, 9, -47 },
  { 4004, 33, 59, 38, 3, -47 },
  { 4248, 31, 47, 38, 4, -47 },
  { 4431, 28, 47, 38, 6, -47 },
  { 4596, 27, 48, 38, 6, -47 },
  { 4758, 26, 47, 38, 6, -47 },
  { 4911, 26, 47, 38, 7, -47 },
  { 5064, 28, 47, 38, 6, -47 },
  { 5229, 27, 48, 38, 6, -47 },
  { 5391, 26, 47, 38, 6, -47 },
  { 5544, 24, 47, 38, 7, -47 },
  { 5685, 28, 48, 38, 3, -47 },
  { 5853, 30, 47, 38, 6, -47 },
  { 6030, 27, 47, 38, 7, -47 },
  { 6189, 28, 47, 38, 5, -47 },
  { 6354, 26, 47, 38, 6, -47 },
  { 6507, 26, 48, 38, 6, -47 },
  { 6663, 29, 47, 38, 6, -47 },
  { 6834, 27, 59, 38, 6, -47 },
  { 7034, 29, 47, 38, 6, -47 },
  { 7205, 29, 48, 38, 5, -47 },
  { 7379, 31, 47, 38, 4, -47 },
  { 7562, 26, 48, 38, 6, -47 },
  { 7718, 31, 47, 38, 4, -47 },
  { 7901, 35, 47, 38, 2, -47 },
  { 8107, 33, 47, 38, 3, -47 },
  { 8301, 34, 47, 38, 2, -47 },
  { 8501, 27, 47, 38, 6, -47 },
  { 8660, 16, 60, 38, 13, -53 },
  { 8780, 28, 60, 38, 5, -53 },
  { 8990, 15, 60, 38, 10, -53 },
  { 9103, 28, 25, 38, 5, -47 },
  { 9191, 31, 4, 38, 4, 2 },
  { 9207, 13, 9, 38, 12, -50 },
  { 9222, 28, 37, 38, 4, -36 },
  { 9352, 27, 48, 38, 6, -47 },
  { 9514, 27, 37, 38, 6, -36 },
  { 9639, 26, 48, 38, 6, -47 },
  { 9795, 27, 37, 38, 6, -36 },
  { 9920, 30, 47, 38, 4, -47 },
  { 10097, 26, 48, 38, 6, -36 },
  { 10253, 26, 47, 38, 6, -47 },
  { 10406, 29, 50, 38, 6, -50 },
  { 10588, 23, 62, 38, 6, -50 },
  { 10767, 29, 47, 38, 6, -47 },
  { 10938, 33, 47, 38, 2, -47 },
  { 11132, 30, 36, 38, 4, -36 },
  { 11267, 26, 36, 38, 6, -36 },
  { 11384, 27, 37, 38, 6, -36 },
  { 11509, 27, 48, 38, 6, -36 },
  { 11671, 26, 48, 38, 6, -36 },
  { 11827, 27, 36, 38, 7, -36 },
  { 11949, 27, 37, 38, 6, -36 },
  { 12074, 29, 45, 38, 4, -45 },
  { 12238, 26, 36, 38, 6, -35 },
  { 12355, 31, 35, 38, 4, -35 },
  { 12491, 34, 35, 38, 2, -35 },
  { 12640, 31, 35, 38, 4, -35 },
  { 12776, 31, 47, 38, 4, -35 },
  { 12959, 26, 35, 38, 6, -35 },
  { 13073, 27, 60, 38, 6, -53 },
  { 13276, 5, 60, 38, 17, -53 },
  { 13314, 27, 60, 38, 6, -53 },
  { 13517, 30, 13, 38, 4, -29 },
};

const GFXfont JetBrainsMono_Light64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_LIGHT64PT7B_H_
