#ifndef _JETBRAINSMONO_LIGHT6PT7B_H_
#define _JETBRAINSMONO_LIGHT6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xD0, 0x5D, 0x3A, 0x80, 0xFA, 0x5A, 0xEA, 0xF0,
  0x80, 0x6A, 0x90, 0xFC, 0x55, 0x80, 0x5C, 0xC0, 0xC0, 0x80, 0x25, 0x25,
  0x00, 0xFE, 0xF0, 0xAB, 0xE5, 0x70, 0x6C, 0xF0, 0xFD, 0xF7, 0x4E, 0xF0,
  0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xA0, 0xA0, 0xB0, 0x69, 0xF0, 0x96, 0xDA,
  0xFF, 0xDC, 0x4D, 0xD0, 0xFF, 0xEB, 0xFF, 0xFB, 0xFA, 0xEF, 0xFF, 0xEB,
  0x64, 0xF0, 0xEF, 0xAB, 0xBE, 0xD0, 0xFF, 0xFF, 0xFA, 0xFF, 0x40, 0xFF,
  0xE8, 0xF0, 0xE9, 0x20, 0xFF, 0xAD, 0xA0, 0xFE, 0xD0, 0xE9, 0x50, 0xA9,
  0x20, 0xEB, 0xEA, 0xB0, 0x89, 0x12, 0x40, 0xFC, 0xB0, 0xE0, 0x80, 0xFF,
  0x80, 0xBF, 0xEC, 0x7F, 0xEC, 0x7D, 0x20, 0xFF, 0xBF, 0x8A, 0xC0, 0x65,
  0x70, 0xBB, 0xC9, 0x30, 0xFF, 0x80, 0xFC, 0xFC, 0xFE, 0xFD, 0xE8, 0xDC,
  0xE9, 0x30, 0xFC, 0xAD, 0x00, 0xEE, 0x80, 0xEA, 0x80, 0xAD, 0x20, 0xEC,
  0x69, 0x90, 0xFC, 0xAE, 0xA0, 0xE0,
};

const GFXglyph JetBrainsMono_Light6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 3, 3, 4, 0, -4 },
  { 18, 3, 2, 4, 0, -3 },
  { 19, 1, 2, 4, 1, -1 },
  { 20, 2, 1, 4, 1, -2 },
  { 21, 1, 1, 4, 1, -1 },
  { 22, 3, 6, 4, 0, -5 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 2, 4, 4, 1, -4 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 2, 4, 4, 1, -4 },
  { 33, 2, 4, 4, 1, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 3, 4, 4, 0, -4 },
  { 40, 3, 4, 4, 0, -4 },
  { 42, 1, 3, 4, 1, -3 },
  { 43, 1, 4, 4, 1, -3 },
  { 44, 2, 4, 4, 1, -4 },
  { 45, 2, 2, 4, 1, -3 },
  { 46, 2, 4, 4, 1, -4 },
  { 47, 2, 4, 4, 1, -4 },
  { 48, 3, 5, 4, 0, -4 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 2, 4, 4, 1, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 2, 4, 4, 1, -4 },
  { 57, 2, 4, 4, 1, -4 },
  { 58, 2, 4, 4, 1, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 2, 4, 4, 1, -4 },
  { 67, 2, 4, 4, 1, -4 },
  { 68, 2, 4, 4, 1, -4 },
  { 69, 2, 5, 4, 1, -4 },
  { 71, 2, 4, 4, 1, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 2, 4, 4, 1, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 2, 4, 4, 1, -4 },
  { 86, 2, 6, 4, 1, -5 },
  { 88, 3, 6, 4, 0, -5 },
  { 91, 1, 6, 4, 1, -5 },
  { 92, 2, 2, 4, 1, -4 },
  { 93, 3, 1, 4, 0, 0 },
  { 94, 1, 1, 4, 1, -5 },
  { 95, 3, 3, 4, 0, -3 },
  { 97, 2, 4, 4, 1, -4 },
  { 98, 2, 3, 4, 1, -3 },
  { 99, 2, 4, 4, 1, -4 },
  { 100, 2, 3, 4, 1, -3 },
  { 101, 3, 4, 4, 0, -4 },
  { 103, 2, 4, 4, 1, -3 },
  { 104, 2, 4, 4, 1, -4 },
  { 105, 2, 5, 4, 1, -5 },
  { 107, 2, 6, 4, 1, -5 },
  { 109, 2, 4, 4, 1, -4 },
  { 110, 3, 4, 4, 0, -4 },
  { 112, 3, 3, 4, 0, -3 },
  { 114, 2, 3, 4, 1, -3 },
  { 115, 2, 3, 4, 1, -3 },
  { 116, 2, 4, 4, 1, -3 },
  { 117, 2, 4, 4, 1, -3 },
  { 118, 2, 3, 4, 1, -3 },
  { 119, 2, 3, 4, 1, -3 },
  { 120, 3, 4, 4, 0, -4 },
  { 122, 2, 3, 4, 1, -3 },
  { 123, 3, 3, 4, 0, -3 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 3, 3, 4, 0, -3 },
  { 129, 3, 4, 4, 0, -3 },
  { 131, 2, 3, 4, 1, -3 },
  { 132, 2, 6, 4, 1, -5 },
  { 134, 1, 6, 4, 1, -5 },
  { 135, 2, 6, 4, 1, -5 },
  { 137, 3, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_Light6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_LIGHT6PT7B_H_
