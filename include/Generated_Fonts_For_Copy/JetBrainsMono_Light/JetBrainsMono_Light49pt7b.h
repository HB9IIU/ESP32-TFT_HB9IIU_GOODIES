#ifndef _JETBRAINSMONO_LIGHT49PT7B_H_
#define _JETBRAINSMONO_LIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFB, 0xE0, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0x80,
  0x78, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07,
  0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0F, 0x07, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0xE0, 0x0E, 0x00, 0x38, 0x07,
  0x80, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x78,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x70, 0x0E, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC0, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80,
  0x70, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x83, 0xF3, 0x7E, 0x0F, 0x8C, 0x7C, 0x7C, 0x30, 0xF9, 0xE0, 0xC1, 0xE7,
  0x83, 0x07, 0x9E, 0x0C, 0x1E, 0x78, 0x30, 0x01, 0xE0, 0xC0, 0x07, 0x83,
  0x00, 0x1F, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0xFC, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0D, 0xFC, 0x00, 0x31, 0xF0, 0x00, 0xC3, 0xE0, 0x03, 0x07, 0x80, 0x0C,
  0x1E, 0x00, 0x30, 0x3C, 0x00, 0xC0, 0xFF, 0x03, 0x03, 0xFC, 0x0C, 0x0F,
  0xF0, 0x30, 0x7B, 0xE0, 0xC1, 0xE7, 0xC3, 0x0F, 0x9F, 0xCC, 0xFC, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xF3, 0xFE, 0x00, 0x1E, 0x7F, 0xF0,
  0x01, 0xC7, 0x87, 0x80, 0x38, 0xF0, 0x38, 0x07, 0x8E, 0x03, 0x80, 0x70,
  0xE0, 0x38, 0x0E, 0x0E, 0x03, 0x81, 0xE0, 0xE0, 0x38, 0x1C, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0x38, 0x78, 0x0F, 0x03, 0x87, 0x00, 0xF0, 0x78, 0xE0,
  0x07, 0xFF, 0x1C, 0x00, 0x3F, 0xF1, 0xC0, 0x01, 0xFC, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x7F, 0x00, 0x03, 0x8F, 0xFC, 0x00, 0x71, 0xFF, 0xC0,
  0x0F, 0x1C, 0x1E, 0x00, 0xE3, 0xC0, 0xE0, 0x1C, 0x38, 0x0E, 0x03, 0xC3,
  0x80, 0xE0, 0x38, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x0E,
  0x0E, 0x03, 0x80, 0xE1, 0xC0, 0x3C, 0x0E, 0x38, 0x01, 0xC1, 0xE7, 0x80,
  0x1F, 0xFC, 0x70, 0x00, 0xFF, 0xCE, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xE0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x3C, 0x03, 0xDF, 0x1F, 0x01, 0xEF,
  0x07, 0x81, 0xE7, 0x81, 0xE0, 0xF3, 0xC0, 0xF8, 0xF1, 0xE0, 0x3E, 0xF0,
  0xF0, 0x0F, 0x78, 0x78, 0x03, 0xF8, 0x3C, 0x01, 0xFC, 0x1E, 0x00, 0x7C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x83, 0xC0, 0x1F, 0xE1, 0xF0, 0x1F,
  0xF0, 0x7C, 0x1F, 0x3C, 0x3F, 0xFF, 0x0F, 0x0F, 0xFF, 0x07, 0xC1, 0xFE,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDC, 0xE7, 0x39, 0xC0,
  0x00, 0x06, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xE0, 0x03, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03,
  0xC0, 0x08, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x01, 0x00, 0x70, 0x04, 0x78, 0x1C, 0x07, 0xBF, 0x87, 0x0F,
  0xEF, 0xF9, 0xCF, 0xFC, 0xFF, 0xB7, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC1, 0xF0,
  0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x02, 0x00,
  0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x1C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0x0F, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x79,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x0E, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xE3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0,
  0xFF, 0x07, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x80, 0x3E, 0x3F, 0x03, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xF7, 0x80, 0x3F, 0x3C, 0x03, 0xE1,
  0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x04, 0x03, 0xC0, 0x20, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xE1, 0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xCF, 0x80, 0x3E, 0x7E, 0x07, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x0F,
  0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x81, 0x80,
  0x3C, 0xFF, 0xC1, 0xEF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF3, 0xF0,
  0x0F, 0x9F, 0x00, 0x3C, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xCF,
  0x80, 0x3E, 0x3F, 0x03, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE7, 0xF0, 0x0F, 0x7F, 0xF0, 0x3F, 0xFF, 0xE1,
  0xFE, 0x1F, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xE7,
  0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0x0F, 0xC3, 0xC0, 0x1F, 0x3E, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1C,
  0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0xF0, 0x7C, 0x1F, 0x01, 0xFB,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0x9F, 0x01,
  0xF0, 0x7E, 0x1E, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x80, 0x1E, 0x3F, 0x03, 0xF1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xE1, 0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xEF, 0x80,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1E, 0x78, 0x00, 0xF9, 0xF0, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xFF,
  0xBC, 0x1F, 0xFF, 0xE0, 0x1F, 0xEF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E,
  0x1F, 0x8F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE,
  0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFE,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1,
  0xF0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x7F, 0x00, 0x1C, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0xEF, 0xE0, 0x3C,
  0x1F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x00, 0xFE, 0x07,
  0x00, 0x7F, 0x03, 0x80, 0x3F, 0x81, 0xC0, 0x1F, 0xC0, 0xE0, 0x0F, 0xE0,
  0x70, 0x07, 0xF0, 0x38, 0x03, 0xF8, 0x1C, 0x01, 0xFC, 0x0E, 0x00, 0xFE,
  0x07, 0x80, 0xFF, 0x03, 0xC0, 0x7F, 0x81, 0xF0, 0x7F, 0xC0, 0x7F, 0xEF,
  0xE0, 0x1F, 0xF7, 0x70, 0x07, 0xF3, 0xB8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xEF, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xE7, 0x00, 0x01,
  0xC7, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0x80, 0x03, 0xC3, 0xC0, 0x03,
  0x83, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x81, 0xE0, 0x07,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0x7E, 0x78, 0x01, 0xF3,
  0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x9E,
  0x03, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xE0, 0x1F,
  0x8F, 0x00, 0x3E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x7C, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x87, 0xF0, 0xFC, 0x7C, 0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xF7, 0x80, 0x3E, 0x7E, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0,
  0x0F, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x7F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xF0, 0xFC, 0x7C, 0x03,
  0xEF, 0x80, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x7E, 0x07, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xCF,
  0x80, 0x3E, 0x7E, 0x07, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C,
  0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x1E,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xBF, 0xE0, 0x1D, 0xF7,
  0x00, 0xEF, 0xB8, 0x0E, 0xFD, 0xE0, 0x77, 0xE7, 0x03, 0xBF, 0x38, 0x39,
  0xF9, 0xE1, 0xCF, 0xC7, 0x0E, 0x7E, 0x38, 0xE3, 0xF1, 0xE7, 0x1F, 0xC7,
  0x38, 0xFE, 0x3B, 0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3E, 0x0F,
  0xE1, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xEE, 0x00, 0xFE, 0xF0, 0x0F, 0xEF, 0x00, 0xFE, 0x70, 0x0F, 0xE7, 0x80,
  0xFE, 0x38, 0x0F, 0xE3, 0x80, 0xFE, 0x3C, 0x0F, 0xE1, 0xC0, 0xFE, 0x1C,
  0x0F, 0xE1, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0,
  0x70, 0xFE, 0x07, 0x8F, 0xE0, 0x38, 0xFE, 0x03, 0x8F, 0xE0, 0x3C, 0xFE,
  0x01, 0xCF, 0xE0, 0x1E, 0xFE, 0x01, 0xEF, 0xE0, 0x0E, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xF1,
  0xFC, 0x7C, 0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x3E, 0x7E,
  0x07, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x03, 0xF3, 0xC0,
  0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF8, 0x3E,
  0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80,
  0x0F, 0x1F, 0x00, 0x7C, 0x3F, 0x03, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x7C,
  0xF0, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x7F,
  0x03, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1E, 0xF8, 0x01, 0xE7, 0x80, 0x3E, 0x7E, 0x07, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0x83,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xC7,
  0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x01, 0xEE, 0x01, 0xE0, 0x3D, 0xC0,
  0x7C, 0x07, 0xB8, 0x0F, 0x80, 0xF7, 0x81, 0xF0, 0x1C, 0xF0, 0x3F, 0x03,
  0x9E, 0x06, 0xE0, 0x73, 0xC0, 0xDC, 0x0E, 0x78, 0x1B, 0x83, 0xC7, 0x03,
  0x30, 0x78, 0xE0, 0xE6, 0x0F, 0x1C, 0x1C, 0xC1, 0xE3, 0x83, 0x98, 0x3C,
  0x78, 0x73, 0x87, 0x0F, 0x0C, 0x70, 0xE1, 0xE1, 0x8E, 0x1C, 0x3C, 0x31,
  0xC3, 0x87, 0x8E, 0x18, 0x70, 0x71, 0xC3, 0x1E, 0x0E, 0x38, 0x63, 0xC1,
  0xC7, 0x0C, 0x78, 0x38, 0xC1, 0x8E, 0x07, 0x98, 0x39, 0xC0, 0xF3, 0x07,
  0x38, 0x1E, 0x60, 0xE7, 0x03, 0xDC, 0x1C, 0xE0, 0x3B, 0x81, 0x9C, 0x07,
  0x70, 0x37, 0x80, 0xEE, 0x06, 0xF0, 0x1D, 0x80, 0xDE, 0x03, 0xB0, 0x1F,
  0x80, 0x76, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0x8F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0,
  0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x78, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x00,
  0xE7, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x3C,
  0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xBC, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xE0, 0x7C, 0x1E, 0x00, 0xF8, 0xF0, 0x01,
  0xE3, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF8,
  0x03, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0x80, 0x0F, 0xDF,
  0x80, 0x7F, 0x3F, 0xFF, 0xBC, 0x7F, 0xFC, 0xF0, 0x7F, 0xC3, 0xC0, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x1F, 0xE0,
  0xF7, 0xFF, 0x8F, 0x7F, 0xFC, 0xFE, 0x07, 0xCF, 0xC0, 0x3E, 0xF8, 0x01,
  0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xFE, 0x07, 0xCF, 0x7F, 0xFC,
  0xF7, 0xFF, 0x8F, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xF8, 0x7E, 0x07, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x7C, 0xF0, 0x07, 0xC7, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE, 0xF3,
  0xF0, 0x77, 0xBE, 0x00, 0xFD, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0,
  0x03, 0xEF, 0x80, 0x3F, 0x3F, 0x03, 0x78, 0xFF, 0xFB, 0xC3, 0xFF, 0x9E,
  0x0F, 0xF8, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C,
  0x07, 0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xEE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xBC, 0x00,
  0x3C, 0xF0, 0x03, 0xC7, 0xC0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF8,
  0xF1, 0xFF, 0xCF, 0x3F, 0xFE, 0xF7, 0xE0, 0xEF, 0xF8, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0x78, 0x03, 0xF7, 0xF0, 0xEF, 0x3F, 0xFE, 0xF1, 0xFF, 0xCF, 0x07, 0xF0,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x1F, 0xE0, 0xF7, 0xFF, 0x8F, 0x7F, 0xFC, 0xFE, 0x07,
  0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F,
  0x8F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0xBC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xF3, 0xE1, 0xF9, 0xEF, 0xE7, 0xFB,
  0xFF, 0xFF, 0xF7, 0xC3, 0xE1, 0xFF, 0x03, 0xC1, 0xFE, 0x07, 0x03, 0xFC,
  0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0,
  0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E,
  0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0,
  0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07,
  0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x78,
  0xF1, 0xFE, 0x0F, 0x7F, 0xF8, 0xF7, 0xFF, 0xCF, 0xE0, 0x7C, 0xFC, 0x03,
  0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0xE0, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0xF1, 0xFE, 0x0F, 0x7F, 0xF8,
  0xF7, 0xFF, 0xCF, 0xE0, 0x7C, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x1E, 0xFC, 0x03, 0xEF, 0xE0, 0x7C, 0xF7, 0xFF, 0xCF, 0x7F, 0xF8,
  0xF1, 0xFE, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xF8, 0xF1, 0xFF, 0xCF, 0x3F, 0xFE, 0xF7, 0xE0, 0xEF, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xF7, 0xE0,
  0x6F, 0x3F, 0xFE, 0xF1, 0xFF, 0xCF, 0x0F, 0xF8, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x0E, 0x7F, 0xF8,
  0xEF, 0xFF, 0xCE, 0xE0, 0x7C, 0xE8, 0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7C,
  0x03, 0xE7, 0xC0, 0x0F, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x03, 0xEF, 0xC0, 0x3E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x80, 0x1E, 0x78, 0x03,
  0xE7, 0xE0, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x3C, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E,
  0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x1E, 0x03, 0xF8, 0x0F, 0x01, 0xFC,
  0x0F, 0x80, 0xFE, 0x07, 0xC0, 0x77, 0x03, 0x60, 0x7B, 0x81, 0xB0, 0x3D,
  0xC0, 0xDC, 0x1C, 0xE0, 0x6E, 0x0E, 0x78, 0x73, 0x07, 0x3C, 0x39, 0x83,
  0x8E, 0x18, 0xC1, 0xC7, 0x0C, 0x71, 0xE3, 0x86, 0x38, 0xE1, 0xC3, 0x1C,
  0x70, 0xF3, 0x86, 0x38, 0x79, 0xC3, 0x1C, 0x1C, 0xC1, 0x8E, 0x0E, 0x60,
  0xEF, 0x07, 0x30, 0x77, 0x03, 0x98, 0x3B, 0x81, 0xDC, 0x1D, 0xC0, 0xFE,
  0x06, 0xE0, 0x3E, 0x03, 0x70, 0x1F, 0x01, 0xB8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0x3E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x81, 0xE0,
  0x07, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x01, 0xEF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xE7, 0x80,
  0x03, 0xC7, 0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x01, 0xF0,
  0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x1F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x1E, 0x7F,
  0xC0, 0x3D, 0xFF, 0xC0, 0x7B, 0xC7, 0xC0, 0xF7, 0x07, 0xC1, 0xFE, 0x07,
  0xC3, 0xFC, 0x07, 0xFF, 0x78, 0x07, 0xFE, 0xF0, 0x07, 0xF8, 0x00, 0x03,
  0x80,
};

const GFXglyph JetBrainsMono_Light49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 36, 29, 11, -36 },
  { 33, 14, 15, 29, 8, -36 },
  { 60, 26, 36, 29, 2, -36 },
  { 177, 22, 50, 29, 4, -43 },
  { 315, 28, 36, 29, 1, -36 },
  { 441, 25, 36, 29, 3, -36 },
  { 554, 5, 15, 29, 12, -36 },
  { 564, 15, 47, 29, 9, -41 },
  { 653, 14, 47, 29, 6, -41 },
  { 736, 26, 25, 29, 2, -30 },
  { 818, 23, 23, 29, 3, -28 },
  { 885, 10, 15, 29, 8, -7 },
  { 904, 16, 4, 29, 7, -18 },
  { 912, 8, 7, 29, 11, -7 },
  { 919, 21, 46, 29, 4, -41 },
  { 1040, 21, 36, 29, 4, -36 },
  { 1135, 21, 36, 29, 5, -36 },
  { 1230, 22, 36, 29, 4, -36 },
  { 1329, 21, 36, 29, 4, -36 },
  { 1424, 20, 36, 29, 4, -36 },
  { 1514, 21, 36, 29, 4, -36 },
  { 1609, 22, 36, 29, 4, -36 },
  { 1708, 22, 36, 29, 4, -36 },
  { 1807, 21, 36, 29, 4, -36 },
  { 1902, 22, 36, 29, 4, -36 },
  { 2001, 8, 27, 29, 11, -27 },
  { 2028, 10, 35, 29, 9, -27 },
  { 2072, 21, 26, 29, 4, -29 },
  { 2141, 21, 15, 29, 4, -24 },
  { 2181, 21, 26, 29, 4, -29 },
  { 2250, 17, 36, 29, 7, -36 },
  { 2327, 25, 45, 29, 2, -36 },
  { 2468, 24, 36, 29, 3, -36 },
  { 2576, 21, 36, 29, 5, -36 },
  { 2671, 20, 36, 29, 5, -36 },
  { 2761, 20, 36, 29, 5, -36 },
  { 2851, 20, 36, 29, 5, -36 },
  { 2941, 21, 36, 29, 5, -36 },
  { 3036, 20, 36, 29, 5, -36 },
  { 3126, 20, 36, 29, 5, -36 },
  { 3216, 19, 36, 29, 5, -36 },
  { 3302, 21, 36, 29, 3, -36 },
  { 3397, 22, 36, 29, 5, -36 },
  { 3496, 20, 36, 29, 6, -36 },
  { 3586, 21, 36, 29, 4, -36 },
  { 3681, 20, 36, 29, 5, -36 },
  { 3771, 20, 36, 29, 5, -36 },
  { 3861, 22, 36, 29, 5, -36 },
  { 3960, 22, 45, 29, 4, -36 },
  { 4084, 22, 36, 29, 5, -36 },
  { 4183, 22, 36, 29, 4, -36 },
  { 4282, 24, 36, 29, 3, -36 },
  { 4390, 20, 36, 29, 5, -36 },
  { 4480, 24, 36, 29, 3, -36 },
  { 4588, 27, 36, 29, 1, -36 },
  { 4710, 25, 36, 29, 2, -36 },
  { 4823, 25, 36, 29, 2, -36 },
  { 4936, 21, 36, 29, 4, -36 },
  { 5031, 12, 46, 29, 10, -41 },
  { 5100, 21, 46, 29, 4, -41 },
  { 5221, 12, 46, 29, 7, -41 },
  { 5290, 21, 19, 29, 4, -36 },
  { 5340, 23, 4, 29, 3, 1 },
  { 5352, 10, 6, 29, 9, -38 },
  { 5360, 22, 27, 29, 3, -27 },
  { 5435, 20, 36, 29, 5, -36 },
  { 5525, 21, 27, 29, 4, -27 },
  { 5596, 21, 36, 29, 4, -36 },
  { 5691, 21, 27, 29, 4, -27 },
  { 5762, 23, 36, 29, 3, -36 },
  { 5866, 20, 36, 29, 5, -27 },
  { 5956, 20, 36, 29, 5, -36 },
  { 6046, 23, 38, 29, 4, -38 },
  { 6156, 18, 47, 29, 4, -38 },
  { 6262, 22, 36, 29, 5, -36 },
  { 6361, 25, 36, 29, 2, -36 },
  { 6474, 23, 27, 29, 3, -27 },
  { 6552, 20, 27, 29, 5, -27 },
  { 6620, 21, 27, 29, 4, -27 },
  { 6691, 20, 36, 29, 5, -27 },
  { 6781, 20, 36, 29, 5, -27 },
  { 6871, 20, 27, 29, 6, -27 },
  { 6939, 21, 27, 29, 4, -27 },
  { 7010, 22, 35, 29, 3, -35 },
  { 7107, 20, 27, 29, 5, -27 },
  { 7175, 23, 27, 29, 3, -27 },
  { 7253, 25, 27, 29, 2, -27 },
  { 7338, 24, 27, 29, 3, -27 },
  { 7419, 23, 36, 29, 3, -27 },
  { 7523, 20, 27, 29, 5, -27 },
  { 7591, 21, 46, 29, 4, -41 },
  { 7712, 4, 46, 29, 13, -41 },
  { 7735, 21, 46, 29, 4, -41 },
  { 7856, 23, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_Light49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_LIGHT49PT7B_H_
