#ifndef _JETBRAINSMONO_LIGHT14PT7B_H_
#define _JETBRAINSMONO_LIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x54, 0x70, 0x99, 0x99, 0x12, 0x12, 0x12, 0x6F, 0x24, 0x24,
  0xFE, 0x24, 0x44, 0x48, 0x10, 0x47, 0xF5, 0x91, 0x47, 0x07, 0x16, 0x5D,
  0x5E, 0x10, 0x40, 0x71, 0x92, 0x94, 0x74, 0x08, 0x16, 0x19, 0x29, 0x49,
  0xC7, 0x79, 0x93, 0x02, 0x06, 0x16, 0xE5, 0x44, 0x8D, 0xEC, 0xF0, 0x16,
  0x48, 0x88, 0x88, 0x88, 0x84, 0x71, 0x8C, 0x22, 0x11, 0x11, 0x13, 0x26,
  0xC8, 0x10, 0x22, 0x4F, 0xF1, 0x05, 0x13, 0x24, 0x10, 0x41, 0x3F, 0x10,
  0x41, 0x00, 0x6D, 0x60, 0xF0, 0xF0, 0x04, 0x10, 0x82, 0x08, 0x41, 0x0C,
  0x20, 0x84, 0x10, 0x42, 0x00, 0x7B, 0x18, 0x61, 0xB6, 0x58, 0x61, 0xC5,
  0xE0, 0x31, 0xA2, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x7A, 0x18,
  0x41, 0x0C, 0x61, 0x08, 0x43, 0xF0, 0xFC, 0x21, 0x08, 0x38, 0x10, 0x61,
  0xC5, 0xE0, 0x08, 0x43, 0x08, 0x47, 0x18, 0x7F, 0x04, 0x10, 0x7D, 0x0C,
  0x3E, 0xCC, 0x10, 0x41, 0xC5, 0xE0, 0x18, 0xC2, 0x10, 0x7E, 0x18, 0x61,
  0xC5, 0xE0, 0xFE, 0x10, 0x42, 0x08, 0x61, 0x04, 0x20, 0x80, 0x7B, 0x18,
  0x53, 0x31, 0x28, 0x61, 0xC5, 0xE0, 0x7B, 0x18, 0x61, 0xC5, 0xF0, 0x84,
  0x10, 0x80, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x58, 0x04, 0x66, 0x20, 0x60,
  0x60, 0x40, 0xFC, 0x00, 0x00, 0xFC, 0xC0, 0xC1, 0xC1, 0x19, 0x88, 0x00,
  0xF0, 0xC2, 0x11, 0x31, 0x00, 0x43, 0x00, 0x7D, 0x0A, 0x0C, 0xDB, 0x74,
  0x68, 0xD1, 0x9F, 0x02, 0x03, 0x01, 0x80, 0x30, 0x60, 0xA3, 0x44, 0x89,
  0x1F, 0x62, 0x85, 0x0C, 0xFA, 0x18, 0x61, 0xFA, 0x38, 0x61, 0x87, 0xE0,
  0x7B, 0x18, 0x60, 0x82, 0x08, 0x21, 0x45, 0xE0, 0xFA, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x8F, 0xE0, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC3, 0xF0,
  0xFE, 0x08, 0x20, 0xFF, 0x0C, 0x30, 0xC3, 0x00, 0x7B, 0x18, 0x60, 0x82,
  0x78, 0x61, 0x45, 0xE0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x3C, 0x10, 0x41, 0x04, 0x10,
  0x61, 0x8D, 0xE0, 0x87, 0x0A, 0x24, 0x4F, 0x13, 0x22, 0x46, 0x85, 0x0C,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0xC7, 0x3A, 0xEB, 0xB6, 0x58,
  0x61, 0x86, 0x10, 0xC7, 0x1A, 0x69, 0x96, 0x59, 0x63, 0x8E, 0x30, 0x7B,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xE0, 0xFD, 0x0A, 0x1C, 0x38, 0x5F,
  0x20, 0x40, 0x81, 0x00, 0x7B, 0x18, 0x61, 0x86, 0x18, 0x61, 0xC5, 0xE0,
  0x83, 0x04, 0xFD, 0x0A, 0x14, 0x28, 0xDE, 0x22, 0x44, 0x85, 0x0C, 0x7F,
  0x18, 0x10, 0x70, 0x30, 0x61, 0xC5, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xE0,
  0x87, 0x0B, 0x12, 0x24, 0x89, 0x0A, 0x14, 0x30, 0x60, 0xC9, 0x59, 0x59,
  0x59, 0x56, 0x56, 0x56, 0x66, 0x66, 0x26, 0x86, 0x99, 0x21, 0xC3, 0x06,
  0x0A, 0x24, 0xC5, 0x0C, 0x87, 0x89, 0x33, 0x43, 0x86, 0x04, 0x08, 0x10,
  0x20, 0xFC, 0x10, 0x86, 0x10, 0x82, 0x10, 0xC3, 0xF0, 0xF2, 0x49, 0x24,
  0x92, 0x49, 0xC0, 0x81, 0x04, 0x10, 0x20, 0x83, 0x04, 0x10, 0x20, 0x83,
  0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x93, 0xC0, 0x30, 0xA4, 0x92, 0xC4,
  0xFE, 0x90, 0x39, 0x38, 0x47, 0xE6, 0x18, 0x5F, 0x82, 0x0B, 0xB3, 0xC6,
  0x18, 0x61, 0xC6, 0xE0, 0x39, 0x38, 0x60, 0x82, 0x1C, 0x5E, 0x04, 0x17,
  0x53, 0x86, 0x18, 0x61, 0xC5, 0xF0, 0x39, 0x38, 0x7F, 0x82, 0x0C, 0x5E,
  0x1C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x80, 0x75, 0x38, 0x61, 0x87,
  0x17, 0xC9, 0x04, 0x37, 0x00, 0x82, 0x0B, 0xB3, 0xC6, 0x18, 0x61, 0x86,
  0x10, 0x10, 0x60, 0x03, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x08,
  0xC0, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x60, 0xC1, 0x83, 0x1E, 0x2C,
  0x9A, 0x3C, 0x64, 0xCD, 0x8C, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x0F, 0xEE, 0x59, 0x65, 0x96, 0x59, 0x65, 0xBB, 0x3C, 0x61,
  0x86, 0x18, 0x61, 0x39, 0x38, 0x61, 0x86, 0x1C, 0x5E, 0xBB, 0x3C, 0x61,
  0x86, 0x1C, 0x6E, 0x82, 0x08, 0x00, 0x75, 0x38, 0x61, 0x86, 0x1C, 0x5F,
  0x04, 0x10, 0x40, 0xF4, 0x63, 0x08, 0x42, 0x10, 0x79, 0x1C, 0x18, 0x1C,
  0x1C, 0x5F, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20, 0x70, 0x86, 0x18,
  0x61, 0x86, 0x14, 0x5E, 0x87, 0x09, 0x12, 0x44, 0x85, 0x0C, 0x18, 0x93,
  0x66, 0xCD, 0xAA, 0xD5, 0xB3, 0x26, 0x84, 0x99, 0xA1, 0x83, 0x05, 0x13,
  0x43, 0x87, 0x89, 0x12, 0x42, 0x85, 0x0C, 0x08, 0x20, 0x40, 0x80, 0xFC,
  0x10, 0x84, 0x21, 0x84, 0x3F, 0x04, 0x61, 0x04, 0x10, 0x4F, 0x0C, 0x10,
  0x41, 0x04, 0x18, 0x10, 0xFF, 0xFC, 0xC0, 0x82, 0x08, 0x20, 0x81, 0xCC,
  0x20, 0x82, 0x08, 0x62, 0x00, 0xE6, 0x70,
};

const GFXglyph JetBrainsMono_Light14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 14, 8, 1, -12 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 7, 10, 8, 1, -10 },
  { 46, 1, 4, 8, 4, -10 },
  { 47, 4, 14, 8, 3, -12 },
  { 54, 4, 14, 8, 2, -12 },
  { 61, 7, 8, 8, 1, -9 },
  { 68, 6, 7, 8, 1, -8 },
  { 74, 3, 4, 8, 2, -2 },
  { 76, 4, 1, 8, 2, -5 },
  { 77, 2, 2, 8, 3, -2 },
  { 78, 6, 14, 8, 1, -12 },
  { 89, 6, 10, 8, 1, -10 },
  { 97, 7, 10, 8, 1, -10 },
  { 106, 6, 10, 8, 1, -10 },
  { 114, 6, 10, 8, 1, -10 },
  { 122, 6, 10, 8, 1, -10 },
  { 130, 6, 10, 8, 1, -10 },
  { 138, 6, 10, 8, 1, -10 },
  { 146, 6, 10, 8, 1, -10 },
  { 154, 6, 10, 8, 1, -10 },
  { 162, 6, 10, 8, 1, -10 },
  { 170, 2, 8, 8, 3, -8 },
  { 172, 3, 10, 8, 2, -8 },
  { 176, 6, 7, 8, 1, -8 },
  { 182, 6, 5, 8, 1, -7 },
  { 186, 6, 7, 8, 1, -8 },
  { 192, 5, 10, 8, 2, -10 },
  { 199, 7, 13, 8, 1, -10 },
  { 211, 7, 10, 8, 1, -10 },
  { 220, 6, 10, 8, 1, -10 },
  { 228, 6, 10, 8, 1, -10 },
  { 236, 6, 10, 8, 1, -10 },
  { 244, 6, 10, 8, 1, -10 },
  { 252, 6, 10, 8, 1, -10 },
  { 260, 6, 10, 8, 1, -10 },
  { 268, 6, 10, 8, 1, -10 },
  { 276, 5, 10, 8, 2, -10 },
  { 283, 6, 10, 8, 1, -10 },
  { 291, 7, 10, 8, 1, -10 },
  { 300, 5, 10, 8, 2, -10 },
  { 307, 6, 10, 8, 1, -10 },
  { 315, 6, 10, 8, 1, -10 },
  { 323, 6, 10, 8, 1, -10 },
  { 331, 7, 10, 8, 1, -10 },
  { 340, 6, 13, 8, 1, -10 },
  { 350, 7, 10, 8, 1, -10 },
  { 359, 6, 10, 8, 1, -10 },
  { 367, 7, 10, 8, 1, -10 },
  { 376, 6, 10, 8, 1, -10 },
  { 384, 7, 10, 8, 1, -10 },
  { 393, 8, 10, 8, 0, -10 },
  { 403, 7, 10, 8, 1, -10 },
  { 412, 7, 10, 8, 1, -10 },
  { 421, 6, 10, 8, 1, -10 },
  { 429, 3, 14, 8, 3, -12 },
  { 435, 6, 14, 8, 1, -12 },
  { 446, 3, 14, 8, 2, -12 },
  { 452, 6, 5, 8, 1, -10 },
  { 456, 7, 1, 8, 1, 0 },
  { 457, 2, 2, 8, 3, -11 },
  { 458, 6, 8, 8, 1, -8 },
  { 464, 6, 10, 8, 1, -10 },
  { 472, 6, 8, 8, 1, -8 },
  { 478, 6, 10, 8, 1, -10 },
  { 486, 6, 8, 8, 1, -8 },
  { 492, 6, 10, 8, 1, -10 },
  { 500, 6, 11, 8, 1, -8 },
  { 509, 6, 10, 8, 1, -10 },
  { 517, 7, 11, 8, 1, -11 },
  { 527, 5, 14, 8, 1, -11 },
  { 536, 7, 10, 8, 1, -10 },
  { 545, 8, 10, 8, 0, -10 },
  { 555, 6, 8, 8, 1, -8 },
  { 561, 6, 8, 8, 1, -8 },
  { 567, 6, 8, 8, 1, -8 },
  { 573, 6, 11, 8, 1, -8 },
  { 582, 6, 11, 8, 1, -8 },
  { 591, 5, 8, 8, 2, -8 },
  { 596, 6, 8, 8, 1, -8 },
  { 602, 6, 10, 8, 1, -10 },
  { 610, 6, 8, 8, 1, -8 },
  { 616, 7, 8, 8, 1, -8 },
  { 623, 7, 8, 8, 1, -8 },
  { 630, 7, 8, 8, 1, -8 },
  { 637, 7, 11, 8, 1, -8 },
  { 647, 6, 8, 8, 1, -8 },
  { 653, 6, 14, 8, 1, -12 },
  { 664, 1, 14, 8, 4, -12 },
  { 666, 6, 14, 8, 1, -12 },
  { 677, 6, 2, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Light14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_LIGHT14PT7B_H_
