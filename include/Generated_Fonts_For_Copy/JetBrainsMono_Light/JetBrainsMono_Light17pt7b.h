#ifndef _JETBRAINSMONO_LIGHT17PT7B_H_
#define _JETBRAINSMONO_LIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF5, 0x0F, 0x9C, 0xE5, 0x29, 0x00, 0x13, 0x11, 0x08, 0x9F,
  0xF2, 0x21, 0x11, 0x90, 0x88, 0xFF, 0x22, 0x11, 0x19, 0x80, 0x08, 0x08,
  0x18, 0x7E, 0x4B, 0x4B, 0x48, 0x68, 0x3C, 0x0E, 0x0B, 0x09, 0xCB, 0x4B,
  0x3E, 0x08, 0x08, 0x20, 0x5E, 0x2C, 0x9A, 0x24, 0xCA, 0x1D, 0x80, 0x40,
  0x24, 0x16, 0xC5, 0x12, 0x45, 0x11, 0xC3, 0x80, 0x18, 0x3E, 0x11, 0x88,
  0x04, 0x01, 0x01, 0xC1, 0x32, 0x8B, 0x43, 0x21, 0x99, 0xE7, 0x98, 0xFF,
  0xC0, 0x19, 0x98, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x84, 0x30, 0xE1, 0xC3,
  0x0C, 0x21, 0x84, 0x21, 0x08, 0x42, 0x31, 0x19, 0x90, 0x18, 0x0C, 0x22,
  0x5D, 0xF1, 0x81, 0xE0, 0x98, 0xC4, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18,
  0x18, 0x18, 0x6D, 0x6D, 0x00, 0xFC, 0x7C, 0x03, 0x02, 0x06, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0xC0, 0x18,
  0x7E, 0x43, 0xC3, 0xC3, 0xC3, 0xDB, 0xDB, 0xC3, 0xC3, 0x43, 0x62, 0x3C,
  0x71, 0xA2, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x18,
  0x7E, 0x42, 0xC3, 0x03, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x7F,
  0x7E, 0x06, 0x0C, 0x18, 0x1C, 0x06, 0x02, 0x03, 0x03, 0xC2, 0x46, 0x3C,
  0x06, 0x18, 0x60, 0x83, 0x0C, 0x50, 0xE1, 0xFE, 0x04, 0x08, 0x10, 0xFD,
  0x02, 0x04, 0x0B, 0xD8, 0x81, 0x83, 0x07, 0x0E, 0x13, 0xC0, 0x0C, 0x18,
  0x10, 0x20, 0x6C, 0x7E, 0xC3, 0xC1, 0xC1, 0xC3, 0x62, 0x3C, 0xFF, 0xC3,
  0xC2, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x18, 0x7E,
  0x42, 0x43, 0x42, 0x66, 0x18, 0x66, 0x42, 0xC3, 0xC3, 0x42, 0x3E, 0x18,
  0x7E, 0x43, 0xC1, 0xC1, 0xC3, 0x43, 0x7E, 0x06, 0x0C, 0x08, 0x18, 0x30,
  0x7C, 0x00, 0xF0, 0x27, 0x60, 0x00, 0x06, 0x64, 0x4C, 0x80, 0x01, 0x06,
  0x18, 0x60, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x0E, 0x38, 0xE0, 0x80, 0xF8, 0x30, 0x41,
  0x04, 0xF3, 0x08, 0x20, 0x06, 0x1C, 0x18, 0x76, 0x41, 0x81, 0x81, 0x8F,
  0x91, 0x91, 0x91, 0x91, 0x99, 0x8F, 0x80, 0xC0, 0x60, 0x3C, 0x18, 0x1C,
  0x3C, 0x24, 0x24, 0x26, 0x66, 0x7E, 0x7E, 0x43, 0xC1, 0x81, 0xFD, 0x0A,
  0x1C, 0x38, 0x5F, 0x21, 0x43, 0x83, 0x0E, 0x37, 0xC0, 0x31, 0xFA, 0x1C,
  0x38, 0x10, 0x20, 0x40, 0x81, 0x02, 0x1E, 0x27, 0x80, 0xF9, 0x0A, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0A, 0x37, 0xC0, 0xFF, 0x02, 0x04, 0x08,
  0x1F, 0xA0, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F,
  0xA0, 0x40, 0x81, 0x02, 0x04, 0x00, 0x31, 0xFA, 0x1C, 0x38, 0x10, 0x20,
  0x4F, 0x87, 0x0E, 0x1E, 0x27, 0x80, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x3F, 0x1E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x83, 0x07, 0x1B,
  0xE0, 0x87, 0x0A, 0x34, 0x49, 0x9E, 0x26, 0x44, 0x8D, 0x0A, 0x1C, 0x10,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xC3,
  0xA7, 0xA5, 0xE5, 0xDD, 0xD9, 0xD9, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC7,
  0x8F, 0x1D, 0x3A, 0x76, 0xE5, 0xCB, 0x9F, 0x1E, 0x3C, 0x30, 0x31, 0xFA,
  0x14, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x27, 0x80, 0xFD, 0x0E,
  0x0C, 0x18, 0x31, 0xFE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x18, 0x7E, 0x42,
  0x43, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x62, 0x3C, 0x04, 0x06,
  0x03, 0xFD, 0x0E, 0x0C, 0x18, 0x7F, 0xBE, 0x44, 0x89, 0x1A, 0x14, 0x30,
  0x18, 0x7E, 0x43, 0x43, 0x40, 0x60, 0x3C, 0x06, 0x03, 0x01, 0xC3, 0x43,
  0x3E, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x13, 0xC0,
  0xC1, 0xC3, 0x43, 0x42, 0x62, 0x66, 0x24, 0x24, 0x34, 0x1C, 0x18, 0x18,
  0xCC, 0xD3, 0x24, 0xC9, 0x32, 0x4A, 0x92, 0xA7, 0x29, 0xCA, 0x32, 0x8C,
  0xE3, 0x30, 0xCC, 0xC3, 0x62, 0x26, 0x34, 0x18, 0x18, 0x18, 0x3C, 0x26,
  0x62, 0x43, 0xC1, 0xC1, 0xA1, 0x90, 0x84, 0xC2, 0x40, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x00, 0x7F, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x08, 0x0C,
  0x04, 0x06, 0x02, 0x02, 0x03, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0x18, 0x1C, 0x24, 0x26, 0x42, 0xC3, 0xFF, 0xFF, 0xC3, 0x08, 0x7E,
  0x42, 0x03, 0x03, 0x7F, 0xC3, 0xC3, 0xC3, 0x7F, 0x81, 0x02, 0x47, 0xE8,
  0x50, 0xE1, 0xC3, 0x87, 0x0F, 0x15, 0xE0, 0x11, 0xFA, 0x1C, 0x38, 0x10,
  0x20, 0x43, 0xC4, 0xF0, 0x06, 0x0C, 0x9F, 0xF8, 0x70, 0xE1, 0xC3, 0x87,
  0x0F, 0x1B, 0xF0, 0x11, 0xFA, 0x14, 0x38, 0x7F, 0xE0, 0x41, 0xC4, 0xF0,
  0x1F, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x21, 0xFE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFE, 0x0C, 0x18, 0x27, 0xC0,
  0x81, 0x02, 0x47, 0xE8, 0x50, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x1C,
  0x18, 0x00, 0x00, 0x78, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF,
  0x0E, 0x0C, 0x00, 0x07, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x83, 0x7C, 0x81, 0x02, 0x04, 0x38, 0xD1, 0x26, 0x78, 0x99, 0x1A, 0x14,
  0x30, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x0F, 0x22, 0xB7, 0xC9, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x11,
  0xFA, 0x14, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x11, 0xFA, 0x14, 0x38,
  0x70, 0xE1, 0xC3, 0xC4, 0xF0, 0x11, 0xFA, 0x14, 0x38, 0x70, 0xE1, 0xC3,
  0xC5, 0x7A, 0x04, 0x08, 0x00, 0x21, 0xFE, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0xC6, 0xFC, 0x18, 0x30, 0x60, 0x11, 0x7B, 0x1C, 0x18, 0x10, 0x20, 0x40,
  0x81, 0x00, 0x11, 0xFA, 0x1C, 0x0E, 0x07, 0x81, 0x83, 0x86, 0xF8, 0x10,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE2, 0x78, 0xC1, 0x43, 0x42, 0x62, 0x26,
  0x24, 0x34, 0x1C, 0x18, 0x99, 0xCC, 0xA6, 0x53, 0x2D, 0x53, 0x39, 0x98,
  0xCC, 0x66, 0x00, 0xC3, 0x66, 0x34, 0x18, 0x18, 0x3C, 0x26, 0x62, 0xC3,
  0xC3, 0x42, 0x62, 0x26, 0x24, 0x34, 0x1C, 0x18, 0x18, 0x18, 0x10, 0x30,
  0xFC, 0x18, 0x20, 0x83, 0x0C, 0x30, 0x40, 0xFE, 0x0E, 0x30, 0x40, 0x81,
  0x02, 0x04, 0x78, 0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x0F, 0x38, 0x40, 0x81,
  0x02, 0x04, 0x18, 0x60, 0x61, 0xD1, 0x8B, 0x86,
};

const GFXglyph JetBrainsMono_Light17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 5, 5, 10, 3, -12 },
  { 8, 9, 12, 10, 1, -12 },
  { 22, 8, 17, 10, 1, -15 },
  { 39, 10, 13, 10, 0, -13 },
  { 56, 9, 13, 10, 1, -13 },
  { 71, 2, 5, 10, 4, -12 },
  { 73, 5, 16, 10, 3, -14 },
  { 83, 5, 16, 10, 2, -14 },
  { 93, 9, 8, 10, 1, -10 },
  { 102, 8, 8, 10, 1, -10 },
  { 110, 3, 6, 10, 3, -3 },
  { 113, 6, 1, 10, 2, -6 },
  { 114, 2, 3, 10, 4, -3 },
  { 115, 8, 16, 10, 1, -14 },
  { 131, 8, 13, 10, 1, -13 },
  { 144, 7, 12, 10, 2, -12 },
  { 155, 8, 13, 10, 1, -13 },
  { 168, 8, 12, 10, 1, -12 },
  { 180, 7, 12, 10, 1, -12 },
  { 191, 7, 12, 10, 2, -12 },
  { 202, 8, 12, 10, 1, -12 },
  { 214, 8, 12, 10, 1, -12 },
  { 226, 8, 13, 10, 1, -13 },
  { 239, 8, 13, 10, 1, -13 },
  { 252, 2, 10, 10, 4, -10 },
  { 255, 4, 13, 10, 3, -10 },
  { 262, 8, 9, 10, 1, -10 },
  { 271, 8, 5, 10, 1, -8 },
  { 276, 8, 9, 10, 1, -10 },
  { 285, 6, 12, 10, 2, -12 },
  { 294, 8, 16, 10, 1, -13 },
  { 310, 8, 12, 10, 1, -12 },
  { 322, 7, 12, 10, 2, -12 },
  { 333, 7, 13, 10, 2, -13 },
  { 345, 7, 12, 10, 2, -12 },
  { 356, 7, 12, 10, 2, -12 },
  { 367, 7, 12, 10, 2, -12 },
  { 378, 7, 13, 10, 2, -13 },
  { 390, 7, 12, 10, 2, -12 },
  { 401, 6, 12, 10, 2, -12 },
  { 410, 7, 12, 10, 1, -12 },
  { 421, 7, 12, 10, 2, -12 },
  { 432, 7, 12, 10, 2, -12 },
  { 443, 8, 12, 10, 1, -12 },
  { 455, 7, 12, 10, 2, -12 },
  { 466, 7, 13, 10, 2, -13 },
  { 478, 7, 12, 10, 2, -12 },
  { 489, 8, 16, 10, 1, -13 },
  { 505, 7, 12, 10, 2, -12 },
  { 516, 8, 13, 10, 1, -13 },
  { 529, 8, 12, 10, 1, -12 },
  { 541, 7, 12, 10, 2, -12 },
  { 552, 8, 12, 10, 1, -12 },
  { 564, 10, 12, 10, 0, -12 },
  { 579, 8, 12, 10, 1, -12 },
  { 591, 9, 12, 10, 1, -12 },
  { 605, 8, 12, 10, 1, -12 },
  { 617, 4, 16, 10, 4, -14 },
  { 625, 8, 16, 10, 1, -14 },
  { 641, 4, 16, 10, 3, -14 },
  { 649, 8, 6, 10, 1, -12 },
  { 655, 8, 2, 10, 1, 0 },
  { 657, 4, 2, 10, 3, -13 },
  { 658, 8, 10, 10, 1, -10 },
  { 668, 7, 12, 10, 2, -12 },
  { 679, 7, 10, 10, 2, -10 },
  { 688, 7, 12, 10, 2, -12 },
  { 699, 7, 10, 10, 2, -10 },
  { 708, 8, 12, 10, 1, -12 },
  { 720, 7, 13, 10, 2, -10 },
  { 732, 7, 12, 10, 2, -12 },
  { 743, 8, 13, 10, 1, -13 },
  { 756, 7, 16, 10, 1, -13 },
  { 770, 7, 12, 10, 2, -12 },
  { 781, 8, 12, 10, 1, -12 },
  { 793, 8, 10, 10, 1, -10 },
  { 803, 7, 10, 10, 2, -10 },
  { 812, 7, 10, 10, 2, -10 },
  { 821, 7, 13, 10, 2, -10 },
  { 833, 7, 13, 10, 2, -10 },
  { 845, 7, 10, 10, 2, -10 },
  { 854, 7, 10, 10, 2, -10 },
  { 863, 8, 12, 10, 1, -12 },
  { 875, 7, 9, 10, 2, -9 },
  { 883, 8, 9, 10, 1, -9 },
  { 892, 9, 9, 10, 1, -9 },
  { 903, 8, 9, 10, 1, -9 },
  { 912, 8, 12, 10, 1, -9 },
  { 924, 7, 9, 10, 2, -9 },
  { 932, 7, 16, 10, 2, -14 },
  { 946, 2, 16, 10, 4, -14 },
  { 950, 7, 16, 10, 2, -14 },
  { 964, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_Light17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_LIGHT17PT7B_H_
