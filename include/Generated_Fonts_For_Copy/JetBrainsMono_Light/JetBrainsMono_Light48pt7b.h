#ifndef _JETBRAINSMONO_LIGHT48PT7B_H_
#define _JETBRAINSMONO_LIGHT48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFD, 0xF0, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3D,
  0xC0, 0xF7, 0x03, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x70, 0x00, 0xF0, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x1C, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x07, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x38,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x0F, 0x9C, 0xF8, 0xF8, 0xE3, 0xE7, 0x87, 0x0F, 0x3C, 0x38, 0x39,
  0xC1, 0xC1, 0xEE, 0x0E, 0x0F, 0x70, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1C,
  0x00, 0xF8, 0xE0, 0x03, 0xE7, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xE7,
  0xE0, 0x07, 0x0F, 0x00, 0x38, 0x7C, 0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00,
  0x70, 0x7F, 0x03, 0x83, 0xFC, 0x1C, 0x1F, 0xE0, 0xE0, 0xFF, 0x87, 0x0F,
  0xBC, 0x38, 0x79, 0xF9, 0xCF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x01, 0xE7,
  0xFC, 0x00, 0x39, 0xFF, 0xC0, 0x0E, 0x78, 0x3C, 0x03, 0xCE, 0x03, 0x80,
  0x71, 0xC0, 0x70, 0x1C, 0x38, 0x0E, 0x07, 0x87, 0x01, 0xC0, 0xE0, 0xE0,
  0x38, 0x38, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0xE1, 0xC0, 0x78, 0x3C, 0x70,
  0x07, 0x8F, 0x1C, 0x00, 0xFF, 0xE3, 0x80, 0x0F, 0xF8, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0x8F, 0xF8, 0x00, 0xE3, 0xFF, 0x80, 0x3C,
  0xF0, 0xF0, 0x07, 0x1C, 0x0F, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x70, 0x1C,
  0x0E, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0x70, 0xE0, 0x38, 0x0E, 0x1C, 0x07,
  0x01, 0xC7, 0x00, 0xE0, 0x79, 0xC0, 0x1E, 0x0E, 0x78, 0x01, 0xFF, 0xCE,
  0x00, 0x1F, 0xF3, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x01, 0xF8, 0xF0, 0x1E, 0xF0, 0x78, 0x1E, 0xF0, 0x7C,
  0x3C, 0xF0, 0x3C, 0x3C, 0xF0, 0x1E, 0x78, 0xF0, 0x1F, 0x78, 0xF0, 0x0F,
  0xF0, 0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03,
  0xE0, 0xF0, 0x07, 0xF0, 0xF0, 0x0F, 0x78, 0x7C, 0x1F, 0x7C, 0x7F, 0xFE,
  0x3C, 0x3F, 0xFC, 0x1E, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xC0,
  0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x38, 0x0E, 0xFC, 0x1C, 0x1F,
  0x7F, 0x8E, 0x7F, 0xDF, 0xF6, 0x7F, 0xC3, 0xFF, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x78,
  0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0,
  0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0,
  0x7E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC,
  0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x07, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x80, 0x3E,
  0x3E, 0x07, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0x3C,
  0x01, 0xF8, 0xF0, 0x07, 0xC3, 0xC0, 0x1C, 0x0F, 0x00, 0x60, 0x3C, 0x01,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xE0,
  0x7E, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x77,
  0x00, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0x78, 0x03, 0xE7, 0xE0, 0x7C, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F,
  0x3C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x8F, 0xE0, 0x3D, 0xFF, 0xC1, 0xEF, 0xFF, 0x0F, 0xF1,
  0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x0F, 0x9E, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x3C,
  0x00, 0x79, 0xF0, 0x07, 0x87, 0xC0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x30, 0x01, 0xE7, 0xF8, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFC, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D,
  0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0,
  0x01, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01,
  0xE7, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x0F, 0x01, 0xF1, 0xF0, 0x07,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xBF, 0x01, 0xF0, 0x7C,
  0x1F, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xCF, 0x80, 0x3E, 0x7E, 0x03, 0xE1, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x7C, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xF0, 0x1F, 0x87, 0xFF, 0xFE, 0x0F,
  0xFE, 0xF0, 0x1F, 0xF7, 0x80, 0x04, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x39, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x1F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF0, 0x0F, 0x07, 0xF1, 0xFC, 0xFF,
  0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xE1, 0xF8,
  0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01,
  0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xF8,
  0x07, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xF7,
  0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x03, 0xFC, 0x0E, 0x01, 0xFE, 0x07, 0x00,
  0xFF, 0x03, 0x80, 0x7F, 0x81, 0xC0, 0x3F, 0xC0, 0xE0, 0x1F, 0xE0, 0x70,
  0x0F, 0xF0, 0x38, 0x07, 0xF8, 0x1C, 0x03, 0xFC, 0x0E, 0x01, 0xFE, 0x07,
  0x00, 0xFF, 0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x7F, 0xC0, 0x7E, 0xEF, 0xE0,
  0x3F, 0xE7, 0xF0, 0x0F, 0xE3, 0xB8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00,
  0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x01,
  0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x1E, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xF0, 0x01,
  0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x38, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8E, 0x03, 0xFC, 0xE0, 0x07,
  0xCE, 0x00, 0x3E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0,
  0x07, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xE0, 0x3F, 0xCE,
  0x00, 0x3E, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1E, 0xE0, 0x03, 0xEE, 0x03, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xF0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xBC, 0x00, 0x79, 0xE0,
  0x03, 0xC7, 0x80, 0x3E, 0x3F, 0x03, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x3F,
  0xCE, 0x00, 0x7D, 0xC0, 0x07, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xB8, 0x01, 0xF7, 0x03, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x3E,
  0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xF7, 0x00, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80, 0x3E, 0x3F,
  0x03, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F,
  0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xE0,
  0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x78, 0xE0, 0x01,
  0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x83,
  0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0x80,
  0xF0, 0x0E, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0E,
  0x01, 0xE0, 0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x1E, 0x0E, 0x00,
  0x78, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x8E, 0x00, 0x1E,
  0x38, 0x00, 0x7C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xEE, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF7, 0x01, 0xDF, 0xB8, 0x0E, 0xFD, 0xC0,
  0xF7, 0xE7, 0x07, 0x3F, 0x38, 0x39, 0xF9, 0xE3, 0xCF, 0xC7, 0x1C, 0x7E,
  0x38, 0xE7, 0xF1, 0xCF, 0x3F, 0x87, 0x71, 0xFC, 0x3B, 0x8F, 0xE1, 0xDC,
  0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFB, 0x80, 0x3F, 0x70, 0x07, 0xEF, 0x00, 0xFC, 0xE0, 0x1F,
  0x9E, 0x03, 0xF1, 0xC0, 0x7E, 0x38, 0x0F, 0xC7, 0x81, 0xF8, 0x70, 0x3F,
  0x0E, 0x07, 0xE1, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x78, 0x7E,
  0x07, 0x0F, 0xC0, 0xF1, 0xF8, 0x0E, 0x3F, 0x01, 0xC7, 0xE0, 0x3C, 0xFC,
  0x03, 0x9F, 0x80, 0x73, 0xF0, 0x0F, 0x7E, 0x00, 0xEF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x80,
  0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x07,
  0xE7, 0xC0, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x70, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x1E, 0x3E, 0x07, 0xE1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xC0, 0x3F, 0xCE, 0x00, 0x1F, 0x70, 0x00, 0x7B, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x3E,
  0xE0, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xE0, 0x7E, 0x3E, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF0,
  0x00, 0x77, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF,
  0x80, 0x3C, 0x3F, 0x07, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xC0, 0x3F, 0x8E,
  0x00, 0x3E, 0x70, 0x00, 0xFB, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x70,
  0x00, 0x7B, 0x80, 0x07, 0xDC, 0x00, 0x7C, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0x78, 0x1C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x01, 0xE1,
  0xC0, 0x0F, 0x0E, 0x00, 0x7C, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x9C, 0x00,
  0x3C, 0xE0, 0x01, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x3E, 0x00, 0x30, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x3E, 0x3E, 0x00,
  0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDC,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xEF, 0x00, 0x1E, 0x7E, 0x03, 0xF1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xDE, 0x00, 0xF3, 0xE0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0x80, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x38, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x01, 0xDC, 0x07, 0xC0,
  0x77, 0x01, 0xF0, 0x1D, 0xC0, 0x6C, 0x07, 0x70, 0x1B, 0x03, 0xDE, 0x06,
  0xC0, 0xF7, 0x81, 0xB0, 0x3D, 0xE0, 0xEC, 0x0F, 0x78, 0x3B, 0x83, 0x8E,
  0x0E, 0xE0, 0xE3, 0x83, 0xB8, 0x38, 0xE0, 0xC6, 0x0E, 0x38, 0x31, 0x83,
  0x8E, 0x0C, 0x61, 0xE3, 0xC3, 0x18, 0x78, 0xF1, 0xC6, 0x1E, 0x3C, 0x71,
  0xC7, 0x0F, 0x1C, 0x71, 0xC1, 0xC7, 0x1C, 0x70, 0x71, 0x87, 0x1C, 0x1C,
  0x60, 0xC7, 0x07, 0x18, 0x31, 0xC1, 0xC6, 0x0C, 0xF0, 0x7B, 0x83, 0x3C,
  0x1E, 0xE0, 0xEF, 0x07, 0xB8, 0x3B, 0x80, 0xEE, 0x0E, 0xE0, 0x3B, 0x03,
  0xB8, 0x0E, 0xC0, 0x6E, 0x03, 0xB0, 0x1B, 0x80, 0xEC, 0x06, 0xE0, 0x3F,
  0x01, 0xB8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x07,
  0x81, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xC7, 0x80, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC7,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xEF, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xE0,
  0x07, 0x07, 0x00, 0x78, 0x3C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0,
  0x3C, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xF3,
  0x80, 0x03, 0xBC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x7C, 0x00,
  0x7E, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xF0, 0x1F,
  0x1E, 0x00, 0x7C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xEF,
  0x80, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFB, 0xC3, 0xFF, 0x1E, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xF8, 0x1C, 0x7F, 0xE3, 0x9F, 0xFE,
  0x77, 0xDF, 0xEE, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0x60, 0x3E, 0xEF, 0xFF, 0x9C, 0xFF, 0xE3, 0x8F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xE0, 0x3E, 0x3E,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1F,
  0xE0, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xF0, 0x07, 0xC7, 0xE0,
  0x7C, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xF0, 0xF0, 0xFF, 0xCF, 0x1F, 0xFE,
  0xF3, 0xFD, 0xFF, 0x7E, 0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F,
  0x7C, 0x01, 0xF3, 0xE0, 0x7F, 0x3F, 0xFE, 0xF1, 0xFF, 0xEF, 0x07, 0xF8,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xF9, 0xFC, 0x3C,
  0x03, 0xE7, 0x80, 0x1F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x77, 0x80, 0x0F, 0x7C, 0x01, 0xF3, 0xE0,
  0x3E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xFD, 0xFF,
  0x3E, 0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF3, 0xF0, 0x7F, 0x1F, 0xFE, 0xF0,
  0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0xF8, 0x1C, 0x7F, 0xE3, 0x9F, 0xFE, 0x77, 0xDF,
  0xEE, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07,
  0xFC, 0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x78, 0x03, 0xE3, 0xC0,
  0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1E, 0x0F,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x01,
  0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x03, 0xC1, 0xE3, 0xDF, 0xCF, 0xEF, 0xFF, 0x7F, 0xBE,
  0x3F, 0x1F, 0xF0, 0x7C, 0x3F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E,
  0x07, 0xF0, 0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07,
  0xF0, 0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0,
  0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x38,
  0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x38, 0x1F,
  0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xC0, 0x00, 0xF8, 0x1C, 0x7F, 0xE3, 0x9F,
  0xFE, 0x77, 0xDF, 0xEE, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x03, 0xE7,
  0xC0, 0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xE3, 0xF0, 0x7E, 0x1F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x1C, 0x7F, 0xE3,
  0x9F, 0xFE, 0x77, 0xDF, 0xEE, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0x70, 0x3E, 0xEF, 0xFF, 0x9C, 0xFF, 0xE3, 0x87, 0xF8, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xFD, 0xFF, 0x3E, 0x03, 0xF7, 0xC0, 0x1F,
  0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x7F, 0x3F, 0xFE, 0xF1,
  0xFF, 0xEF, 0x07, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x1C, 0x7F, 0xC3, 0x9F, 0xFE, 0x77, 0xDF,
  0xEF, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x79,
  0xE0, 0x01, 0xEF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0xC0, 0x3E, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3E, 0xF0, 0x07, 0x9F, 0x03, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE3, 0x80, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x3C,
  0x03, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xCE, 0x06, 0xC0, 0xE7, 0x03,
  0x60, 0x73, 0x81, 0xB0, 0x39, 0xC1, 0xD8, 0x1C, 0xE0, 0xEE, 0x1E, 0x78,
  0x67, 0x0E, 0x3C, 0x31, 0x87, 0x0E, 0x18, 0xC3, 0x87, 0x0C, 0x61, 0xC3,
  0x8E, 0x30, 0xE1, 0xC7, 0x1C, 0x70, 0xF3, 0x0E, 0x70, 0x79, 0x87, 0x38,
  0x1C, 0xC1, 0x9C, 0x0E, 0x60, 0xCE, 0x07, 0x70, 0x67, 0x03, 0xB8, 0x3B,
  0x81, 0xD8, 0x1F, 0x80, 0xEC, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x78,
  0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xF0,
  0x7C, 0x01, 0xE0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x80, 0x07, 0x8F, 0x00,
  0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x1E, 0x0F,
  0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1F, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x1C, 0xFF, 0x00, 0x77,
  0xFE, 0x01, 0xDF, 0x7C, 0x07, 0x70, 0x78, 0x1F, 0xC0, 0xF0, 0x7F, 0x03,
  0xE3, 0xFC, 0x07, 0xFE, 0xF0, 0x0F, 0xFB, 0xC0, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_Light48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 35, 29, 11, -35 },
  { 32, 14, 14, 29, 7, -35 },
  { 57, 25, 35, 29, 2, -35 },
  { 167, 21, 49, 29, 4, -42 },
  { 296, 27, 35, 29, 1, -35 },
  { 415, 24, 36, 29, 3, -36 },
  { 523, 4, 14, 29, 12, -35 },
  { 530, 14, 46, 29, 9, -40 },
  { 611, 14, 46, 29, 6, -40 },
  { 692, 25, 24, 29, 2, -29 },
  { 767, 23, 22, 29, 3, -27 },
  { 831, 10, 15, 29, 8, -7 },
  { 850, 15, 4, 29, 7, -18 },
  { 858, 7, 7, 29, 11, -7 },
  { 865, 21, 45, 29, 4, -40 },
  { 984, 21, 36, 29, 4, -36 },
  { 1079, 22, 35, 29, 4, -35 },
  { 1176, 21, 36, 29, 4, -36 },
  { 1271, 20, 35, 29, 4, -35 },
  { 1359, 20, 35, 29, 4, -35 },
  { 1447, 21, 35, 29, 4, -35 },
  { 1539, 22, 35, 29, 3, -35 },
  { 1636, 22, 35, 29, 4, -35 },
  { 1733, 21, 36, 29, 4, -36 },
  { 1828, 22, 36, 29, 3, -36 },
  { 1927, 7, 27, 29, 11, -27 },
  { 1951, 10, 35, 29, 8, -27 },
  { 1995, 21, 25, 29, 4, -28 },
  { 2061, 21, 15, 29, 4, -23 },
  { 2101, 21, 25, 29, 4, -28 },
  { 2167, 17, 35, 29, 7, -35 },
  { 2242, 25, 45, 29, 2, -36 },
  { 2383, 23, 35, 29, 3, -35 },
  { 2484, 20, 35, 29, 5, -35 },
  { 2572, 21, 36, 29, 4, -36 },
  { 2667, 19, 35, 29, 5, -35 },
  { 2751, 20, 35, 29, 5, -35 },
  { 2839, 20, 35, 29, 5, -35 },
  { 2927, 21, 36, 29, 4, -36 },
  { 3022, 19, 35, 29, 5, -35 },
  { 3106, 19, 35, 29, 5, -35 },
  { 3190, 22, 35, 29, 2, -35 },
  { 3287, 22, 35, 29, 5, -35 },
  { 3384, 20, 35, 29, 6, -35 },
  { 3472, 21, 35, 29, 4, -35 },
  { 3564, 19, 35, 29, 5, -35 },
  { 3648, 20, 36, 29, 4, -36 },
  { 3738, 21, 35, 29, 5, -35 },
  { 3830, 21, 45, 29, 4, -36 },
  { 3949, 21, 35, 29, 5, -35 },
  { 4041, 21, 36, 29, 4, -36 },
  { 4136, 23, 35, 29, 3, -35 },
  { 4237, 19, 35, 29, 5, -35 },
  { 4321, 23, 35, 29, 3, -35 },
  { 4422, 26, 35, 29, 1, -35 },
  { 4536, 25, 35, 29, 2, -35 },
  { 4646, 25, 35, 29, 2, -35 },
  { 4756, 21, 35, 29, 4, -35 },
  { 4848, 12, 45, 29, 10, -40 },
  { 4916, 21, 45, 29, 4, -40 },
  { 5035, 12, 45, 29, 7, -40 },
  { 5103, 21, 19, 29, 4, -35 },
  { 5153, 23, 3, 29, 3, 1 },
  { 5162, 10, 7, 29, 9, -38 },
  { 5171, 21, 27, 29, 3, -27 },
  { 5242, 19, 35, 29, 5, -35 },
  { 5326, 21, 27, 29, 4, -27 },
  { 5397, 20, 35, 29, 4, -35 },
  { 5485, 20, 27, 29, 4, -27 },
  { 5553, 23, 35, 29, 3, -35 },
  { 5654, 20, 36, 29, 4, -27 },
  { 5744, 19, 35, 29, 5, -35 },
  { 5828, 22, 37, 29, 4, -37 },
  { 5930, 18, 46, 29, 4, -37 },
  { 6034, 21, 35, 29, 5, -35 },
  { 6126, 24, 35, 29, 2, -35 },
  { 6231, 22, 27, 29, 3, -27 },
  { 6306, 19, 27, 29, 5, -27 },
  { 6371, 20, 27, 29, 4, -27 },
  { 6439, 19, 36, 29, 5, -27 },
  { 6525, 20, 36, 29, 4, -27 },
  { 6615, 19, 27, 29, 6, -27 },
  { 6680, 21, 27, 29, 4, -27 },
  { 6751, 22, 34, 29, 3, -34 },
  { 6845, 19, 26, 29, 5, -26 },
  { 6907, 23, 26, 29, 3, -26 },
  { 6982, 25, 26, 29, 2, -26 },
  { 7064, 23, 26, 29, 3, -26 },
  { 7139, 23, 35, 29, 3, -26 },
  { 7240, 20, 26, 29, 4, -26 },
  { 7305, 21, 45, 29, 4, -40 },
  { 7424, 4, 45, 29, 12, -40 },
  { 7447, 21, 45, 29, 4, -40 },
  { 7566, 22, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_Light48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_LIGHT48PT7B_H_
