#ifndef _JETBRAINSMONO_LIGHT37PT7B_H_
#define _JETBRAINSMONO_LIGHT37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light37pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x73, 0x9C, 0xE6, 0x31, 0x8C, 0x63,
  0x18, 0x00, 0x00, 0x1E, 0xFF, 0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0C, 0x01, 0xC0, 0xC0, 0x18,
  0x1C, 0x01, 0x81, 0xC0, 0x38, 0x18, 0x03, 0x81, 0x80, 0x38, 0x18, 0x03,
  0x03, 0x83, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0x03, 0x00,
  0x60, 0x30, 0x06, 0x07, 0x00, 0x60, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0x60,
  0x0C, 0x06, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xC0, 0xC0, 0x1C, 0x0C,
  0x01, 0xC0, 0xC0, 0x18, 0x1C, 0x01, 0x81, 0xC0, 0x18, 0x1C, 0x03, 0x81,
  0x80, 0x38, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xBE, 0x79, 0x8E, 0x71, 0x87,
  0x71, 0x87, 0x61, 0x87, 0x71, 0x80, 0x71, 0x80, 0x71, 0x80, 0x79, 0x80,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xBE, 0x01, 0x8F,
  0x01, 0x87, 0x01, 0x87, 0x01, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87,
  0x71, 0x8F, 0x7D, 0xBE, 0x3F, 0xFC, 0x0F, 0xF8, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F, 0x00, 0x3B, 0xFC, 0x03, 0xB8,
  0xE0, 0x39, 0x83, 0x81, 0x8C, 0x1C, 0x1C, 0x60, 0xE1, 0xC3, 0x07, 0x0C,
  0x18, 0x38, 0xC0, 0xC1, 0xCE, 0x07, 0x1C, 0x60, 0x1F, 0xE6, 0x00, 0x7E,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0xF8,
  0x01, 0x9F, 0xE0, 0x1C, 0xE3, 0x81, 0xCE, 0x0C, 0x0C, 0x70, 0x60, 0xE3,
  0x83, 0x0E, 0x1C, 0x18, 0x60, 0xE0, 0xC6, 0x07, 0x06, 0x70, 0x1C, 0x73,
  0x00, 0xFF, 0x30, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x78, 0xF0,
  0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x5C, 0xF0, 0x77, 0x0E, 0x0E, 0xE0, 0xE3, 0x9C, 0x0E, 0x73,
  0x81, 0xFC, 0x70, 0x1F, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0xC7,
  0x81, 0xF8, 0x78, 0xF3, 0x87, 0xFC, 0x38, 0x7F, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x66, 0x60, 0x00, 0x60, 0x3C, 0x1F, 0x87, 0xC1, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xE0, 0x7C, 0x03, 0x80, 0xC0, 0x1E, 0x03, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0xFC, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x70, 0x60, 0x67,
  0xC6, 0x3E, 0xFF, 0x6F, 0xF1, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x39, 0xC0, 0x07, 0x9E, 0x00, 0x70, 0xE0, 0x0F, 0x07,
  0x01, 0xE0, 0x78, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x3C, 0x38, 0x78, 0x70, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x11, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3C, 0x3E, 0x78, 0x0E, 0x70,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE1, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE1, 0x87, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70,
  0x0F, 0x78, 0x0E, 0x3E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF0, 0x03, 0xE0, 0x03,
  0xF0, 0x07, 0xF8, 0x07, 0x9C, 0x07, 0x8E, 0x03, 0x87, 0x01, 0x03, 0x81,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F,
  0x0F, 0x8E, 0x01, 0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0E, 0x70, 0x1E, 0x7C, 0x7C, 0x3F, 0xF8, 0x0F, 0xF0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x71, 0xC0, 0xE7,
  0x01, 0xDE, 0x03, 0xB8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x71, 0xE0, 0x77, 0xF8,
  0x7F, 0xFC, 0x7C, 0x1E, 0x78, 0x0E, 0x70, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0x70, 0x0E,
  0x70, 0x0E, 0x3C, 0x3C, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x38, 0x07, 0xFF, 0x07, 0xFF, 0xC3,
  0xC0, 0xF3, 0xC0, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x00,
  0xFC, 0x00, 0x6E, 0x00, 0x77, 0x00, 0x3B, 0xC0, 0x1C, 0xF0, 0x1C, 0x3E,
  0x7E, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3C, 0x3E, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x78, 0x0E,
  0x3C, 0x3C, 0x1F, 0x78, 0x07, 0xE0, 0x07, 0xF0, 0x1E, 0x78, 0x3C, 0x1C,
  0x70, 0x0E, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0x70, 0x0E, 0x7C, 0x3E, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFE, 0x0F, 0x9F, 0x8F, 0x01, 0xCF, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xE7,
  0x00, 0xF3, 0xC0, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x03, 0x1C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x31, 0xFF, 0xFF, 0x7C,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78,
  0x0E, 0x3F, 0x3F, 0x3F, 0x3F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x38, 0x70,
  0x70, 0x70, 0xE0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x1F, 0x0F, 0xF0, 0x7E, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xF8, 0x1E, 0x1C, 0x01, 0xC7, 0x00,
  0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0x9F, 0x83, 0xFB, 0xF0, 0x71, 0xFE, 0x1C, 0x1F, 0xC3, 0x81, 0xF8, 0x70,
  0x3F, 0x0E, 0x07, 0xE1, 0xC0, 0xFC, 0x38, 0x1F, 0x87, 0x03, 0xF0, 0xE0,
  0x7E, 0x1C, 0x0F, 0xC3, 0x83, 0xF8, 0x38, 0xFF, 0x07, 0xF7, 0xE0, 0x3C,
  0xFC, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xB0, 0x00, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06,
  0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x03, 0x1C, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1C, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0xE6, 0x01, 0xEC, 0x01, 0xD8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3B, 0x00, 0x76, 0x03, 0xCF, 0xFF, 0x1F,
  0xFE, 0x30, 0x1F, 0x60, 0x0E, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF, 0xF3,
  0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E, 0x78, 0x0E, 0x70, 0x07,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x78, 0x0E, 0x3E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xC1, 0xFF, 0xE3,
  0xFF, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xB8, 0x07, 0x70, 0x1E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xDF,
  0xFF, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E, 0x78,
  0x0E, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xFF, 0xE1, 0xFF, 0xE1,
  0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x78, 0x0E, 0x3E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF0, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0x70, 0x0E, 0x7E, 0x3E, 0x3F, 0xFC, 0x0F, 0xF0, 0xE0, 0x07, 0x70, 0x07,
  0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xC0,
  0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0x87, 0x01, 0xC3, 0xC0, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C,
  0x1C, 0x0F, 0x0E, 0x03, 0x87, 0x01, 0xE3, 0x80, 0x71, 0xC0, 0x3C, 0xE0,
  0x0E, 0x70, 0x07, 0xB8, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xD8, 0x1F, 0xD8, 0x1B, 0xDC, 0x1B,
  0xCC, 0x3B, 0xEC, 0x33, 0xEE, 0x33, 0xE6, 0x73, 0xE6, 0x67, 0xE7, 0x67,
  0xE3, 0xE7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7D, 0x80, 0xFB, 0x01, 0xF7, 0x03, 0xE6, 0x07, 0xCE, 0x0F, 0x9C,
  0x1F, 0x18, 0x3E, 0x38, 0x7C, 0x70, 0xF8, 0x61, 0xF0, 0xE3, 0xE0, 0xC7,
  0xC1, 0xCF, 0x83, 0x9F, 0x03, 0x3E, 0x07, 0x7C, 0x0E, 0xF8, 0x0D, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x78, 0x0F, 0xF0, 0x1F,
  0xFC, 0x3E, 0x3C, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x78, 0x0E, 0x3E, 0x3C, 0x1F,
  0xFC, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x1E, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0E, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x1F,
  0xFC, 0x3E, 0x3C, 0x78, 0x0E, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x78, 0x0E, 0x3E, 0x3E, 0x1F,
  0xFC, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0,
  0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xE1,
  0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0x0F,
  0xF0, 0x1F, 0xFC, 0x3C, 0x3E, 0x78, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x60,
  0x07, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x7E,
  0x3E, 0x3F, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0x78, 0x1E, 0x7C, 0x78, 0x7F, 0xF0, 0x7F, 0x80, 0xE0, 0x01, 0xF8,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE3, 0x80,
  0x30, 0xE0, 0x1C, 0x38, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x60, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x3B,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x70,
  0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0x60, 0xF0, 0x76, 0x0D,
  0x06, 0x70, 0xD8, 0x67, 0x0D, 0x86, 0x70, 0x98, 0xE7, 0x19, 0x8E, 0x71,
  0x98, 0xE7, 0x19, 0x8E, 0x31, 0x98, 0xE3, 0x18, 0x8E, 0x31, 0x8C, 0xC3,
  0x90, 0xCC, 0x3B, 0x0C, 0xC3, 0xB0, 0xCC, 0x3B, 0x0D, 0xC3, 0xB0, 0xDC,
  0x3B, 0x0D, 0xC1, 0xB0, 0xDC, 0x1B, 0x05, 0x81, 0xA0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x01, 0xCE, 0x00, 0x71, 0xE0,
  0x0E, 0x1C, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0xE7,
  0x00, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x0E, 0x01,
  0xC1, 0xC0, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x7B, 0x80, 0x07, 0x80, 0xF0,
  0x00, 0xF7, 0x00, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x1C, 0x01, 0xC1,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0,
  0x03, 0x8E, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70,
  0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x18, 0x38, 0x1C, 0x38, 0x0C,
  0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x01, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E,
  0x70, 0x0E, 0x70, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x37, 0x7F, 0xF7, 0x3F, 0xC7, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x70, 0x77,
  0xF8, 0xFF, 0xF9, 0xB0, 0x7B, 0xC0, 0x77, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x0E, 0xF8, 0x7D, 0xFF, 0xF3, 0x9F,
  0xC0, 0x03, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x70, 0x0E, 0x70,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78,
  0x0E, 0x3E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0x87, 0x1F, 0xE7, 0x3F,
  0xF7, 0x78, 0x17, 0x70, 0x0F, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x3C, 0x37, 0x3F, 0xF7, 0x0F,
  0xE7, 0x03, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x38, 0x1E, 0x70, 0x0E, 0x70,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x70,
  0x0E, 0x3C, 0x1E, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x1F, 0xE7,
  0x3F, 0xF7, 0x78, 0x17, 0x70, 0x0F, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07,
  0x70, 0x0F, 0x70, 0x0F, 0x7C, 0x37, 0x3F, 0xF7, 0x1F, 0xE7, 0x03, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x60, 0x77, 0xF8, 0xFF, 0xF9, 0xF0, 0x7B, 0x80,
  0x77, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x38, 0x00, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0x80,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x78,
  0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x1C,
  0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0E,
  0x1C, 0x6F, 0x9F, 0x3F, 0xFF, 0xDC, 0x78, 0xEC, 0x18, 0x3E, 0x0C, 0x1F,
  0x06, 0x0F, 0x83, 0x07, 0xC1, 0x83, 0xE0, 0xC1, 0xF0, 0x60, 0xF8, 0x30,
  0x7C, 0x18, 0x3E, 0x0C, 0x1F, 0x06, 0x0F, 0x83, 0x07, 0xC1, 0x83, 0xE0,
  0xC1, 0xF0, 0x60, 0xF8, 0x30, 0x7C, 0x18, 0x38, 0x01, 0x81, 0xDF, 0xE3,
  0xFF, 0xE7, 0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x70, 0x0E, 0x70, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0E, 0x78, 0x0E,
  0x3E, 0x7C, 0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0xC1, 0xDF, 0xE3, 0xFF, 0xE7,
  0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xA0, 0x3B, 0x61, 0xF6, 0x7F, 0xCE, 0x7F, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0xE7, 0x3F, 0xF7, 0x78, 0x17, 0x70, 0x0F, 0x70, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x3C,
  0x37, 0x3F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0xE0, 0xE7, 0xF8, 0xEF,
  0xFC, 0xF8, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x78, 0x0E, 0x70, 0x07, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x07, 0x70,
  0x0F, 0x7C, 0x1E, 0x3F, 0xFE, 0x0F, 0xF8, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xC0, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x0E, 0xF0, 0x3C, 0xF0,
  0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x38,
  0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x07, 0x1C, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x0E, 0xE0, 0x03, 0xB0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0xE0, 0x70, 0x76, 0x0F, 0x06, 0x60, 0xF0, 0x67, 0x0F, 0x06,
  0x70, 0xD0, 0xE7, 0x0D, 0x0E, 0x30, 0x98, 0xE3, 0x19, 0x8C, 0x31, 0x98,
  0xC3, 0x99, 0x8C, 0x39, 0x98, 0xC3, 0x98, 0xDC, 0x19, 0x0D, 0xC1, 0xB0,
  0xD8, 0x1B, 0x0D, 0x81, 0xB0, 0xD8, 0x1F, 0x0D, 0x81, 0xF0, 0x58, 0x1E,
  0x07, 0x80, 0xE0, 0x70, 0x78, 0x03, 0xCE, 0x01, 0xC1, 0xC0, 0xF0, 0x70,
  0x38, 0x0E, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0x38, 0x01, 0xCF, 0x00,
  0xE1, 0xC0, 0x78, 0x38, 0x1C, 0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x3B, 0xC0,
  0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07,
  0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x3B, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x18, 0x03, 0xBF, 0x81, 0xFF, 0xE0, 0xFC, 0x70,
  0x7C, 0x1C, 0x76, 0x07, 0xFB, 0x01, 0xF9, 0x80, 0x30,
};

const GFXglyph JetBrainsMono_Light37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 5, 27, 22, 9, -27 },
  { 18, 10, 11, 22, 6, -27 },
  { 32, 20, 27, 22, 1, -27 },
  { 100, 16, 37, 22, 3, -32 },
  { 174, 21, 27, 22, 1, -27 },
  { 245, 19, 27, 22, 2, -27 },
  { 310, 4, 11, 22, 9, -27 },
  { 316, 11, 35, 22, 7, -31 },
  { 365, 11, 35, 22, 4, -31 },
  { 414, 20, 19, 22, 1, -23 },
  { 462, 17, 17, 22, 3, -21 },
  { 499, 8, 12, 22, 6, -6 },
  { 511, 12, 3, 22, 5, -14 },
  { 516, 6, 6, 22, 8, -6 },
  { 521, 16, 35, 22, 3, -31 },
  { 591, 16, 27, 22, 3, -27 },
  { 645, 17, 27, 22, 3, -27 },
  { 703, 17, 27, 22, 3, -27 },
  { 761, 16, 27, 22, 3, -27 },
  { 815, 15, 27, 22, 3, -27 },
  { 866, 16, 27, 22, 3, -27 },
  { 920, 17, 27, 22, 3, -27 },
  { 978, 17, 27, 22, 3, -27 },
  { 1036, 16, 27, 22, 3, -27 },
  { 1090, 17, 27, 22, 3, -27 },
  { 1148, 6, 21, 22, 8, -21 },
  { 1164, 8, 27, 22, 6, -21 },
  { 1191, 16, 19, 22, 3, -22 },
  { 1229, 16, 11, 22, 3, -18 },
  { 1251, 16, 19, 22, 3, -22 },
  { 1289, 13, 27, 22, 5, -27 },
  { 1333, 19, 34, 22, 2, -27 },
  { 1414, 18, 27, 22, 2, -27 },
  { 1475, 15, 27, 22, 4, -27 },
  { 1526, 16, 27, 22, 3, -27 },
  { 1580, 15, 27, 22, 4, -27 },
  { 1631, 15, 27, 22, 4, -27 },
  { 1682, 15, 27, 22, 4, -27 },
  { 1733, 16, 27, 22, 3, -27 },
  { 1787, 15, 27, 22, 4, -27 },
  { 1838, 14, 27, 22, 4, -27 },
  { 1886, 16, 27, 22, 2, -27 },
  { 1940, 17, 27, 22, 4, -27 },
  { 1998, 16, 27, 22, 4, -27 },
  { 2052, 16, 27, 22, 3, -27 },
  { 2106, 15, 27, 22, 4, -27 },
  { 2157, 16, 27, 22, 3, -27 },
  { 2211, 16, 27, 22, 4, -27 },
  { 2265, 16, 34, 22, 3, -27 },
  { 2333, 16, 27, 22, 4, -27 },
  { 2387, 16, 27, 22, 3, -27 },
  { 2441, 18, 27, 22, 2, -27 },
  { 2502, 15, 27, 22, 4, -27 },
  { 2553, 18, 27, 22, 2, -27 },
  { 2614, 20, 27, 22, 1, -27 },
  { 2682, 19, 27, 22, 2, -27 },
  { 2747, 20, 27, 22, 1, -27 },
  { 2815, 16, 27, 22, 3, -27 },
  { 2869, 9, 35, 22, 8, -31 },
  { 2909, 16, 35, 22, 3, -31 },
  { 2979, 8, 35, 22, 6, -31 },
  { 3014, 16, 14, 22, 3, -27 },
  { 3042, 18, 2, 22, 2, 1 },
  { 3047, 7, 5, 22, 7, -29 },
  { 3052, 16, 21, 22, 3, -21 },
  { 3094, 15, 27, 22, 4, -27 },
  { 3145, 16, 21, 22, 3, -21 },
  { 3187, 16, 27, 22, 3, -27 },
  { 3241, 16, 21, 22, 3, -21 },
  { 3283, 18, 27, 22, 2, -27 },
  { 3344, 16, 28, 22, 3, -21 },
  { 3400, 15, 27, 22, 4, -27 },
  { 3451, 17, 29, 22, 3, -29 },
  { 3513, 14, 36, 22, 3, -29 },
  { 3576, 16, 27, 22, 4, -27 },
  { 3630, 19, 27, 22, 1, -27 },
  { 3695, 17, 21, 22, 3, -21 },
  { 3740, 15, 21, 22, 4, -21 },
  { 3780, 16, 21, 22, 3, -21 },
  { 3822, 15, 28, 22, 4, -21 },
  { 3875, 16, 28, 22, 3, -21 },
  { 3931, 16, 21, 22, 4, -21 },
  { 3973, 16, 21, 22, 3, -21 },
  { 4015, 17, 26, 22, 2, -26 },
  { 4071, 15, 20, 22, 4, -20 },
  { 4109, 18, 20, 22, 2, -20 },
  { 4154, 20, 20, 22, 1, -20 },
  { 4204, 18, 20, 22, 2, -20 },
  { 4249, 18, 27, 22, 2, -20 },
  { 4310, 16, 20, 22, 3, -20 },
  { 4350, 16, 35, 22, 3, -31 },
  { 4420, 3, 35, 22, 10, -31 },
  { 4434, 16, 35, 22, 3, -31 },
  { 4504, 17, 8, 22, 3, -17 },
};

const GFXfont JetBrainsMono_Light37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_LIGHT37PT7B_H_
