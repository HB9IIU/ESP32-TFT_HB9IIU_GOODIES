#ifndef _JETBRAINSMONO_LIGHT8PT7B_H_
#define _JETBRAINSMONO_LIGHT8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x52, 0x9E, 0xAF, 0x30, 0x5F, 0xE7, 0xFA, 0xCD,
  0xB8, 0x66, 0xDC, 0x62, 0x91, 0x69, 0x3C, 0xE0, 0x6A, 0xA9, 0x95, 0x56,
  0x27, 0xC8, 0xA0, 0x4B, 0xA0, 0x60, 0xE0, 0x80, 0x24, 0xA5, 0x24, 0xF6,
  0xFB, 0xC0, 0x59, 0x25, 0xC0, 0xF4, 0xA9, 0xC0, 0xE9, 0x1B, 0xC0, 0x2A,
  0x5E, 0x40, 0xF3, 0x93, 0xC0, 0x4B, 0x5B, 0xC0, 0xF4, 0xA4, 0x80, 0xF6,
  0xFB, 0xC0, 0xF6, 0xF4, 0x80, 0x90, 0x41, 0x80, 0x2A, 0x30, 0xE3, 0x80,
  0x88, 0xE0, 0xC4, 0xA1, 0x80, 0x79, 0xBB, 0xBA, 0x60, 0x26, 0x55, 0x79,
  0xF7, 0xDB, 0xC0, 0xF6, 0x4B, 0xC0, 0xD6, 0xDB, 0xC0, 0xF3, 0xC9, 0xC0,
  0xF2, 0x79, 0x00, 0xF6, 0x7B, 0xC0, 0xB7, 0xDB, 0x40, 0xE9, 0x25, 0xC0,
  0x31, 0x11, 0x97, 0xB7, 0x6B, 0x40, 0x92, 0x49, 0xC0, 0xB7, 0xDB, 0x40,
  0xB6, 0xFB, 0x40, 0xF6, 0xDB, 0xC0, 0xF6, 0xE9, 0x00, 0xF6, 0xDB, 0xC8,
  0xF6, 0xEB, 0x40, 0xF6, 0x3B, 0xC0, 0xF2, 0x22, 0x22, 0xB6, 0xDB, 0xC0,
  0x95, 0x55, 0x62, 0xAD, 0x7B, 0xE5, 0x28, 0x95, 0x22, 0x59, 0x95, 0x52,
  0x22, 0xE5, 0x29, 0xC0, 0xEA, 0xAB, 0x92, 0x24, 0x89, 0xD5, 0x57, 0x56,
  0x80, 0xF0, 0xC0, 0xEE, 0xF0, 0x9A, 0xDB, 0xC0, 0xF2, 0x70, 0x2E, 0xDB,
  0xC0, 0xFE, 0x70, 0x32, 0xF2, 0x22, 0xF6, 0xFE, 0x9A, 0xDB, 0x40, 0x51,
  0x25, 0xC0, 0x38, 0x92, 0x70, 0x92, 0xEB, 0x40, 0xC2, 0x22, 0x23, 0xFF,
  0xF0, 0xF6, 0xD0, 0xF6, 0xF0, 0xF6, 0xF8, 0xF6, 0xF2, 0xF2, 0x40, 0xF8,
  0xF0, 0x2F, 0x22, 0x23, 0xB6, 0xF0, 0xD5, 0x52, 0xBF, 0x75, 0x52, 0x6D,
  0xD5, 0x62, 0x60, 0xEA, 0x70, 0x29, 0x2C, 0x91, 0xFF, 0x89, 0x26, 0x94,
  0xBC,
};

const GFXglyph JetBrainsMono_Light8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 3, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 3, 5, 2, -6 },
  { 20, 2, 8, 5, 2, -7 },
  { 22, 2, 8, 5, 1, -7 },
  { 24, 5, 4, 5, 0, -5 },
  { 27, 3, 4, 5, 1, -5 },
  { 29, 2, 2, 5, 1, -1 },
  { 30, 3, 1, 5, 1, -3 },
  { 31, 1, 1, 5, 2, -1 },
  { 32, 3, 8, 5, 1, -7 },
  { 35, 3, 6, 5, 1, -6 },
  { 38, 3, 6, 5, 1, -6 },
  { 41, 3, 6, 5, 1, -6 },
  { 44, 3, 6, 5, 1, -6 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 3, 6, 5, 1, -6 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 3, 6, 5, 1, -6 },
  { 62, 3, 6, 5, 1, -6 },
  { 65, 1, 4, 5, 2, -4 },
  { 66, 2, 5, 5, 1, -4 },
  { 68, 3, 4, 5, 1, -5 },
  { 70, 3, 3, 5, 1, -4 },
  { 72, 3, 4, 5, 1, -5 },
  { 74, 3, 6, 5, 1, -6 },
  { 77, 4, 7, 5, 0, -6 },
  { 81, 4, 6, 5, 0, -6 },
  { 84, 3, 6, 5, 1, -6 },
  { 87, 3, 6, 5, 1, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 3, 6, 5, 1, -6 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 3, 6, 5, 1, -6 },
  { 108, 4, 6, 5, 0, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 3, 6, 5, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 3, 6, 5, 1, -6 },
  { 126, 3, 6, 5, 1, -6 },
  { 129, 3, 7, 5, 1, -6 },
  { 132, 3, 6, 5, 1, -6 },
  { 135, 3, 6, 5, 1, -6 },
  { 138, 4, 6, 5, 0, -6 },
  { 141, 3, 6, 5, 1, -6 },
  { 144, 4, 6, 5, 0, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 4, 6, 5, 0, -6 },
  { 154, 4, 6, 5, 0, -6 },
  { 157, 3, 6, 5, 1, -6 },
  { 160, 2, 8, 5, 2, -7 },
  { 162, 3, 8, 5, 1, -7 },
  { 165, 2, 8, 5, 1, -7 },
  { 167, 3, 3, 5, 1, -6 },
  { 169, 4, 1, 5, 0, 0 },
  { 170, 2, 1, 5, 1, -6 },
  { 171, 3, 4, 5, 1, -4 },
  { 173, 3, 6, 5, 1, -6 },
  { 176, 3, 4, 5, 1, -4 },
  { 178, 3, 6, 5, 1, -6 },
  { 181, 3, 4, 5, 1, -4 },
  { 183, 4, 6, 5, 0, -6 },
  { 186, 3, 5, 5, 1, -4 },
  { 188, 3, 6, 5, 1, -6 },
  { 191, 3, 6, 5, 1, -6 },
  { 194, 3, 7, 5, 1, -6 },
  { 197, 3, 6, 5, 1, -6 },
  { 200, 4, 6, 5, 0, -6 },
  { 203, 3, 4, 5, 1, -4 },
  { 205, 3, 4, 5, 1, -4 },
  { 207, 3, 4, 5, 1, -4 },
  { 209, 3, 5, 5, 1, -4 },
  { 211, 3, 5, 5, 1, -4 },
  { 213, 3, 4, 5, 1, -4 },
  { 215, 3, 4, 5, 1, -4 },
  { 217, 4, 6, 5, 0, -6 },
  { 220, 3, 4, 5, 1, -4 },
  { 222, 4, 4, 5, 0, -4 },
  { 224, 4, 4, 5, 0, -4 },
  { 226, 4, 4, 5, 0, -4 },
  { 228, 4, 5, 5, 0, -4 },
  { 231, 3, 4, 5, 1, -4 },
  { 233, 3, 8, 5, 1, -7 },
  { 236, 1, 8, 5, 2, -7 },
  { 237, 3, 8, 5, 1, -7 },
  { 240, 3, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_Light8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_LIGHT8PT7B_H_
