#ifndef _JETBRAINSMONO_LIGHT58PT7B_H_
#define _JETBRAINSMONO_LIGHT58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light58pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x87, 0xF3, 0xFB, 0xFF, 0xFE, 0x7F, 0x1F,
  0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0,
  0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x01, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x80, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x07, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xBB, 0xFC,
  0x1F, 0x8E, 0x1F, 0x0F, 0xC3, 0x83, 0xE3, 0xE0, 0xE0, 0xF8, 0xF0, 0x38,
  0x1F, 0x3C, 0x0E, 0x07, 0xCF, 0x03, 0x81, 0xF3, 0xC0, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x3E, 0x0E, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xF0, 0xE0, 0x00,
  0x7E, 0x38, 0x00, 0x1F, 0xCE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3B, 0xFC, 0x00, 0x0E, 0x3F, 0x80, 0x03, 0x87, 0xE0,
  0x00, 0xE0, 0xFC, 0x00, 0x38, 0x1F, 0x00, 0x0E, 0x07, 0xC0, 0x03, 0x80,
  0xF0, 0x00, 0xE0, 0x3F, 0xE0, 0x38, 0x0F, 0xF8, 0x0E, 0x03, 0xDE, 0x03,
  0x80, 0xF7, 0xC0, 0xE0, 0x7D, 0xF0, 0x38, 0x1F, 0x3E, 0x0E, 0x0F, 0x8F,
  0xE3, 0x8F, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x87, 0xFC,
  0x00, 0x07, 0x8F, 0xFF, 0x00, 0x03, 0xCF, 0xFF, 0xC0, 0x03, 0xC7, 0xC3,
  0xE0, 0x03, 0xC3, 0xC0, 0xF8, 0x01, 0xE3, 0xC0, 0x3C, 0x01, 0xE1, 0xE0,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x70, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x80, 0x78, 0x78, 0x03, 0xE0, 0x3C, 0x38, 0x00, 0xF0, 0x3C, 0x3C, 0x00,
  0x7F, 0xFE, 0x3C, 0x00, 0x1F, 0xFE, 0x3C, 0x00, 0x07, 0xFE, 0x1E, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x07,
  0xF0, 0x00, 0x07, 0x8F, 0xFE, 0x00, 0x07, 0x8F, 0xFF, 0x80, 0x03, 0x87,
  0xEF, 0xE0, 0x03, 0xC7, 0xC0, 0xF0, 0x03, 0xC3, 0xC0, 0x78, 0x01, 0xC1,
  0xE0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0,
  0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0xF0,
  0x07, 0x80, 0x78, 0x78, 0x03, 0xC0, 0x78, 0x78, 0x01, 0xF0, 0x3C, 0x78,
  0x00, 0x7C, 0x7E, 0x38, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x0F, 0xFE, 0x3C,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3E,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x0F, 0x9F, 0x0F, 0xC0, 0x3E, 0x78, 0x1F,
  0x01, 0xF3, 0xE0, 0x3E, 0x07, 0x8F, 0x80, 0x7C, 0x3E, 0x3E, 0x01, 0xF0,
  0xF0, 0xF8, 0x03, 0xE7, 0xC3, 0xE0, 0x07, 0xDE, 0x0F, 0x80, 0x1F, 0xF8,
  0x3E, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0xFF, 0x81, 0xF0,
  0x07, 0xFF, 0x07, 0xE0, 0x3F, 0x7C, 0x0F, 0xFF, 0xF8, 0xF8, 0x3F, 0xFF,
  0xC1, 0xF0, 0x7F, 0xFE, 0x03, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF0,
  0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x07, 0xC0, 0x08, 0xF8, 0x0F, 0x00,
  0xF9, 0xFE, 0x0E, 0x0F, 0xF7, 0xFF, 0x1C, 0x7F, 0xE7, 0xFF, 0x39, 0xFF,
  0xE3, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x3F,
  0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83,
  0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0x03, 0xFE, 0x07,
  0xC1, 0xFF, 0x07, 0xF0, 0xFF, 0x83, 0xF8, 0x7F, 0xC1, 0xFC, 0x3F, 0xE0,
  0x7C, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x3F, 0xEF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xEF, 0x80, 0x0F, 0xE3, 0xE0,
  0x07, 0xF0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1C, 0x03,
  0xE0, 0x06, 0x00, 0xF8, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01,
  0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0xF9, 0xFF, 0xE0, 0x7D,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0x8F, 0xE0, 0x0F, 0xC7,
  0xE0, 0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0xE0, 0x01, 0xE7, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xC1, 0xF8,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x1F, 0x81,
  0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xFC, 0x01, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x05, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF8,
  0x7E, 0x00, 0x7F, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xDF, 0x00, 0x7F, 0xF7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x0C, 0x00, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0x8F, 0xF0, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xFB, 0xFC, 0x03, 0xF0, 0xEF,
  0xE0, 0x1E, 0x01, 0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0x3F, 0xC0,
  0x78, 0x01, 0xFE, 0x03, 0xC0, 0x0F, 0xF0, 0x1E, 0x00, 0x7F, 0x80, 0xF0,
  0x03, 0xFC, 0x07, 0x80, 0x1F, 0xE0, 0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x07,
  0xF8, 0x0F, 0x00, 0x3F, 0xC0, 0x78, 0x01, 0xFE, 0x03, 0xC0, 0x0F, 0xF0,
  0x1E, 0x00, 0x7F, 0x80, 0xF8, 0x03, 0xFC, 0x07, 0xC0, 0x3F, 0xE0, 0x1F,
  0x03, 0xFF, 0x00, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0x9F, 0xC0, 0x0F, 0xF8,
  0xFE, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8,
  0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0x00, 0x1F, 0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF9, 0xE0,
  0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xDE,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF9,
  0xE0, 0x00, 0xF8, 0xF0, 0x00, 0xFC, 0x78, 0x00, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xC0, 0x07,
  0xF1, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xBC, 0x00,
  0x07, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBC,
  0x00, 0x07, 0xDE, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xE7, 0x80, 0x1F, 0xE3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFC, 0x1F, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0x40, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00, 0x3F, 0x9E, 0x00, 0x1F,
  0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xEF, 0x00, 0x1F, 0x9E, 0x00, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xE1,
  0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0x40, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x03, 0xF7, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x07,
  0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00,
  0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xF8, 0x0F,
  0x00, 0x7C, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x07, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0xC0, 0x3C,
  0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xE0,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E,
  0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFE, 0xE0, 0x07, 0xBF, 0x78, 0x03, 0xDF, 0xBC, 0x01, 0xEF, 0xCE,
  0x01, 0xE7, 0xE7, 0x80, 0xF7, 0xFB, 0xC0, 0x7B, 0xFC, 0xE0, 0x79, 0xFE,
  0x78, 0x3C, 0xFF, 0x3C, 0x1E, 0x7F, 0x8E, 0x0E, 0x3F, 0xC7, 0x8F, 0x1F,
  0xE3, 0xC7, 0x8F, 0xF0, 0xE3, 0x87, 0xF8, 0x7B, 0xC3, 0xFC, 0x3D, 0xE1,
  0xFE, 0x0E, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xF8,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xC0, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F,
  0xF7, 0x80, 0x1F, 0xEF, 0x00, 0x3F, 0xCF, 0x00, 0x7F, 0x9E, 0x00, 0xFF,
  0x3C, 0x01, 0xFE, 0x3C, 0x03, 0xFC, 0x78, 0x07, 0xF8, 0xF0, 0x0F, 0xF0,
  0xF0, 0x1F, 0xE1, 0xE0, 0x3F, 0xC3, 0xE0, 0x7F, 0x83, 0xC0, 0xFF, 0x07,
  0x81, 0xFE, 0x07, 0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x1E,
  0x1F, 0xE0, 0x3C, 0x3F, 0xC0, 0x7C, 0x7F, 0x80, 0x78, 0xFF, 0x00, 0xF1,
  0xFE, 0x00, 0xF3, 0xFC, 0x01, 0xE7, 0xF8, 0x03, 0xCF, 0xF0, 0x03, 0xDF,
  0xE0, 0x07, 0xBF, 0xC0, 0x0F, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x28, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0xFE, 0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x01,
  0xFB, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xEF, 0x00, 0x03, 0xF3, 0xC0, 0x03, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xC1, 0xF8,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7,
  0xC0, 0x01, 0xF3, 0xF0, 0x01, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x00, 0x0F, 0xE7, 0x80, 0x01, 0xF3,
  0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0xBC, 0x00, 0x1F, 0x9E, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07,
  0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xFD, 0xE0, 0x00, 0x3E, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xE0, 0x0F,
  0xC3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xF8, 0x03, 0xF8,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x14, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x07, 0xCF,
  0xC0, 0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F,
  0x00, 0x7F, 0x80, 0x36, 0x01, 0xFF, 0x80, 0xEE, 0x03, 0xFF, 0x01, 0xDC,
  0x07, 0xBE, 0x03, 0xB8, 0x0F, 0x3C, 0x07, 0x70, 0x1E, 0x78, 0x0E, 0xE0,
  0x3C, 0xF0, 0x1D, 0xC0, 0x79, 0xE0, 0x3B, 0x80, 0xF3, 0xC0, 0x73, 0x01,
  0xE7, 0x81, 0xC7, 0x07, 0xCF, 0x83, 0x8E, 0x0F, 0x1F, 0x07, 0x1C, 0x1E,
  0x1E, 0x0E, 0x38, 0x3C, 0x3C, 0x1C, 0x70, 0x78, 0x78, 0x38, 0xE0, 0xF0,
  0xF0, 0x71, 0xC1, 0xE1, 0xE1, 0xC3, 0x83, 0xC3, 0xC3, 0x83, 0x87, 0x87,
  0x87, 0x07, 0x0F, 0x0F, 0x8E, 0x0E, 0x3C, 0x1F, 0x1C, 0x1C, 0x78, 0x1E,
  0x38, 0x38, 0xF0, 0x3C, 0x70, 0x71, 0xE0, 0x78, 0xE0, 0xE3, 0xC0, 0xF3,
  0x81, 0xC7, 0x81, 0xE7, 0x01, 0x8F, 0x03, 0xCE, 0x03, 0x9E, 0x07, 0x9C,
  0x07, 0x38, 0x0F, 0x38, 0x0E, 0xF0, 0x0F, 0x70, 0x1D, 0xE0, 0x1E, 0xE0,
  0x3B, 0xC0, 0x3D, 0xC0, 0x77, 0x80, 0x7F, 0x00, 0xEF, 0x00, 0xFE, 0x01,
  0xDE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x1F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE7, 0x80, 0x00, 0xF7, 0xC0,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0x80,
  0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x0E, 0xF3, 0xF8, 0x1F, 0x79,
  0xFF, 0xFF, 0x3C, 0x3F, 0xFF, 0x1E, 0x0F, 0xFE, 0x0F, 0x00, 0x30, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0xFF, 0xC0, 0xF1, 0xFF,
  0xE0, 0xF3, 0xFF, 0xF0, 0xF7, 0xFF, 0xF8, 0xF7, 0x00, 0xFC, 0xFC, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0xF7, 0xE7, 0xF8, 0xF3, 0xFF,
  0xF8, 0xF1, 0xFF, 0xE0, 0xF0, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8,
  0x07, 0xE1, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0,
  0x0F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x03, 0xFE, 0x0F, 0x0F, 0xFF, 0x8F, 0x1F, 0xFF, 0xCF, 0x3F, 0xFF, 0xEF,
  0x3F, 0x00, 0xEF, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0xEF,
  0x3F, 0xE7, 0xEF, 0x1F, 0xFF, 0xCF, 0x0F, 0xFF, 0x8F, 0x03, 0xFF, 0x0F,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x03, 0xFC, 0x7F, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x0F, 0xC1, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x2C, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x0F,
  0x07, 0xFF, 0x8F, 0x1F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x3F, 0x00, 0xEF,
  0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x6F,
  0x3F, 0xC1, 0xEF, 0x1F, 0xFF, 0xCF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x0F,
  0x00, 0xFC, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC3, 0xFF, 0x07, 0x8F,
  0xFF, 0x0F, 0x3F, 0xFF, 0x1E, 0xF8, 0xFF, 0x3D, 0x80, 0x3F, 0x7E, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x07, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7E, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x8F, 0x00,
  0x07, 0xE3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7E, 0x0F,
  0x00, 0x3F, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x3C, 0x03, 0xF0,
  0x0F, 0x00, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x80, 0x3C,
  0x03, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xF0,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xF0, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x7C, 0xF0,
  0x00, 0x0F, 0xBC, 0x00, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0xF3, 0xF8, 0x7F, 0x1E,
  0xFF, 0x9F, 0xF3, 0xDF, 0xF3, 0xFF, 0x7E, 0x1F, 0xC3, 0xEF, 0x81, 0xF0,
  0x3D, 0xF0, 0x3E, 0x07, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF0, 0x1F, 0xF0,
  0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x0F, 0xF8, 0x0F, 0x01,
  0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x3C, 0x07, 0xFC, 0x07, 0x80, 0xFF, 0x80,
  0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x0F,
  0xF8, 0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x3C, 0x07, 0xFC, 0x07,
  0x80, 0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7F,
  0xC0, 0x78, 0x0F, 0xF8, 0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x3C,
  0x07, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0xFF, 0xC1, 0xE3,
  0xFF, 0xC3, 0xCF, 0xFF, 0xC7, 0xBF, 0xFF, 0xCF, 0x70, 0x1F, 0xDF, 0x80,
  0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE1, 0xF0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x80, 0x0F, 0x87, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xF0, 0xFF, 0xC0, 0xF1, 0xFF, 0xE0, 0xF3, 0xFF, 0xF8, 0xF7, 0xFF, 0xF8,
  0xF7, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xF6, 0x00, 0xFC,
  0xF7, 0xE7, 0xF8, 0xF3, 0xFF, 0xF8, 0xF1, 0xFF, 0xE0, 0xF0, 0xFF, 0xC0,
  0xF0, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0x0F, 0xFF, 0x8F,
  0x1F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x3F, 0x00, 0xEF, 0x7E, 0x00, 0x7F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0xEF, 0x3F, 0xE7, 0xEF, 0x1F, 0xFF, 0xCF,
  0x0F, 0xFF, 0x8F, 0x03, 0xFF, 0x0F, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0xC0, 0xF1, 0xFF, 0xE0, 0xF3, 0xFF, 0xF8, 0xF7, 0xC7, 0xF8,
  0xF7, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC3, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDF, 0x00, 0x07,
  0xCF, 0xC0, 0x07, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x0F, 0xE3,
  0xFE, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x79, 0xE0, 0x1F,
  0x00, 0xF3, 0xC0, 0x3E, 0x01, 0xE7, 0x80, 0xFC, 0x03, 0xCF, 0x01, 0xDC,
  0x07, 0x9E, 0x03, 0xB8, 0x0E, 0x3C, 0x07, 0x70, 0x3C, 0x3C, 0x0E, 0xE0,
  0x78, 0x78, 0x19, 0xC0, 0xF0, 0xF0, 0x71, 0x81, 0xE1, 0xE0, 0xE3, 0x83,
  0xC3, 0xC1, 0xC7, 0x07, 0x07, 0x83, 0x8E, 0x0E, 0x07, 0x87, 0x1C, 0x3C,
  0x0F, 0x0C, 0x38, 0x78, 0x1E, 0x38, 0x70, 0xF0, 0x3C, 0x70, 0x71, 0xE0,
  0x78, 0xE0, 0xE3, 0x80, 0xF1, 0xC1, 0xC7, 0x00, 0xE3, 0x83, 0x9E, 0x01,
  0xE6, 0x07, 0x3C, 0x03, 0xDC, 0x0E, 0x78, 0x07, 0xB8, 0x0E, 0xF0, 0x0F,
  0x70, 0x1D, 0xC0, 0x1E, 0xE0, 0x3B, 0x80, 0x1D, 0xC0, 0x77, 0x00, 0x3B,
  0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x3E,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x78, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x1F,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xE7, 0xFE, 0x00, 0x7D, 0xFF, 0xE0, 0x0F, 0xBF, 0xFE,
  0x01, 0xFF, 0x83, 0xE0, 0x3F, 0xF0, 0x3E, 0x07, 0xFC, 0x03, 0xE0, 0xF7,
  0x80, 0x7F, 0xFE, 0xF0, 0x07, 0xFF, 0x9E, 0x00, 0x7F, 0xF3, 0xC0, 0x03,
  0xF8, 0x00,
};

const GFXglyph JetBrainsMono_Light58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 42, 35, 13, -42 },
  { 49, 17, 17, 35, 9, -42 },
  { 86, 31, 42, 35, 2, -42 },
  { 249, 26, 58, 35, 4, -50 },
  { 438, 33, 43, 35, 1, -43 },
  { 616, 30, 44, 35, 3, -43 },
  { 781, 5, 17, 35, 15, -42 },
  { 792, 17, 56, 35, 11, -49 },
  { 911, 17, 56, 35, 7, -49 },
  { 1030, 31, 29, 35, 2, -35 },
  { 1143, 27, 27, 35, 4, -33 },
  { 1235, 11, 18, 35, 10, -9 },
  { 1260, 19, 4, 35, 8, -21 },
  { 1270, 9, 10, 35, 13, -9 },
  { 1282, 25, 54, 35, 5, -48 },
  { 1451, 25, 44, 35, 5, -43 },
  { 1589, 26, 42, 35, 5, -42 },
  { 1726, 27, 43, 35, 4, -43 },
  { 1872, 25, 43, 35, 4, -42 },
  { 2007, 24, 42, 35, 5, -42 },
  { 2133, 25, 43, 35, 5, -42 },
  { 2268, 27, 43, 35, 4, -42 },
  { 2414, 26, 42, 35, 5, -42 },
  { 2551, 25, 44, 35, 5, -43 },
  { 2689, 27, 43, 35, 4, -43 },
  { 2835, 9, 33, 35, 13, -32 },
  { 2873, 12, 41, 35, 10, -32 },
  { 2935, 25, 30, 35, 5, -34 },
  { 3029, 25, 18, 35, 5, -28 },
  { 3086, 25, 30, 35, 5, -34 },
  { 3180, 21, 42, 35, 8, -42 },
  { 3291, 29, 53, 35, 3, -43 },
  { 3484, 29, 42, 35, 3, -42 },
  { 3637, 25, 42, 35, 6, -42 },
  { 3769, 25, 44, 35, 5, -43 },
  { 3907, 23, 42, 35, 6, -42 },
  { 4028, 24, 42, 35, 6, -42 },
  { 4154, 24, 42, 35, 6, -42 },
  { 4280, 25, 44, 35, 5, -43 },
  { 4418, 23, 42, 35, 6, -42 },
  { 4539, 22, 42, 35, 6, -42 },
  { 4655, 25, 43, 35, 3, -42 },
  { 4790, 26, 42, 35, 6, -42 },
  { 4927, 24, 42, 35, 7, -42 },
  { 5053, 25, 42, 35, 5, -42 },
  { 5185, 23, 42, 35, 6, -42 },
  { 5306, 24, 44, 35, 5, -43 },
  { 5438, 26, 42, 35, 6, -42 },
  { 5575, 25, 53, 35, 5, -43 },
  { 5741, 25, 42, 35, 6, -42 },
  { 5873, 26, 44, 35, 4, -43 },
  { 6016, 29, 42, 35, 3, -42 },
  { 6169, 23, 43, 35, 6, -42 },
  { 6293, 29, 42, 35, 3, -42 },
  { 6446, 31, 42, 35, 2, -42 },
  { 6609, 30, 42, 35, 2, -42 },
  { 6767, 31, 42, 35, 2, -42 },
  { 6930, 25, 42, 35, 5, -42 },
  { 7062, 14, 54, 35, 12, -48 },
  { 7157, 25, 54, 35, 5, -48 },
  { 7326, 14, 54, 35, 9, -48 },
  { 7421, 25, 22, 35, 5, -42 },
  { 7490, 28, 4, 35, 3, 1 },
  { 7504, 11, 9, 35, 11, -46 },
  { 7517, 25, 33, 35, 4, -32 },
  { 7621, 24, 43, 35, 6, -42 },
  { 7750, 25, 33, 35, 5, -32 },
  { 7854, 24, 43, 35, 5, -42 },
  { 7983, 25, 33, 35, 5, -32 },
  { 8087, 27, 42, 35, 4, -42 },
  { 8229, 24, 42, 35, 5, -32 },
  { 8355, 23, 42, 35, 6, -42 },
  { 8476, 27, 45, 35, 5, -45 },
  { 8628, 21, 55, 35, 5, -45 },
  { 8773, 26, 42, 35, 6, -42 },
  { 8910, 30, 42, 35, 2, -42 },
  { 9068, 27, 32, 35, 4, -32 },
  { 9176, 23, 32, 35, 6, -32 },
  { 9268, 25, 33, 35, 5, -32 },
  { 9372, 24, 42, 35, 6, -32 },
  { 9498, 24, 42, 35, 5, -32 },
  { 9624, 24, 32, 35, 7, -32 },
  { 9720, 25, 33, 35, 5, -32 },
  { 9824, 27, 41, 35, 3, -41 },
  { 9963, 23, 33, 35, 6, -32 },
  { 10058, 27, 32, 35, 4, -32 },
  { 10166, 31, 32, 35, 2, -32 },
  { 10290, 29, 32, 35, 3, -32 },
  { 10406, 27, 42, 35, 4, -32 },
  { 10548, 24, 32, 35, 5, -32 },
  { 10644, 25, 54, 35, 5, -48 },
  { 10813, 5, 54, 35, 15, -48 },
  { 10847, 25, 54, 35, 5, -48 },
  { 11016, 27, 11, 35, 4, -26 },
};

const GFXfont JetBrainsMono_Light58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_LIGHT58PT7B_H_
