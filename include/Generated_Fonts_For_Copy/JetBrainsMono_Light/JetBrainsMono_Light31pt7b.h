#ifndef _JETBRAINSMONO_LIGHT31PT7B_H_
#define _JETBRAINSMONO_LIGHT31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light31pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x98, 0xC6, 0x31, 0x8C, 0x00,
  0x00, 0x0F, 0x7D, 0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xC0, 0x03, 0x06, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0xFF, 0xFF, 0x0C, 0x18, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0xC1,
  0xFF, 0xFC, 0xFF, 0xFE, 0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x0C, 0x03, 0x06,
  0x01, 0x83, 0x00, 0xC1, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x07, 0xC0, 0x7F, 0xC3, 0xD7, 0x9C, 0x46, 0x71, 0x1D, 0x84, 0x76, 0x10,
  0x1C, 0x40, 0x71, 0x00, 0xF4, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x04,
  0xE0, 0x11, 0xC0, 0x47, 0x01, 0x0F, 0x84, 0x3E, 0x10, 0xDC, 0x47, 0x79,
  0x38, 0xFF, 0xE0, 0xFE, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x1E, 0x00, 0xCF, 0xC0, 0x67, 0x38, 0x19, 0x86, 0x0C, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0xC1, 0x86, 0x60, 0x73, 0xB8, 0x0F, 0xCC, 0x00, 0x86,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x67, 0xC0, 0x33, 0xF8, 0x0C, 0xC3,
  0x06, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x60, 0xC3, 0x30, 0x31, 0xCC,
  0x0F, 0xEE, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0xE0, 0x38, 0xF0, 0x70, 0x70,
  0x70, 0x30, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0xE7, 0x0E, 0xC3, 0x8C, 0xC1, 0x9C, 0xC1, 0xD8,
  0xC0, 0xF8, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0xF8, 0xE1, 0xDC, 0x7F, 0x8C,
  0x3F, 0x0F, 0xFF, 0xFF, 0xF6, 0xD8, 0x01, 0x83, 0xC3, 0xC3, 0x83, 0x83,
  0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xF0, 0x38, 0x04, 0x80, 0x70, 0x3E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E,
  0x04, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x71, 0x87, 0xFC, 0x9F, 0x3E, 0xFE, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0x60,
  0x06, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x3C, 0x1C, 0x08, 0x08, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x1C, 0xF3, 0xCE, 0x39, 0xC7, 0x1C, 0x63, 0x80, 0xFF, 0xFF, 0xF0,
  0x67, 0xBF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3D,
  0xC0, 0xEE, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF1,
  0xC7, 0x8E, 0x3C, 0x71, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0xC0, 0x77, 0x07, 0x3F, 0xF0, 0x7F, 0x00, 0x07, 0x80, 0x3E,
  0x03, 0xF8, 0x1E, 0xE0, 0xE3, 0x83, 0x0E, 0x08, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xC3, 0xC7, 0x9C, 0x0E, 0x60, 0x1F, 0x80,
  0x7E, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00,
  0x1F, 0x80, 0x7E, 0x01, 0x9C, 0x0E, 0x78, 0x78, 0xFF, 0xC1, 0xFC, 0x00,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x38, 0x37, 0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE7, 0x87, 0xFF, 0x3E, 0x3D, 0xE0, 0xEE, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x67, 0x07, 0x3F, 0xF0, 0x7F,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xEF, 0x83, 0x7F, 0x1E, 0x1E, 0x70, 0x1D,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x36, 0x01, 0xDC, 0x07,
  0x78, 0x38, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3C, 0x03, 0xE0, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x00, 0x0F, 0x81, 0xFF, 0x1E,
  0x3D, 0xC0, 0xEE, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x06, 0x70, 0x71, 0xC7,
  0x07, 0xF0, 0x1F, 0x03, 0xDC, 0x38, 0x3B, 0x80, 0xD8, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x07, 0x3F, 0xF0, 0x7F, 0x00, 0x07, 0xC0,
  0x7F, 0xC3, 0xC7, 0x9C, 0x0E, 0x60, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x77, 0x01, 0xDE, 0x0F, 0x3F, 0xF8, 0x7E, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xF7, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B,
  0xFF, 0xF0, 0x3C, 0x7C, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE3, 0x8F, 0x1C, 0x38, 0x61, 0xC3, 0x86, 0x1C, 0x00, 0x00, 0x18,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x18, 0x00, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x03, 0x00, 0x10, 0x00, 0xFC, 0x1F, 0xF3, 0xFF, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x07, 0x0F, 0xE1,
  0xF0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0x6E, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC1, 0xF7, 0x87, 0xFF, 0x0C, 0x3E,
  0x18, 0x3C, 0x70, 0x78, 0xE0, 0xF1, 0xC1, 0xE3, 0x83, 0xC7, 0x07, 0x86,
  0x0F, 0x0C, 0x3E, 0x1F, 0xFC, 0x1F, 0x78, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x6C, 0x01, 0xD8, 0x03, 0x38, 0x06,
  0x70, 0x0C, 0x60, 0x38, 0xC0, 0x61, 0xC0, 0xC3, 0x83, 0x83, 0x07, 0x06,
  0x0C, 0x0E, 0x1F, 0xFC, 0x7F, 0xF8, 0xE0, 0x31, 0x80, 0x73, 0x00, 0x6E,
  0x00, 0xDC, 0x01, 0xB0, 0x03, 0x80, 0xFE, 0x07, 0xFE, 0x3F, 0xFD, 0x80,
  0xEC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x03, 0xBF, 0xF9,
  0xFF, 0x8C, 0x1F, 0x60, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x0F, 0x7F, 0xF3, 0xFF, 0x00, 0x0F, 0x81, 0xFF, 0x1E,
  0x3D, 0xC0, 0x6E, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x01, 0xF8, 0x0F, 0xC0, 0x77, 0x07, 0x1F, 0xF0, 0x7F, 0x00, 0xFE, 0x07,
  0xFE, 0x3F, 0xF9, 0x80, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0D, 0x80, 0xEC, 0x0E, 0x7F, 0xE3, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xEF, 0xFF, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3D, 0xC0, 0x6E, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x3F, 0xE1, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0xC0,
  0x77, 0x07, 0x1F, 0xF0, 0x7F, 0x00, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1E, 0x00,
  0xF0, 0x0F, 0xC0, 0x77, 0x07, 0x3F, 0xF0, 0x7F, 0x00, 0xC0, 0x1F, 0x00,
  0x6C, 0x03, 0xB0, 0x0C, 0xC0, 0x73, 0x01, 0x8C, 0x0E, 0x30, 0x30, 0xC1,
  0xC3, 0x06, 0x0F, 0xF8, 0x3F, 0xC0, 0xC3, 0x83, 0x06, 0x0C, 0x1C, 0x30,
  0x30, 0xC0, 0xE3, 0x01, 0x8C, 0x07, 0x30, 0x0C, 0xC0, 0x3B, 0x00, 0x6C,
  0x01, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xF0, 0x1F, 0xC0, 0xFF, 0x83, 0xF6, 0x0F, 0xD8, 0x7F, 0xF1, 0xBE,
  0xC6, 0xFB, 0x1B, 0xEE, 0xCF, 0x9B, 0x3E, 0x6C, 0xF8, 0xE3, 0xE3, 0x8F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xC0, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7D, 0x83, 0xEC, 0x1F, 0x60, 0xF9, 0x87, 0xCC, 0x3E, 0x71, 0xF1, 0x8F,
  0x8C, 0x7C, 0x73, 0xE1, 0x9F, 0x0C, 0xF8, 0x37, 0xC1, 0xBE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xE0, 0x0F, 0x81, 0xFF, 0x1E,
  0x3D, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x67, 0x07, 0x3F, 0xF0, 0x7F, 0x00, 0xFF, 0x03,
  0xFF, 0x8F, 0xFF, 0x30, 0x0E, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xBF, 0xFC, 0xFF, 0xE3, 0xF8, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3D, 0xC0, 0xEE, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x67,
  0x07, 0x3F, 0xF0, 0x7F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0x30, 0x0E, 0xC0, 0x3B,
  0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x07, 0x3F, 0xFC,
  0xFF, 0xC3, 0x0E, 0x0C, 0x1C, 0x30, 0x70, 0xC0, 0xE3, 0x03, 0x8C, 0x07,
  0x30, 0x1C, 0xC0, 0x3B, 0x00, 0xEC, 0x01, 0xC0, 0x07, 0xC0, 0x7F, 0xC3,
  0xC7, 0x9C, 0x06, 0x70, 0x1D, 0x80, 0x76, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0xDC, 0x07, 0x78, 0x38, 0xFF, 0xE0, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x67, 0x07, 0x1F, 0xF0, 0x7F, 0x00, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x33, 0x00, 0x66, 0x01, 0xCE, 0x03, 0x9C, 0x06,
  0x18, 0x0C, 0x30, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0xC1, 0x81, 0x87, 0x03,
  0x8C, 0x07, 0x18, 0x06, 0x30, 0x0C, 0xE0, 0x1D, 0x80, 0x3B, 0x00, 0x36,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xC1, 0xC3, 0xE0, 0xE1, 0xF0,
  0x70, 0xDC, 0x28, 0x6E, 0x14, 0x33, 0x1A, 0x19, 0x8D, 0x0C, 0xC6, 0xC6,
  0x63, 0x63, 0x31, 0x33, 0x98, 0x99, 0xCC, 0x4C, 0xC7, 0x62, 0x63, 0xB1,
  0x30, 0xD8, 0x98, 0x6C, 0x6C, 0x36, 0x36, 0x1A, 0x1B, 0x0D, 0x0F, 0x86,
  0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x07, 0x70, 0x06,
  0x38, 0x0E, 0x38, 0x1C, 0x1C, 0x1C, 0x0C, 0x38, 0x0E, 0x30, 0x06, 0x70,
  0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x0C,
  0x30, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x06,
  0x30, 0x0E, 0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x18, 0x0C, 0x38, 0x0E, 0x30,
  0x06, 0x70, 0x07, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x1F, 0xFF, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1B, 0x01, 0xD8,
  0x0C, 0x60, 0xE3, 0x06, 0x0C, 0x70, 0x63, 0x03, 0x98, 0x0D, 0x80, 0x70,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0F, 0xE0, 0xFF, 0xC3, 0x83,
  0x9C, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0xFF, 0x3F, 0xFD, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0xDF, 0xFF, 0x3F,
  0x9C, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x3F,
  0x1B, 0xFC, 0xD0, 0x77, 0x01, 0xB8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x6D, 0x07, 0x6F,
  0xF3, 0x3F, 0x00, 0x1F, 0xC3, 0xFF, 0x1C, 0x1D, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x7C, 0x03,
  0xF0, 0x1D, 0xC1, 0xCF, 0xFC, 0x1F, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0xFE, 0xEF, 0xFF, 0x70, 0x7F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0xF7, 0x07, 0xBF, 0xDC, 0xFC, 0xE0, 0x1F, 0xC3, 0xFF,
  0x1C, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x1D, 0xC1, 0xCF, 0xFC, 0x1F,
  0xC0, 0x00, 0x7C, 0x0F, 0xF0, 0x7F, 0xC1, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x3F, 0xBB, 0xFF, 0xDC, 0x1F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x07, 0xBC, 0x7C, 0xFE, 0xE3, 0xE7, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x63, 0xFF, 0x1F, 0xF0, 0xFC, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x3F, 0x1B, 0xFC, 0xD0, 0x77, 0x01,
  0xB8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x7F, 0xCF, 0xF1, 0xE0, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01, 0xF8, 0x0E,
  0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x70, 0xE3, 0x83, 0xFE, 0x0F, 0xF8,
  0x38, 0xE0, 0xE1, 0xC3, 0x83, 0x0E, 0x0E, 0x38, 0x1C, 0xE0, 0x33, 0x80,
  0xEE, 0x01, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0xDE, 0x7B, 0x7F, 0xFE, 0x38, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C,
  0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F,
  0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0C, 0xCF, 0xC6, 0xFF, 0x34, 0x1D,
  0xC0, 0x6E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x38, 0x1F,
  0xC3, 0xFF, 0x1C, 0x1D, 0xC0, 0x6E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x19, 0xC1, 0xCF,
  0xFC, 0x1F, 0xC0, 0xCF, 0xC6, 0xFF, 0x34, 0x1D, 0xC0, 0x6E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x1B, 0x41, 0xDB, 0xFC, 0xCF, 0xC6, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x3F, 0xBB, 0xFF, 0xDC, 0x1F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xF0, 0x3D, 0xC1, 0xEF, 0xFF, 0x3F, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xCF, 0xCD, 0xFE, 0xE0, 0xFE,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0xE3, 0xFF,
  0x9C, 0x1D, 0xC0, 0x7E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x0F, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xF0, 0x1F, 0x81, 0xEF, 0xFE, 0x3F,
  0xE0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xFF,
  0xFF, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0xFC, 0x07, 0xF0, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x19, 0xC1, 0xC7, 0xFC, 0x1F, 0xC0, 0xE0, 0x0F, 0xC0, 0x19,
  0x80, 0x73, 0x80, 0xE7, 0x01, 0x86, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x18,
  0x70, 0x38, 0xC0, 0x71, 0x80, 0x67, 0x00, 0xEC, 0x01, 0xD8, 0x01, 0xB0,
  0x03, 0xC0, 0x07, 0x80, 0xC1, 0xC3, 0xE1, 0xC3, 0x61, 0xC3, 0x61, 0x43,
  0x63, 0x43, 0x63, 0x46, 0x63, 0x66, 0x72, 0x66, 0x32, 0x66, 0x32, 0x26,
  0x36, 0x26, 0x36, 0x24, 0x36, 0x3C, 0x34, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C,
  0x1C, 0x1C, 0xE0, 0x1C, 0xE0, 0x30, 0xE0, 0xE0, 0xC3, 0x81, 0xC6, 0x01,
  0xDC, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x3B, 0x00, 0x67,
  0x01, 0xC7, 0x07, 0x06, 0x1C, 0x0E, 0x38, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F,
  0xC0, 0x19, 0xC0, 0x73, 0x80, 0xC3, 0x03, 0x87, 0x07, 0x0E, 0x0C, 0x0C,
  0x38, 0x1C, 0x70, 0x18, 0xC0, 0x3B, 0x80, 0x76, 0x00, 0x6C, 0x00, 0xF8,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x78,
  0x0F, 0xC0, 0xF8, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x83, 0xF8, 0x1F, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0xFF, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3C, 0x0D, 0xF8,
  0x3E, 0x70, 0xF8, 0xE3, 0xE1, 0xFF, 0x83, 0xE0,
};

const GFXglyph JetBrainsMono_Light31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 9, 10, 19, 5, -23 },
  { 28, 17, 23, 19, 1, -23 },
  { 77, 14, 31, 19, 2, -27 },
  { 132, 18, 23, 19, 0, -23 },
  { 184, 16, 23, 19, 2, -23 },
  { 230, 3, 10, 19, 8, -23 },
  { 234, 9, 30, 19, 6, -26 },
  { 268, 9, 30, 19, 4, -26 },
  { 302, 16, 16, 19, 1, -19 },
  { 334, 14, 15, 19, 2, -18 },
  { 361, 6, 10, 19, 5, -5 },
  { 369, 10, 2, 19, 4, -11 },
  { 372, 5, 5, 19, 7, -5 },
  { 376, 14, 29, 19, 2, -26 },
  { 427, 13, 23, 19, 3, -23 },
  { 465, 14, 23, 19, 3, -23 },
  { 506, 14, 23, 19, 2, -23 },
  { 547, 14, 23, 19, 2, -23 },
  { 588, 12, 23, 19, 3, -23 },
  { 623, 13, 23, 19, 3, -23 },
  { 661, 14, 23, 19, 2, -23 },
  { 702, 13, 23, 19, 3, -23 },
  { 740, 13, 23, 19, 3, -23 },
  { 778, 14, 23, 19, 2, -23 },
  { 819, 5, 17, 19, 7, -17 },
  { 830, 7, 22, 19, 5, -17 },
  { 850, 13, 16, 19, 3, -18 },
  { 876, 13, 10, 19, 3, -15 },
  { 893, 13, 16, 19, 3, -18 },
  { 919, 11, 23, 19, 4, -23 },
  { 951, 15, 29, 19, 2, -23 },
  { 1006, 15, 23, 19, 2, -23 },
  { 1050, 13, 23, 19, 3, -23 },
  { 1088, 13, 23, 19, 3, -23 },
  { 1126, 13, 23, 19, 3, -23 },
  { 1164, 13, 23, 19, 3, -23 },
  { 1202, 13, 23, 19, 3, -23 },
  { 1240, 13, 23, 19, 3, -23 },
  { 1278, 13, 23, 19, 3, -23 },
  { 1316, 12, 23, 19, 3, -23 },
  { 1351, 13, 23, 19, 2, -23 },
  { 1389, 14, 23, 19, 3, -23 },
  { 1430, 12, 23, 19, 4, -23 },
  { 1465, 14, 23, 19, 2, -23 },
  { 1506, 13, 23, 19, 3, -23 },
  { 1544, 13, 23, 19, 3, -23 },
  { 1582, 14, 23, 19, 3, -23 },
  { 1623, 13, 29, 19, 3, -23 },
  { 1671, 14, 23, 19, 3, -23 },
  { 1712, 14, 23, 19, 2, -23 },
  { 1753, 15, 23, 19, 2, -23 },
  { 1797, 13, 23, 19, 3, -23 },
  { 1835, 15, 23, 19, 2, -23 },
  { 1879, 17, 23, 19, 1, -23 },
  { 1928, 16, 23, 19, 1, -23 },
  { 1974, 16, 23, 19, 1, -23 },
  { 2020, 13, 23, 19, 3, -23 },
  { 2058, 8, 29, 19, 6, -26 },
  { 2087, 14, 29, 19, 2, -26 },
  { 2138, 7, 29, 19, 5, -26 },
  { 2164, 13, 12, 19, 3, -23 },
  { 2184, 15, 2, 19, 2, 1 },
  { 2188, 6, 4, 19, 6, -24 },
  { 2191, 14, 17, 19, 2, -17 },
  { 2221, 13, 23, 19, 3, -23 },
  { 2259, 13, 17, 19, 3, -17 },
  { 2287, 13, 23, 19, 3, -23 },
  { 2325, 13, 17, 19, 3, -17 },
  { 2353, 14, 23, 19, 2, -23 },
  { 2394, 13, 23, 19, 3, -17 },
  { 2432, 13, 23, 19, 3, -23 },
  { 2470, 14, 24, 19, 3, -24 },
  { 2512, 11, 30, 19, 3, -24 },
  { 2554, 14, 23, 19, 3, -23 },
  { 2595, 16, 23, 19, 1, -23 },
  { 2641, 14, 17, 19, 2, -17 },
  { 2671, 13, 17, 19, 3, -17 },
  { 2699, 13, 17, 19, 3, -17 },
  { 2727, 13, 23, 19, 3, -17 },
  { 2765, 13, 23, 19, 3, -17 },
  { 2803, 12, 17, 19, 4, -17 },
  { 2829, 13, 17, 19, 3, -17 },
  { 2857, 14, 22, 19, 2, -22 },
  { 2896, 13, 17, 19, 3, -17 },
  { 2924, 15, 17, 19, 2, -17 },
  { 2956, 16, 17, 19, 1, -17 },
  { 2990, 15, 17, 19, 2, -17 },
  { 3022, 15, 23, 19, 2, -17 },
  { 3066, 13, 17, 19, 3, -17 },
  { 3094, 13, 29, 19, 3, -26 },
  { 3142, 3, 29, 19, 8, -26 },
  { 3153, 13, 29, 19, 3, -26 },
  { 3201, 14, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_Light31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_LIGHT31PT7B_H_
