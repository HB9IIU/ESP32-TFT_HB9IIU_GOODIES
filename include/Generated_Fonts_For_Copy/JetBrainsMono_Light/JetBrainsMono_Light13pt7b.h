#ifndef _JETBRAINSMONO_LIGHT13PT7B_H_
#define _JETBRAINSMONO_LIGHT13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xA0, 0xC0, 0x99, 0x90, 0x12, 0x49, 0xF9, 0x22, 0x56, 0xD2,
  0x24, 0x48, 0x20, 0xC6, 0xA9, 0xA1, 0x83, 0x8B, 0x26, 0x97, 0x88, 0x20,
  0x61, 0x92, 0x94, 0x94, 0x68, 0x10, 0x1E, 0x29, 0x49, 0x8E, 0x21, 0x68,
  0x90, 0x42, 0x99, 0x66, 0x9B, 0xD0, 0xE0, 0x12, 0x44, 0xCC, 0xCC, 0x44,
  0x63, 0x10, 0xC2, 0x11, 0x11, 0x11, 0x11, 0x36, 0x80, 0x10, 0x23, 0x59,
  0xE1, 0x84, 0x99, 0x00, 0x20, 0x8F, 0xC8, 0x20, 0x80, 0x69, 0x40, 0xF0,
  0xF0, 0x04, 0x20, 0x86, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x31, 0x28,
  0x61, 0xA6, 0xD8, 0x61, 0x8D, 0xE0, 0x72, 0x41, 0x04, 0x10, 0x41, 0x04,
  0xFC, 0x33, 0x28, 0x41, 0x08, 0x61, 0x08, 0x43, 0xF0, 0xF8, 0x42, 0x0E,
  0x08, 0x18, 0x62, 0x78, 0x18, 0x88, 0x84, 0xC7, 0xE1, 0x08, 0xFA, 0x08,
  0x2E, 0xCC, 0x10, 0x62, 0x78, 0x10, 0x84, 0x1E, 0xCE, 0x18, 0x63, 0x78,
  0xFE, 0x30, 0x82, 0x10, 0x43, 0x08, 0x60, 0x31, 0x28, 0x62, 0x79, 0xE8,
  0xA1, 0x8D, 0xE0, 0x31, 0x28, 0x61, 0x85, 0xE0, 0x84, 0x30, 0x80, 0xE0,
  0x3C, 0x6C, 0x00, 0xD2, 0x80, 0x04, 0x66, 0x20, 0x60, 0x60, 0xC0, 0xFC,
  0x00, 0x3F, 0x83, 0x03, 0x03, 0x19, 0x88, 0x00, 0xF1, 0x11, 0x64, 0x00,
  0xC0, 0x33, 0x38, 0x61, 0xBE, 0x9A, 0x69, 0xBE, 0x08, 0x1C, 0x30, 0xC5,
  0x12, 0x49, 0xE8, 0xA1, 0x84, 0xFA, 0x18, 0x62, 0xFA, 0x18, 0x63, 0xF8,
  0x31, 0x28, 0x60, 0x82, 0x08, 0x21, 0xCD, 0xE0, 0xFA, 0x28, 0x61, 0x86,
  0x18, 0x62, 0xF0, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0xFC, 0xFE, 0x08,
  0x20, 0x83, 0xE8, 0x20, 0x82, 0x00, 0x31, 0x28, 0x60, 0x82, 0x78, 0x61,
  0xCD, 0xE0, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8C, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0xF8, 0x38, 0x42, 0x10, 0x86, 0x31, 0x70, 0x8E, 0x29, 0xA4,
  0xF2, 0x48, 0xA2, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0xCF, 0x3D,
  0x6D, 0xB6, 0x18, 0x61, 0x84, 0xC7, 0x1A, 0x69, 0xA6, 0x59, 0x63, 0x8C,
  0x31, 0x28, 0x61, 0x86, 0x18, 0x61, 0x89, 0xE0, 0xFE, 0x18, 0x61, 0xFA,
  0x08, 0x20, 0x80, 0x31, 0x28, 0x61, 0x86, 0x18, 0x61, 0x89, 0xE1, 0x83,
  0xFA, 0x18, 0x63, 0xFA, 0x48, 0xA2, 0x84, 0x31, 0x28, 0x60, 0x60, 0xE0,
  0xC1, 0x85, 0xE0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x72, 0x78, 0x86, 0x14, 0x92, 0x49, 0x23, 0x0C,
  0x30, 0x9A, 0xB5, 0x6A, 0xD5, 0xAD, 0x5A, 0xB2, 0x64, 0x8D, 0x25, 0x0C,
  0x30, 0xC4, 0xB2, 0x84, 0xC2, 0xC8, 0x91, 0xC1, 0x82, 0x04, 0x08, 0x10,
  0xFC, 0x21, 0x04, 0x20, 0x84, 0x20, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x70,
  0x81, 0x04, 0x10, 0x20, 0x83, 0x04, 0x10, 0x20, 0x83, 0xE4, 0x92, 0x49,
  0x24, 0xF0, 0x31, 0x44, 0x92, 0x84, 0xFC, 0xC4, 0x7A, 0x30, 0x7F, 0x86,
  0x37, 0x40, 0x82, 0x0B, 0xB3, 0x86, 0x18, 0x72, 0xB8, 0x7A, 0x38, 0x20,
  0x82, 0x37, 0x80, 0x04, 0x17, 0x63, 0x86, 0x18, 0x63, 0x74, 0x7A, 0x38,
  0x7F, 0x82, 0x37, 0x80, 0x3C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x76,
  0x38, 0x61, 0x8D, 0x52, 0xC3, 0x78, 0x82, 0x0B, 0xB2, 0x86, 0x18, 0x61,
  0x84, 0x30, 0x40, 0x3C, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x18, 0x40, 0xF0,
  0x84, 0x21, 0x08, 0x47, 0xE0, 0x82, 0x08, 0xE2, 0x93, 0xC9, 0xA2, 0x84,
  0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1E, 0xFE, 0x9A, 0x69, 0xA6,
  0x9A, 0x40, 0xBB, 0x28, 0x61, 0x86, 0x18, 0x40, 0x7A, 0x38, 0x61, 0x86,
  0x27, 0x80, 0xBB, 0x38, 0x61, 0x87, 0x2B, 0xA0, 0x80, 0x76, 0x38, 0x61,
  0x86, 0x37, 0x41, 0x04, 0xFB, 0x1C, 0x70, 0xC3, 0x0C, 0x00, 0x7A, 0x1C,
  0x0E, 0x06, 0x17, 0x80, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x3C, 0x86,
  0x18, 0x61, 0x87, 0x27, 0x80, 0x86, 0x24, 0x92, 0x50, 0xC3, 0x00, 0xDA,
  0xB5, 0x6A, 0xD6, 0xAD, 0x89, 0x00, 0xCD, 0x23, 0x0C, 0x71, 0x28, 0x40,
  0x87, 0x24, 0x92, 0x30, 0xC3, 0x08, 0x60, 0xF8, 0x21, 0x08, 0x61, 0x0F,
  0xC0, 0x0C, 0x41, 0x04, 0x10, 0x4E, 0x04, 0x10, 0x41, 0x07, 0xFF, 0xF0,
  0xC0, 0x82, 0x08, 0x20, 0x81, 0xC8, 0x20, 0x82, 0x38, 0xE6, 0xD9, 0x80,
};

const GFXglyph JetBrainsMono_Light13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 2, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 13, 8, 1, -11 },
  { 24, 8, 10, 8, 0, -10 },
  { 34, 6, 10, 8, 1, -10 },
  { 42, 1, 3, 8, 3, -9 },
  { 43, 4, 13, 8, 2, -11 },
  { 50, 4, 13, 8, 1, -11 },
  { 57, 7, 7, 8, 0, -8 },
  { 64, 6, 6, 8, 1, -7 },
  { 69, 3, 4, 8, 2, -2 },
  { 71, 4, 1, 8, 2, -5 },
  { 72, 2, 2, 8, 3, -2 },
  { 73, 6, 12, 8, 1, -11 },
  { 82, 6, 10, 8, 1, -10 },
  { 90, 6, 9, 8, 1, -9 },
  { 97, 6, 10, 8, 1, -10 },
  { 105, 6, 9, 8, 1, -9 },
  { 112, 5, 9, 8, 1, -9 },
  { 118, 6, 9, 8, 1, -9 },
  { 125, 6, 9, 8, 1, -9 },
  { 132, 6, 9, 8, 1, -9 },
  { 139, 6, 10, 8, 1, -10 },
  { 147, 6, 10, 8, 1, -10 },
  { 155, 2, 7, 8, 3, -7 },
  { 157, 3, 9, 8, 2, -7 },
  { 161, 6, 7, 8, 1, -8 },
  { 167, 6, 4, 8, 1, -6 },
  { 170, 6, 7, 8, 1, -8 },
  { 176, 4, 9, 8, 2, -9 },
  { 181, 6, 12, 8, 1, -10 },
  { 190, 6, 9, 8, 1, -9 },
  { 197, 6, 9, 8, 1, -9 },
  { 204, 6, 10, 8, 1, -10 },
  { 212, 6, 9, 8, 1, -9 },
  { 219, 6, 9, 8, 1, -9 },
  { 226, 6, 10, 8, 1, -10 },
  { 234, 6, 10, 8, 1, -10 },
  { 242, 6, 9, 8, 1, -9 },
  { 249, 5, 9, 8, 1, -9 },
  { 255, 5, 9, 8, 1, -9 },
  { 261, 6, 9, 8, 1, -9 },
  { 268, 5, 9, 8, 2, -9 },
  { 274, 6, 9, 8, 1, -9 },
  { 281, 6, 9, 8, 1, -9 },
  { 288, 6, 10, 8, 1, -10 },
  { 296, 6, 9, 8, 1, -9 },
  { 303, 6, 12, 8, 1, -10 },
  { 312, 6, 9, 8, 1, -9 },
  { 319, 6, 10, 8, 1, -10 },
  { 327, 6, 10, 8, 1, -10 },
  { 335, 6, 9, 8, 1, -9 },
  { 342, 6, 9, 8, 1, -9 },
  { 349, 7, 9, 8, 0, -9 },
  { 357, 6, 9, 8, 1, -9 },
  { 364, 7, 9, 8, 0, -9 },
  { 372, 6, 9, 8, 1, -9 },
  { 379, 3, 12, 8, 3, -11 },
  { 384, 6, 12, 8, 1, -11 },
  { 393, 3, 12, 8, 2, -11 },
  { 398, 6, 5, 8, 1, -9 },
  { 402, 6, 1, 8, 1, 0 },
  { 403, 3, 2, 8, 2, -10 },
  { 404, 6, 7, 8, 1, -7 },
  { 410, 6, 9, 8, 1, -9 },
  { 417, 6, 7, 8, 1, -7 },
  { 423, 6, 9, 8, 1, -9 },
  { 430, 6, 7, 8, 1, -7 },
  { 436, 6, 9, 8, 1, -9 },
  { 443, 6, 9, 8, 1, -7 },
  { 450, 6, 9, 8, 1, -9 },
  { 457, 6, 10, 8, 1, -10 },
  { 465, 5, 12, 8, 1, -10 },
  { 473, 6, 9, 8, 1, -9 },
  { 480, 7, 9, 8, 0, -9 },
  { 488, 6, 7, 8, 1, -7 },
  { 494, 6, 7, 8, 1, -7 },
  { 500, 6, 7, 8, 1, -7 },
  { 506, 6, 9, 8, 1, -7 },
  { 513, 6, 9, 8, 1, -7 },
  { 520, 6, 7, 8, 1, -7 },
  { 526, 6, 7, 8, 1, -7 },
  { 532, 6, 9, 8, 1, -9 },
  { 539, 6, 7, 8, 1, -7 },
  { 545, 6, 7, 8, 1, -7 },
  { 551, 7, 7, 8, 0, -7 },
  { 558, 6, 7, 8, 1, -7 },
  { 564, 6, 9, 8, 1, -7 },
  { 571, 6, 7, 8, 1, -7 },
  { 577, 6, 12, 8, 1, -11 },
  { 586, 1, 12, 8, 3, -11 },
  { 588, 6, 12, 8, 1, -11 },
  { 597, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Light13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_LIGHT13PT7B_H_
