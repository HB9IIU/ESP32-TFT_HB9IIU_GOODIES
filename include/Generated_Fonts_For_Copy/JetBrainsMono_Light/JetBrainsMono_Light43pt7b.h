#ifndef _JETBRAINSMONO_LIGHT43PT7B_H_
#define _JETBRAINSMONO_LIGHT43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light43pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x1C, 0x70, 0xC3, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7,
  0x80, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x0C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x38, 0x0C, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x83, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x18, 0x06, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0x6F, 0xC3, 0xC6, 0x3C, 0x38, 0x61, 0xE7, 0x86, 0x1E, 0x78, 0x60, 0xE7,
  0x86, 0x0E, 0x78, 0x60, 0x07, 0x86, 0x00, 0x3C, 0x60, 0x03, 0xC6, 0x00,
  0x1F, 0x60, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x06, 0xFC, 0x00, 0x63, 0xC0, 0x06, 0x1E, 0x00, 0x60, 0xE0, 0x06,
  0x0E, 0x00, 0x60, 0xFF, 0x06, 0x0F, 0xF0, 0x60, 0xE7, 0x06, 0x0E, 0x78,
  0x61, 0xE3, 0xC6, 0x3C, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x7F, 0xC0, 0x0E,
  0xF0, 0xE0, 0x1C, 0xE0, 0xE0, 0x18, 0xE0, 0x70, 0x38, 0xE0, 0x70, 0x70,
  0xE0, 0x70, 0x60, 0xE0, 0x70, 0xE0, 0xE0, 0x71, 0xC0, 0xE0, 0xE3, 0x80,
  0xF0, 0xE3, 0x80, 0x7F, 0xE7, 0x00, 0x3F, 0xCE, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x71, 0xF8,
  0x00, 0xE3, 0xFC, 0x00, 0xC7, 0xFE, 0x01, 0xC7, 0x07, 0x03, 0x8E, 0x07,
  0x03, 0x0E, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x0E, 0x07,
  0x1C, 0x0E, 0x07, 0x38, 0x07, 0x07, 0x70, 0x07, 0xFE, 0x70, 0x03, 0xFE,
  0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07,
  0xC3, 0xE0, 0x1E, 0x07, 0x80, 0x70, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7D,
  0xE0, 0x05, 0xE3, 0xC0, 0xE7, 0x07, 0x07, 0x9C, 0x1E, 0x1C, 0xF0, 0x3C,
  0xF3, 0xC0, 0x7B, 0x8F, 0x00, 0xFE, 0x3C, 0x03, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x1F, 0x07, 0x00, 0x7C, 0x1C, 0x03, 0xF8, 0x78, 0x1E, 0xF0, 0xFF,
  0xF1, 0xC3, 0xFF, 0x87, 0x83, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE,
  0xEE, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x18, 0xC0, 0x07, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x1E, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x07, 0x00, 0xBE,
  0x0C, 0x1F, 0xFE, 0x31, 0xFD, 0xFE, 0xDF, 0xE1, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0,
  0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x0E,
  0x01, 0xC0, 0x10, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1,
  0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0xF9, 0xFF, 0xFF, 0xEF, 0xDF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xF8, 0x7C, 0x78,
  0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x1E, 0x1F,
  0x87, 0x87, 0xE3, 0xE1, 0xF8, 0x78, 0x7E, 0x0C, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x38, 0x07,
  0xC7, 0x01, 0xF0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80, 0x80, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xF0, 0xF8, 0x7C, 0x03, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEE,
  0x00, 0x39, 0xE0, 0x0F, 0x1E, 0x03, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0xF0, 0x0E, 0x78, 0x07,
  0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x07, 0x01, 0xCF, 0xF0, 0x77,
  0xFF, 0x3F, 0xCF, 0xCF, 0xC0, 0x7B, 0xE0, 0x0E, 0xF0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x79, 0xE0, 0x3E, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xC0, 0x7C, 0x78, 0x01,
  0xE7, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x80, 0x1E, 0x78,
  0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0xF1, 0xF8, 0x7C, 0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x1E, 0x3C, 0x0F, 0x07,
  0x87, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xCF, 0x83, 0xC1,
  0xF1, 0xE0, 0x1E, 0xF0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x07, 0x9F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x03, 0xF1, 0xF8, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x70, 0x01, 0xEF,
  0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFB, 0x80, 0x3E, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xF7, 0xFF, 0xDF, 0xBE, 0x1E,
  0x3F, 0x7F, 0x7F, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78,
  0x78, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xC0, 0x7C, 0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0x9C, 0x00,
  0x0F, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xC7,
  0xE0, 0x3F, 0xDF, 0x81, 0xFF, 0xFE, 0x07, 0x83, 0xF8, 0x1C, 0x0F, 0xE0,
  0xF0, 0x1F, 0x83, 0x80, 0x7E, 0x0E, 0x01, 0xF8, 0x38, 0x07, 0xE0, 0xE0,
  0x1F, 0x83, 0x80, 0x7E, 0x0E, 0x01, 0xF8, 0x38, 0x07, 0xE0, 0xF0, 0x1F,
  0x81, 0xC0, 0xFE, 0x07, 0x87, 0xF8, 0x1F, 0xF7, 0xE0, 0x3F, 0xDF, 0x80,
  0x38, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00,
  0x39, 0xC0, 0x03, 0xCF, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E,
  0x00, 0x78, 0x78, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x0E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x00, 0xF1, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0xF0, 0x00, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x1F,
  0xC0, 0x00, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x07,
  0xCF, 0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xF0, 0x1F, 0x9E, 0x00, 0xF3, 0xC0, 0x0F,
  0x78, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x07, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0xF8, 0x7C, 0x78, 0x07, 0x9C, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xE0, 0x0E, 0x7C, 0x0F, 0x8F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xC0, 0x7C, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xBC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x7C, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF8, 0x7C, 0x78, 0x07, 0x9C, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D,
  0xE0, 0x0E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEE, 0x00,
  0x3D, 0xE0, 0x0F, 0x1E, 0x03, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0x00, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0,
  0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x78, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xF6, 0x01, 0xBE, 0xE0, 0x77, 0xDC, 0x0E, 0xF9, 0x81, 0x9F, 0x38, 0x77,
  0xE7, 0x0E, 0xFC, 0x61, 0x9F, 0xCE, 0x73, 0xF9, 0xCE, 0x7F, 0x19, 0x8F,
  0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFB, 0x80, 0xFE, 0xE0, 0x3F, 0x9C,
  0x0F, 0xE7, 0x03, 0xF9, 0xC0, 0xFE, 0x38, 0x3F, 0x8E, 0x0F, 0xE3, 0x83,
  0xF8, 0x70, 0xFE, 0x1C, 0x3F, 0x87, 0x8F, 0xE0, 0xE3, 0xF8, 0x38, 0xFE,
  0x07, 0x3F, 0x81, 0xCF, 0xE0, 0x73, 0xF8, 0x0E, 0xFE, 0x03, 0x9F, 0x80,
  0xE7, 0xE0, 0x1D, 0xF8, 0x07, 0x7E, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0,
  0xF8, 0xFC, 0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x39, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x78, 0x03, 0xEF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xBC, 0x03, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0xE1, 0xF8, 0xFC, 0x78, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x1E, 0x7C, 0x0F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x78, 0x03, 0xEF, 0x00,
  0x3D, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBF, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x03,
  0xFC, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x81, 0xF0,
  0xFC, 0x3C, 0x03, 0xC3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x78,
  0x00, 0xE7, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80,
  0x1E, 0x7C, 0x03, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xE7, 0x80, 0x79, 0xF0, 0x3E,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0x3B, 0x80, 0x01,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0F, 0x07, 0x80, 0x78,
  0x3C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xE0,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x3C, 0x01, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xE7, 0x80, 0x0F, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0E, 0x70,
  0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7E, 0x0E, 0x70,
  0x6E, 0x0E, 0x70, 0x66, 0x0E, 0x70, 0x66, 0x1E, 0x78, 0x66, 0x1C, 0x38,
  0x66, 0x1C, 0x38, 0x66, 0x1C, 0x38, 0x66, 0x1C, 0x38, 0xE7, 0x1C, 0x38,
  0xC7, 0x1C, 0x38, 0xC3, 0x1C, 0x38, 0xC3, 0x1C, 0x38, 0xC3, 0x38, 0x3C,
  0xC3, 0x38, 0x1C, 0xC3, 0x38, 0x1D, 0xC3, 0x38, 0x1D, 0xC3, 0x38, 0x1D,
  0x83, 0xB8, 0x1D, 0x81, 0xB8, 0x1D, 0x81, 0xB8, 0x1D, 0x81, 0xB0, 0x1D,
  0x81, 0xF0, 0x0D, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x0F,
  0x01, 0xF0, 0xF8, 0x00, 0x79, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x00,
  0x38, 0x1E, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xC1, 0xE0,
  0x07, 0x87, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00,
  0x1E, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x78,
  0x07, 0x83, 0xC0, 0x0E, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xC0, 0x01,
  0xEF, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x80, 0x07,
  0x8E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xE0, 0x1E, 0x07,
  0x80, 0x70, 0x0F, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xC0, 0x03, 0x8F, 0x00, 0x0F, 0x38, 0x00, 0x1D, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x1C, 0x78, 0x07,
  0x1C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x7C, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x03, 0xE3, 0xC0, 0x3C, 0xF0, 0x03,
  0x9E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xF7, 0x80, 0x7E,
  0xFE, 0x7F, 0xCF, 0xFF, 0x78, 0x7F, 0xCF, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC7,
  0xE0, 0xF7, 0xFE, 0x3F, 0xFF, 0xCF, 0xC0, 0xFB, 0xE0, 0x1E, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7B, 0xF0, 0x3E, 0xFF, 0xFF,
  0x3D, 0xFF, 0x8F, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1,
  0xF0, 0x3E, 0x78, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3D,
  0xE0, 0x0E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x1F, 0x8F, 0x1F, 0xF3, 0xCF, 0xFE, 0xF7, 0xC1, 0xFD,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7D,
  0xE0, 0x3F, 0x3F, 0xFF, 0xCF, 0xFE, 0xF0, 0xFF, 0x3C, 0x07, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xF1, 0xF0, 0x3C, 0x78, 0x07, 0xBC, 0x00, 0xEF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE3, 0xC7,
  0xFE, 0xF3, 0xFF, 0xBD, 0xF0, 0x7F, 0x78, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDC,
  0x01, 0xF7, 0x80, 0xFC, 0xFF, 0xFF, 0x3F, 0xFB, 0xC3, 0xFC, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC7, 0xE0, 0xF7, 0xFE, 0x3F, 0xFF, 0xCF, 0xC0, 0xFB, 0xE0, 0x1E,
  0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F,
  0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F,
  0x0F, 0x01, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0,
  0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0xE7, 0x87, 0x8E, 0xFC, 0xFE, 0xFF, 0xFF, 0xEF,
  0x0F, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07,
  0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0,
  0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0E,
  0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0,
  0xE0, 0x7E, 0x0E, 0x07, 0xF1, 0xF8, 0x3D, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0,
  0x3E, 0xF8, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xF0, 0x7C, 0x78, 0x07, 0xBC, 0x00, 0xEF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0xF1, 0xF8, 0x3D, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0,
  0x3E, 0xF8, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x1E, 0xFC, 0x0F, 0xBF, 0xFF, 0xCF, 0x7F, 0xE3, 0xCF, 0xF0, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE3, 0xC7, 0xFE, 0xF3, 0xFF, 0xBD, 0xF0,
  0x7F, 0x78, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xC0,
  0x1F, 0x78, 0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xBC, 0x3F, 0xCF, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xE1, 0xF8, 0x39, 0xFF, 0x8E, 0xFF, 0xF3, 0xB0,
  0x3E, 0xF8, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x1E, 0x70, 0x03, 0xDC, 0x00, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07, 0xDF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x39, 0xE0,
  0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x3C, 0x03, 0x81, 0xC0, 0x38, 0x1C,
  0x07, 0x81, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x1E, 0x00, 0x79, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xE0, 0x78,
  0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x19,
  0x83, 0xE0, 0xE7, 0x0D, 0xC3, 0x9C, 0x33, 0x0E, 0x70, 0xCC, 0x39, 0xC3,
  0x30, 0xE7, 0x0C, 0xC3, 0x1C, 0x73, 0x1C, 0x39, 0x8E, 0x70, 0xE6, 0x19,
  0xC3, 0x98, 0x67, 0x0E, 0x61, 0x9C, 0x39, 0x86, 0x60, 0xEE, 0x19, 0x81,
  0xB0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0xC0, 0xF0, 0x78, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x38,
  0x3C, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xC0, 0x1E, 0x1E, 0x00, 0x79,
  0xE0, 0x01, 0xCE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x79, 0xE0, 0x03, 0x8F,
  0x00, 0x3C, 0x3C, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x1E, 0x1E,
  0x00, 0x79, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0x80, 0x1C, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xF0,
  0x70, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xE0, 0x03,
  0x9C, 0x00, 0x3D, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x77, 0xFC, 0x07, 0xFB, 0xE0, 0x7F, 0x0F, 0x0F, 0xE0, 0x78,
  0xFE, 0x07, 0xFE, 0xE0, 0x3F, 0xEE, 0x00, 0xF8,
};

const GFXglyph JetBrainsMono_Light43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 31, 26, 10, -31 },
  { 25, 12, 13, 26, 7, -31 },
  { 45, 23, 31, 26, 1, -31 },
  { 135, 20, 43, 26, 3, -37 },
  { 243, 24, 32, 26, 1, -32 },
  { 339, 22, 32, 26, 2, -32 },
  { 427, 4, 13, 26, 11, -31 },
  { 434, 13, 41, 26, 8, -36 },
  { 501, 13, 41, 26, 5, -36 },
  { 568, 22, 22, 26, 2, -26 },
  { 629, 20, 20, 26, 3, -24 },
  { 679, 9, 14, 26, 7, -7 },
  { 695, 14, 3, 26, 6, -16 },
  { 701, 7, 7, 26, 9, -7 },
  { 708, 19, 41, 26, 3, -36 },
  { 806, 18, 32, 26, 4, -32 },
  { 878, 19, 31, 26, 4, -31 },
  { 952, 20, 32, 26, 3, -32 },
  { 1032, 19, 31, 26, 3, -31 },
  { 1106, 17, 31, 26, 4, -31 },
  { 1172, 18, 31, 26, 4, -31 },
  { 1242, 20, 31, 26, 3, -31 },
  { 1320, 20, 31, 26, 3, -31 },
  { 1398, 18, 32, 26, 4, -32 },
  { 1470, 20, 32, 26, 3, -32 },
  { 1550, 7, 24, 26, 9, -24 },
  { 1571, 8, 31, 26, 8, -24 },
  { 1602, 18, 22, 26, 4, -25 },
  { 1652, 18, 13, 26, 4, -21 },
  { 1682, 18, 22, 26, 4, -25 },
  { 1732, 15, 31, 26, 6, -31 },
  { 1791, 22, 40, 26, 2, -32 },
  { 1901, 21, 31, 26, 2, -31 },
  { 1983, 19, 31, 26, 4, -31 },
  { 2057, 18, 32, 26, 4, -32 },
  { 2129, 18, 31, 26, 4, -31 },
  { 2199, 17, 31, 26, 5, -31 },
  { 2265, 19, 31, 26, 4, -31 },
  { 2339, 18, 32, 26, 4, -32 },
  { 2411, 18, 31, 26, 4, -31 },
  { 2481, 16, 31, 26, 5, -31 },
  { 2543, 19, 31, 26, 2, -31 },
  { 2617, 20, 31, 26, 4, -31 },
  { 2695, 18, 31, 26, 5, -31 },
  { 2765, 19, 31, 26, 3, -31 },
  { 2839, 18, 31, 26, 4, -31 },
  { 2909, 18, 32, 26, 4, -32 },
  { 2981, 19, 31, 26, 4, -31 },
  { 3055, 18, 40, 26, 4, -32 },
  { 3145, 19, 31, 26, 4, -31 },
  { 3219, 20, 32, 26, 3, -32 },
  { 3299, 21, 31, 26, 2, -31 },
  { 3381, 18, 31, 26, 4, -31 },
  { 3451, 21, 31, 26, 2, -31 },
  { 3533, 24, 31, 26, 1, -31 },
  { 3626, 22, 31, 26, 2, -31 },
  { 3712, 22, 31, 26, 2, -31 },
  { 3798, 18, 31, 26, 4, -31 },
  { 3868, 10, 41, 26, 9, -36 },
  { 3920, 19, 41, 26, 3, -36 },
  { 4018, 11, 41, 26, 6, -36 },
  { 4075, 18, 16, 26, 4, -31 },
  { 4111, 20, 3, 26, 3, 1 },
  { 4119, 9, 6, 26, 8, -34 },
  { 4126, 19, 24, 26, 3, -24 },
  { 4183, 18, 31, 26, 4, -31 },
  { 4253, 18, 24, 26, 4, -24 },
  { 4307, 18, 31, 26, 4, -31 },
  { 4377, 18, 24, 26, 4, -24 },
  { 4431, 20, 31, 26, 3, -31 },
  { 4509, 18, 32, 26, 4, -24 },
  { 4581, 18, 31, 26, 4, -31 },
  { 4651, 20, 33, 26, 4, -33 },
  { 4734, 16, 41, 26, 4, -33 },
  { 4816, 20, 31, 26, 4, -31 },
  { 4894, 23, 31, 26, 1, -31 },
  { 4984, 20, 24, 26, 3, -24 },
  { 5044, 18, 24, 26, 4, -24 },
  { 5098, 18, 24, 26, 4, -24 },
  { 5152, 18, 32, 26, 4, -24 },
  { 5224, 18, 32, 26, 4, -24 },
  { 5296, 18, 24, 26, 5, -24 },
  { 5350, 18, 24, 26, 4, -24 },
  { 5404, 19, 30, 26, 3, -30 },
  { 5476, 18, 24, 26, 4, -24 },
  { 5530, 20, 24, 26, 3, -24 },
  { 5590, 22, 24, 26, 2, -24 },
  { 5656, 21, 24, 26, 2, -24 },
  { 5719, 20, 32, 26, 3, -24 },
  { 5799, 18, 24, 26, 4, -24 },
  { 5853, 18, 41, 26, 4, -36 },
  { 5946, 4, 41, 26, 11, -36 },
  { 5967, 18, 41, 26, 4, -36 },
  { 6060, 20, 8, 26, 3, -19 },
};

const GFXfont JetBrainsMono_Light43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_LIGHT43PT7B_H_
