#ifndef _JETBRAINSMONO_LIGHT57PT7B_H_
#define _JETBRAINSMONO_LIGHT57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light57pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xC0, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x03,
  0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x38, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xCE,
  0x7F, 0x07, 0xC3, 0x87, 0xC3, 0xE0, 0xE0, 0xF8, 0xF0, 0x38, 0x3E, 0x3C,
  0x0E, 0x07, 0x9F, 0x03, 0x81, 0xE7, 0xC0, 0xE0, 0x79, 0xF0, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0xFC, 0x38,
  0x00, 0x1F, 0x8E, 0x00, 0x07, 0xFB, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0E, 0x7F, 0x00, 0x03, 0x87, 0xE0, 0x00, 0xE0,
  0xF8, 0x00, 0x38, 0x3E, 0x00, 0x0E, 0x07, 0xC0, 0x03, 0x81, 0xF0, 0x00,
  0xE0, 0x7F, 0xE0, 0x38, 0x1F, 0xF8, 0x0E, 0x07, 0xFE, 0x03, 0x81, 0xF7,
  0xC0, 0xE0, 0x7D, 0xF0, 0x38, 0x3E, 0x7E, 0x0E, 0x1F, 0x8F, 0xE3, 0x8F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0x0F,
  0x3F, 0xFC, 0x00, 0x1E, 0x7F, 0xFE, 0x00, 0x3C, 0x78, 0x1E, 0x00, 0x38,
  0xF0, 0x1E, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0xE0,
  0xF0, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0x80,
  0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x0E, 0x1E, 0x00,
  0x78, 0x1E, 0x1E, 0x00, 0x7C, 0x7E, 0x3C, 0x00, 0x3F, 0xFC, 0x78, 0x00,
  0x1F, 0xF8, 0x78, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x03, 0xE0, 0x00, 0x0F, 0x0F, 0xF8, 0x00, 0x1E, 0x3F, 0xFC,
  0x00, 0x1C, 0x3F, 0xFE, 0x00, 0x3C, 0x7C, 0x1E, 0x00, 0x78, 0x78, 0x0F,
  0x00, 0xF0, 0x70, 0x0F, 0x00, 0xF0, 0x70, 0x0F, 0x01, 0xE0, 0x70, 0x0F,
  0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x70, 0x0F, 0x07, 0x80, 0x70, 0x0F,
  0x0F, 0x00, 0x70, 0x0F, 0x0E, 0x00, 0x78, 0x0F, 0x1E, 0x00, 0x78, 0x1F,
  0x3C, 0x00, 0x7E, 0x3E, 0x38, 0x00, 0x3F, 0xFE, 0x78, 0x00, 0x1F, 0xFC,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xBE, 0x00, 0x7D,
  0xF0, 0xF8, 0x03, 0xCF, 0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x03, 0xE7, 0xC0,
  0x7C, 0x1F, 0x3E, 0x01, 0xF1, 0xF1, 0xF0, 0x07, 0xCF, 0x0F, 0x80, 0x3E,
  0xF8, 0x7C, 0x00, 0xFF, 0x83, 0xE0, 0x03, 0xFC, 0x1F, 0x00, 0x1F, 0xC0,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0xC1, 0xF0,
  0x01, 0xFE, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0x01, 0xF3, 0xE0, 0xFF, 0xFF,
  0x8F, 0x87, 0xFF, 0xF8, 0x7C, 0x1F, 0xFF, 0x01, 0xF0, 0x3F, 0xF0, 0x07,
  0xC0, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7,
  0xBD, 0xEF, 0x78, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x06,
  0x80, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x40, 0x07, 0x80, 0x09,
  0xE0, 0x1E, 0x00, 0xE7, 0xE0, 0x78, 0x1F, 0x9F, 0xF0, 0xE3, 0xFF, 0xFF,
  0xE3, 0x1F, 0xFC, 0xFF, 0xED, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x3F, 0x3F,
  0xDF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x04, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x80, 0xFC, 0x7E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E,
  0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x3F, 0x00,
  0xFE, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x2C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xF3, 0xC0, 0x03,
  0xF8, 0xF0, 0x01, 0xF8, 0x3C, 0x00, 0xFC, 0x0F, 0x00, 0x3E, 0x03, 0xC0,
  0x0E, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0x80,
  0xFE, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF8, 0x03,
  0xF0, 0x7F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x78,
  0x7C, 0x00, 0xF1, 0xF0, 0x01, 0xE7, 0xE0, 0x03, 0xCF, 0x80, 0x07, 0xBE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x7F, 0xC0, 0x79, 0xFF, 0xF0, 0x7B, 0xFF, 0xF8,
  0x7B, 0xFF, 0xFC, 0x7F, 0x80, 0xFE, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0x00, 0x03, 0xEF,
  0xFC, 0x01, 0xF7, 0xFF, 0xC0, 0x7B, 0xFF, 0xF8, 0x3F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0x80, 0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xC3, 0xF8, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7F, 0x00, 0x7E, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0x78, 0x07, 0xFF, 0xBE, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x08, 0x00, 0x07, 0xC1, 0xFE, 0x1F, 0xE3, 0xFF, 0x3F, 0xF1, 0xFF,
  0x1F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0xFC,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0x81, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFF, 0x7F, 0x80, 0x7F,
  0xFB, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x01, 0xE0, 0x0F,
  0xF8, 0x0F, 0x00, 0x7F, 0xC0, 0x78, 0x01, 0xFE, 0x03, 0xC0, 0x0F, 0xF0,
  0x1E, 0x00, 0x7F, 0x80, 0xF0, 0x03, 0xFC, 0x07, 0x80, 0x1F, 0xE0, 0x3C,
  0x00, 0xFF, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0x00, 0x3F, 0xC0, 0x78, 0x01,
  0xFE, 0x03, 0xC0, 0x1F, 0xF0, 0x1E, 0x00, 0xFF, 0x80, 0xF8, 0x07, 0xFC,
  0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0xDE, 0xFF, 0x00, 0x7F, 0xF7, 0xF8, 0x01,
  0xFF, 0x3F, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x0F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF0,
  0x01, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0,
  0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xF0, 0x07, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7E, 0xF0,
  0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x3F, 0x80, 0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0xF7, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x01,
  0xFF, 0x1E, 0x00, 0x7F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0xEF, 0x00, 0x1F, 0x9E, 0x00, 0xFE,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFC, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x1F, 0xF7, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE,
  0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0,
  0x7F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xEF, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7C,
  0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x01,
  0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x3C,
  0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x0F,
  0x80, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0xF0,
  0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0x70, 0x03, 0xFF, 0xBC, 0x01, 0xDF, 0xDE, 0x01, 0xEF, 0xE7,
  0x00, 0xF7, 0xF3, 0xC0, 0x73, 0xF9, 0xE0, 0x79, 0xFC, 0x70, 0x3C, 0xFF,
  0x3C, 0x1C, 0x7F, 0x9E, 0x1E, 0x3F, 0xC7, 0x0F, 0x1F, 0xE3, 0xC7, 0x0F,
  0xF1, 0xE7, 0x8F, 0xF8, 0x73, 0xC7, 0xFC, 0x3D, 0xC3, 0xFE, 0x1E, 0xE1,
  0xFF, 0x07, 0xF0, 0xFF, 0x83, 0xF0, 0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0x7C,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xF7, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0xFB, 0xC0, 0x1F, 0xFB, 0xC0, 0x1F, 0xF9, 0xE0, 0x1F, 0xF9, 0xE0,
  0x1F, 0xF9, 0xE0, 0x1F, 0xF8, 0xF0, 0x1F, 0xF8, 0xF0, 0x1F, 0xF8, 0xF0,
  0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3C,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x1E, 0x1F, 0xF8, 0x1E, 0x1F, 0xF8, 0x1E,
  0x1F, 0xF8, 0x0F, 0x1F, 0xF8, 0x0F, 0x1F, 0xF8, 0x0F, 0x1F, 0xF8, 0x07,
  0x9F, 0xF8, 0x07, 0x9F, 0xF8, 0x07, 0xCF, 0xF8, 0x03, 0xCF, 0xF8, 0x03,
  0xCF, 0xF8, 0x01, 0xEF, 0xF8, 0x01, 0xEF, 0xF8, 0x01, 0xEF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0xFD, 0xE0,
  0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x0F,
  0xDE, 0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x07, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x06, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0x80, 0x07, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7E, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x9E, 0x00, 0x3F, 0x8F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xF0,
  0x1F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0F,
  0x00, 0x7C, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0,
  0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F,
  0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00,
  0x7E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F,
  0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3C, 0x00,
  0x07, 0x9F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xC1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xE0,
  0x0F, 0x80, 0x7B, 0xC0, 0x1F, 0x00, 0xF7, 0x80, 0x7E, 0x01, 0xEF, 0x00,
  0xFC, 0x03, 0xDE, 0x01, 0xF8, 0x07, 0xBE, 0x03, 0xB0, 0x0F, 0x7C, 0x07,
  0x70, 0x1E, 0x78, 0x0E, 0xE0, 0x3C, 0xF0, 0x1D, 0xC0, 0xF1, 0xE0, 0x73,
  0x81, 0xE3, 0xC0, 0xE7, 0x03, 0xC7, 0x81, 0xCE, 0x07, 0x8F, 0x03, 0x9C,
  0x0F, 0x1E, 0x07, 0x38, 0x1E, 0x3E, 0x0E, 0x30, 0x3C, 0x3C, 0x1C, 0x70,
  0x78, 0x78, 0x38, 0xE0, 0xF0, 0xF0, 0xE1, 0xC3, 0xC1, 0xE1, 0xC3, 0x87,
  0x83, 0xC3, 0x87, 0x0F, 0x07, 0x87, 0x0E, 0x1E, 0x0F, 0x0E, 0x1C, 0x3C,
  0x1E, 0x1C, 0x18, 0x78, 0x3E, 0x38, 0x38, 0xF0, 0x3C, 0x60, 0x71, 0xE0,
  0x79, 0xC0, 0xE3, 0x80, 0xF3, 0x81, 0xCF, 0x01, 0xE7, 0x03, 0x9E, 0x03,
  0xCE, 0x07, 0x3C, 0x07, 0x9C, 0x0E, 0x78, 0x0F, 0x38, 0x0C, 0xF0, 0x1E,
  0x70, 0x1D, 0xE0, 0x1F, 0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x77, 0x00, 0x7F,
  0x00, 0xEE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0,
  0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x9F, 0xE0, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x0F, 0xF7,
  0xF8, 0x1F, 0xF9, 0xFF, 0xFF, 0x7C, 0x7F, 0xFF, 0x3E, 0x0F, 0xFE, 0x1F,
  0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xFC, 0x07,
  0x8F, 0xFE, 0x0F, 0x3F, 0xFF, 0x1E, 0xFF, 0xFE, 0x3D, 0xC0, 0xFE, 0x7F,
  0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xEF,
  0xC0, 0x07, 0xDF, 0xC0, 0x1F, 0xBD, 0xF1, 0xFE, 0x7B, 0xFF, 0xF8, 0xF3,
  0xFF, 0xE1, 0xE1, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F,
  0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x1F, 0x07, 0xFF, 0x1F, 0x0F,
  0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x81, 0xFF, 0x7E, 0x00, 0x7F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0xC3, 0xDF, 0x1F, 0xFF, 0xDF, 0x0F,
  0xFF, 0x9F, 0x03, 0xFE, 0x1F, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E,
  0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0xC3, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0x0F, 0xFF,
  0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0x81, 0xFF, 0x3E, 0x00, 0x7F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x81, 0xFF, 0x1F, 0xFF,
  0xDF, 0x0F, 0xFF, 0x9F, 0x07, 0xFF, 0x1F, 0x01, 0xFC, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC1, 0xFC, 0x07, 0x8F, 0xFE, 0x0F, 0x3F, 0xFE, 0x1E,
  0xFF, 0xFE, 0x3D, 0xC0, 0xFE, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xF7, 0x80, 0x01, 0xF3, 0xC0, 0x01, 0xF1, 0xE0, 0x01, 0xF8, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xFC, 0x1E, 0x00, 0x7C, 0x0F, 0x00,
  0x7C, 0x07, 0x80, 0x7E, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F,
  0x01, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3F, 0x01, 0xE0, 0x0F, 0x80,
  0xF0, 0x03, 0xE0, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00,
  0x7E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xC0, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0x3C, 0x3C, 0xFE, 0x3F, 0xCF,
  0x7F, 0xCF, 0xFB, 0xFF, 0xF7, 0xFE, 0xF8, 0x3F, 0x07, 0xFE, 0x07, 0xC0,
  0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07,
  0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC,
  0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03,
  0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0,
  0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0x00, 0x7F, 0x01, 0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0x87, 0xBF, 0xFF,
  0x8F, 0x70, 0x3F, 0x9F, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0x01, 0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0xC7, 0xBF, 0xFF, 0xCF,
  0x70, 0x3F, 0x9F, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xF0, 0x07, 0xEF, 0x7C, 0x7F, 0x9E,
  0xFF, 0xFE, 0x3C, 0xFF, 0xF8, 0x78, 0x7F, 0xC0, 0xF0, 0x08, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF,
  0xDF, 0x3F, 0x81, 0xFF, 0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x00,
  0xFF, 0x3F, 0xC3, 0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x03, 0xFE,
  0x1F, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xE3, 0xFF,
  0x83, 0xCF, 0xFF, 0xC7, 0xBF, 0xFF, 0xCF, 0x70, 0x1F, 0x9F, 0xC0, 0x1F,
  0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x1F, 0xE7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x3D, 0xE0, 0x1F, 0x00,
  0xF7, 0x80, 0xFC, 0x03, 0xDE, 0x03, 0xF0, 0x0E, 0x78, 0x0F, 0xC0, 0x79,
  0xE0, 0x3F, 0x01, 0xE7, 0x80, 0xEC, 0x07, 0x9E, 0x03, 0x38, 0x1E, 0x3C,
  0x1C, 0xE0, 0x78, 0xF0, 0x73, 0x81, 0xC3, 0xC1, 0xCE, 0x0F, 0x0F, 0x07,
  0x38, 0x3C, 0x3C, 0x1C, 0x60, 0xF0, 0xF0, 0x61, 0xC3, 0xC1, 0xC3, 0x87,
  0x0E, 0x07, 0x8E, 0x1C, 0x38, 0x1E, 0x38, 0x70, 0xE0, 0x78, 0xE1, 0xC7,
  0x81, 0xE3, 0x83, 0x1E, 0x07, 0x8C, 0x0E, 0x78, 0x0E, 0x70, 0x39, 0xC0,
  0x3D, 0xC0, 0xE7, 0x00, 0xF7, 0x03, 0x9C, 0x03, 0xDC, 0x0E, 0xF0, 0x0F,
  0x70, 0x1B, 0xC0, 0x3D, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F,
  0x81, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01,
  0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xC7, 0xF8, 0x00, 0xF3, 0xFF, 0x80, 0x3D, 0xFF, 0xF0, 0x0F, 0xF8, 0x7E,
  0x03, 0xFE, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x3F, 0xC0, 0x3F, 0x1F, 0xF0,
  0x07, 0xFF, 0xBC, 0x00, 0xFF, 0xCF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xE0,
};

const GFXglyph JetBrainsMono_Light57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 8, 42, 34, 13, -42 },
  { 43, 16, 17, 34, 9, -42 },
  { 77, 30, 42, 34, 2, -42 },
  { 235, 26, 58, 34, 4, -50 },
  { 424, 32, 42, 34, 1, -42 },
  { 592, 29, 43, 34, 3, -42 },
  { 748, 5, 17, 34, 14, -42 },
  { 759, 17, 55, 34, 11, -48 },
  { 876, 16, 55, 34, 7, -48 },
  { 986, 30, 30, 34, 2, -35 },
  { 1099, 26, 27, 34, 4, -32 },
  { 1187, 11, 18, 34, 10, -9 },
  { 1212, 18, 4, 34, 8, -21 },
  { 1221, 9, 10, 34, 13, -9 },
  { 1233, 25, 53, 34, 5, -47 },
  { 1399, 24, 43, 34, 5, -42 },
  { 1528, 26, 42, 34, 5, -42 },
  { 1665, 26, 42, 34, 4, -42 },
  { 1802, 25, 43, 34, 4, -42 },
  { 1937, 23, 42, 34, 5, -42 },
  { 2058, 24, 43, 34, 5, -42 },
  { 2187, 26, 43, 34, 4, -42 },
  { 2327, 25, 42, 34, 5, -42 },
  { 2459, 24, 43, 34, 5, -42 },
  { 2588, 26, 42, 34, 4, -42 },
  { 2725, 9, 33, 34, 13, -32 },
  { 2763, 12, 41, 34, 10, -32 },
  { 2825, 24, 30, 34, 5, -34 },
  { 2915, 24, 18, 34, 5, -28 },
  { 2969, 24, 30, 34, 5, -34 },
  { 3059, 20, 42, 34, 8, -42 },
  { 3164, 29, 52, 34, 3, -42 },
  { 3353, 28, 42, 34, 3, -42 },
  { 3500, 24, 42, 34, 6, -42 },
  { 3626, 24, 43, 34, 5, -42 },
  { 3755, 23, 42, 34, 6, -42 },
  { 3876, 23, 42, 34, 6, -42 },
  { 3997, 24, 42, 34, 6, -42 },
  { 4123, 24, 43, 34, 5, -42 },
  { 4252, 23, 42, 34, 6, -42 },
  { 4373, 22, 42, 34, 6, -42 },
  { 4489, 25, 43, 34, 3, -42 },
  { 4624, 26, 42, 34, 6, -42 },
  { 4761, 23, 42, 34, 7, -42 },
  { 4882, 25, 42, 34, 5, -42 },
  { 5014, 24, 42, 34, 5, -42 },
  { 5140, 24, 43, 34, 5, -42 },
  { 5269, 25, 42, 34, 6, -42 },
  { 5401, 25, 52, 34, 5, -42 },
  { 5564, 25, 42, 34, 6, -42 },
  { 5696, 26, 43, 34, 4, -42 },
  { 5836, 28, 42, 34, 3, -42 },
  { 5983, 24, 43, 34, 5, -42 },
  { 6112, 28, 42, 34, 3, -42 },
  { 6259, 31, 42, 34, 2, -42 },
  { 6422, 30, 42, 34, 2, -42 },
  { 6580, 30, 42, 34, 2, -42 },
  { 6738, 24, 42, 34, 5, -42 },
  { 6864, 14, 53, 34, 12, -47 },
  { 6957, 25, 53, 34, 5, -47 },
  { 7123, 13, 53, 34, 9, -47 },
  { 7210, 24, 23, 34, 5, -42 },
  { 7279, 28, 4, 34, 3, 1 },
  { 7293, 11, 8, 34, 11, -45 },
  { 7304, 25, 33, 34, 4, -32 },
  { 7408, 23, 43, 34, 6, -42 },
  { 7532, 24, 33, 34, 5, -32 },
  { 7631, 24, 43, 34, 5, -42 },
  { 7760, 24, 33, 34, 5, -32 },
  { 7859, 26, 42, 34, 4, -42 },
  { 7996, 24, 42, 34, 5, -32 },
  { 8122, 23, 42, 34, 6, -42 },
  { 8243, 26, 44, 34, 5, -44 },
  { 8386, 21, 54, 34, 5, -44 },
  { 8528, 25, 42, 34, 6, -42 },
  { 8660, 29, 42, 34, 2, -42 },
  { 8813, 26, 32, 34, 4, -32 },
  { 8917, 23, 32, 34, 6, -32 },
  { 9009, 24, 33, 34, 5, -32 },
  { 9108, 23, 42, 34, 6, -32 },
  { 9229, 24, 42, 34, 5, -32 },
  { 9355, 23, 32, 34, 7, -32 },
  { 9447, 24, 33, 34, 5, -32 },
  { 9546, 26, 40, 34, 3, -40 },
  { 9676, 24, 32, 34, 5, -31 },
  { 9772, 28, 31, 34, 3, -31 },
  { 9881, 30, 31, 34, 2, -31 },
  { 9998, 28, 31, 34, 3, -31 },
  { 10107, 28, 41, 34, 3, -31 },
  { 10251, 24, 31, 34, 5, -31 },
  { 10344, 24, 53, 34, 5, -47 },
  { 10503, 4, 53, 34, 15, -47 },
  { 10530, 24, 53, 34, 5, -47 },
  { 10689, 26, 12, 34, 4, -26 },
};

const GFXfont JetBrainsMono_Light57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_LIGHT57PT7B_H_
