#ifndef _JETBRAINSMONO_LIGHT44PT7B_H_
#define _JETBRAINSMONO_LIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light44pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xC3, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xDF, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xDE, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0x60, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x18, 0x06, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x06, 0x01, 0xC0,
  0x1C, 0x03, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x0F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x38, 0x03, 0x80, 0x60, 0x07, 0x01,
  0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xE7, 0x3E, 0x3C, 0x71, 0xE7, 0x87,
  0x0E, 0x78, 0x70, 0xF7, 0x87, 0x0F, 0x78, 0x70, 0x07, 0x87, 0x00, 0x38,
  0x70, 0x03, 0xC7, 0x00, 0x3E, 0x70, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x77, 0xE0, 0x07, 0x1E,
  0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x07, 0xF0, 0x70,
  0x7F, 0x07, 0x0F, 0x78, 0x70, 0xF7, 0x87, 0x1E, 0x3E, 0x73, 0xE3, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x07,
  0xBF, 0xE0, 0x03, 0x9E, 0x78, 0x03, 0x9C, 0x1E, 0x03, 0x8E, 0x07, 0x01,
  0xC7, 0x03, 0x81, 0xC3, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xC0, 0xE0, 0x70,
  0xE0, 0x70, 0x38, 0xE0, 0x38, 0x3C, 0xE0, 0x0F, 0x3C, 0x70, 0x07, 0xFE,
  0x70, 0x01, 0xFC, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x10, 0x00, 0x1C, 0x7F, 0x00, 0x1C, 0x7F, 0xC0,
  0x0E, 0x78, 0xF0, 0x0E, 0x38, 0x38, 0x0E, 0x1C, 0x1C, 0x06, 0x0C, 0x06,
  0x07, 0x06, 0x03, 0x07, 0x03, 0x01, 0x87, 0x01, 0x80, 0xC3, 0x80, 0xE0,
  0xE3, 0x80, 0x70, 0x73, 0x80, 0x3F, 0xF9, 0xC0, 0x0F, 0xF9, 0xC0, 0x03,
  0xF8, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x3C, 0x0F, 0x80, 0xE0, 0x1E, 0x03, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03,
  0xE7, 0x80, 0xFF, 0x1E, 0x07, 0xB8, 0x3C, 0x1C, 0xE0, 0x78, 0xF3, 0x80,
  0xE3, 0x8E, 0x03, 0xDE, 0x38, 0x07, 0xF0, 0xE0, 0x0F, 0x83, 0x80, 0x3E,
  0x0E, 0x00, 0x78, 0x38, 0x03, 0xF0, 0xF0, 0x1F, 0xE3, 0xE0, 0xF7, 0x87,
  0xFF, 0xCF, 0x0F, 0xFC, 0x1E, 0x1F, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0x00, 0x08, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0xC0,
  0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C,
  0x0F, 0xC1, 0xFC, 0x1F, 0x80, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x20, 0x0E, 0x01, 0x78, 0x1C, 0x0E, 0xFC, 0x38, 0xFD, 0xFE,
  0x67, 0xFC, 0xFF, 0xDF, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x18,
  0x01, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x1F, 0x3E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x31, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xC0, 0x79, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x30, 0x7F, 0x0F, 0x0F, 0xE1, 0xF1, 0xFC, 0x3E, 0x3F, 0x87,
  0x87, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xE7, 0x80,
  0x3C, 0xF8, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xF7, 0x00, 0x7E, 0x70, 0x0F,
  0x87, 0x00, 0xF0, 0x70, 0x0E, 0x07, 0x00, 0x80, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0xBC, 0x01,
  0xE3, 0xC0, 0x7C, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0xF0, 0x0F, 0x78, 0x03,
  0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC7,
  0xF0, 0x77, 0xFF, 0x1D, 0xFF, 0xE7, 0xE0, 0xF9, 0xE0, 0x1F, 0x78, 0x03,
  0xDC, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3D, 0xC0,
  0x0F, 0x7C, 0x07, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x7C, 0x01, 0xDF, 0xF0, 0x3F, 0xFF, 0x83,
  0xF0, 0xFC, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xF7, 0x00, 0x0F, 0x78, 0x00, 0xE7, 0xC0, 0x1E, 0x3E, 0x07, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x77, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xC0, 0x78, 0xF0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x39, 0xC0, 0x0F,
  0x3C, 0x01, 0xC7, 0x80, 0x78, 0x7C, 0x1E, 0x07, 0xCF, 0x80, 0x3F, 0xE0,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7C, 0x7C, 0x1E, 0x07, 0xC7, 0x80, 0x79,
  0xE0, 0x07, 0xBC, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xEF, 0x00, 0x3C, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3E, 0x03, 0xC7, 0xC0, 0x1E, 0x78, 0x00, 0xE7, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1E, 0x3C, 0x03, 0xE3,
  0xF8, 0xFE, 0x1F, 0xFD, 0xC0, 0xFF, 0xBC, 0x01, 0xE7, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x31, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xDF, 0xFF,
  0xFE, 0x7C, 0x0C, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xF8, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3,
  0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83,
  0x81, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03,
  0xF0, 0xFC, 0x1E, 0x00, 0xF8, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0xDE, 0x00,
  0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0xDF, 0x80, 0xFF, 0xBE, 0x07, 0xC6, 0xF8, 0x1C, 0x07, 0xE0,
  0x70, 0x1F, 0x81, 0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70,
  0x1F, 0x81, 0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F,
  0x81, 0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1E, 0x0F, 0xE0, 0x3F, 0xEF, 0x80,
  0x7F, 0x3F, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xEE, 0x00, 0x07, 0xB8,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x0F, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x0E, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x8E, 0x00,
  0x1E, 0x78, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x07, 0xCF, 0x00, 0x7D,
  0xE0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B,
  0xC0, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x3E, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1E, 0x01, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xEF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xEF, 0x00, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x80,
  0x3C, 0xF8, 0x0F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xC0, 0x7C, 0xF0, 0x07, 0xBC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1E, 0xF0, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC7, 0xC0, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x80, 0x3C,
  0xF8, 0x0F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78,
  0x01, 0xE7, 0x80, 0x1E, 0x3E, 0x07, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0x07, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xEC, 0x03, 0xFD, 0xC0, 0x7F, 0xB8, 0x1D,
  0xF3, 0x03, 0xBE, 0x70, 0x77, 0xEE, 0x1C, 0xFC, 0xC3, 0x9F, 0x9C, 0x73,
  0xF3, 0x9C, 0x7E, 0x33, 0x8F, 0xC7, 0x71, 0xF8, 0xEC, 0x3F, 0x0F, 0x8F,
  0xE1, 0xF1, 0xFC, 0x3C, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFB, 0x80, 0x7E, 0xE0, 0x1F, 0x9C, 0x07, 0xE7, 0x01, 0xFD, 0xC0,
  0x7F, 0x38, 0x1F, 0xCE, 0x07, 0xF3, 0xC1, 0xFC, 0x70, 0x7F, 0x1C, 0x1F,
  0xC7, 0x87, 0xF0, 0xE1, 0xFC, 0x38, 0x7F, 0x07, 0x1F, 0xC1, 0xC7, 0xF0,
  0x71, 0xFC, 0x0E, 0x7F, 0x03, 0x9F, 0xC0, 0xF7, 0xF0, 0x1D, 0xFC, 0x07,
  0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0x00, 0x60, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C,
  0x07, 0x9E, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x03, 0xDF, 0x03, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0x00, 0x7C, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0xC7, 0xC0,
  0x78, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x1F,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x00,
  0xFC, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x3C, 0xF0, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0x00,
  0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x03, 0xE3,
  0xC0, 0x1E, 0x78, 0x00, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xE3,
  0xE0, 0x3E, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xF7, 0x00, 0x3D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xF0, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0x9E, 0x00,
  0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C,
  0x1C, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xE0, 0x0E, 0x07, 0x80, 0x78, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0xF0, 0x07, 0x03,
  0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80,
  0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x07,
  0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x3C, 0x07, 0xF0, 0x3C, 0x07,
  0x70, 0x3E, 0x07, 0x70, 0x3E, 0x07, 0x70, 0x36, 0x0F, 0x70, 0x36, 0x0E,
  0x70, 0x36, 0x0E, 0x70, 0x76, 0x0E, 0x78, 0x76, 0x0E, 0x78, 0x66, 0x0E,
  0x38, 0x66, 0x0E, 0x38, 0x67, 0x0E, 0x38, 0x67, 0x0E, 0x38, 0x63, 0x1E,
  0x38, 0x63, 0x1C, 0x38, 0xE3, 0x1C, 0x38, 0xE3, 0x1C, 0x38, 0xC3, 0x1C,
  0x3C, 0xC3, 0x1C, 0x1C, 0xC3, 0x9C, 0x1C, 0xC3, 0x9C, 0x1C, 0xC1, 0x9C,
  0x1D, 0xC1, 0xB8, 0x1D, 0xC1, 0xB8, 0x1D, 0x81, 0xB8, 0x1D, 0x81, 0xB8,
  0x1D, 0x81, 0xB8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x78, 0x03, 0x81,
  0xE0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xE3, 0xC0,
  0x03, 0xC3, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x38, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0x38, 0x78, 0x00, 0x78, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xF7, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x70, 0x01,
  0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x1E,
  0x03, 0x83, 0x80, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0xF7, 0x80, 0x0E, 0xE0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0xEF, 0xE3, 0xC0, 0x3C, 0x70, 0x03, 0xDE, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x83, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7F, 0xFF, 0xDE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x0F, 0xDF, 0xCF,
  0xB9, 0xFF, 0xE7, 0x0F, 0xF8, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xC0,
  0xF3, 0xFE, 0x3D, 0xFF, 0xCF, 0xFB, 0xFB, 0xF0, 0x1E, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xBF,
  0xFF, 0xEF, 0x7F, 0xF3, 0xCF, 0xF0, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0xBC, 0x00, 0x77, 0x80,
  0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x3F, 0xC0, 0x07, 0x78, 0x00, 0xE7, 0x80, 0x3C, 0xF8, 0x0F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x0E, 0x07,
  0x0F, 0xF1, 0xCF, 0xFE, 0x73, 0xF3, 0xDD, 0xF0, 0x17, 0x78, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x1F, 0x7C, 0x0D, 0xCF,
  0xFF, 0x71, 0xFF, 0x9C, 0x3F, 0xC7, 0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0xF0, 0xFC, 0xFE, 0x78, 0x07, 0x9C, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0x78, 0x03, 0xDF, 0x01, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x03, 0xFC, 0x71, 0xFF, 0x9C, 0xFC, 0xF7, 0x7C, 0x07, 0xDE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xF7, 0x80, 0x7D, 0xF0, 0x37, 0x3F, 0xFD, 0xC7, 0xFE,
  0x70, 0xFF, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0xF3, 0xFE, 0x3D, 0xFF,
  0xCF, 0xF3, 0xFB, 0xF0, 0x1E, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0x07, 0x80, 0xF0, 0x3C,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00,
  0x78, 0xF0, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x01, 0x01, 0x0E, 0xFC, 0x7E, 0xEF, 0xEF, 0xEF, 0x9E,
  0x8F, 0xF0, 0xF0, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0,
  0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E,
  0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07,
  0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70,
  0x7E, 0x07, 0x07, 0xE0, 0x70, 0x70, 0x00, 0x70, 0x3C, 0xFF, 0x8F, 0x7F,
  0xF3, 0xFE, 0xFE, 0xFC, 0x07, 0xBE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7C, 0x07, 0x9E, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0x78, 0x03, 0xDF, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0x70, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xFE, 0xFE, 0xFC, 0x07, 0xBE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x01, 0xEF, 0xFF, 0xFB, 0xDF, 0xFC, 0xF3, 0xFC, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFC, 0x73, 0xFF, 0x9C, 0xFC, 0xF7,
  0x7C, 0x07, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0x78, 0x07, 0xDF, 0x03, 0x73, 0xFF, 0xDC, 0x7F, 0xE7, 0x0F, 0xF1, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x38, 0xFF, 0x0E, 0x7F,
  0xF3, 0xBC, 0xFE, 0xEC, 0x07, 0xBE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1C, 0xF0, 0x07, 0x9F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xF0, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0,
  0x01, 0xC7, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x80, 0x38,
  0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x0F, 0x00, 0xE0,
  0x70, 0x07, 0x83, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x8E, 0x00,
  0x1C, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xE0, 0x78, 0x0F, 0xC0, 0xF0, 0x3B,
  0x81, 0xE0, 0x77, 0x03, 0xE0, 0xEF, 0x07, 0xC1, 0xCE, 0x0D, 0x83, 0x9C,
  0x3B, 0x07, 0x38, 0x66, 0x0C, 0x70, 0xCC, 0x38, 0xE1, 0x9C, 0x71, 0xC3,
  0x38, 0xE1, 0xC6, 0x31, 0xC3, 0x9C, 0x63, 0x87, 0x30, 0xC6, 0x0E, 0x61,
  0x9C, 0x1C, 0xC3, 0xB8, 0x39, 0x87, 0x70, 0x33, 0x06, 0xE0, 0x7E, 0x0D,
  0xC0, 0xF8, 0x1B, 0x01, 0xF0, 0x36, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x07, 0x80, 0xF0, 0xF8, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C,
  0x07, 0x81, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xC0,
  0x03, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00,
  0x78, 0x38, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x00,
  0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x03, 0x80, 0x78, 0x1E, 0x03, 0x80, 0x70, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x0E, 0x00, 0x70, 0xF0, 0x03, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x73, 0xC0,
  0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x73, 0xF8, 0x07,
  0x7F, 0xE0, 0x7F, 0x1E, 0x07, 0xF0, 0xF0, 0x7E, 0x07, 0x8F, 0xE0, 0x3F,
  0xFE, 0x01, 0xFE, 0xE0, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_Light44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 32, 26, 10, -32 },
  { 25, 13, 13, 26, 7, -32 },
  { 47, 23, 32, 26, 2, -32 },
  { 139, 20, 44, 26, 3, -38 },
  { 249, 25, 32, 26, 1, -32 },
  { 349, 22, 33, 26, 3, -33 },
  { 440, 4, 13, 26, 11, -32 },
  { 447, 13, 42, 26, 8, -37 },
  { 516, 13, 42, 26, 5, -37 },
  { 585, 23, 23, 26, 2, -27 },
  { 652, 20, 21, 26, 3, -25 },
  { 705, 8, 14, 26, 8, -7 },
  { 719, 14, 3, 26, 6, -16 },
  { 725, 7, 7, 26, 10, -7 },
  { 732, 19, 42, 26, 4, -37 },
  { 832, 19, 33, 26, 4, -33 },
  { 911, 20, 32, 26, 4, -32 },
  { 991, 20, 33, 26, 3, -33 },
  { 1074, 19, 32, 26, 3, -32 },
  { 1150, 18, 32, 26, 4, -32 },
  { 1222, 18, 32, 26, 4, -32 },
  { 1294, 20, 32, 26, 3, -32 },
  { 1374, 19, 32, 26, 4, -32 },
  { 1450, 19, 33, 26, 4, -33 },
  { 1529, 20, 33, 26, 3, -33 },
  { 1612, 7, 25, 26, 10, -25 },
  { 1634, 9, 32, 26, 8, -25 },
  { 1670, 19, 23, 26, 4, -26 },
  { 1725, 19, 13, 26, 4, -21 },
  { 1756, 19, 23, 26, 4, -26 },
  { 1811, 16, 32, 26, 6, -32 },
  { 1875, 22, 41, 26, 2, -33 },
  { 1988, 22, 32, 26, 2, -32 },
  { 2076, 19, 32, 26, 4, -32 },
  { 2152, 19, 33, 26, 4, -33 },
  { 2231, 18, 32, 26, 4, -32 },
  { 2303, 18, 32, 26, 5, -32 },
  { 2375, 19, 32, 26, 4, -32 },
  { 2451, 19, 33, 26, 4, -33 },
  { 2530, 18, 32, 26, 4, -32 },
  { 2602, 17, 32, 26, 5, -32 },
  { 2670, 20, 32, 26, 2, -32 },
  { 2750, 20, 32, 26, 4, -32 },
  { 2830, 18, 32, 26, 5, -32 },
  { 2902, 19, 32, 26, 4, -32 },
  { 2978, 18, 32, 26, 4, -32 },
  { 3050, 18, 33, 26, 4, -33 },
  { 3125, 20, 32, 26, 4, -32 },
  { 3205, 19, 41, 26, 4, -33 },
  { 3303, 20, 32, 26, 4, -32 },
  { 3383, 20, 33, 26, 3, -33 },
  { 3466, 22, 32, 26, 2, -32 },
  { 3554, 18, 32, 26, 4, -32 },
  { 3626, 22, 32, 26, 2, -32 },
  { 3714, 24, 32, 26, 1, -32 },
  { 3810, 23, 32, 26, 2, -32 },
  { 3902, 23, 32, 26, 2, -32 },
  { 3994, 19, 32, 26, 4, -32 },
  { 4070, 11, 42, 26, 9, -37 },
  { 4128, 19, 42, 26, 4, -37 },
  { 4228, 10, 42, 26, 7, -37 },
  { 4281, 19, 17, 26, 4, -32 },
  { 4322, 21, 3, 26, 3, 1 },
  { 4330, 9, 7, 26, 8, -35 },
  { 4338, 19, 25, 26, 3, -25 },
  { 4398, 18, 32, 26, 4, -32 },
  { 4470, 19, 25, 26, 4, -25 },
  { 4530, 18, 32, 26, 4, -32 },
  { 4602, 18, 25, 26, 4, -25 },
  { 4659, 20, 32, 26, 3, -32 },
  { 4739, 18, 33, 26, 4, -25 },
  { 4814, 18, 32, 26, 4, -32 },
  { 4886, 20, 34, 26, 4, -34 },
  { 4971, 16, 42, 26, 4, -34 },
  { 5055, 20, 32, 26, 4, -32 },
  { 5135, 22, 32, 26, 2, -32 },
  { 5223, 20, 25, 26, 3, -25 },
  { 5286, 18, 25, 26, 4, -25 },
  { 5343, 18, 25, 26, 4, -25 },
  { 5400, 18, 33, 26, 4, -25 },
  { 5475, 18, 33, 26, 4, -25 },
  { 5550, 18, 25, 26, 5, -25 },
  { 5607, 19, 25, 26, 4, -25 },
  { 5667, 20, 31, 26, 3, -31 },
  { 5745, 18, 24, 26, 4, -24 },
  { 5799, 21, 24, 26, 3, -24 },
  { 5862, 23, 24, 26, 2, -24 },
  { 5931, 21, 24, 26, 3, -24 },
  { 5994, 21, 32, 26, 3, -24 },
  { 6078, 18, 24, 26, 4, -24 },
  { 6132, 18, 42, 26, 4, -37 },
  { 6227, 4, 42, 26, 11, -37 },
  { 6248, 18, 42, 26, 4, -37 },
  { 6343, 20, 9, 26, 3, -20 },
};

const GFXfont JetBrainsMono_Light44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_LIGHT44PT7B_H_
