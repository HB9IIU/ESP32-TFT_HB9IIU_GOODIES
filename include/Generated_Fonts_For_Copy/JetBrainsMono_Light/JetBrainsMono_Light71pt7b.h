#ifndef _JETBRAINSMONO_LIGHT71PT7B_H_
#define _JETBRAINSMONO_LIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light71pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF7, 0xFC, 0xFE, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8,
  0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF1, 0xE3,
  0xF8, 0x1F, 0xC1, 0xE1, 0xFC, 0x1F, 0x81, 0xE0, 0xFC, 0x3F, 0x01, 0xE0,
  0x7E, 0x3F, 0x01, 0xE0, 0x7E, 0x3F, 0x01, 0xE0, 0x3E, 0x3E, 0x01, 0xE0,
  0x3E, 0x3E, 0x01, 0xE0, 0x3F, 0x3E, 0x01, 0xE0, 0x00, 0x3F, 0x01, 0xE0,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x3F, 0x81, 0xE0,
  0x00, 0x1F, 0x81, 0xE0, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0x0F, 0xF1, 0xE0,
  0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xEF,
  0xF8, 0x00, 0x01, 0xE3, 0xFC, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x01, 0xE0,
  0xFE, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x01, 0xE0,
  0x3F, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xE0,
  0x1F, 0xFC, 0x01, 0xE0, 0x1F, 0xFC, 0x01, 0xE0, 0x3F, 0x7C, 0x01, 0xE0,
  0x3F, 0x7E, 0x01, 0xE0, 0x3F, 0x7E, 0x01, 0xE0, 0x7F, 0x3F, 0x01, 0xE0,
  0x7E, 0x3F, 0x81, 0xE0, 0xFE, 0x1F, 0xE1, 0xE3, 0xFC, 0x1F, 0xFD, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x00, 0x3E,
  0x3F, 0xFF, 0xC0, 0x00, 0x7C, 0x7F, 0x0F, 0xE0, 0x00, 0x7C, 0x7C, 0x03,
  0xE0, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x01,
  0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x03,
  0xE0, 0xF8, 0x00, 0x7E, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0xFF, 0xC3, 0xE0,
  0x00, 0x1F, 0xFF, 0xC3, 0xE0, 0x00, 0x0F, 0xFF, 0x87, 0xC0, 0x00, 0x07,
  0xFE, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0xFF, 0xF8, 0x00, 0x03, 0xE1, 0xFF,
  0xFC, 0x00, 0x03, 0xC3, 0xFF, 0xFE, 0x00, 0x07, 0xC3, 0xF0, 0x7E, 0x00,
  0x0F, 0x87, 0xE0, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x07, 0xE0, 0x3F, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x1E, 0x00, 0x03,
  0xFF, 0xFE, 0x3E, 0x00, 0x01, 0xFF, 0xFC, 0x7C, 0x00, 0x00, 0xFF, 0xF8,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7F,
  0x0F, 0xC0, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x7C, 0xFC, 0x07, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC3, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x0F, 0xC0, 0x07, 0xE7, 0xE0, 0xFC,
  0x00, 0x3F, 0x7E, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xF8,
  0x0F, 0xC0, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0xFE,
  0x07, 0xF0, 0x07, 0xF3, 0xF0, 0x3F, 0xE3, 0xFE, 0x1F, 0x83, 0xFF, 0xFF,
  0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0x7E, 0x03,
  0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7C,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x18, 0xF8, 0x01, 0xF0, 0x03, 0xE7,
  0xF8, 0x0F, 0x80, 0xFF, 0x7F, 0xF0, 0x78, 0x3F, 0xFB, 0xFF, 0xE3, 0xC3,
  0xFF, 0xFF, 0xFF, 0x8E, 0x7F, 0xFE, 0x1F, 0xFF, 0x77, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x0F, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xDF, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xE0, 0x3F,
  0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0xC0, 0xFF, 0xF0, 0x7F, 0x81, 0xFF,
  0xE0, 0xFF, 0x03, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0x01, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x7C, 0x00, 0x07, 0xFC, 0xF8, 0x00,
  0x1F, 0xE1, 0xF0, 0x00, 0x7F, 0x83, 0xE0, 0x01, 0xFE, 0x07, 0xC0, 0x03,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x18,
  0x00, 0x7C, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xBA, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0xF8,
  0x7E, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x3E, 0x7F, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0xBF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x7F,
  0xC0, 0x1F, 0x8F, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0x81, 0xFB, 0xFF, 0xFF,
  0x87, 0xEF, 0xFF, 0xFE, 0x1F, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xF9,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x07, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xEF, 0xFF,
  0x80, 0x0F, 0xDF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xEF,
  0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFD, 0xF8, 0x01, 0xFF, 0xF3, 0xF0, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E,
  0x0F, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xF3, 0xFC, 0x0E, 0x00, 0x01, 0xE0, 0x0F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xF3, 0xFE, 0x00,
  0x7F, 0xFF, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0xF8, 0x03, 0xF0, 0x07, 0xFF,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xFC, 0x03, 0xE0, 0x01,
  0xFF, 0x80, 0x7C, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x07, 0xFE, 0x01, 0xF0,
  0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xFF, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x0F, 0xFC, 0x03, 0xE0, 0x01, 0xFF,
  0x80, 0x7C, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x07, 0xFE, 0x01, 0xF0, 0x00,
  0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xC1, 0xDF, 0xF0, 0x03, 0xFF, 0xFB, 0xFE, 0x00, 0x3F, 0xFE, 0x7F,
  0xC0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x01, 0xFF, 0x8F, 0x80, 0x00,
  0xFE, 0x3E, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7F, 0x8F, 0x80, 0x0F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0xE3,
  0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFB,
  0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xF0,
  0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x5E, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x7F, 0xE3, 0xF0,
  0x00, 0xFF, 0x1F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE3,
  0xF0, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7F,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x5E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7B, 0xFD, 0xE0, 0x01, 0xF7, 0xFB, 0xE0, 0x03, 0xEF,
  0xF7, 0xC0, 0x07, 0x9F, 0xE7, 0x80, 0x1F, 0x3F, 0xCF, 0x80, 0x3E, 0xFF,
  0x9F, 0x00, 0x79, 0xFF, 0x1E, 0x01, 0xF3, 0xFE, 0x3E, 0x03, 0xE7, 0xFE,
  0x7C, 0x07, 0x8F, 0xFC, 0x78, 0x1F, 0x1F, 0xF8, 0xF8, 0x3E, 0x3F, 0xF1,
  0xF0, 0x78, 0x7F, 0xE1, 0xE1, 0xF0, 0xFF, 0xC3, 0xE3, 0xE1, 0xFF, 0x87,
  0xC7, 0x83, 0xFF, 0x07, 0x9F, 0x07, 0xFE, 0x0F, 0xBE, 0x0F, 0xFC, 0x1F,
  0x78, 0x1F, 0xF8, 0x1E, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE0, 0x7F,
  0x81, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xDF, 0x00, 0x0F, 0xFE, 0xF8, 0x00, 0x7F, 0xF7, 0xC0, 0x03, 0xFF, 0x9F,
  0x00, 0x1F, 0xFC, 0xF8, 0x00, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0x1F, 0x00,
  0x3F, 0xF8, 0xF8, 0x01, 0xFF, 0xC3, 0xE0, 0x0F, 0xFE, 0x1F, 0x00, 0x7F,
  0xF0, 0xF8, 0x03, 0xFF, 0x83, 0xE0, 0x1F, 0xFC, 0x1F, 0x00, 0xFF, 0xE0,
  0xF8, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xF8, 0x1F, 0x01, 0xFF, 0xC0, 0x7C,
  0x0F, 0xFE, 0x03, 0xE0, 0x7F, 0xF0, 0x1F, 0x03, 0xFF, 0x80, 0x7C, 0x1F,
  0xFC, 0x03, 0xE0, 0xFF, 0xE0, 0x1F, 0x07, 0xFF, 0x00, 0x7C, 0x3F, 0xF8,
  0x03, 0xE1, 0xFF, 0xC0, 0x0F, 0x8F, 0xFE, 0x00, 0x7C, 0x7F, 0xF0, 0x03,
  0xE3, 0xFF, 0x80, 0x0F, 0x9F, 0xFC, 0x00, 0x7C, 0x7F, 0xE0, 0x03, 0xE3,
  0xFF, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0x7C, 0xFF, 0xC0, 0x03, 0xE7, 0xFE,
  0x00, 0x0F, 0xBF, 0xF0, 0x00, 0x7D, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x00,
  0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x1F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x07, 0xFE, 0x3F,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x7F,
  0x87, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xF8,
  0x01, 0xF7, 0xE0, 0x07, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xE0, 0x07, 0xCF,
  0x80, 0x1D, 0xC0, 0x0F, 0x9F, 0x00, 0x3B, 0x80, 0x1F, 0x3E, 0x00, 0xF7,
  0x00, 0x3E, 0x7C, 0x01, 0xEF, 0x00, 0xFC, 0xF8, 0x03, 0xDE, 0x01, 0xF1,
  0xF8, 0x07, 0xBC, 0x03, 0xE3, 0xF0, 0x0F, 0x78, 0x07, 0xC3, 0xE0, 0x1C,
  0xF0, 0x0F, 0x87, 0xC0, 0x38, 0xE0, 0x1F, 0x0F, 0x80, 0x71, 0xC0, 0x3E,
  0x1F, 0x01, 0xE3, 0x80, 0x7C, 0x3E, 0x03, 0xC7, 0x00, 0xF8, 0x7C, 0x07,
  0x8F, 0x03, 0xE0, 0xF8, 0x0F, 0x1E, 0x07, 0xC1, 0xF0, 0x1E, 0x3C, 0x0F,
  0x83, 0xF0, 0x38, 0x78, 0x1F, 0x03, 0xE0, 0x70, 0xF0, 0x3E, 0x07, 0xC0,
  0xE0, 0xE0, 0x7C, 0x0F, 0x83, 0xC1, 0xC0, 0xF8, 0x1F, 0x07, 0x83, 0x81,
  0xF0, 0x3E, 0x0F, 0x07, 0x83, 0xE0, 0x7C, 0x1E, 0x0F, 0x07, 0x80, 0xF8,
  0x3C, 0x1E, 0x1F, 0x01, 0xF0, 0x70, 0x3C, 0x3E, 0x01, 0xF0, 0xE0, 0x78,
  0x7C, 0x03, 0xE1, 0xC0, 0x70, 0xF8, 0x07, 0xC7, 0x80, 0xE1, 0xF0, 0x0F,
  0x8F, 0x01, 0xC3, 0xE0, 0x1F, 0x1E, 0x03, 0xC7, 0xC0, 0x3E, 0x3C, 0x07,
  0x8F, 0x00, 0x7C, 0x70, 0x0F, 0x1E, 0x00, 0xF8, 0xE0, 0x1E, 0x7C, 0x01,
  0xF1, 0xC0, 0x3C, 0xF8, 0x01, 0xF7, 0x80, 0x39, 0xF0, 0x03, 0xEF, 0x00,
  0x73, 0xE0, 0x07, 0xDE, 0x00, 0xE7, 0xC0, 0x0F, 0xBC, 0x01, 0xEF, 0x80,
  0x1F, 0x78, 0x03, 0xDF, 0x00, 0x3E, 0xE0, 0x07, 0xBC, 0x00, 0x7D, 0xC0,
  0x0F, 0x78, 0x00, 0xFB, 0x80, 0x1F, 0xF0, 0x00, 0xF7, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0xFB,
  0xF3, 0xFF, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0xFF, 0x1F,
  0x80, 0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x1F, 0xFE, 0x03, 0xE1,
  0xFF, 0xFC, 0x1F, 0x1F, 0xFF, 0xF0, 0xF9, 0xFF, 0xFF, 0xC7, 0xDF, 0x83,
  0xFF, 0x3E, 0xE0, 0x03, 0xF9, 0xF6, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0x7F, 0x80, 0x03, 0xFB, 0xFE, 0x00, 0x3F, 0x9F, 0xFE,
  0x0F, 0xFC, 0xFD, 0xFF, 0xFF, 0xC7, 0xE7, 0xFF, 0xFC, 0x3F, 0x1F, 0xFF,
  0xC1, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xFF, 0x83, 0xF0,
  0x3F, 0xFF, 0x8F, 0xC1, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFE, 0xFC, 0x7F,
  0xC0, 0xFB, 0xF3, 0xFC, 0x00, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0x7F, 0x00,
  0x03, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x0F, 0xBF, 0x0F, 0xFF, 0xFE, 0xFC, 0x1F,
  0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0x8F, 0xC0, 0x3F, 0xF8, 0x3F, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0x81, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x7F, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x0F,
  0xC1, 0xFF, 0xFC, 0x7E, 0x1F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0xDF, 0x9F,
  0xF0, 0x3E, 0xFD, 0xFE, 0x00, 0x7F, 0xEF, 0xE0, 0x01, 0xFF, 0x7E, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xBF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x03,
  0xFF, 0x3F, 0xFD, 0xFD, 0xF8, 0xFF, 0xFF, 0xEF, 0xC3, 0xFF, 0xFE, 0x7E,
  0x0F, 0xFF, 0xC3, 0xF0, 0x1F, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x1F, 0xFE, 0x03, 0xF1, 0xFF, 0xFC,
  0x1F, 0x9F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0xE0, 0x7C, 0x7F, 0x83, 0xFC, 0x3E, 0x7F, 0xE3, 0xFF,
  0x1F, 0x7F, 0xF3, 0xFF, 0xCF, 0xBF, 0xFD, 0xFF, 0xF7, 0xF0, 0x7E, 0x81,
  0xFB, 0xF0, 0x1F, 0xC0, 0x7D, 0xF8, 0x07, 0xC0, 0x3E, 0xF8, 0x03, 0xE0,
  0x1F, 0xFC, 0x01, 0xF0, 0x0F, 0xFE, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0x7C,
  0x03, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0xFF, 0xE0, 0x0F,
  0x80, 0x7F, 0xF0, 0x07, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x01,
  0xF0, 0x0F, 0xFE, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x80,
  0x3E, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xF0,
  0x07, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x01, 0xF0, 0x0F, 0xFE,
  0x00, 0xF8, 0x07, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x3E, 0x01, 0xFF,
  0xC0, 0x1F, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xF0, 0x07, 0xC0, 0x3F,
  0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x01, 0xF0, 0x0F, 0xFE, 0x00, 0xF8, 0x07,
  0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0xC0, 0x1F, 0x00,
  0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xE1, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0xC1, 0xF9, 0xFF, 0xFF, 0x0F,
  0xDF, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xE1, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0xC1, 0xF9, 0xFF, 0xFF, 0x0F, 0xDF,
  0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF7, 0xD8, 0x00, 0x3F, 0xBE,
  0xF0, 0x03, 0xF9, 0xF7, 0xE0, 0xFF, 0xCF, 0x9F, 0xFF, 0xFC, 0x7C, 0x7F,
  0xFF, 0xC3, 0xE1, 0xFF, 0xFC, 0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x03, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xFE, 0x0F, 0xC1, 0xFF, 0xFC, 0x7E, 0x1F, 0xFF, 0xF3, 0xF1,
  0xFF, 0xFF, 0xDF, 0x9F, 0xF0, 0x3E, 0xFD, 0xFE, 0x00, 0x7F, 0xEF, 0xE0,
  0x01, 0xFF, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0xFB, 0xF1, 0xFF, 0xFF, 0xDF, 0x87,
  0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0x3F, 0xF8, 0x3F, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF,
  0xE0, 0xFD, 0xFF, 0xFF, 0xC3, 0xF7, 0xC0, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x3D, 0xF0,
  0x03, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xC0, 0x1F, 0x3E, 0x00, 0xFE, 0x00,
  0xF9, 0xF0, 0x0F, 0x70, 0x07, 0xCF, 0x80, 0x7B, 0x80, 0x3E, 0x7C, 0x03,
  0xDC, 0x01, 0xE3, 0xE0, 0x1C, 0xF0, 0x0F, 0x1F, 0x00, 0xE7, 0x80, 0xF8,
  0x7C, 0x07, 0x3C, 0x07, 0xC3, 0xE0, 0x78, 0xE0, 0x3E, 0x1F, 0x03, 0xC7,
  0x01, 0xF0, 0xF8, 0x1E, 0x38, 0x0F, 0x07, 0xC0, 0xE1, 0xE0, 0x78, 0x3E,
  0x07, 0x0F, 0x07, 0xC0, 0xF0, 0x38, 0x78, 0x3E, 0x07, 0xC3, 0xC1, 0xC1,
  0xF0, 0x3E, 0x1E, 0x0E, 0x0F, 0x81, 0xF0, 0xF0, 0x70, 0x78, 0x0F, 0x87,
  0x03, 0xC3, 0xC0, 0x7C, 0x38, 0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0xF1, 0xF0,
  0x0F, 0x1E, 0x03, 0x8F, 0x80, 0x7C, 0xF0, 0x1C, 0x7C, 0x03, 0xE7, 0x80,
  0xE3, 0xC0, 0x1F, 0x38, 0x07, 0x9E, 0x00, 0xF9, 0xC0, 0x3C, 0xF0, 0x03,
  0xCE, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x3B,
  0xE0, 0x07, 0xFC, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x8F,
  0xFE, 0x00, 0x0F, 0xCF, 0xFF, 0xC0, 0x07, 0xEF, 0xFF, 0xF0, 0x03, 0xF7,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x7F,
  0xF0, 0x07, 0xE0, 0x3E, 0xF8, 0x03, 0xF8, 0x3F, 0x7C, 0x00, 0xFF, 0xFF,
  0xBE, 0x00, 0x3F, 0xFF, 0x9F, 0x00, 0x0F, 0xFF, 0x8F, 0x80, 0x03, 0xFF,
  0x87, 0xC0, 0x00, 0x7F, 0x00,
};

const GFXglyph JetBrainsMono_Light71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 10, 52, 43, 16, -52 },
  { 66, 21, 21, 43, 11, -52 },
  { 122, 38, 52, 43, 2, -52 },
  { 369, 32, 72, 43, 5, -62 },
  { 657, 40, 52, 43, 1, -52 },
  { 917, 36, 54, 43, 4, -53 },
  { 1160, 6, 21, 43, 18, -52 },
  { 1176, 21, 69, 43, 13, -60 },
  { 1358, 21, 69, 43, 8, -60 },
  { 1540, 37, 36, 43, 3, -43 },
  { 1707, 33, 33, 43, 5, -40 },
  { 1844, 14, 22, 43, 12, -11 },
  { 1883, 23, 5, 43, 10, -26 },
  { 1898, 11, 12, 43, 16, -11 },
  { 1915, 31, 67, 43, 6, -59 },
  { 2175, 31, 54, 43, 6, -53 },
  { 2385, 31, 52, 43, 7, -52 },
  { 2587, 32, 53, 43, 5, -53 },
  { 2799, 31, 53, 43, 5, -52 },
  { 3005, 29, 52, 43, 6, -52 },
  { 3194, 30, 53, 43, 6, -52 },
  { 3393, 32, 53, 43, 5, -52 },
  { 3605, 32, 52, 43, 6, -52 },
  { 3813, 31, 54, 43, 6, -53 },
  { 4023, 32, 53, 43, 5, -53 },
  { 4235, 11, 41, 43, 16, -40 },
  { 4292, 15, 51, 43, 12, -40 },
  { 4388, 31, 37, 43, 6, -42 },
  { 4532, 30, 21, 43, 6, -34 },
  { 4611, 31, 37, 43, 6, -42 },
  { 4755, 25, 52, 43, 10, -52 },
  { 4918, 35, 66, 43, 4, -53 },
  { 5207, 35, 52, 43, 4, -52 },
  { 5435, 30, 52, 43, 7, -52 },
  { 5630, 30, 54, 43, 7, -53 },
  { 5833, 29, 52, 43, 7, -52 },
  { 6022, 30, 52, 43, 7, -52 },
  { 6217, 30, 52, 43, 7, -52 },
  { 6412, 30, 54, 43, 7, -53 },
  { 6615, 29, 52, 43, 7, -52 },
  { 6804, 27, 52, 43, 8, -52 },
  { 6980, 31, 53, 43, 4, -52 },
  { 7186, 32, 52, 43, 7, -52 },
  { 7394, 30, 52, 43, 8, -52 },
  { 7589, 31, 52, 43, 6, -52 },
  { 7791, 29, 52, 43, 7, -52 },
  { 7980, 29, 54, 43, 7, -53 },
  { 8176, 32, 52, 43, 7, -52 },
  { 8384, 31, 66, 43, 6, -53 },
  { 8640, 31, 52, 43, 7, -52 },
  { 8842, 32, 54, 43, 5, -53 },
  { 9058, 35, 52, 43, 4, -52 },
  { 9286, 29, 53, 43, 7, -52 },
  { 9479, 35, 52, 43, 4, -52 },
  { 9707, 39, 52, 43, 2, -52 },
  { 9961, 37, 52, 43, 3, -52 },
  { 10202, 37, 52, 43, 3, -52 },
  { 10443, 30, 52, 43, 6, -52 },
  { 10638, 17, 67, 43, 15, -59 },
  { 10781, 31, 67, 43, 6, -59 },
  { 11041, 17, 67, 43, 11, -59 },
  { 11184, 31, 28, 43, 6, -52 },
  { 11293, 34, 5, 43, 4, 2 },
  { 11315, 14, 10, 43, 13, -56 },
  { 11333, 31, 41, 43, 5, -40 },
  { 11492, 29, 53, 43, 7, -52 },
  { 11685, 30, 41, 43, 6, -40 },
  { 11839, 30, 53, 43, 6, -52 },
  { 12038, 30, 41, 43, 6, -40 },
  { 12192, 34, 52, 43, 4, -52 },
  { 12413, 29, 53, 43, 7, -40 },
  { 12606, 29, 52, 43, 7, -52 },
  { 12795, 33, 55, 43, 6, -55 },
  { 13022, 26, 68, 43, 6, -55 },
  { 13243, 32, 52, 43, 7, -52 },
  { 13451, 37, 52, 43, 2, -52 },
  { 13692, 33, 40, 43, 5, -40 },
  { 13857, 29, 40, 43, 7, -40 },
  { 14002, 30, 41, 43, 6, -40 },
  { 14156, 29, 53, 43, 7, -40 },
  { 14349, 29, 53, 43, 7, -40 },
  { 14542, 30, 40, 43, 8, -40 },
  { 14692, 31, 41, 43, 6, -40 },
  { 14851, 33, 50, 43, 4, -50 },
  { 15058, 29, 40, 43, 7, -39 },
  { 15203, 34, 39, 43, 4, -39 },
  { 15369, 37, 39, 43, 3, -39 },
  { 15550, 35, 39, 43, 4, -39 },
  { 15721, 34, 52, 43, 4, -39 },
  { 15942, 29, 39, 43, 7, -39 },
  { 16084, 30, 67, 43, 6, -59 },
  { 16336, 6, 67, 43, 18, -59 },
  { 16387, 30, 67, 43, 6, -59 },
  { 16639, 33, 14, 43, 5, -32 },
};

const GFXfont JetBrainsMono_Light71pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light71pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _JETBRAINSMONO_LIGHT71PT7B_H_
