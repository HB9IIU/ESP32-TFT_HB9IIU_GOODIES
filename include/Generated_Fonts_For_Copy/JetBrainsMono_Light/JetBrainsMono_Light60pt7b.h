#ifndef _JETBRAINSMONO_LIGHT60PT7B_H_
#define _JETBRAINSMONO_LIGHT60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light60pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xE7, 0x3F, 0x81, 0xF8, 0x70, 0xFC, 0x1F,
  0x07, 0x07, 0xC3, 0xE0, 0x70, 0x7C, 0x3E, 0x07, 0x03, 0xE3, 0xE0, 0x70,
  0x3E, 0x3E, 0x07, 0x03, 0xE3, 0xE0, 0x70, 0x00, 0x3E, 0x07, 0x00, 0x03,
  0xE0, 0x70, 0x00, 0x3E, 0x07, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x1F, 0x87,
  0x00, 0x01, 0xFC, 0x70, 0x00, 0x0F, 0xF7, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x73, 0xF8, 0x00, 0x07, 0x0F,
  0xC0, 0x00, 0x70, 0x7C, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x70, 0x3E, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x70, 0x1E, 0x80, 0x07, 0x01, 0xF7, 0x80, 0x70,
  0x1E, 0x78, 0x07, 0x01, 0xE7, 0xC0, 0x70, 0x3E, 0x7C, 0x07, 0x03, 0xE7,
  0xE0, 0x70, 0x7E, 0x3F, 0x07, 0x0F, 0xC1, 0xFC, 0x71, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC7, 0xFF, 0x00, 0x01,
  0xE3, 0xFF, 0xE0, 0x00, 0xF1, 0xFF, 0xF8, 0x00, 0x3C, 0x78, 0x1F, 0x00,
  0x1E, 0x1E, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x1E,
  0x01, 0xE0, 0xF0, 0x07, 0x80, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x0F, 0x00,
  0x78, 0x1E, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x3C,
  0x03, 0xC1, 0xE0, 0x07, 0x80, 0xF0, 0xF0, 0x01, 0xF0, 0x7C, 0x3C, 0x00,
  0x7F, 0xFE, 0x1E, 0x00, 0x0F, 0xFF, 0x8F, 0x00, 0x01, 0xFF, 0xC7, 0x80,
  0x00, 0x1F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x01, 0xE1, 0xFF, 0x80, 0x00, 0xF0, 0xFF, 0xF0, 0x00,
  0x78, 0x7F, 0xFE, 0x00, 0x1E, 0x3E, 0x0F, 0x80, 0x0F, 0x0F, 0x01, 0xE0,
  0x07, 0x83, 0xC0, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0xF0, 0x78, 0x03,
  0xC0, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x01, 0xE0,
  0x0F, 0x07, 0x80, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0xF0, 0xF0, 0x03,
  0xC0, 0x7C, 0x78, 0x00, 0xF0, 0x1E, 0x3C, 0x00, 0x3F, 0xBF, 0x8F, 0x00,
  0x07, 0xFF, 0xC7, 0x80, 0x00, 0xFF, 0xE3, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xCF, 0x80, 0x1F, 0x3F, 0x0F, 0x80, 0x3E, 0x7C, 0x1F, 0x80, 0xF8,
  0xF0, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x8F,
  0x80, 0x3F, 0x3E, 0x1F, 0x00, 0x3E, 0x7C, 0x3E, 0x00, 0x3F, 0xF0, 0x7C,
  0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x01, 0xFC, 0x07, 0x80, 0x03, 0xF8, 0x0F, 0x80,
  0x0F, 0xF8, 0x1F, 0x00, 0x3E, 0xF8, 0x3F, 0x81, 0xFD, 0xF8, 0x3F, 0xFF,
  0xF1, 0xF0, 0x3F, 0xFF, 0xC1, 0xF0, 0x3F, 0xFE, 0x01, 0xF0, 0x3F, 0xF8,
  0x03, 0xF0, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x20, 0x03, 0xC0, 0x04, 0x7C, 0x03, 0xC0, 0x3E, 0x7F, 0x83, 0xC1, 0xFE,
  0x7F, 0xE3, 0xC7, 0xFE, 0xFF, 0xF1, 0x8F, 0xFF, 0x1F, 0xFD, 0xBF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x1F, 0xE7,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x80, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07,
  0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x1E,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xEF, 0x00, 0x07,
  0xF3, 0xC0, 0x07, 0xF8, 0xF0, 0x03, 0xF8, 0x3C, 0x00, 0xFC, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0x80, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0x83,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0x7E,
  0x01, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x7F, 0xF0, 0x1F, 0x3F, 0xFF, 0x07,
  0xDF, 0xFF, 0xE1, 0xFF, 0xCF, 0xFC, 0x7F, 0x80, 0x3F, 0x1F, 0xC0, 0x07,
  0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xFE, 0x01, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0xFE, 0x00, 0x0F, 0xBF, 0xFC, 0x01, 0xF7,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x1F,
  0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x03, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x79, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xE7, 0xE0, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x78, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xEF, 0x80, 0x3F, 0xFD, 0xF0, 0x00, 0xFF, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0C, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0xC0, 0x01, 0xC0, 0x7F, 0x83,
  0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0x8F, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x1F, 0xFE, 0xFF, 0x00, 0x7F, 0x3D,
  0xFC, 0x03, 0xE0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xC0, 0x3C, 0x00, 0xFF,
  0x01, 0xF0, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0xFF, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x1F,
  0x00, 0x3F, 0xC0, 0x7C, 0x00, 0xFF, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xC0,
  0x0F, 0xF0, 0x1F, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0xFF, 0x00, 0xF0, 0x07,
  0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F,
  0x00, 0x3F, 0xF9, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x3F, 0x8F, 0x80, 0x03, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xE0, 0x0F, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x00,
  0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xF3, 0xE0, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xF8, 0x0F, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x00, 0xFD, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xF8,
  0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x00, 0xFD,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF8, 0x00, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xEF, 0x00, 0x3D, 0xFB, 0xC0, 0x0F, 0x7E, 0xF0, 0x03,
  0xDF, 0xDE, 0x01, 0xE7, 0xF7, 0x80, 0x7B, 0xFD, 0xE0, 0x1E, 0xFF, 0x3C,
  0x0F, 0x3F, 0xCF, 0x03, 0xCF, 0xF3, 0xC0, 0xF3, 0xFC, 0x78, 0x38, 0xFF,
  0x1E, 0x1E, 0x3F, 0xC7, 0x87, 0x8F, 0xF0, 0xF1, 0xC3, 0xFC, 0x3C, 0xF0,
  0xFF, 0x0F, 0x3C, 0x3F, 0xC1, 0xEE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF7, 0x80,
  0x0F, 0xF7, 0x80, 0x0F, 0xF7, 0x80, 0x0F, 0xF3, 0xC0, 0x0F, 0xF3, 0xC0,
  0x0F, 0xF3, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xF1, 0xF0,
  0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78,
  0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3E,
  0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0, 0x0F,
  0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x07, 0x8F, 0xF0, 0x07, 0x8F, 0xF0, 0x07,
  0xCF, 0xF0, 0x03, 0xCF, 0xF0, 0x03, 0xCF, 0xF0, 0x03, 0xEF, 0xF0, 0x01,
  0xEF, 0xF0, 0x01, 0xEF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0x81, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0x7F,
  0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xCF,
  0x80, 0x03, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC0,
  0xFF, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07,
  0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3E, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0xFC, 0xF8, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F,
  0x81, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x80,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x07,
  0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x07,
  0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0x78, 0x07,
  0x70, 0x1E, 0x78, 0x07, 0x70, 0x1E, 0x78, 0x0E, 0x70, 0x1E, 0x78, 0x0E,
  0x70, 0x1E, 0x78, 0x0E, 0x70, 0x1E, 0x7C, 0x0E, 0x70, 0x1E, 0x7C, 0x0E,
  0x70, 0x3E, 0x7C, 0x0E, 0x70, 0x3E, 0x3C, 0x0E, 0x38, 0x3C, 0x3C, 0x1E,
  0x38, 0x3C, 0x3C, 0x1C, 0x38, 0x3C, 0x3C, 0x1C, 0x38, 0x3C, 0x3C, 0x1C,
  0x38, 0x3C, 0x3C, 0x1C, 0x38, 0x3C, 0x3E, 0x1C, 0x38, 0x3C, 0x3E, 0x1C,
  0x38, 0x7C, 0x3E, 0x1C, 0x38, 0x7C, 0x1E, 0x3C, 0x1C, 0x78, 0x1E, 0x38,
  0x1C, 0x78, 0x1E, 0x38, 0x1C, 0x78, 0x1E, 0x38, 0x1C, 0x78, 0x1E, 0x38,
  0x1C, 0x78, 0x1E, 0x38, 0x1C, 0x78, 0x1F, 0x38, 0x1C, 0x78, 0x1F, 0x38,
  0x1C, 0x78, 0x0F, 0x70, 0x0E, 0xF0, 0x0F, 0x70, 0x0E, 0xF0, 0x0F, 0x70,
  0x0E, 0xF0, 0x0F, 0x70, 0x0E, 0xF0, 0x0F, 0x70, 0x0E, 0xF0, 0x0F, 0x70,
  0x0E, 0xF0, 0x0F, 0x70, 0x0E, 0xF0, 0x0F, 0x70, 0x0E, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07,
  0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xF0,
  0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x07, 0xF0, 0x0F, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFC, 0x00,
  0x0F, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xDF, 0xC0, 0x0E, 0xF3, 0xFE, 0x1F,
  0xBC, 0x7F, 0xFF, 0xCF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFF, 0xE0, 0xF0, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0x80,
  0x1F, 0x0F, 0xFC, 0x0F, 0x9F, 0xFF, 0x07, 0xDF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF1, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x01,
  0xFB, 0xF8, 0x00, 0xF9, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0x7D, 0xFF,
  0xFC, 0x3E, 0x7F, 0xFC, 0x1F, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x1F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x0E, 0x03, 0xE0, 0x7F, 0xE1, 0xF0, 0x7F, 0xFC, 0xF8, 0x7F, 0xFF,
  0x7C, 0x7F, 0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0x3E, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xF7, 0xC1, 0xFF, 0xF3, 0xE0, 0x7F, 0xE1, 0xF0, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xF3, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC1, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x1F,
  0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0xFF, 0xFF, 0x7F, 0x00, 0xFF,
  0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7F,
  0x7E, 0x00, 0xFF, 0x3F, 0xC3, 0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F,
  0x07, 0xFF, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF0,
  0xFB, 0xFF, 0xF8, 0xFF, 0xE7, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x20, 0x06, 0x0F, 0x1F, 0xC3, 0xF8, 0xF3, 0xFC, 0x7F, 0xCF, 0x7F, 0xEF,
  0xFE, 0xF6, 0x3E, 0xC7, 0xEF, 0x81, 0xF8, 0x1E, 0xF8, 0x0F, 0x01, 0xFF,
  0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F,
  0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F,
  0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80,
  0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01,
  0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8,
  0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0,
  0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF,
  0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0x00, 0x0E,
  0x00, 0xF8, 0x7F, 0xE0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0E,
  0x00, 0x7C, 0x3F, 0xF0, 0x3E, 0x7F, 0xFC, 0x1F, 0x7F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xF8, 0x07, 0xF3, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80,
  0x07, 0xEF, 0xE0, 0x03, 0xE7, 0xF8, 0x07, 0xF3, 0xFF, 0xFF, 0xF1, 0xF7,
  0xFF, 0xF0, 0xF9, 0xFF, 0xF0, 0x7C, 0x3F, 0xF0, 0x3E, 0x03, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFE,
  0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0xFF, 0xFF, 0x7F, 0x00,
  0xFF, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x07, 0xFE,
  0x1F, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0E,
  0x00, 0x7C, 0x3F, 0xF0, 0x3E, 0x7F, 0xFC, 0x1F, 0x7F, 0xFF, 0x8F, 0xBE,
  0x7F, 0xC7, 0xF8, 0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x0F, 0xC0, 0x0F, 0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x78, 0x07, 0xE0, 0x1E, 0x78,
  0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x78,
  0x07, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x3C, 0x0E, 0x70, 0x3C, 0x3C,
  0x0E, 0x70, 0x3C, 0x3C, 0x0E, 0x70, 0x3C, 0x3C, 0x0E, 0x70, 0x3C, 0x3C,
  0x0E, 0x70, 0x3C, 0x3C, 0x0E, 0x70, 0x3C, 0x1E, 0x1C, 0x38, 0x38, 0x1E,
  0x1C, 0x38, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x1E,
  0x1C, 0x38, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x1F, 0x38, 0x1C, 0x70, 0x0F,
  0x38, 0x1C, 0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x0F,
  0x38, 0x1C, 0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x0F, 0x70, 0x1E, 0xE0, 0x07,
  0x70, 0x0E, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xF1, 0xFF, 0x80, 0x1F, 0x3F, 0xFC, 0x01, 0xF7,
  0xFF, 0xE0, 0x1F, 0x7C, 0x3F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x0F,
  0x81, 0xFF, 0x80, 0x7E, 0x3E, 0xF8, 0x03, 0xFF, 0xEF, 0x80, 0x3F, 0xFC,
  0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_Light60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 8, 44, 36, 14, -44 },
  { 45, 18, 18, 36, 9, -44 },
  { 86, 32, 44, 36, 2, -44 },
  { 262, 28, 60, 36, 4, -52 },
  { 472, 34, 44, 36, 1, -44 },
  { 659, 31, 45, 36, 3, -44 },
  { 834, 5, 18, 36, 15, -44 },
  { 846, 18, 57, 36, 11, -50 },
  { 975, 18, 57, 36, 7, -50 },
  { 1104, 32, 31, 36, 2, -37 },
  { 1228, 28, 28, 36, 4, -34 },
  { 1326, 12, 19, 36, 10, -9 },
  { 1355, 20, 4, 36, 8, -22 },
  { 1365, 10, 10, 36, 13, -9 },
  { 1378, 26, 57, 36, 5, -50 },
  { 1564, 26, 45, 36, 5, -44 },
  { 1711, 26, 44, 36, 6, -44 },
  { 1854, 28, 44, 36, 4, -44 },
  { 2008, 26, 45, 36, 4, -44 },
  { 2155, 25, 44, 36, 5, -44 },
  { 2293, 26, 45, 36, 5, -44 },
  { 2440, 28, 45, 36, 4, -44 },
  { 2598, 27, 44, 36, 5, -44 },
  { 2747, 26, 45, 36, 5, -44 },
  { 2894, 28, 44, 36, 4, -44 },
  { 3048, 10, 35, 36, 13, -34 },
  { 3092, 13, 44, 36, 10, -34 },
  { 3164, 26, 31, 36, 5, -35 },
  { 3265, 26, 18, 36, 5, -29 },
  { 3324, 26, 31, 36, 5, -35 },
  { 3425, 21, 44, 36, 9, -44 },
  { 3541, 30, 55, 36, 3, -44 },
  { 3748, 30, 44, 36, 3, -44 },
  { 3913, 26, 44, 36, 6, -44 },
  { 4056, 25, 45, 36, 6, -44 },
  { 4197, 24, 44, 36, 6, -44 },
  { 4329, 25, 44, 36, 6, -44 },
  { 4467, 26, 44, 36, 6, -44 },
  { 4610, 25, 45, 36, 6, -44 },
  { 4751, 24, 44, 36, 6, -44 },
  { 4883, 22, 44, 36, 7, -44 },
  { 5004, 26, 45, 36, 3, -44 },
  { 5151, 27, 44, 36, 6, -44 },
  { 5300, 25, 44, 36, 7, -44 },
  { 5438, 26, 44, 36, 5, -44 },
  { 5581, 24, 44, 36, 6, -44 },
  { 5713, 24, 45, 36, 6, -44 },
  { 5848, 27, 44, 36, 6, -44 },
  { 5997, 26, 55, 36, 5, -44 },
  { 6176, 26, 44, 36, 6, -44 },
  { 6319, 28, 45, 36, 4, -44 },
  { 6477, 30, 44, 36, 3, -44 },
  { 6642, 24, 45, 36, 6, -44 },
  { 6777, 30, 44, 36, 3, -44 },
  { 6942, 32, 44, 36, 2, -44 },
  { 7118, 30, 44, 36, 3, -44 },
  { 7283, 32, 44, 36, 2, -44 },
  { 7459, 26, 44, 36, 5, -44 },
  { 7602, 14, 57, 36, 13, -50 },
  { 7702, 26, 57, 36, 5, -50 },
  { 7888, 14, 57, 36, 9, -50 },
  { 7988, 26, 24, 36, 5, -44 },
  { 8066, 28, 5, 36, 4, 1 },
  { 8084, 12, 8, 36, 11, -47 },
  { 8096, 26, 35, 36, 4, -34 },
  { 8210, 25, 45, 36, 6, -44 },
  { 8351, 26, 35, 36, 5, -34 },
  { 8465, 25, 45, 36, 5, -44 },
  { 8606, 26, 35, 36, 5, -34 },
  { 8720, 28, 44, 36, 4, -44 },
  { 8874, 24, 45, 36, 6, -34 },
  { 9009, 24, 44, 36, 6, -44 },
  { 9141, 28, 46, 36, 5, -46 },
  { 9302, 22, 57, 36, 5, -46 },
  { 9459, 27, 44, 36, 6, -44 },
  { 9608, 31, 44, 36, 2, -44 },
  { 9779, 28, 34, 36, 4, -34 },
  { 9898, 24, 34, 36, 6, -34 },
  { 10000, 26, 35, 36, 5, -34 },
  { 10114, 25, 45, 36, 6, -34 },
  { 10255, 24, 45, 36, 6, -34 },
  { 10390, 25, 34, 36, 7, -34 },
  { 10497, 26, 35, 36, 5, -34 },
  { 10611, 27, 42, 36, 4, -42 },
  { 10753, 24, 34, 36, 6, -33 },
  { 10855, 28, 33, 36, 4, -33 },
  { 10971, 32, 33, 36, 2, -33 },
  { 11103, 30, 33, 36, 3, -33 },
  { 11227, 28, 44, 36, 4, -33 },
  { 11381, 24, 33, 36, 6, -33 },
  { 11480, 26, 57, 36, 5, -50 },
  { 11666, 4, 57, 36, 16, -50 },
  { 11695, 26, 57, 36, 5, -50 },
  { 11881, 28, 12, 36, 4, -27 },
};

const GFXfont JetBrainsMono_Light60pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light60pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _JETBRAINSMONO_LIGHT60PT7B_H_
