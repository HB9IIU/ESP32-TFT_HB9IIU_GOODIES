#ifndef _JETBRAINSMONO_LIGHT29PT7B_H_
#define _JETBRAINSMONO_LIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light29pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x60, 0x00, 0xFF, 0xE0,
  0xE3, 0xF1, 0xD8, 0xEC, 0x76, 0x3B, 0x0D, 0x86, 0xC3, 0x61, 0x80, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x20, 0x30, 0xC0, 0x41, 0x81, 0x83, 0x1F, 0xFF,
  0x86, 0x0C, 0x0C, 0x30, 0x10, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x1F,
  0xFF, 0xBF, 0xFF, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x01, 0x86,
  0x06, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01, 0xFE, 0x1F,
  0xF9, 0xCC, 0xCC, 0x67, 0x63, 0x1B, 0x18, 0x18, 0xC0, 0xE6, 0x03, 0xB0,
  0x0F, 0x80, 0x3F, 0x80, 0x7E, 0x03, 0x70, 0x19, 0xC0, 0xC6, 0x06, 0x3E,
  0x31, 0xF1, 0x9D, 0xCC, 0xC7, 0xFE, 0x1F, 0xC0, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x3E, 0x01, 0xBB, 0x81, 0x98, 0xC1, 0x8C, 0x21, 0x86,
  0x10, 0xC3, 0x08, 0xC1, 0x8C, 0xC0, 0xEE, 0x60, 0x3E, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x31, 0x00, 0x33, 0xF0, 0x1B, 0x98, 0x19, 0x86, 0x18,
  0xC3, 0x08, 0x61, 0x8C, 0x30, 0xCC, 0x18, 0x6C, 0x0F, 0xEE, 0x03, 0xE0,
  0x1F, 0x80, 0xFF, 0x07, 0x0E, 0x18, 0x18, 0x60, 0x61, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x01, 0xF0, 0x0F, 0xE0, 0x31, 0x87, 0xC3, 0x1B, 0x0E,
  0xEC, 0x1F, 0x30, 0x38, 0xC0, 0xE3, 0x03, 0xCE, 0x1F, 0x9F, 0xE6, 0x3F,
  0x1C, 0xFF, 0xFF, 0xFB, 0x60, 0x03, 0x0F, 0x1C, 0x38, 0x70, 0x60, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0F, 0x07, 0xE0, 0x78, 0x0F, 0x01,
  0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x3C,
  0x7C, 0x38, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x08, 0x18,
  0x3E, 0x31, 0xFF, 0x4F, 0x9F, 0xFC, 0x01, 0x80, 0x05, 0x80, 0x1B, 0x80,
  0x73, 0x01, 0xC7, 0x07, 0x07, 0x06, 0x04, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xE0, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x3C, 0xE3, 0x9C, 0x71, 0x86, 0x30,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xF0, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x00, 0x1F, 0xC1, 0xFF, 0x9C, 0x1C, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x38, 0xF9, 0xC7, 0xCE, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0x60, 0x3B, 0x01, 0xDC, 0x1C, 0x7F, 0xC1,
  0xFC, 0x00, 0x0F, 0x01, 0xF8, 0x1F, 0xC1, 0xCE, 0x0C, 0x70, 0x43, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xC1, 0xFF, 0x9C, 0x1C, 0xC0, 0x7E, 0x03, 0xF0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x7F, 0xF3, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xFC, 0x07, 0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C,
  0x03, 0x83, 0x30, 0x37, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0xEF, 0xFE, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xCF, 0x0E, 0xE0, 0x6C,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x7C, 0x06, 0xE0, 0xE7,
  0xFC, 0x3F, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x37, 0xC3, 0xFF, 0x9C, 0x1C, 0xC0, 0x7E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1B, 0x01, 0xDC, 0x1C, 0x7F, 0xC1,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x00, 0x1F, 0xC1, 0xFF, 0x9C, 0x1C, 0xC0, 0x66, 0x03, 0xB0, 0x1D, 0x80,
  0xC6, 0x0E, 0x3C, 0xE0, 0x7E, 0x03, 0xF0, 0x79, 0xC7, 0x07, 0x30, 0x1D,
  0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x01, 0xDC, 0x1C, 0x7F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC1, 0xFF, 0x9C, 0x1C, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x1B, 0x01, 0xDE, 0x1C, 0x7F, 0x60, 0xF6, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x7F,
  0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xEF, 0x3D, 0xF7, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xE3, 0x9C, 0x71, 0x86, 0x38,
  0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x18, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1C,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x70, 0x02, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x38, 0x07, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0xE3, 0xF0, 0xF8, 0x38, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x81, 0xF0, 0x38, 0x00, 0x0F, 0xF0, 0x3C, 0xF0,
  0xE0, 0x73, 0x80, 0x76, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xF0, 0x7B, 0xE1,
  0xFF, 0xC7, 0x0F, 0x8C, 0x1F, 0x18, 0x3E, 0x30, 0x7C, 0x60, 0xF8, 0xC1,
  0xF1, 0x83, 0xE3, 0x07, 0xC7, 0x1F, 0x87, 0xDB, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0xF8, 0x03, 0x60, 0x0D, 0x80, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x18,
  0xE0, 0x61, 0x83, 0x86, 0x0C, 0x18, 0x30, 0x70, 0xFF, 0xC7, 0xFF, 0x18,
  0x0C, 0x60, 0x3B, 0x80, 0x6E, 0x01, 0xB0, 0x06, 0xC0, 0x1C, 0xFF, 0x8F,
  0xFC, 0xC0, 0xEC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0xEF,
  0xFC, 0xFF, 0xCC, 0x0E, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0xEF, 0xFC, 0xFF, 0x80, 0x3F, 0x87, 0xFE, 0xE0, 0xEC, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0xE7, 0xFC,
  0x3F, 0x80, 0xFF, 0x0F, 0xFC, 0xC1, 0xEC, 0x06, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x6C, 0x0E, 0xC1, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F,
  0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x3F, 0x87, 0xFE, 0xE0, 0xEC, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC7, 0xFC, 0x7F, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0xE7, 0xFC, 0x3F, 0x80, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x7F, 0xFF, 0xFE, 0x07,
  0xF0, 0x7F, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xE0, 0xE7, 0xFE, 0x3F, 0x80, 0xC0, 0x3E, 0x03, 0xB0, 0x19,
  0x81, 0xCC, 0x0C, 0x60, 0xE3, 0x06, 0x18, 0x70, 0xC3, 0x07, 0xF8, 0x3F,
  0xC1, 0x86, 0x0C, 0x38, 0x60, 0xC3, 0x07, 0x18, 0x18, 0xC0, 0xE6, 0x03,
  0x30, 0x1D, 0x80, 0x6C, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xB0, 0xFD, 0x8D, 0xEC, 0x6F,
  0x33, 0x79, 0xB3, 0xCD, 0x9F, 0x3C, 0xF9, 0xC7, 0xCE, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0x80, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xD8, 0x7D, 0x87, 0xD8, 0x7C,
  0xC7, 0xCC, 0x7C, 0xC7, 0xC6, 0x7C, 0x67, 0xC6, 0x7C, 0x37, 0xC3, 0x7C,
  0x1F, 0xC1, 0xBC, 0x1B, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0, 0x3F, 0x87, 0xFC,
  0xE0, 0xEC, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06,
  0xE0, 0xE7, 0xFC, 0x3F, 0x80, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x6C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x03, 0xBF, 0xF9, 0xFF,
  0x8C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x3F, 0x87, 0xFC, 0xE0, 0xEC, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xE0, 0xE7, 0xFC, 0x3F, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x30, 0x3D,
  0x80, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x76, 0x07, 0x3F,
  0xF1, 0xFF, 0x0C, 0x38, 0x61, 0xC3, 0x07, 0x18, 0x38, 0xC0, 0xC6, 0x07,
  0x30, 0x19, 0x80, 0xEC, 0x03, 0x80, 0x1F, 0xE1, 0xFF, 0x9C, 0x0C, 0xC0,
  0x76, 0x01, 0xB0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFC, 0x03, 0xF8,
  0x03, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xE0, 0x1F, 0x01, 0xDC,
  0x1C, 0x7F, 0xE1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x06, 0xE0, 0xE7, 0xFC,
  0x3F, 0x80, 0xC0, 0x1F, 0x00, 0x6E, 0x01, 0x98, 0x06, 0x60, 0x39, 0x80,
  0xC7, 0x03, 0x0C, 0x0C, 0x30, 0x70, 0xC1, 0x83, 0x86, 0x06, 0x38, 0x18,
  0xC0, 0x63, 0x01, 0xCC, 0x03, 0x70, 0x0D, 0x80, 0x36, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x00, 0xC3, 0x87, 0xC3, 0x86, 0xC3, 0x86, 0xC3, 0x86, 0xE2,
  0xC6, 0x62, 0xC6, 0x62, 0xC6, 0x62, 0xC6, 0x66, 0x46, 0x66, 0x4C, 0x66,
  0x4C, 0x66, 0x4C, 0x64, 0x6C, 0x74, 0x6C, 0x34, 0x6C, 0x3C, 0x6C, 0x3C,
  0x2C, 0x3C, 0x28, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x0E, 0x60,
  0x38, 0xE0, 0x60, 0xC1, 0xC1, 0xC3, 0x01, 0x8E, 0x03, 0x98, 0x03, 0x60,
  0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x6C, 0x01, 0xDC, 0x03,
  0x1C, 0x0E, 0x18, 0x18, 0x38, 0x70, 0x30, 0xC0, 0x73, 0x80, 0x6E, 0x00,
  0xE0, 0xE0, 0x06, 0xC0, 0x19, 0xC0, 0x31, 0x80, 0xC3, 0x81, 0x83, 0x07,
  0x07, 0x0C, 0x06, 0x38, 0x0E, 0x60, 0x0D, 0xC0, 0x1F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF,
  0xF8, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0xFF, 0xFC, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xF8, 0x07, 0x00, 0x3C,
  0x03, 0x60, 0x1B, 0x00, 0xCC, 0x0C, 0x60, 0x61, 0x86, 0x0C, 0x30, 0x33,
  0x01, 0xB8, 0x0E, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x87, 0x1F, 0xC1,
  0xFF, 0x1C, 0x1C, 0xC0, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE7, 0xFF, 0x7F,
  0xFF, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x3D, 0xFF, 0xE7, 0xF7,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xCE, 0x0E,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0xED, 0xFE, 0xCF, 0x80, 0x3F, 0x87, 0xFC, 0xE0,
  0xEC, 0x07, 0xC0, 0x7C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x07, 0xC0, 0x7E, 0x0E, 0x7F, 0xC3, 0xF8, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x73, 0xF7, 0x7F, 0xFE, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0xF7, 0xFF, 0x3F, 0x70, 0x3F, 0x87, 0xFC, 0xE0, 0xEC, 0x06, 0xC0, 0x7C,
  0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x7E,
  0x06, 0x7F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0xC1, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x3F, 0x77, 0xFF, 0xE0, 0xFC, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF,
  0x1E, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x63, 0xFE, 0x3F, 0xC0, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xCE, 0x0E, 0xE0,
  0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF0, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0xBF, 0xCF, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x1F, 0x01, 0xD8, 0x1C, 0xC0, 0xC6, 0x0E, 0x30, 0xE1, 0x86,
  0x0F, 0xF0, 0x7F, 0x83, 0x0E, 0x18, 0x30, 0xC1, 0xC6, 0x07, 0x30, 0x19,
  0x80, 0xEC, 0x03, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0xDE, 0xF7, 0xF7, 0xF1,
  0xC7, 0x86, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18,
  0xF0, 0xC7, 0x86, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xCF, 0x8D,
  0xFC, 0xE0, 0xEE, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x1F, 0x87,
  0xFC, 0xE0, 0xEC, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x6E, 0x0E, 0x7F, 0xC3, 0xF8, 0xCF, 0x8D,
  0xFC, 0xE0, 0xEE, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x0E, 0xDF, 0xCC, 0xF8, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0x77, 0xFF, 0xE0, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x0F, 0x7F, 0xF3, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0xEF, 0xCF, 0xFE, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x3F, 0xC7, 0xFE, 0xE0, 0x6C, 0x07, 0xC0, 0x0E, 0x00, 0x78,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x07, 0x7F,
  0xE3, 0xFC, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xFC,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xFE, 0x07, 0xF0, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x6E, 0x0E, 0x7F, 0xC3, 0xF8, 0xC0,
  0x1F, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x70, 0x30, 0xC0, 0xC3, 0x06, 0x0E,
  0x18, 0x18, 0x60, 0x63, 0x01, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xC0, 0xC1, 0x87, 0x87, 0x0D, 0x8E, 0x1B, 0x14, 0x36, 0x2C,
  0x6C, 0x59, 0x98, 0xB3, 0x33, 0x26, 0x26, 0x4C, 0x68, 0x98, 0xD1, 0xB1,
  0xA3, 0x43, 0x47, 0x87, 0x87, 0x0F, 0x0E, 0x0C, 0x1C, 0xE0, 0x39, 0xC0,
  0xC3, 0x07, 0x0E, 0x38, 0x1C, 0xC0, 0x37, 0x00, 0xF8, 0x01, 0xC0, 0x07,
  0x80, 0x3E, 0x01, 0xDC, 0x06, 0x38, 0x38, 0x61, 0xC1, 0xC6, 0x03, 0xB8,
  0x07, 0xE0, 0x1F, 0x80, 0x66, 0x03, 0x9C, 0x0C, 0x30, 0x30, 0xC1, 0xC3,
  0x86, 0x06, 0x38, 0x1C, 0xC0, 0x33, 0x00, 0xDC, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x1E, 0x0F, 0xC0, 0xFE,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x3F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0F, 0x00, 0x3F, 0x0F,
  0xF0, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x1F, 0xF0, 0xF1, 0xC7,
  0x87, 0x7C, 0x1F, 0xE0, 0x30,
};

const GFXglyph JetBrainsMono_Light29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 21, 17, 7, -21 },
  { 12, 9, 9, 17, 4, -21 },
  { 23, 15, 21, 17, 1, -21 },
  { 63, 13, 29, 17, 2, -25 },
  { 111, 17, 21, 17, 0, -21 },
  { 156, 14, 21, 17, 2, -21 },
  { 193, 3, 9, 17, 7, -21 },
  { 197, 8, 27, 17, 6, -24 },
  { 224, 9, 27, 17, 3, -24 },
  { 255, 15, 15, 17, 1, -18 },
  { 284, 13, 13, 17, 2, -16 },
  { 306, 6, 9, 17, 5, -4 },
  { 313, 9, 2, 17, 4, -11 },
  { 316, 5, 4, 17, 6, -4 },
  { 319, 13, 27, 17, 2, -24 },
  { 363, 13, 21, 17, 2, -21 },
  { 398, 13, 21, 17, 3, -21 },
  { 433, 13, 21, 17, 2, -21 },
  { 468, 13, 21, 17, 2, -21 },
  { 503, 12, 21, 17, 2, -21 },
  { 535, 12, 21, 17, 3, -21 },
  { 567, 13, 21, 17, 2, -21 },
  { 602, 13, 21, 17, 2, -21 },
  { 637, 13, 21, 17, 2, -21 },
  { 672, 13, 21, 17, 2, -21 },
  { 707, 5, 16, 17, 6, -16 },
  { 717, 6, 21, 17, 5, -16 },
  { 733, 13, 15, 17, 2, -17 },
  { 758, 12, 9, 17, 3, -14 },
  { 772, 13, 15, 17, 2, -17 },
  { 797, 10, 21, 17, 4, -21 },
  { 824, 15, 26, 17, 1, -21 },
  { 873, 14, 21, 17, 2, -21 },
  { 910, 12, 21, 17, 3, -21 },
  { 942, 12, 21, 17, 3, -21 },
  { 974, 12, 21, 17, 3, -21 },
  { 1006, 12, 21, 17, 3, -21 },
  { 1038, 12, 21, 17, 3, -21 },
  { 1070, 12, 21, 17, 3, -21 },
  { 1102, 12, 21, 17, 3, -21 },
  { 1134, 11, 21, 17, 3, -21 },
  { 1163, 12, 21, 17, 2, -21 },
  { 1195, 13, 21, 17, 3, -21 },
  { 1230, 12, 21, 17, 3, -21 },
  { 1262, 13, 21, 17, 2, -21 },
  { 1297, 12, 21, 17, 3, -21 },
  { 1329, 12, 21, 17, 3, -21 },
  { 1361, 13, 21, 17, 3, -21 },
  { 1396, 12, 26, 17, 3, -21 },
  { 1435, 13, 21, 17, 3, -21 },
  { 1470, 13, 21, 17, 2, -21 },
  { 1505, 14, 21, 17, 2, -21 },
  { 1542, 12, 21, 17, 3, -21 },
  { 1574, 14, 21, 17, 2, -21 },
  { 1611, 16, 21, 17, 1, -21 },
  { 1653, 15, 21, 17, 1, -21 },
  { 1693, 15, 21, 17, 1, -21 },
  { 1733, 12, 21, 17, 3, -21 },
  { 1765, 7, 27, 17, 6, -24 },
  { 1789, 13, 27, 17, 2, -24 },
  { 1833, 7, 27, 17, 4, -24 },
  { 1857, 13, 11, 17, 2, -21 },
  { 1875, 14, 2, 17, 2, 1 },
  { 1879, 6, 4, 17, 5, -23 },
  { 1882, 13, 16, 17, 2, -16 },
  { 1908, 12, 21, 17, 3, -21 },
  { 1940, 12, 16, 17, 3, -16 },
  { 1964, 12, 21, 17, 3, -21 },
  { 1996, 12, 16, 17, 3, -16 },
  { 2020, 13, 21, 17, 2, -21 },
  { 2055, 12, 21, 17, 3, -16 },
  { 2087, 12, 21, 17, 3, -21 },
  { 2119, 13, 22, 17, 3, -22 },
  { 2155, 10, 27, 17, 3, -22 },
  { 2189, 13, 21, 17, 3, -21 },
  { 2224, 15, 21, 17, 1, -21 },
  { 2264, 13, 16, 17, 2, -16 },
  { 2290, 12, 16, 17, 3, -16 },
  { 2314, 12, 16, 17, 3, -16 },
  { 2338, 12, 21, 17, 3, -16 },
  { 2370, 12, 21, 17, 3, -16 },
  { 2402, 12, 16, 17, 3, -16 },
  { 2426, 12, 16, 17, 3, -16 },
  { 2450, 13, 20, 17, 2, -20 },
  { 2483, 12, 16, 17, 3, -16 },
  { 2507, 14, 16, 17, 2, -16 },
  { 2535, 15, 16, 17, 1, -16 },
  { 2565, 14, 16, 17, 2, -16 },
  { 2593, 14, 21, 17, 2, -16 },
  { 2630, 12, 16, 17, 3, -16 },
  { 2654, 12, 27, 17, 3, -24 },
  { 2695, 2, 27, 17, 8, -24 },
  { 2702, 12, 27, 17, 3, -24 },
  { 2743, 13, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_Light29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_LIGHT29PT7B_H_
