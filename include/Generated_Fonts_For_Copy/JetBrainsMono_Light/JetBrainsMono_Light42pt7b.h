#ifndef _JETBRAINSMONO_LIGHT42PT7B_H_
#define _JETBRAINSMONO_LIGHT42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light42pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x3E, 0xFF, 0xEF,
  0x80, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xE0, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x06, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80, 0xE0, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x60,
  0x38, 0x00, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x00, 0x1C, 0x06, 0x00, 0x30, 0x1C, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x18, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x06,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x87, 0xCC, 0xF0, 0xE1, 0x8F, 0x3C, 0x30, 0xE7, 0x06, 0x1C, 0xE0, 0xC3,
  0xDC, 0x18, 0x03, 0xC3, 0x00, 0x78, 0x60, 0x07, 0x8C, 0x00, 0xF9, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x67, 0xC0, 0x0C, 0x78, 0x01, 0x87, 0x80, 0x30, 0xF0, 0x06, 0x0F,
  0xE0, 0xC1, 0xFC, 0x18, 0x3F, 0x83, 0x0F, 0x78, 0x61, 0xCF, 0x8C, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00,
  0x07, 0x3F, 0xC0, 0x0E, 0x7F, 0xC0, 0x1C, 0xE0, 0xE0, 0x18, 0xE0, 0xE0,
  0x38, 0xE0, 0xE0, 0x70, 0xE0, 0xE0, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1,
  0xC0, 0xE0, 0xE3, 0x80, 0xE0, 0xE3, 0x80, 0xFB, 0xE7, 0x00, 0x7F, 0xCE,
  0x00, 0x1F, 0x8C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x71, 0xF0, 0x00, 0xE3, 0xFC, 0x00, 0xC7, 0xFC, 0x01, 0xCE,
  0x0E, 0x03, 0x8E, 0x0E, 0x03, 0x0E, 0x06, 0x07, 0x0E, 0x06, 0x0E, 0x0E,
  0x06, 0x1C, 0x0E, 0x06, 0x1C, 0x0E, 0x0E, 0x38, 0x0E, 0x0E, 0x70, 0x07,
  0xBE, 0x60, 0x07, 0xFC, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0x83, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x0E, 0x03,
  0xC0, 0x38, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x79, 0xE0, 0x39, 0xC3, 0xC1, 0xEF, 0x07, 0x87, 0x3C,
  0x0E, 0x38, 0xF0, 0x3D, 0xE3, 0xC0, 0x7F, 0x0F, 0x00, 0xFC, 0x3C, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1F, 0x07, 0x00, 0xFC, 0x1E, 0x07, 0xF8,
  0x7F, 0xFC, 0xF0, 0xFF, 0xE1, 0xE0, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0x7E, 0x0F, 0x81, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x08, 0x07, 0x00, 0xBC, 0x1C, 0x0E,
  0xFC, 0x71, 0xFB, 0xFC, 0xDF, 0xF3, 0xFA, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0x70, 0x00, 0x03, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0xF3, 0x80, 0x07, 0x8F,
  0x00, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x80, 0xF0, 0x1C, 0x01, 0xC0,
  0x10, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1F, 0x8F, 0x87, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x70,
  0x78, 0x38, 0x1C, 0x0E, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0x07, 0xC7, 0x80, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE1,
  0xC3, 0xFC, 0x7C, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x1C, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0x80,
  0x0F, 0x70, 0x01, 0xEE, 0x00, 0x39, 0xE0, 0x0F, 0x1E, 0x03, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x07, 0xEF, 0x01, 0xF1, 0xE0, 0x3C, 0x3C, 0x06, 0x07,
  0x80, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0x80, 0x3C, 0xE0, 0x07, 0xBC, 0x00,
  0x77, 0x80, 0x0E, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x80, 0x39, 0xF0,
  0x1E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x1C, 0xF0, 0x0E, 0x78, 0x07, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCE, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x7F, 0x0F, 0x7F, 0xE7, 0xFF, 0xFB, 0xF0, 0x3D, 0xF0, 0x0F,
  0xF0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xEF,
  0x01, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xEF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF0, 0x7E, 0x78, 0x03,
  0xCE, 0x00, 0x3B, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x0F,
  0x1E, 0x03, 0xE3, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x77, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0x80, 0x3C,
  0xF0, 0x07, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCF, 0x00, 0x78,
  0xE0, 0x0F, 0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x1F, 0x7C, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x0F, 0xFE, 0x03, 0xE1, 0xE0, 0xF0, 0x1E, 0x3C, 0x01, 0xE7,
  0x00, 0x1C, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x70, 0x01, 0xEE,
  0x00, 0x39, 0xE0, 0x0F, 0x1E, 0x03, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7,
  0x80, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xE0, 0x03, 0xDE,
  0x00, 0xF3, 0xE0, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF, 0x70, 0x1F, 0xDE, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xEF, 0xFF, 0xFF,
  0xBE, 0x04, 0x0F, 0x8F, 0xE7, 0xF3, 0xF8, 0xF8, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x47, 0xC3, 0xE1,
  0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x3E, 0x0F, 0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3C, 0x03, 0xC3, 0xC0, 0x0F, 0x3C, 0x00,
  0x39, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7F, 0x7E, 0x07, 0xFD, 0xF0, 0x3C, 0x3F, 0x83, 0xC0,
  0xFC, 0x1C, 0x07, 0xE0, 0xE0, 0x3F, 0x07, 0x01, 0xF8, 0x38, 0x0F, 0xC1,
  0xC0, 0x7E, 0x0E, 0x03, 0xF0, 0x70, 0x1F, 0x83, 0x80, 0xFC, 0x1C, 0x07,
  0xE0, 0xF0, 0x3F, 0x03, 0x83, 0xF8, 0x1F, 0xF7, 0xC0, 0x7F, 0x3E, 0x00,
  0x60, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x39,
  0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x0E, 0x00,
  0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1E, 0x01, 0xE0, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x3C, 0x03, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x3F, 0xC0,
  0x01, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0xFC, 0xE0,
  0x0F, 0xB8, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x0F, 0x38, 0x0F, 0x8F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFF, 0x38, 0x03, 0xEE, 0x00, 0x7B, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7B, 0x80, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x3C, 0x78, 0x07, 0xBC,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xE7, 0x00,
  0x79, 0xE0, 0x3C, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x0F, 0xCE, 0x00, 0xF7, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xDC, 0x03, 0xEF, 0xFF, 0xE7,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x3C, 0x78, 0x07, 0xBC,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xE7, 0x00,
  0x79, 0xE0, 0x3C, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xCE, 0x00, 0x39, 0xE0, 0x0F, 0x3E, 0x03,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0x3B, 0x80, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03,
  0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0x83, 0x80, 0xF0, 0x70, 0x1C,
  0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1E, 0x0E, 0x03, 0xC1, 0xC0, 0x3C,
  0x38, 0x07, 0x87, 0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0x80, 0x1E,
  0x70, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0D, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xDC, 0x0D, 0xFB, 0x83, 0xBF, 0x30, 0x77, 0xE7,
  0x0C, 0xFC, 0xE3, 0x9F, 0x8C, 0x73, 0xF1, 0xCC, 0x7E, 0x3B, 0x8F, 0xE3,
  0x71, 0xFC, 0x6C, 0x3F, 0x8F, 0x87, 0xF0, 0xF0, 0xFE, 0x1C, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xB8, 0x0F, 0xDC, 0x07, 0xEE,
  0x03, 0xF3, 0x81, 0xF9, 0xC0, 0xFC, 0x70, 0x7E, 0x38, 0x3F, 0x1C, 0x1F,
  0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0x71, 0xF8, 0x38, 0xFC, 0x0E,
  0x7E, 0x07, 0x3F, 0x03, 0x9F, 0x80, 0xEF, 0xC0, 0x77, 0xE0, 0x3B, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1E,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0x77, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xDC, 0x01, 0xEF, 0x01, 0xE3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x70, 0x0F, 0xCE, 0x00, 0x7D, 0xC0, 0x07, 0xB8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1D, 0xC0, 0x07, 0xB8, 0x01, 0xE7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x79, 0xE0, 0x3C, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x1F, 0xCE, 0x00, 0x79,
  0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0x38, 0x07, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E,
  0x03, 0xC1, 0xC0, 0x78, 0x38, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x0F, 0x1C,
  0x01, 0xE3, 0x80, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x3D, 0xC0, 0x07, 0xB8,
  0x00, 0x78, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x03, 0xC3,
  0x80, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0x3E, 0x01, 0xE3, 0xFF, 0xF8, 0x3F,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xDC, 0x01, 0xEF,
  0x01, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0, 0xF0, 0x00, 0x7B, 0x80,
  0x03, 0xDC, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x0F, 0x1C, 0x00, 0x78,
  0xE0, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x00,
  0x70, 0x3C, 0x03, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xE0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0F, 0x0E,
  0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x79, 0xC0, 0x01,
  0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x3C, 0x0F, 0xC0, 0x78, 0x1F,
  0xC0, 0xF0, 0x3B, 0x83, 0xE0, 0x77, 0x06, 0xC1, 0xEE, 0x0D, 0x83, 0x9C,
  0x1B, 0x07, 0x38, 0x36, 0x0E, 0x70, 0x6C, 0x1C, 0xE0, 0xDC, 0x39, 0xC1,
  0x98, 0x71, 0xC7, 0x30, 0xE3, 0x8C, 0x61, 0xC7, 0x18, 0xC7, 0x0E, 0x31,
  0x8E, 0x1C, 0x63, 0x1C, 0x38, 0xC6, 0x38, 0x71, 0x8E, 0x70, 0xE3, 0x0C,
  0xE1, 0xCE, 0x19, 0xC1, 0xD8, 0x33, 0x83, 0xB0, 0x66, 0x07, 0x60, 0xCC,
  0x0E, 0xC1, 0xB8, 0x1D, 0x83, 0x70, 0x3B, 0x07, 0xE0, 0x76, 0x07, 0xC0,
  0xFC, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x00, 0x7B, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x78, 0x03, 0xC1, 0xC0,
  0x1E, 0x0F, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x00,
  0x3C, 0x78, 0x00, 0xF3, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0xBC, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x1E,
  0x01, 0xE0, 0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x0E, 0x0F, 0x00, 0x78, 0x70,
  0x01, 0xC7, 0x80, 0x0F, 0x38, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x1C, 0x38, 0x00, 0xF0,
  0xF0, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x3C,
  0x0E, 0x00, 0x70, 0x78, 0x01, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x38,
  0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0x70,
  0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C, 0x1C, 0x07, 0x07, 0x03,
  0x80, 0xE0, 0xE0, 0x38, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x7E, 0xFE, 0x3C, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x3F, 0xFF, 0x3F, 0xFF, 0xDF,
  0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x0F, 0x78, 0x07, 0xDF, 0x8F, 0x73, 0xFF, 0x9C, 0x7F, 0xC7,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x80, 0xE3, 0xFC, 0x73, 0xFF, 0x3B, 0xDF, 0xDF,
  0x01, 0xEF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFD, 0x01, 0xEE,
  0xFF, 0xF7, 0x3F, 0xF3, 0x8F, 0xF0, 0x00, 0x80, 0x03, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x78, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xEF, 0x00,
  0x3B, 0xC0, 0x1E, 0x78, 0x0F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x02, 0x07, 0x1F, 0xE3, 0x9F, 0xFD, 0xDF, 0xDE, 0xEF,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x01, 0xF7,
  0xF7, 0xB9, 0xFF, 0xDC, 0x3F, 0x8E, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF,
  0x87, 0xC7, 0xE7, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xFE, 0x00,
  0xF7, 0x80, 0x79, 0xF9, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01,
  0x00, 0x07, 0xF1, 0xCF, 0xFE, 0xEF, 0xEF, 0x77, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xDE, 0x03, 0xEF, 0xEF, 0x73, 0xFF, 0xB8, 0x7F, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x03,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x80,
  0xE3, 0xFC, 0x73, 0xFF, 0x3B, 0xCF, 0xDD, 0x01, 0xEF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0E, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFE,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xFE, 0x00,
  0x7B, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1E,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x39, 0xE0, 0x07,
  0xBC, 0x00, 0x78, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x02, 0x02, 0x1D, 0xF9, 0xFB, 0xFF, 0x7F,
  0x78, 0xF8, 0xFE, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07,
  0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F,
  0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F,
  0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F,
  0x07, 0x07, 0x00, 0x40, 0x71, 0xFE, 0x39, 0xFF, 0x9D, 0xEF, 0xEE, 0x80,
  0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF,
  0x01, 0xEF, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xE3,
  0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x40, 0x71, 0xFE, 0x39, 0xFF,
  0x9D, 0xEF, 0xEF, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x80, 0xF7, 0x7F, 0xFB, 0x9F, 0xF9, 0xC7, 0xF8, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x01, 0x00, 0x0F, 0xF1, 0xCF, 0xFE, 0xEF, 0xEF, 0x77, 0x80,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0xFB, 0xFB,
  0xDC, 0xFF, 0xCE, 0x1F, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x40,
  0x73, 0xFC, 0x3B, 0xFF, 0x9D, 0xC7, 0xEF, 0x80, 0xF7, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xE0, 0x1E, 0xF0, 0x03,
  0xBC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3B, 0xE0, 0x1E, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xDC, 0x01,
  0xEF, 0x01, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0xE0, 0x00, 0xFF,
  0x00, 0x0E, 0xF0, 0x01, 0xE7, 0x00, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C,
  0x38, 0x03, 0x83, 0xC0, 0x38, 0x3C, 0x07, 0x81, 0xC0, 0x70, 0x1E, 0x07,
  0x01, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x70, 0x1F, 0x81, 0xC0,
  0xEE, 0x07, 0x83, 0xB8, 0x36, 0x0E, 0xE0, 0xD8, 0x39, 0x83, 0x60, 0xE7,
  0x0D, 0x83, 0x1C, 0x36, 0x0C, 0x70, 0xCC, 0x71, 0xC6, 0x31, 0xC7, 0x18,
  0xC7, 0x0C, 0x63, 0x1C, 0x39, 0x8C, 0x60, 0xE6, 0x39, 0x83, 0x98, 0x6E,
  0x0E, 0xC1, 0xB8, 0x3B, 0x06, 0xE0, 0xEC, 0x1B, 0x81, 0xB0, 0x6C, 0x06,
  0xC1, 0xB0, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x00, 0xF1, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x78,
  0x03, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xDC, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xEE, 0x00,
  0x0F, 0x78, 0x00, 0x71, 0xE0, 0x07, 0x87, 0x00, 0x78, 0x3C, 0x07, 0x80,
  0xF0, 0x3C, 0x03, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x7B, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0xFF, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03,
  0xC3, 0x80, 0x3C, 0x3C, 0x03, 0x81, 0xC0, 0x78, 0x1E, 0x07, 0x01, 0xE0,
  0x70, 0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x07,
  0x9C, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x3F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0x80, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0xEF, 0xF0, 0x1D, 0xFF, 0x03, 0xF8, 0xF0, 0x7E, 0x0F, 0x0F,
  0xC0, 0xF3, 0xF8, 0x0F, 0xF7, 0x00, 0xFC,
};

const GFXglyph JetBrainsMono_Light42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 31, 25, 10, -31 },
  { 25, 12, 13, 25, 7, -31 },
  { 45, 23, 31, 25, 1, -31 },
  { 135, 19, 43, 25, 3, -37 },
  { 238, 24, 31, 25, 1, -31 },
  { 331, 22, 31, 25, 2, -31 },
  { 417, 3, 13, 25, 11, -31 },
  { 422, 12, 40, 25, 8, -35 },
  { 482, 12, 40, 25, 5, -35 },
  { 542, 22, 22, 25, 2, -26 },
  { 603, 19, 20, 25, 3, -24 },
  { 651, 9, 13, 25, 7, -6 },
  { 666, 13, 3, 25, 6, -15 },
  { 671, 7, 6, 25, 9, -6 },
  { 677, 19, 40, 25, 3, -35 },
  { 772, 19, 31, 25, 3, -31 },
  { 846, 19, 31, 25, 4, -31 },
  { 920, 19, 31, 25, 3, -31 },
  { 994, 18, 31, 25, 3, -31 },
  { 1064, 17, 31, 25, 4, -31 },
  { 1130, 17, 31, 25, 4, -31 },
  { 1196, 19, 31, 25, 3, -31 },
  { 1270, 19, 31, 25, 3, -31 },
  { 1344, 19, 31, 25, 3, -31 },
  { 1418, 19, 31, 25, 3, -31 },
  { 1492, 7, 24, 25, 9, -24 },
  { 1513, 9, 31, 25, 7, -24 },
  { 1548, 18, 22, 25, 4, -25 },
  { 1598, 18, 13, 25, 4, -20 },
  { 1628, 18, 22, 25, 4, -25 },
  { 1678, 15, 31, 25, 6, -31 },
  { 1737, 21, 39, 25, 2, -31 },
  { 1840, 21, 31, 25, 2, -31 },
  { 1922, 18, 31, 25, 4, -31 },
  { 1992, 18, 31, 25, 4, -31 },
  { 2062, 17, 31, 25, 4, -31 },
  { 2128, 18, 31, 25, 4, -31 },
  { 2198, 18, 31, 25, 4, -31 },
  { 2268, 18, 31, 25, 4, -31 },
  { 2338, 17, 31, 25, 4, -31 },
  { 2404, 16, 31, 25, 5, -31 },
  { 2466, 19, 31, 25, 2, -31 },
  { 2540, 19, 31, 25, 4, -31 },
  { 2614, 17, 31, 25, 5, -31 },
  { 2680, 19, 31, 25, 3, -31 },
  { 2754, 17, 31, 25, 4, -31 },
  { 2820, 17, 31, 25, 4, -31 },
  { 2886, 19, 31, 25, 4, -31 },
  { 2960, 18, 39, 25, 4, -31 },
  { 3048, 19, 31, 25, 4, -31 },
  { 3122, 19, 31, 25, 3, -31 },
  { 3196, 21, 31, 25, 2, -31 },
  { 3278, 17, 31, 25, 4, -31 },
  { 3344, 21, 31, 25, 2, -31 },
  { 3426, 23, 31, 25, 1, -31 },
  { 3516, 21, 31, 25, 2, -31 },
  { 3598, 22, 31, 25, 2, -31 },
  { 3684, 18, 31, 25, 4, -31 },
  { 3754, 10, 40, 25, 9, -35 },
  { 3804, 19, 40, 25, 3, -35 },
  { 3899, 10, 40, 25, 6, -35 },
  { 3949, 18, 17, 25, 4, -31 },
  { 3988, 20, 3, 25, 3, 1 },
  { 3996, 8, 6, 25, 8, -33 },
  { 4002, 18, 24, 25, 3, -24 },
  { 4056, 17, 31, 25, 4, -31 },
  { 4122, 18, 24, 25, 4, -24 },
  { 4176, 17, 31, 25, 4, -31 },
  { 4242, 17, 24, 25, 4, -24 },
  { 4293, 19, 31, 25, 3, -31 },
  { 4367, 17, 32, 25, 4, -24 },
  { 4435, 17, 31, 25, 4, -31 },
  { 4501, 19, 33, 25, 4, -33 },
  { 4580, 15, 41, 25, 4, -33 },
  { 4657, 19, 31, 25, 4, -31 },
  { 4731, 22, 31, 25, 1, -31 },
  { 4817, 19, 24, 25, 3, -24 },
  { 4874, 17, 24, 25, 4, -24 },
  { 4925, 17, 23, 25, 4, -23 },
  { 4974, 17, 32, 25, 4, -24 },
  { 5042, 17, 32, 25, 4, -24 },
  { 5110, 17, 24, 25, 5, -24 },
  { 5161, 18, 23, 25, 4, -23 },
  { 5213, 20, 30, 25, 2, -30 },
  { 5288, 17, 23, 25, 4, -23 },
  { 5337, 20, 23, 25, 3, -23 },
  { 5395, 22, 23, 25, 2, -23 },
  { 5459, 21, 23, 25, 2, -23 },
  { 5520, 20, 31, 25, 3, -23 },
  { 5598, 17, 23, 25, 4, -23 },
  { 5647, 17, 40, 25, 4, -35 },
  { 5732, 3, 40, 25, 11, -35 },
  { 5747, 17, 40, 25, 4, -35 },
  { 5832, 19, 8, 25, 3, -19 },
};

const GFXfont JetBrainsMono_Light42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_LIGHT42PT7B_H_
