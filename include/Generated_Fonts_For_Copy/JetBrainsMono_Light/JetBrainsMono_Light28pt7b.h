#ifndef _JETBRAINSMONO_LIGHT28PT7B_H_
#define _JETBRAINSMONO_LIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light28pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x66, 0x62, 0x22, 0x00, 0x07, 0xF7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0x63, 0x63, 0x63, 0x06, 0x18, 0x0C, 0x30, 0x10,
  0x60, 0x60, 0xC0, 0xC1, 0x8F, 0xFF, 0xDF, 0xFF, 0x84, 0x18, 0x08, 0x30,
  0x30, 0x60, 0x60, 0x80, 0xC3, 0x01, 0x86, 0x1F, 0xFF, 0x8C, 0x18, 0x18,
  0x20, 0x30, 0xC0, 0x61, 0x80, 0x83, 0x03, 0x06, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0E, 0x01, 0xFC, 0x1D, 0x71, 0xC8, 0xCC, 0x46, 0x62, 0x33,
  0x10, 0x18, 0x80, 0xE4, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x4E, 0x02,
  0x30, 0x11, 0xC0, 0x8F, 0x84, 0x7E, 0x23, 0x39, 0x38, 0xFF, 0x83, 0xF8,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x18, 0x00, 0x3E, 0x03, 0x63,
  0x06, 0x63, 0x0C, 0x43, 0x0C, 0x43, 0x18, 0x43, 0x30, 0x63, 0x30, 0x7E,
  0x60, 0x1C, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x3E, 0x02, 0x77, 0x06,
  0x63, 0x0C, 0x43, 0x08, 0x43, 0x18, 0x43, 0x30, 0x63, 0x60, 0x7F, 0xE0,
  0x3E, 0x0F, 0x00, 0xFE, 0x07, 0x9C, 0x18, 0x38, 0x60, 0x61, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xC0, 0x33, 0x87, 0xC7, 0x3B,
  0x0C, 0xCC, 0x1F, 0x30, 0x78, 0xC0, 0xE3, 0x03, 0x8C, 0x1B, 0x3F, 0xCE,
  0x7E, 0x1C, 0xFF, 0xFD, 0xB6, 0x00, 0x81, 0xC3, 0xE3, 0x83, 0x81, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1E, 0x07, 0xC0, 0xE0,
  0x80, 0xE0, 0xF0, 0x3C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x0E, 0x1C,
  0x38, 0xF0, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x04, 0x30,
  0xDF, 0x27, 0xDF, 0x7E, 0x03, 0xE0, 0x03, 0x80, 0x0D, 0x80, 0x33, 0x80,
  0xE3, 0x83, 0x83, 0x83, 0x06, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x00, 0x39, 0xDC, 0xE6, 0x33, 0x98, 0xFF, 0xFF, 0xC0,
  0x77, 0xFE, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x00, 0x07, 0x03,
  0xFC, 0x78, 0xE6, 0x07, 0x60, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x63, 0xE7, 0x3E, 0x73, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36,
  0x03, 0x70, 0x73, 0xFE, 0x1F, 0xC0, 0x1E, 0x03, 0xE0, 0xF6, 0x0C, 0x60,
  0x86, 0x08, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0x0F, 0x01, 0xFE, 0x1E, 0x38, 0xC0, 0xEE, 0x03, 0x60, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F,
  0xF7, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xF8, 0x0F,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x77, 0x06, 0x3F, 0xE1, 0xF8, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x33, 0x03, 0x70, 0x36, 0x03, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x7F,
  0xF7, 0xFF, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0xFC, 0x7F,
  0xE7, 0x07, 0x60, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3E, 0x03, 0x60,
  0x37, 0x07, 0x3F, 0xE1, 0xFC, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x06, 0x20, 0x7F, 0xE3, 0xC7, 0x98, 0x1D, 0xC0,
  0x6C, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x60, 0x33, 0x83, 0x8F, 0xF8,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x6E, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0x0F,
  0x03, 0xFC, 0x38, 0xE7, 0x07, 0x60, 0x36, 0x03, 0x60, 0x37, 0x07, 0x38,
  0xE1, 0xFC, 0x0F, 0x01, 0xDC, 0x30, 0xE6, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x36, 0x03, 0x70, 0x73, 0xFE, 0x1F, 0xC0, 0x07, 0x01, 0xFE, 0x1E, 0x38,
  0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x3F, 0x01, 0x9C,
  0x1C, 0x7F, 0xE1, 0xF6, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x67, 0xBF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x7F, 0xEE, 0x39, 0xF7, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0xE7, 0x1C, 0x71, 0x8E, 0x30, 0x00, 0x10, 0x03, 0x00, 0xF0,
  0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x00, 0x70, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x0E, 0x00, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x8F, 0xC3, 0xE0, 0xC0, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x3F, 0xE0,
  0xE0, 0xE1, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0x98, 0x01, 0xE0, 0x23, 0xC1,
  0xF7, 0x87, 0x1F, 0x0C, 0x3E, 0x18, 0x3C, 0x30, 0x78, 0x60, 0xF0, 0xC1,
  0xE1, 0x87, 0xC3, 0x0F, 0x87, 0x3F, 0x07, 0xDB, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x78,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0C, 0xC0, 0x63, 0x03, 0x18, 0x18, 0xC1,
  0x87, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x3F, 0xF9, 0x80, 0xCC, 0x06, 0xE0,
  0x36, 0x01, 0xF0, 0x07, 0x80, 0x30, 0xFF, 0x8F, 0xFC, 0xC0, 0xEC, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF8, 0xC3, 0xCC, 0x0E,
  0xC0, 0x6C, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF0,
  0x0E, 0x07, 0xF1, 0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x03, 0xC0, 0x78,
  0x0F, 0x83, 0xBF, 0xE3, 0xF8, 0xFF, 0x9F, 0xFB, 0x03, 0x60, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x3B, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x07, 0xF1, 0xC7, 0x70,
  0x7C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x63, 0xFC,
  0x7F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xBF, 0xE3, 0xF8,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x30, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC3, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0x80, 0xEC, 0x07, 0x60, 0x33,
  0x83, 0x8F, 0xF8, 0x3F, 0x80, 0xC0, 0x76, 0x03, 0x30, 0x39, 0x81, 0x8C,
  0x1C, 0x60, 0xC3, 0x0E, 0x18, 0x60, 0xFF, 0x07, 0xF0, 0x31, 0xC1, 0x86,
  0x0C, 0x38, 0x60, 0xC3, 0x07, 0x18, 0x18, 0xC0, 0xE6, 0x03, 0x30, 0x1D,
  0x80, 0x70, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC,
  0x17, 0xB1, 0xBD, 0x8D, 0xEC, 0x4F, 0x36, 0x79, 0xB7, 0xCD, 0x3E, 0x39,
  0xF1, 0xCF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x70, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xB0, 0xF6, 0x1E, 0x63, 0xCC, 0x79, 0x8F, 0x19, 0xE3, 0x3C, 0x67, 0x86,
  0xF0, 0xDE, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x70, 0x0E, 0x07, 0xF1,
  0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xBF,
  0xE3, 0xF8, 0xFF, 0xCF, 0xFE, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7F, 0xFE, 0xFF, 0xCC, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x01, 0xFE, 0x1E,
  0x38, 0xE0, 0xE6, 0x03, 0x70, 0x1B, 0x80, 0xDC, 0x06, 0xE0, 0x37, 0x01,
  0xB8, 0x0D, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x80, 0xDC, 0x06, 0xE0, 0x33,
  0x01, 0x9C, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0xFF, 0x8F, 0xFE, 0xC0, 0xEC, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0xEF, 0xFC, 0xFF, 0x8C, 0x30, 0xC3, 0x0C, 0x38,
  0xC1, 0x8C, 0x1C, 0xC0, 0xCC, 0x0E, 0xC0, 0x6C, 0x07, 0x07, 0x00, 0xFF,
  0x0E, 0x38, 0xE0, 0xE6, 0x03, 0x30, 0x19, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0xC0,
  0x3F, 0x01, 0x9C, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC1,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x1D, 0xFF, 0x1F, 0xC0, 0xC0, 0x1E, 0x00,
  0xF8, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x39, 0xC1, 0x86, 0x0C, 0x30, 0x61,
  0x87, 0x0E, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0xE0, 0x76, 0x01, 0xB0, 0x0D,
  0x80, 0x6C, 0x03, 0xC0, 0x0E, 0x00, 0xC3, 0x87, 0x85, 0x0F, 0x0A, 0x1E,
  0x14, 0x7C, 0x28, 0xCC, 0xD1, 0x99, 0xA3, 0x33, 0x66, 0x66, 0xCC, 0xC9,
  0x99, 0x91, 0x33, 0x22, 0x66, 0x44, 0x8D, 0x8B, 0x0F, 0x16, 0x1E, 0x3C,
  0x3C, 0x78, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xC0, 0x70, 0x1C, 0x60, 0x30,
  0xE0, 0xE0, 0xC1, 0x81, 0xC6, 0x01, 0x8C, 0x03, 0xB0, 0x03, 0x60, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x36, 0x00, 0xEC, 0x01, 0x8C, 0x07, 0x1C,
  0x0C, 0x18, 0x38, 0x38, 0x60, 0x31, 0xC0, 0x77, 0x00, 0x70, 0xE0, 0x0E,
  0xC0, 0x38, 0xC0, 0x61, 0x81, 0xC3, 0x83, 0x03, 0x06, 0x07, 0x18, 0x06,
  0x30, 0x0E, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xFF, 0xFC, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xFC, 0x07,
  0x00, 0xD0, 0x0D, 0x80, 0xD8, 0x18, 0xC1, 0x8C, 0x30, 0x63, 0x06, 0x60,
  0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x87, 0x07, 0x01, 0xFC,
  0x38, 0xE6, 0x07, 0x60, 0x30, 0x03, 0x00, 0x31, 0xFF, 0x7F, 0xFE, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0x7F, 0xB3, 0xF3, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x61, 0xBF, 0xBC, 0x77, 0x07, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x1F, 0xFF, 0x6F,
  0xC0, 0x0E, 0x07, 0xF1, 0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x3C, 0x07, 0xC1, 0xDF, 0xF1, 0xFC, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0xC6, 0xFE, 0xFC, 0x7E, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xFC, 0x1D,
  0xFD, 0x9F, 0x30, 0x0E, 0x07, 0xF1, 0xC7, 0x60, 0x7C, 0x07, 0x80, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x07, 0xC1, 0xDF, 0xF1,
  0xFC, 0x03, 0xF8, 0x3F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x03, 0xFF,
  0xFF, 0xFF, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x0C, 0x0F,
  0xEF, 0xC7, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x7E, 0x1E, 0xFE, 0xCF, 0x98, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x9F, 0xE3, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x61, 0xBF, 0xBC,
  0x77, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0x02, 0x00, 0x3C, 0x01, 0xE0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x3C, 0x07, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x03, 0x9F, 0xE3, 0xF8, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x07, 0xC0, 0xEC, 0x0C, 0xC1, 0xCC, 0x38,
  0xC3, 0x0F, 0xE0, 0xFF, 0x0C, 0x30, 0xC3, 0x8C, 0x18, 0xC1, 0xCC, 0x0E,
  0xC0, 0x6C, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3F,
  0xC0, 0x7F, 0x0C, 0x67, 0xF7, 0xB9, 0xCF, 0x8C, 0x3C, 0x61, 0xE3, 0x0F,
  0x18, 0x78, 0xC3, 0xC6, 0x1E, 0x30, 0xF1, 0x87, 0x8C, 0x3C, 0x61, 0xE3,
  0x0F, 0x18, 0x78, 0xC3, 0x06, 0x1B, 0xFB, 0xC7, 0x70, 0x7C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x0E, 0x07, 0xF1, 0xCF, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0xDF, 0xF1, 0xFC,
  0x06, 0x1B, 0xFB, 0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0xFF, 0xF6, 0xFC, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x0F, 0xEF, 0xC7, 0xF0, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0xC1,
  0xDF, 0xD9, 0xF3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x07, 0x0D,
  0xFC, 0xD0, 0xEE, 0x06, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x1E, 0x0F,
  0xFB, 0xC7, 0xE0, 0x3C, 0x01, 0x80, 0x38, 0x03, 0xF8, 0x3F, 0xC0, 0x3C,
  0x01, 0x80, 0x3C, 0x07, 0xC0, 0xFF, 0xF9, 0xFE, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0xF0, 0x3F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7E, 0x0C, 0xFF, 0x8F, 0xE0, 0xC0,
  0x1F, 0x01, 0x98, 0x0C, 0xC0, 0x67, 0x06, 0x18, 0x30, 0xC1, 0x87, 0x18,
  0x18, 0xC0, 0xC6, 0x07, 0x60, 0x1B, 0x00, 0xD8, 0x07, 0x80, 0x1C, 0x00,
  0xC3, 0x87, 0x87, 0x09, 0x8A, 0x33, 0x14, 0x66, 0x28, 0xCC, 0xD1, 0x99,
  0xB3, 0x32, 0x64, 0x24, 0x58, 0x68, 0xB0, 0xD1, 0x61, 0xE2, 0xC3, 0xC7,
  0x87, 0x0E, 0x0E, 0x1C, 0x00, 0xE0, 0x3B, 0x83, 0x8C, 0x38, 0x31, 0x81,
  0xDC, 0x06, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x80, 0xEC, 0x06, 0x30, 0x71,
  0xC7, 0x06, 0x30, 0x1B, 0x80, 0xE0, 0xE0, 0x3F, 0x01, 0x98, 0x0C, 0xE0,
  0xE3, 0x06, 0x18, 0x30, 0xE3, 0x83, 0x18, 0x1C, 0xC0, 0x6C, 0x03, 0x60,
  0x1F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x1F, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0xFE, 0x0F, 0xE0, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x0F, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0xF0, 0x7F, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0xFC, 0x0F, 0x80, 0x30, 0x1B, 0xE0, 0xFB, 0x87, 0x8E, 0x7C, 0x3F,
  0x60, 0x70,
};

const GFXglyph JetBrainsMono_Light28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 20, 17, 6, -20 },
  { 11, 8, 8, 17, 4, -20 },
  { 19, 15, 20, 17, 1, -20 },
  { 57, 13, 28, 17, 2, -24 },
  { 103, 16, 21, 17, 0, -21 },
  { 145, 14, 21, 17, 2, -21 },
  { 182, 3, 8, 17, 7, -20 },
  { 185, 9, 27, 17, 5, -24 },
  { 216, 8, 27, 17, 3, -24 },
  { 243, 15, 14, 17, 1, -17 },
  { 270, 13, 13, 17, 2, -16 },
  { 292, 5, 8, 17, 5, -4 },
  { 297, 9, 2, 17, 4, -10 },
  { 300, 5, 4, 17, 6, -4 },
  { 303, 13, 26, 17, 2, -23 },
  { 346, 12, 21, 17, 2, -21 },
  { 378, 12, 20, 17, 3, -20 },
  { 408, 13, 21, 17, 2, -21 },
  { 443, 12, 20, 17, 2, -20 },
  { 473, 12, 20, 17, 2, -20 },
  { 503, 12, 20, 17, 2, -20 },
  { 533, 13, 20, 17, 2, -20 },
  { 566, 13, 20, 17, 2, -20 },
  { 599, 12, 21, 17, 2, -21 },
  { 631, 13, 21, 17, 2, -21 },
  { 666, 5, 16, 17, 6, -16 },
  { 676, 6, 20, 17, 5, -16 },
  { 691, 12, 15, 17, 2, -17 },
  { 714, 12, 9, 17, 2, -14 },
  { 728, 12, 15, 17, 2, -17 },
  { 751, 10, 20, 17, 4, -20 },
  { 776, 15, 26, 17, 1, -21 },
  { 825, 13, 20, 17, 2, -20 },
  { 858, 12, 20, 17, 3, -20 },
  { 888, 11, 21, 17, 3, -21 },
  { 917, 11, 20, 17, 3, -20 },
  { 945, 11, 20, 17, 3, -20 },
  { 973, 12, 20, 17, 3, -20 },
  { 1003, 11, 21, 17, 3, -21 },
  { 1032, 11, 20, 17, 3, -20 },
  { 1060, 11, 20, 17, 3, -20 },
  { 1088, 13, 20, 17, 1, -20 },
  { 1121, 13, 20, 17, 3, -20 },
  { 1154, 12, 20, 17, 3, -20 },
  { 1184, 13, 20, 17, 2, -20 },
  { 1217, 11, 20, 17, 3, -20 },
  { 1245, 11, 21, 17, 3, -21 },
  { 1274, 12, 20, 17, 3, -20 },
  { 1304, 13, 26, 17, 2, -21 },
  { 1347, 12, 20, 17, 3, -20 },
  { 1377, 13, 21, 17, 2, -21 },
  { 1412, 13, 20, 17, 2, -20 },
  { 1445, 11, 20, 17, 3, -20 },
  { 1473, 13, 20, 17, 2, -20 },
  { 1506, 15, 20, 17, 1, -20 },
  { 1544, 15, 20, 17, 1, -20 },
  { 1582, 15, 20, 17, 1, -20 },
  { 1620, 12, 20, 17, 2, -20 },
  { 1650, 7, 26, 17, 6, -23 },
  { 1673, 13, 26, 17, 2, -23 },
  { 1716, 7, 26, 17, 4, -23 },
  { 1739, 12, 10, 17, 2, -20 },
  { 1754, 13, 2, 17, 2, 1 },
  { 1758, 6, 4, 17, 5, -22 },
  { 1761, 12, 16, 17, 2, -16 },
  { 1785, 11, 20, 17, 3, -20 },
  { 1813, 11, 16, 17, 3, -16 },
  { 1835, 11, 20, 17, 3, -20 },
  { 1863, 11, 16, 17, 3, -16 },
  { 1885, 13, 20, 17, 2, -20 },
  { 1918, 11, 21, 17, 3, -16 },
  { 1947, 11, 20, 17, 3, -20 },
  { 1975, 13, 22, 17, 2, -22 },
  { 2011, 11, 27, 17, 2, -22 },
  { 2049, 12, 20, 17, 3, -20 },
  { 2079, 14, 20, 17, 1, -20 },
  { 2114, 13, 16, 17, 2, -16 },
  { 2140, 11, 16, 17, 3, -16 },
  { 2162, 11, 16, 17, 3, -16 },
  { 2184, 11, 21, 17, 3, -16 },
  { 2213, 11, 21, 17, 3, -16 },
  { 2242, 12, 16, 17, 3, -16 },
  { 2266, 11, 16, 17, 3, -16 },
  { 2288, 12, 20, 17, 2, -20 },
  { 2318, 11, 15, 17, 3, -15 },
  { 2339, 13, 15, 17, 2, -15 },
  { 2364, 15, 15, 17, 1, -15 },
  { 2393, 13, 15, 17, 2, -15 },
  { 2418, 13, 20, 17, 2, -15 },
  { 2451, 11, 15, 17, 3, -15 },
  { 2472, 12, 26, 17, 2, -23 },
  { 2511, 3, 26, 17, 7, -23 },
  { 2521, 12, 26, 17, 2, -23 },
  { 2560, 13, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_Light28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_LIGHT28PT7B_H_
