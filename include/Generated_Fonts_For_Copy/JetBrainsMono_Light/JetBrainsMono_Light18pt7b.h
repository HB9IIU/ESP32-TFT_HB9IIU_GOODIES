#ifndef _JETBRAINSMONO_LIGHT18PT7B_H_
#define _JETBRAINSMONO_LIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light18pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x40, 0x7E, 0x9C, 0xE7, 0x18, 0x80, 0x11, 0x08,
  0x8C, 0x44, 0x6F, 0xF9, 0x10, 0x88, 0x44, 0xFF, 0xA2, 0x11, 0x08, 0x84,
  0x40, 0x08, 0x08, 0x08, 0x3E, 0x6B, 0x49, 0x48, 0x68, 0x38, 0x1E, 0x0B,
  0x09, 0x09, 0xC9, 0x6B, 0x3E, 0x08, 0x08, 0x08, 0x78, 0x79, 0x13, 0x22,
  0x64, 0x84, 0xA0, 0x6C, 0x01, 0x00, 0x5E, 0x1A, 0x42, 0x48, 0x89, 0x31,
  0x2C, 0x3C, 0x3C, 0x33, 0x10, 0x88, 0x06, 0x01, 0x83, 0x41, 0x93, 0x8F,
  0x43, 0x21, 0x99, 0xE7, 0x98, 0xF8, 0x0C, 0x62, 0x18, 0x41, 0x0C, 0x30,
  0xC3, 0x0C, 0x10, 0x41, 0x82, 0x06, 0x0C, 0xC3, 0x0C, 0x30, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x8C, 0xCC, 0xC0, 0x08, 0x04, 0x02, 0x1D, 0x77, 0xF0,
  0xC0, 0xD0, 0x4C, 0x63, 0x00, 0x08, 0x04, 0x02, 0x1F, 0xFF, 0xF8, 0x40,
  0x20, 0x10, 0x76, 0x64, 0xC8, 0xFF, 0xC0, 0x5F, 0x80, 0x01, 0x03, 0x02,
  0x02, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x60,
  0x60, 0xC0, 0x3E, 0x63, 0x41, 0xC1, 0xC1, 0xC9, 0xD9, 0xC1, 0xC1, 0x41,
  0x41, 0x63, 0x3E, 0x38, 0x78, 0x98, 0x98, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0x3E, 0x63, 0xC1, 0xC1, 0x01, 0x03, 0x06, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x7F, 0x7F, 0x03, 0x06, 0x0C, 0x18, 0x1E, 0x03,
  0x01, 0x01, 0xC1, 0xC3, 0x63, 0x3E, 0x0C, 0x10, 0x61, 0x82, 0x0C, 0xF1,
  0xC3, 0x87, 0xFC, 0x18, 0x30, 0x60, 0xFF, 0x02, 0x04, 0x09, 0x9F, 0xB1,
  0x81, 0x02, 0x06, 0x0E, 0x37, 0xC0, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x7E,
  0x63, 0xC1, 0xC1, 0xC1, 0x41, 0x63, 0x3E, 0xFF, 0xE0, 0xB0, 0x40, 0x60,
  0x20, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x00, 0x3E, 0x63,
  0x41, 0x41, 0x63, 0x36, 0x1C, 0x62, 0x41, 0xC1, 0x41, 0x63, 0x3E, 0x3E,
  0x63, 0xC1, 0xC1, 0xC1, 0x41, 0x63, 0x3E, 0x06, 0x04, 0x0C, 0x18, 0x30,
  0xFD, 0x00, 0x00, 0xFC, 0x77, 0x20, 0x00, 0x03, 0x66, 0x44, 0xC0, 0x02,
  0x0C, 0x73, 0x8C, 0x18, 0x1C, 0x0E, 0x06, 0x04, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0xC7, 0x38, 0xC1, 0x00, 0xF0,
  0x60, 0xC3, 0x0C, 0x27, 0x90, 0x40, 0x00, 0x38, 0xE0, 0x3E, 0x30, 0xB0,
  0x70, 0x18, 0x6C, 0x4E, 0x63, 0x31, 0x98, 0xCC, 0x62, 0x71, 0xD8, 0x06,
  0x01, 0x80, 0x78, 0x1C, 0x0E, 0x05, 0x02, 0x83, 0x61, 0x30, 0x88, 0xC4,
  0x7F, 0x21, 0x90, 0x58, 0x2C, 0x18, 0xFD, 0x0E, 0x0C, 0x18, 0x71, 0xBF,
  0x43, 0x83, 0x06, 0x0C, 0x3F, 0xC0, 0x7D, 0x8E, 0x0C, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x06, 0x0E, 0x37, 0xC0, 0xF9, 0x0A, 0x1C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x1C, 0x6F, 0x80, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xFF,
  0xC0, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0xC0, 0x81, 0x02, 0x04, 0x08, 0x00, 0x7D, 0x8E, 0x0C, 0x08, 0x10, 0x27,
  0xCF, 0x83, 0x06, 0x0E, 0x37, 0xC0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x1F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x83, 0xC3, 0xC6, 0x7C, 0x83, 0x86, 0x84, 0x8C, 0x88,
  0x98, 0xF8, 0x88, 0x8C, 0x84, 0x86, 0x82, 0x83, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xE3, 0xE3, 0xE3,
  0xF5, 0xD5, 0xD5, 0xD9, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0x87,
  0x8D, 0x1A, 0x36, 0x64, 0xC9, 0x8B, 0x16, 0x3C, 0x38, 0x60, 0x7D, 0x8E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x37, 0xC0, 0xFC, 0x86,
  0x83, 0x83, 0x83, 0x82, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7D,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x37, 0xC1, 0x81,
  0x03, 0xFC, 0x86, 0x82, 0x83, 0x82, 0x86, 0xFC, 0x88, 0x8C, 0x8C, 0x86,
  0x86, 0x83, 0x3E, 0x63, 0x41, 0x40, 0x60, 0x30, 0x1E, 0x03, 0x01, 0x01,
  0xC1, 0x63, 0x3E, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0E, 0x37, 0xC0, 0xC1, 0xE0, 0x90, 0x48, 0x66, 0x33,
  0x10, 0x88, 0x4C, 0x36, 0x0A, 0x05, 0x02, 0x81, 0x80, 0x88, 0xCC, 0x65,
  0x32, 0x99, 0x5C, 0xAF, 0x55, 0xAA, 0x55, 0x32, 0x98, 0xCC, 0x66, 0x30,
  0xC1, 0xB1, 0x98, 0x86, 0xC1, 0x40, 0xE0, 0x60, 0x38, 0x34, 0x13, 0x18,
  0xC8, 0x2C, 0x18, 0x81, 0xA0, 0x90, 0xCC, 0x42, 0x61, 0xA0, 0x70, 0x30,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xFE, 0x0C, 0x10, 0x60, 0x83, 0x04,
  0x10, 0x60, 0x83, 0x04, 0x0F, 0xE0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0xF0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08,
  0x0C, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x03, 0x01, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xF0, 0x30, 0x50, 0xA2, 0x64, 0x50, 0xE0, 0x80,
  0xFF, 0xFF, 0xC0, 0xC3, 0x3E, 0x63, 0x41, 0x01, 0x3F, 0x61, 0xC1, 0xC1,
  0x43, 0x7D, 0x81, 0x02, 0x05, 0xEC, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0E,
  0x3B, 0xC0, 0x7D, 0x8E, 0x0C, 0x08, 0x10, 0x20, 0x41, 0xC6, 0xF8, 0x02,
  0x04, 0x0B, 0xDC, 0x70, 0xE0, 0xC1, 0x83, 0x06, 0x1E, 0x37, 0xA0, 0x7D,
  0x8E, 0x0C, 0x1F, 0xF0, 0x20, 0x41, 0xC6, 0xF8, 0x0F, 0x8C, 0x04, 0x02,
  0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x7B,
  0x8E, 0x1C, 0x18, 0x30, 0x60, 0xE3, 0x7A, 0x04, 0x08, 0x37, 0xC0, 0x81,
  0x02, 0x05, 0xEC, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x18,
  0x38, 0x00, 0x00, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0x0C, 0x30, 0x00, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC6, 0xF0, 0x80, 0x80, 0x80, 0x83, 0x86, 0x8C, 0x88, 0xF8, 0xF8, 0x8C,
  0x84, 0x86, 0x83, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0x00, 0xF8, 0xFF, 0x64, 0xB2, 0x79, 0x3C, 0x9E,
  0x4F, 0x27, 0x93, 0xC9, 0xE4, 0xC0, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x04, 0x7D, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC6, 0xF8,
  0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC7, 0x7A, 0x04, 0x08, 0x00,
  0x7B, 0x8E, 0x1C, 0x18, 0x30, 0x60, 0xC3, 0xC6, 0xF4, 0x08, 0x10, 0x20,
  0xBC, 0xA6, 0xC2, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7D, 0x8E,
  0x06, 0x0F, 0x83, 0xC0, 0x81, 0xC6, 0xF8, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xC6, 0xF8, 0xC1, 0xA0, 0x90, 0xCC, 0x62, 0x21, 0x10,
  0xD8, 0x28, 0x14, 0x0E, 0x00, 0x88, 0xCC, 0x65, 0x32, 0xBD, 0x52, 0xA9,
  0x54, 0xCA, 0x63, 0x31, 0x80, 0xC1, 0xB1, 0x89, 0x82, 0x81, 0xC0, 0xE0,
  0xD0, 0x4C, 0x63, 0x60, 0xC0, 0xC1, 0xA0, 0x98, 0xCC, 0x42, 0x21, 0xB0,
  0x50, 0x28, 0x1C, 0x04, 0x06, 0x02, 0x03, 0x00, 0xFE, 0x0C, 0x30, 0x41,
  0x86, 0x18, 0x20, 0x81, 0xFC, 0x0E, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0xE0, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0E, 0xFF, 0xFF, 0x80, 0xC0,
  0xC0, 0xC1, 0x83, 0x04, 0x08, 0x18, 0x0E, 0x60, 0x81, 0x03, 0x06, 0x0C,
  0x30, 0xC0, 0x71, 0xEC, 0xF3, 0xC0,
};

const GFXglyph JetBrainsMono_Light18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -13 },
  { 10, 9, 13, 11, 1, -13 },
  { 25, 8, 19, 11, 1, -16 },
  { 44, 11, 13, 11, 0, -13 },
  { 62, 9, 13, 11, 1, -13 },
  { 77, 1, 5, 11, 5, -13 },
  { 78, 6, 17, 11, 3, -15 },
  { 91, 5, 17, 11, 2, -15 },
  { 102, 9, 9, 11, 1, -11 },
  { 113, 9, 8, 11, 1, -10 },
  { 122, 4, 6, 11, 3, -3 },
  { 125, 5, 2, 11, 3, -7 },
  { 127, 3, 3, 11, 4, -3 },
  { 129, 8, 17, 11, 1, -15 },
  { 146, 8, 13, 11, 1, -13 },
  { 159, 8, 13, 11, 2, -13 },
  { 172, 8, 13, 11, 1, -13 },
  { 185, 8, 13, 11, 1, -13 },
  { 198, 7, 13, 11, 2, -13 },
  { 210, 7, 13, 11, 2, -13 },
  { 222, 8, 13, 11, 1, -13 },
  { 235, 9, 13, 11, 1, -13 },
  { 250, 8, 13, 11, 1, -13 },
  { 263, 8, 13, 11, 1, -13 },
  { 276, 3, 10, 11, 4, -10 },
  { 280, 4, 13, 11, 3, -10 },
  { 287, 7, 10, 11, 2, -11 },
  { 296, 7, 6, 11, 2, -9 },
  { 302, 7, 10, 11, 2, -11 },
  { 311, 6, 13, 11, 3, -13 },
  { 321, 9, 16, 11, 1, -13 },
  { 339, 9, 13, 11, 1, -13 },
  { 354, 7, 13, 11, 2, -13 },
  { 366, 7, 13, 11, 2, -13 },
  { 378, 7, 13, 11, 2, -13 },
  { 390, 7, 13, 11, 2, -13 },
  { 402, 7, 13, 11, 2, -13 },
  { 414, 7, 13, 11, 2, -13 },
  { 426, 7, 13, 11, 2, -13 },
  { 438, 7, 13, 11, 2, -13 },
  { 450, 8, 13, 11, 1, -13 },
  { 463, 8, 13, 11, 2, -13 },
  { 476, 8, 13, 11, 2, -13 },
  { 489, 8, 13, 11, 1, -13 },
  { 502, 7, 13, 11, 2, -13 },
  { 514, 7, 13, 11, 2, -13 },
  { 526, 8, 13, 11, 2, -13 },
  { 539, 7, 16, 11, 2, -13 },
  { 553, 8, 13, 11, 2, -13 },
  { 566, 8, 13, 11, 1, -13 },
  { 579, 9, 13, 11, 1, -13 },
  { 594, 7, 13, 11, 2, -13 },
  { 606, 9, 13, 11, 1, -13 },
  { 621, 9, 13, 11, 1, -13 },
  { 636, 9, 13, 11, 1, -13 },
  { 651, 9, 13, 11, 1, -13 },
  { 666, 7, 13, 11, 2, -13 },
  { 678, 4, 17, 11, 4, -15 },
  { 687, 8, 17, 11, 1, -15 },
  { 704, 4, 17, 11, 3, -15 },
  { 713, 7, 7, 11, 2, -13 },
  { 720, 9, 2, 11, 1, 0 },
  { 723, 4, 2, 11, 3, -14 },
  { 724, 8, 10, 11, 1, -10 },
  { 734, 7, 13, 11, 2, -13 },
  { 746, 7, 10, 11, 2, -10 },
  { 755, 7, 13, 11, 2, -13 },
  { 767, 7, 10, 11, 2, -10 },
  { 776, 9, 13, 11, 1, -13 },
  { 791, 7, 13, 11, 2, -10 },
  { 803, 7, 13, 11, 2, -13 },
  { 815, 8, 14, 11, 2, -14 },
  { 829, 6, 17, 11, 2, -14 },
  { 842, 8, 13, 11, 2, -13 },
  { 855, 9, 13, 11, 1, -13 },
  { 870, 9, 10, 11, 1, -10 },
  { 882, 7, 10, 11, 2, -10 },
  { 891, 7, 10, 11, 2, -10 },
  { 900, 7, 13, 11, 2, -10 },
  { 912, 7, 13, 11, 2, -10 },
  { 924, 8, 10, 11, 2, -10 },
  { 934, 7, 10, 11, 2, -10 },
  { 943, 8, 13, 11, 1, -13 },
  { 956, 7, 10, 11, 2, -10 },
  { 965, 9, 10, 11, 1, -10 },
  { 977, 9, 10, 11, 1, -10 },
  { 989, 9, 10, 11, 1, -10 },
  { 1001, 9, 13, 11, 1, -10 },
  { 1016, 7, 10, 11, 2, -10 },
  { 1025, 7, 17, 11, 2, -15 },
  { 1040, 1, 17, 11, 5, -15 },
  { 1043, 7, 17, 11, 2, -15 },
  { 1058, 9, 3, 11, 1, -8 },
};

const GFXfont JetBrainsMono_Light18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_LIGHT18PT7B_H_
