#ifndef _JETBRAINSMONO_LIGHT15PT7B_H_
#define _JETBRAINSMONO_LIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light15pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x0B, 0x80, 0xDE, 0xF7, 0xBC, 0x80, 0x22, 0x48,
  0x97, 0xF4, 0x48, 0x91, 0x7F, 0x48, 0x92, 0x20, 0x10, 0x20, 0xF2, 0xAD,
  0x3A, 0x1C, 0x1C, 0x14, 0x26, 0x4E, 0xB7, 0xC2, 0x04, 0x00, 0x71, 0xC8,
  0xA4, 0x92, 0x87, 0x40, 0x40, 0x5C, 0x29, 0x24, 0xA2, 0x71, 0xC0, 0x78,
  0x99, 0x02, 0x06, 0x1C, 0x24, 0xC6, 0x8D, 0x19, 0xC8, 0xF8, 0x13, 0x4C,
  0x88, 0x88, 0x88, 0x8C, 0x43, 0x10, 0x8C, 0x23, 0x11, 0x11, 0x11, 0x13,
  0x2C, 0x80, 0x10, 0x22, 0x4B, 0xE3, 0x05, 0x11, 0x22, 0x10, 0x20, 0x47,
  0xF1, 0x02, 0x04, 0x00, 0x7A, 0x40, 0xF8, 0xFC, 0x06, 0x08, 0x30, 0x40,
  0x83, 0x04, 0x08, 0x20, 0x41, 0x82, 0x04, 0x18, 0x00, 0x7C, 0x8B, 0x1C,
  0x18, 0x32, 0x60, 0xC1, 0x82, 0x89, 0xF0, 0x38, 0xF2, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x33, 0xF8, 0x7C, 0x8A, 0x18, 0x30, 0x41, 0x82, 0x08,
  0x20, 0x83, 0xF8, 0x7C, 0x08, 0x20, 0x83, 0x80, 0x81, 0x83, 0x87, 0x89,
  0xE0, 0x0C, 0x21, 0x0C, 0x21, 0x1C, 0x7F, 0xFC, 0x10, 0x40, 0x7C, 0x81,
  0x02, 0x07, 0xC8, 0x81, 0x83, 0x86, 0x89, 0xF0, 0x18, 0x20, 0xC1, 0x05,
  0x8C, 0xB0, 0xC1, 0x82, 0x89, 0xF0, 0xFF, 0x06, 0x10, 0x20, 0xC1, 0x02,
  0x0C, 0x10, 0x60, 0x80, 0x7C, 0x8B, 0x1A, 0x26, 0xC7, 0x11, 0x63, 0x83,
  0x8D, 0xF0, 0x7C, 0x8A, 0x0C, 0x18, 0x28, 0xCF, 0x04, 0x18, 0x20, 0xC0,
  0xE8, 0x00, 0x3F, 0xE8, 0x00, 0x56, 0x90, 0x02, 0x18, 0xC6, 0x0C, 0x06,
  0x03, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x63, 0x18,
  0x40, 0xF0, 0xC2, 0x10, 0xB9, 0x08, 0x03, 0x18, 0x7D, 0x86, 0x0C, 0x19,
  0xF2, 0x64, 0xC9, 0x93, 0x3E, 0x04, 0x06, 0x07, 0x00, 0x10, 0x50, 0xA1,
  0x42, 0x88, 0x91, 0x3E, 0xC7, 0x06, 0x08, 0xF9, 0x8B, 0x1E, 0x3C, 0x5F,
  0xB1, 0xE1, 0xC3, 0x8F, 0xF0, 0x3C, 0x8B, 0x0E, 0x0C, 0x18, 0x30, 0x60,
  0xC2, 0x89, 0xF0, 0xF9, 0x8B, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8B,
  0xE0, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFF, 0x83,
  0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83, 0x00, 0x3C, 0x8B, 0x0E, 0x0C,
  0x1B, 0xF7, 0xE1, 0xC2, 0x89, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1,
  0xE3, 0xC7, 0x8F, 0x18, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x3C,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x87, 0x17, 0x80, 0xC3, 0x8B, 0x16, 0x4C,
  0x9F, 0x32, 0x66, 0xC5, 0x8F, 0x08, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x0F, 0xC0, 0xC7, 0x8E, 0xAD, 0x5A, 0xB2, 0x60, 0xC1, 0x83, 0x06,
  0x08, 0xC7, 0xCF, 0x9F, 0x3D, 0x7A, 0xF5, 0xE7, 0xCF, 0x9F, 0x18, 0x7C,
  0x8B, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x89, 0xF0, 0xFD, 0x8F, 0x0E,
  0x1C, 0x3F, 0xB0, 0x60, 0xC1, 0x83, 0x00, 0x7C, 0x8B, 0x1C, 0x18, 0x30,
  0x60, 0xC1, 0xC6, 0x89, 0xF0, 0x40, 0x40, 0xC0, 0xFD, 0x8F, 0x0E, 0x1C,
  0x7F, 0xB2, 0x64, 0xC5, 0x8B, 0x18, 0x3C, 0x8B, 0x0E, 0x06, 0x07, 0x01,
  0x01, 0x83, 0x8D, 0xF0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x89, 0xF0,
  0x83, 0x07, 0x1A, 0x24, 0x48, 0x8A, 0x14, 0x28, 0x50, 0x40, 0xC9, 0xA4,
  0x95, 0x4A, 0xA5, 0x52, 0xA9, 0x54, 0xAA, 0x55, 0x11, 0x08, 0x80, 0x82,
  0x89, 0x91, 0x43, 0x82, 0x0A, 0x14, 0x45, 0x8E, 0x08, 0x83, 0x8D, 0x12,
  0x22, 0x85, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x08, 0x10, 0x41, 0x82,
  0x08, 0x10, 0x41, 0x83, 0xF8, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F,
  0xC0, 0x81, 0x81, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40,
  0xC0, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x50, 0xA2, 0x24,
  0x58, 0xC0, 0xFE, 0x8C, 0x7D, 0x88, 0x1B, 0xFC, 0x70, 0xF1, 0xBF, 0xC1,
  0x83, 0x07, 0xEC, 0x78, 0xF1, 0xE3, 0xC7, 0x8B, 0xF0, 0x7C, 0x8F, 0x06,
  0x0C, 0x18, 0xD1, 0x3E, 0x06, 0x0C, 0x1B, 0xFC, 0x78, 0xF1, 0xE3, 0xC6,
  0x8D, 0xF8, 0x7C, 0x8B, 0x1F, 0xFC, 0x18, 0x11, 0xBE, 0x1E, 0x60, 0xC1,
  0x8F, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x7E, 0x8F, 0x1E, 0x3C, 0x68,
  0xDF, 0x83, 0x06, 0x09, 0xE0, 0xC1, 0x83, 0x07, 0xEC, 0x58, 0xF1, 0xE3,
  0xC7, 0x8F, 0x18, 0x10, 0x30, 0x00, 0x07, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x47, 0xF0, 0x08, 0x30, 0x00, 0x78, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x6F, 0x00, 0xC1, 0x83, 0x06, 0x3C, 0x59, 0x3E, 0x64, 0xCD, 0x8B, 0x08,
  0xE0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x78, 0xFF, 0x26,
  0x4C, 0x99, 0x32, 0x64, 0xC9, 0xFD, 0x8B, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0x7C, 0x8B, 0x1E, 0x3C, 0x78, 0xD1, 0x3E, 0xFD, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0x7E, 0xC1, 0x83, 0x00, 0x7E, 0x8F, 0x1E, 0x3C, 0x78, 0xD1, 0xBF,
  0x06, 0x0C, 0x18, 0xFA, 0x38, 0x60, 0x82, 0x08, 0x20, 0x7C, 0x8D, 0x03,
  0xC0, 0xC0, 0x71, 0xBE, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20,
  0x60, 0x78, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xD1, 0x3E, 0x82, 0x89, 0x12,
  0x22, 0x85, 0x0A, 0x08, 0x93, 0x66, 0xAD, 0x5A, 0xAD, 0x9B, 0x22, 0xC6,
  0xD8, 0xA0, 0x83, 0x85, 0x11, 0x63, 0xC2, 0x89, 0x13, 0x62, 0x85, 0x06,
  0x08, 0x10, 0x40, 0x80, 0x7C, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x7F, 0x0E,
  0x30, 0x60, 0xC1, 0x83, 0x3C, 0x08, 0x18, 0x30, 0x60, 0xC0, 0x80, 0xC0,
  0xFF, 0xFC, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x07, 0x88, 0x30, 0x60, 0xC1,
  0x82, 0x18, 0x00, 0x63, 0x26, 0x38,
};

const GFXglyph JetBrainsMono_Light15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 2, -11 },
  { 10, 7, 11, 9, 1, -11 },
  { 20, 7, 15, 9, 1, -13 },
  { 34, 9, 11, 9, 0, -11 },
  { 47, 7, 11, 9, 1, -11 },
  { 57, 1, 5, 9, 4, -11 },
  { 58, 4, 15, 9, 3, -13 },
  { 66, 4, 15, 9, 2, -13 },
  { 74, 7, 8, 9, 1, -9 },
  { 81, 7, 7, 9, 1, -8 },
  { 88, 3, 4, 9, 3, -2 },
  { 90, 5, 1, 9, 2, -5 },
  { 91, 3, 2, 9, 3, -2 },
  { 92, 7, 14, 9, 1, -12 },
  { 105, 7, 11, 9, 1, -11 },
  { 115, 7, 11, 9, 1, -11 },
  { 125, 7, 11, 9, 1, -11 },
  { 135, 7, 11, 9, 1, -11 },
  { 145, 6, 11, 9, 1, -11 },
  { 154, 7, 11, 9, 1, -11 },
  { 164, 7, 11, 9, 1, -11 },
  { 174, 7, 11, 9, 1, -11 },
  { 184, 7, 11, 9, 1, -11 },
  { 194, 7, 11, 9, 1, -11 },
  { 204, 3, 8, 9, 3, -8 },
  { 207, 3, 10, 9, 3, -8 },
  { 211, 7, 8, 9, 1, -9 },
  { 218, 7, 4, 9, 1, -7 },
  { 222, 7, 8, 9, 1, -9 },
  { 229, 5, 11, 9, 2, -11 },
  { 236, 7, 14, 9, 1, -11 },
  { 249, 7, 11, 9, 1, -11 },
  { 259, 7, 11, 9, 1, -11 },
  { 269, 7, 11, 9, 1, -11 },
  { 279, 7, 11, 9, 1, -11 },
  { 289, 6, 11, 9, 2, -11 },
  { 298, 7, 11, 9, 1, -11 },
  { 308, 7, 11, 9, 1, -11 },
  { 318, 7, 11, 9, 1, -11 },
  { 328, 5, 11, 9, 2, -11 },
  { 335, 6, 11, 9, 1, -11 },
  { 344, 7, 11, 9, 1, -11 },
  { 354, 6, 11, 9, 2, -11 },
  { 363, 7, 11, 9, 1, -11 },
  { 373, 7, 11, 9, 1, -11 },
  { 383, 7, 11, 9, 1, -11 },
  { 393, 7, 11, 9, 1, -11 },
  { 403, 7, 14, 9, 1, -11 },
  { 416, 7, 11, 9, 1, -11 },
  { 426, 7, 11, 9, 1, -11 },
  { 436, 7, 11, 9, 1, -11 },
  { 446, 7, 11, 9, 1, -11 },
  { 456, 7, 11, 9, 1, -11 },
  { 466, 9, 11, 9, 0, -11 },
  { 479, 7, 11, 9, 1, -11 },
  { 489, 7, 11, 9, 1, -11 },
  { 499, 7, 11, 9, 1, -11 },
  { 509, 4, 14, 9, 3, -12 },
  { 516, 7, 14, 9, 1, -12 },
  { 529, 4, 14, 9, 2, -12 },
  { 536, 7, 6, 9, 1, -11 },
  { 542, 7, 1, 9, 1, 0 },
  { 543, 3, 2, 9, 3, -12 },
  { 544, 7, 8, 9, 1, -8 },
  { 551, 7, 11, 9, 1, -11 },
  { 561, 7, 8, 9, 1, -8 },
  { 568, 7, 11, 9, 1, -11 },
  { 578, 7, 8, 9, 1, -8 },
  { 585, 7, 11, 9, 1, -11 },
  { 595, 7, 11, 9, 1, -8 },
  { 605, 7, 11, 9, 1, -11 },
  { 615, 7, 12, 9, 1, -12 },
  { 626, 6, 15, 9, 1, -12 },
  { 638, 7, 11, 9, 1, -11 },
  { 648, 7, 11, 9, 1, -11 },
  { 658, 7, 8, 9, 1, -8 },
  { 665, 7, 8, 9, 1, -8 },
  { 672, 7, 8, 9, 1, -8 },
  { 679, 7, 11, 9, 1, -8 },
  { 689, 7, 11, 9, 1, -8 },
  { 699, 6, 8, 9, 2, -8 },
  { 705, 7, 8, 9, 1, -8 },
  { 712, 7, 11, 9, 1, -11 },
  { 722, 7, 8, 9, 1, -8 },
  { 729, 7, 8, 9, 1, -8 },
  { 736, 7, 8, 9, 1, -8 },
  { 743, 7, 8, 9, 1, -8 },
  { 750, 7, 11, 9, 1, -8 },
  { 760, 7, 8, 9, 1, -8 },
  { 767, 7, 14, 9, 1, -12 },
  { 780, 1, 14, 9, 4, -12 },
  { 782, 7, 14, 9, 1, -12 },
  { 795, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_Light15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_LIGHT15PT7B_H_
