#ifndef _JETBRAINSMONO_LIGHT54PT7B_H_
#define _JETBRAINSMONO_LIGHT54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light54pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0x7F, 0x7E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0xF0, 0x07, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x38, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0,
  0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0x00, 0x07, 0x80, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x07, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x70, 0x07, 0x80, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x9C, 0xFC, 0x3E, 0x1C,
  0x7E, 0x3C, 0x1C, 0x3E, 0x7C, 0x1C, 0x1E, 0x7C, 0x1C, 0x1F, 0x78, 0x1C,
  0x1F, 0x78, 0x1C, 0x0F, 0x7C, 0x1C, 0x00, 0x7C, 0x1C, 0x00, 0x3C, 0x1C,
  0x00, 0x3E, 0x1C, 0x00, 0x3F, 0x1C, 0x00, 0x1F, 0x9C, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1C, 0xFE, 0x00, 0x1C, 0x3E, 0x00, 0x1C,
  0x1F, 0x00, 0x1C, 0x1F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C,
  0x0F, 0xF0, 0x1C, 0x0F, 0xF8, 0x1C, 0x0F, 0xF8, 0x1C, 0x0F, 0x78, 0x1C,
  0x1F, 0x7C, 0x1C, 0x3E, 0x3E, 0x1C, 0x7E, 0x3F, 0xDD, 0xFC, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x02, 0x3F,
  0xE0, 0x00, 0x78, 0xFF, 0xE0, 0x00, 0xE3, 0xFF, 0xE0, 0x03, 0xC7, 0x83,
  0xC0, 0x0F, 0x1E, 0x03, 0xC0, 0x1C, 0x3C, 0x07, 0x80, 0x70, 0x78, 0x0F,
  0x01, 0xE0, 0xF0, 0x1E, 0x03, 0x81, 0xE0, 0x3C, 0x0E, 0x03, 0xC0, 0x78,
  0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x01, 0xE1, 0xC0, 0x1E, 0x03, 0x87,
  0x80, 0x1E, 0x0F, 0x1E, 0x00, 0x3F, 0xFE, 0x38, 0x00, 0x3F, 0xF8, 0xF0,
  0x00, 0x3F, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x0F, 0x1F, 0xF8, 0x00, 0x1C, 0x7F, 0xF8, 0x00, 0x70, 0xFF, 0xF0,
  0x01, 0xE3, 0xC0, 0xF0, 0x07, 0x87, 0x81, 0xE0, 0x0E, 0x0E, 0x01, 0xC0,
  0x3C, 0x1C, 0x03, 0x80, 0xF0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x07,
  0x80, 0xE0, 0x1C, 0x1E, 0x01, 0xC0, 0x38, 0x38, 0x03, 0x80, 0x70, 0xF0,
  0x07, 0x81, 0xE3, 0xC0, 0x0F, 0x87, 0xC7, 0x00, 0x0F, 0xFF, 0x1C, 0x00,
  0x0F, 0xFC, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x81, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x3E, 0xF8,
  0x3E, 0x03, 0xCF, 0x81, 0xE0, 0x7C, 0xF0, 0x1F, 0x07, 0x8F, 0x00, 0xF8,
  0xF0, 0xF0, 0x07, 0xDF, 0x0F, 0x00, 0x3D, 0xE0, 0xF0, 0x03, 0xFE, 0x0F,
  0x00, 0x1F, 0xC0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x03, 0xFE, 0x07, 0xC0, 0x7F, 0xF0,
  0x7F, 0x1F, 0xCF, 0x83, 0xFF, 0xF8, 0x7C, 0x1F, 0xFE, 0x03, 0xC0, 0xFF,
  0xC0, 0x3F, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0x67, 0xC0, 0xF0,
  0x3F, 0xFF, 0x87, 0x0F, 0xFF, 0xFC, 0x73, 0xFF, 0x3F, 0xF6, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x8F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0x00, 0x0E,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x3F, 0xBF, 0xDF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x1F, 0xC3, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xDE, 0x00, 0x1F, 0x9E,
  0x00, 0x7F, 0x1E, 0x00, 0xFC, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0xC0, 0x1E, 0x00, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xF1,
  0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3D,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0xE0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0xFE, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xE0, 0x03, 0xE7,
  0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x7C, 0xF0, 0x00, 0xF9, 0xF8, 0x03, 0xE1, 0xFE, 0x7F, 0x81, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x3F, 0xC0, 0x1E, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1E,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x1F, 0xC3, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3C, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0x80, 0xFC, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C,
  0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F,
  0xC1, 0xF0, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F,
  0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x28, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0x78, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x7F, 0xBF, 0xDF, 0xFF, 0xF7, 0xF9, 0xFC, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0x7F, 0xBF, 0xFF, 0xEF, 0xF3, 0xF0,
  0x20, 0x0F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFE, 0x0F, 0xE0,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFC, 0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0xEF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xE0, 0xFF, 0xC0, 0xF8, 0x0F, 0xF8, 0x1E, 0x00, 0xFF, 0x03, 0xC0, 0x1F,
  0xE0, 0x78, 0x03, 0xFC, 0x0F, 0x00, 0x7F, 0x81, 0xE0, 0x0F, 0xF0, 0x3C,
  0x01, 0xFE, 0x07, 0x80, 0x3F, 0xC0, 0xF0, 0x07, 0xF8, 0x1E, 0x00, 0xFF,
  0x03, 0xC0, 0x1F, 0xE0, 0x78, 0x03, 0xFC, 0x0F, 0x00, 0x7F, 0x81, 0xE0,
  0x0F, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xE0, 0xDF, 0xC0, 0x3F, 0xFB, 0xF8,
  0x07, 0xFE, 0x7F, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x1E,
  0x00, 0x7C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x78,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0x80, 0xFF, 0xCF, 0x00, 0x1F, 0x9E,
  0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x0F, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0x00, 0xFF, 0x9E, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xC0,
  0x07, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x7C, 0x00,
  0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3C, 0xF0, 0x00, 0x79, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xFC, 0x7F,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3E, 0x07, 0xFC, 0xF8,
  0x03, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00,
  0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xF0, 0x01, 0xF1, 0xF0, 0x07,
  0xC3, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x00,
  0xF8, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xEE,
  0x00, 0x7F, 0xEE, 0x00, 0x7F, 0xFF, 0x00, 0x77, 0xF7, 0x00, 0xF7, 0xF7,
  0x00, 0xF7, 0xF7, 0x80, 0xE7, 0xF3, 0x81, 0xE7, 0xF3, 0x81, 0xEF, 0xF3,
  0xC1, 0xCF, 0xF1, 0xC3, 0xCF, 0xF1, 0xC3, 0xCF, 0xF1, 0xE3, 0x8F, 0xF0,
  0xE3, 0x8F, 0xF0, 0xE7, 0x8F, 0xF0, 0xF7, 0x0F, 0xF0, 0x77, 0x0F, 0xF0,
  0x7F, 0x0F, 0xF0, 0x7E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x70, 0x03, 0xFD, 0xE0, 0x0F,
  0xF7, 0x80, 0x3F, 0xCF, 0x00, 0xFF, 0x3C, 0x03, 0xFC, 0xF0, 0x0F, 0xF1,
  0xE0, 0x3F, 0xC7, 0x80, 0xFF, 0x0E, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0,
  0x3F, 0xC1, 0xC0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x3C, 0x3F,
  0xC0, 0xF0, 0xFF, 0x03, 0xC3, 0xFC, 0x07, 0x8F, 0xF0, 0x1E, 0x3F, 0xC0,
  0x38, 0xFF, 0x00, 0xF3, 0xFC, 0x03, 0xCF, 0xF0, 0x07, 0xBF, 0xC0, 0x1E,
  0xFF, 0x00, 0x7B, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x7F,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0x03, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xF7,
  0xC0, 0x07, 0x9F, 0x80, 0x7E, 0x3F, 0xCF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x07, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7E, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3D, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x0F, 0xC3,
  0xF8, 0x7F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x17, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xF8, 0x07, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x01, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0x7E, 0x3C, 0x00, 0x3E, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x7E, 0x3F, 0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x8F,
  0xE3, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06,
  0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7D, 0xE0,
  0x00, 0x1E, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8,
  0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x78,
  0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x7F,
  0x80, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x1D, 0xE0, 0x1F, 0x01, 0xEF, 0x01,
  0xD8, 0x0F, 0x78, 0x0E, 0xC0, 0x7B, 0xC0, 0x76, 0x03, 0xDE, 0x03, 0xB8,
  0x1E, 0x78, 0x1D, 0xC0, 0xF3, 0xC0, 0xEE, 0x07, 0x9E, 0x06, 0x70, 0x3C,
  0xF0, 0x73, 0x81, 0xC7, 0x83, 0x9C, 0x1E, 0x3C, 0x1C, 0x60, 0xF1, 0xE0,
  0xE3, 0x07, 0x8F, 0x07, 0x1C, 0x3C, 0x38, 0x38, 0xE1, 0xE1, 0xE1, 0x87,
  0x0F, 0x0F, 0x0C, 0x38, 0x78, 0x78, 0xE1, 0xC3, 0x83, 0xC7, 0x0E, 0x1C,
  0x1E, 0x38, 0x30, 0xE0, 0xF1, 0xC1, 0x8F, 0x07, 0x8E, 0x0E, 0x78, 0x3C,
  0x70, 0x73, 0xC0, 0xE3, 0x03, 0x9E, 0x07, 0x98, 0x1C, 0xF0, 0x3D, 0xC0,
  0xE7, 0x81, 0xEE, 0x07, 0x38, 0x0F, 0x70, 0x39, 0xC0, 0x7B, 0x80, 0xCE,
  0x03, 0xDC, 0x06, 0xF0, 0x1E, 0xE0, 0x3F, 0x80, 0x76, 0x01, 0xFC, 0x03,
  0xB0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0,
  0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0xF8, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0xF1, 0xC0,
  0x01, 0xC3, 0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x38, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC1, 0xF0, 0x0F, 0xC7, 0xC0, 0x07, 0xCF, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x7E, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x01, 0xFD, 0xFC, 0x07, 0x79, 0xFF, 0xFE,
  0xF1, 0xFF, 0xF9, 0xE1, 0xFF, 0xC3, 0xC0, 0x10, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0xFF, 0x03, 0xE7, 0xFF, 0x07, 0x9F, 0xFF, 0x8F, 0x7F, 0xFF, 0x1E,
  0xE0, 0x3F, 0x3D, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xF8, 0x03, 0xE7, 0xFC, 0x3F, 0xCF, 0xBF, 0xFF, 0x1F, 0x3F, 0xFC, 0x3E,
  0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xE0, 0x1F, 0x8F, 0x80, 0x0F, 0x9E, 0x00,
  0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0xF0, 0xF0, 0xFF, 0xE3, 0xC7, 0xFF, 0xCF, 0x3F, 0xFF, 0xBD, 0xF8,
  0x07, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xCF,
  0xE1, 0xEF, 0x3F, 0xFF, 0xBC, 0x3F, 0xFC, 0xF0, 0x7F, 0xC3, 0xC0, 0x10,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFE, 0x3F,
  0x83, 0xE0, 0x1F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x7C, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x7C, 0x00,
  0x7C, 0xFC, 0x01, 0xF0, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFC, 0x3C, 0x3F, 0xF8, 0xF1, 0xFF, 0xFB, 0xCF, 0xFF,
  0xEF, 0x7E, 0x01, 0xFD, 0xF0, 0x03, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D,
  0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x7F, 0x3F, 0xFF, 0xBC, 0x7F,
  0xFC, 0xF0, 0xFF, 0xE3, 0xC0, 0xFE, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE1, 0xFE, 0x0F, 0x9F, 0xFC, 0x3E, 0xFF,
  0xFC, 0xFF, 0xCF, 0xF3, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3E,
  0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x7E, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0xF3, 0xE0, 0xFC,
  0x7B, 0xFC, 0xFF, 0x3F, 0xFE, 0xFF, 0xDF, 0x0F, 0xE3, 0xEF, 0x03, 0xE0,
  0xF7, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C,
  0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0xFF, 0x03,
  0xC0, 0x7F, 0x81, 0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0,
  0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0xFF,
  0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78, 0x0F,
  0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x01, 0xFE, 0x07, 0x80,
  0xFF, 0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x3C, 0xF8, 0x7F, 0x83, 0xE7, 0xFF,
  0x0F, 0xBF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0x01, 0xFB, 0xF0, 0x03, 0xEF,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x1E,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBE, 0x00, 0x0F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x03, 0xF0, 0xFF, 0x3F, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x7F, 0x81,
  0xF3, 0xFF, 0xC3, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F, 0x9F,
  0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xEC, 0x01, 0xF3,
  0xDE, 0x1F, 0xE7, 0x9F, 0xFF, 0x8F, 0x1F, 0xFE, 0x1E, 0x1F, 0xF0, 0x3C,
  0x06, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xFC, 0x3C, 0x3F, 0xF8, 0xF1, 0xFF, 0xF3,
  0xCF, 0xFF, 0xEF, 0x7E, 0x01, 0xFD, 0xF0, 0x03, 0xF7, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00,
  0xFD, 0xF8, 0x07, 0xF3, 0xF8, 0x7B, 0xC7, 0xFF, 0xEF, 0x0F, 0xFF, 0x3C,
  0x1F, 0xF0, 0xF0, 0x04, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x81, 0xE3, 0xFF, 0x83,
  0xCF, 0xFF, 0xC7, 0xBE, 0x3F, 0xCF, 0x60, 0x1F, 0x9F, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xE0, 0x0F, 0xCF,
  0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xF9,
  0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF8,
  0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xF0,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x03,
  0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x78,
  0x07, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x78,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x80, 0xF7, 0x00, 0xF8, 0x0F, 0x78, 0x1F, 0x80, 0xF7, 0x81, 0xF8, 0x0E,
  0x78, 0x1D, 0x80, 0xE7, 0x81, 0xD8, 0x0E, 0x78, 0x19, 0xC1, 0xE3, 0x81,
  0x9C, 0x1E, 0x38, 0x39, 0xC1, 0xE3, 0xC3, 0x9C, 0x1C, 0x3C, 0x38, 0xC1,
  0xC3, 0xC3, 0x8C, 0x1C, 0x3C, 0x30, 0xE3, 0xC1, 0xC3, 0x0E, 0x3C, 0x1C,
  0x70, 0xE3, 0xC1, 0xE7, 0x0E, 0x38, 0x1E, 0x70, 0x63, 0x81, 0xE7, 0x07,
  0x38, 0x1E, 0x60, 0x73, 0x80, 0xE6, 0x07, 0x78, 0x0E, 0xE0, 0x77, 0x80,
  0xEE, 0x07, 0x70, 0x0E, 0xE0, 0x37, 0x00, 0xFE, 0x03, 0x70, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x3E, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xBC, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x3C, 0x00,
  0x7C, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC1, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x1E, 0x00,
  0x3C, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x9F, 0xF8,
  0x03, 0xDF, 0xFE, 0x01, 0xFF, 0x1F, 0x00, 0xFF, 0x07, 0xC0, 0xFF, 0x81,
  0xF0, 0x7B, 0xC0, 0x7E, 0x7D, 0xE0, 0x1F, 0xFE, 0xF0, 0x07, 0xFE, 0x78,
  0x01, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_Light54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 39, 32, 12, -39 },
  { 40, 16, 16, 32, 8, -39 },
  { 72, 29, 39, 32, 2, -39 },
  { 214, 24, 55, 32, 4, -47 },
  { 379, 31, 40, 32, 1, -40 },
  { 534, 28, 41, 32, 3, -40 },
  { 678, 4, 16, 32, 14, -39 },
  { 686, 16, 51, 32, 10, -45 },
  { 788, 16, 51, 32, 6, -45 },
  { 890, 28, 28, 32, 2, -33 },
  { 988, 25, 26, 32, 4, -31 },
  { 1070, 11, 17, 32, 9, -8 },
  { 1094, 17, 4, 32, 8, -20 },
  { 1103, 9, 9, 32, 12, -8 },
  { 1114, 24, 51, 32, 4, -45 },
  { 1267, 24, 41, 32, 4, -40 },
  { 1390, 24, 39, 32, 5, -39 },
  { 1507, 24, 40, 32, 4, -40 },
  { 1627, 23, 40, 32, 4, -39 },
  { 1742, 22, 39, 32, 5, -39 },
  { 1850, 23, 40, 32, 5, -39 },
  { 1965, 24, 40, 32, 4, -39 },
  { 2085, 25, 39, 32, 4, -39 },
  { 2207, 24, 41, 32, 4, -40 },
  { 2330, 24, 40, 32, 4, -40 },
  { 2450, 9, 31, 32, 12, -30 },
  { 2485, 12, 39, 32, 9, -30 },
  { 2544, 23, 28, 32, 5, -32 },
  { 2625, 23, 16, 32, 5, -26 },
  { 2671, 23, 28, 32, 5, -32 },
  { 2752, 19, 39, 32, 8, -39 },
  { 2845, 27, 50, 32, 3, -40 },
  { 3014, 26, 39, 32, 3, -39 },
  { 3141, 23, 39, 32, 5, -39 },
  { 3254, 23, 41, 32, 5, -40 },
  { 3372, 22, 39, 32, 5, -39 },
  { 3480, 22, 39, 32, 6, -39 },
  { 3588, 23, 39, 32, 5, -39 },
  { 3701, 23, 41, 32, 5, -40 },
  { 3819, 22, 39, 32, 5, -39 },
  { 3927, 21, 39, 32, 6, -39 },
  { 4030, 24, 40, 32, 3, -39 },
  { 4150, 25, 39, 32, 5, -39 },
  { 4272, 23, 39, 32, 6, -39 },
  { 4385, 24, 39, 32, 4, -39 },
  { 4502, 22, 39, 32, 5, -39 },
  { 4610, 22, 41, 32, 5, -40 },
  { 4723, 24, 39, 32, 5, -39 },
  { 4840, 23, 50, 32, 5, -40 },
  { 4984, 24, 39, 32, 5, -39 },
  { 5101, 24, 41, 32, 4, -40 },
  { 5224, 26, 39, 32, 3, -39 },
  { 5351, 22, 40, 32, 5, -39 },
  { 5461, 26, 39, 32, 3, -39 },
  { 5588, 29, 39, 32, 2, -39 },
  { 5730, 28, 39, 32, 2, -39 },
  { 5867, 28, 39, 32, 2, -39 },
  { 6004, 23, 39, 32, 5, -39 },
  { 6117, 13, 51, 32, 11, -45 },
  { 6200, 24, 51, 32, 4, -45 },
  { 6353, 13, 51, 32, 8, -45 },
  { 6436, 23, 21, 32, 5, -39 },
  { 6497, 26, 4, 32, 3, 1 },
  { 6510, 11, 7, 32, 10, -42 },
  { 6520, 23, 31, 32, 4, -30 },
  { 6610, 23, 40, 32, 5, -39 },
  { 6725, 23, 31, 32, 5, -30 },
  { 6815, 22, 40, 32, 5, -39 },
  { 6925, 23, 31, 32, 5, -30 },
  { 7015, 26, 39, 32, 3, -39 },
  { 7142, 22, 40, 32, 5, -30 },
  { 7252, 22, 39, 32, 5, -39 },
  { 7360, 25, 42, 32, 5, -42 },
  { 7492, 20, 52, 32, 5, -42 },
  { 7622, 25, 39, 32, 5, -39 },
  { 7744, 28, 39, 32, 2, -39 },
  { 7881, 25, 30, 32, 4, -30 },
  { 7975, 22, 30, 32, 5, -30 },
  { 8058, 23, 30, 32, 5, -30 },
  { 8145, 23, 40, 32, 5, -30 },
  { 8260, 22, 40, 32, 5, -30 },
  { 8370, 23, 30, 32, 6, -30 },
  { 8457, 23, 30, 32, 5, -30 },
  { 8544, 25, 38, 32, 3, -38 },
  { 8663, 22, 31, 32, 5, -30 },
  { 8749, 26, 30, 32, 3, -30 },
  { 8847, 28, 30, 32, 2, -30 },
  { 8952, 26, 30, 32, 3, -30 },
  { 9050, 26, 40, 32, 3, -30 },
  { 9180, 22, 30, 32, 5, -30 },
  { 9263, 23, 51, 32, 5, -45 },
  { 9410, 4, 51, 32, 14, -45 },
  { 9436, 23, 51, 32, 5, -45 },
  { 9583, 25, 10, 32, 4, -24 },
};

const GFXfont JetBrainsMono_Light54pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light54pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _JETBRAINSMONO_LIGHT54PT7B_H_
