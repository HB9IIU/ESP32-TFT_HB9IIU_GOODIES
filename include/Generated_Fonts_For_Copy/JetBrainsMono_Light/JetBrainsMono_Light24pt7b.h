#ifndef _JETBRAINSMONO_LIGHT24PT7B_H_
#define _JETBRAINSMONO_LIGHT24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light24pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x64, 0x06, 0xFC, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE2, 0x0C, 0x20, 0x61, 0x02, 0x18, 0x10, 0xC0, 0x86, 0x3F,
  0xFD, 0xFF, 0xE3, 0x18, 0x10, 0xC0, 0x86, 0x0C, 0x30, 0x61, 0x0F, 0xFF,
  0x10, 0xC0, 0x86, 0x0C, 0x30, 0x61, 0x03, 0x08, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x0F, 0x03, 0xF8, 0xCB, 0xB1, 0x36, 0x26, 0xC4, 0x0C, 0x81, 0xD0,
  0x1F, 0x00, 0xF8, 0x0B, 0x81, 0x30, 0x23, 0xC4, 0x78, 0x8F, 0x13, 0x3F,
  0xE3, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x18, 0x0D, 0xF0, 0x24, 0x61, 0xB1,
  0x8C, 0xC6, 0x23, 0x19, 0x84, 0x6C, 0x1F, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x27, 0x01, 0x3E, 0x0D, 0x8C, 0x66, 0x31, 0x18, 0xCC, 0x63, 0x60, 0xDF,
  0x01, 0xE0, 0x0E, 0x01, 0xFC, 0x0C, 0x70, 0xC1, 0x86, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x3C, 0x03, 0x61, 0xB1, 0x8D, 0x86, 0xCC, 0x3E, 0x60,
  0xE3, 0x03, 0x0C, 0x3C, 0x77, 0x61, 0xF1, 0xC0, 0xFF, 0xFF, 0x06, 0x3C,
  0xE3, 0x86, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x81, 0x83, 0x83, 0x83, 0xC1, 0x80, 0xC1, 0xC0, 0xC0, 0xC0, 0xC1,
  0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x70,
  0xC7, 0x1C, 0x20, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0E, 0x63,
  0x7D, 0x7C, 0xFF, 0x00, 0xC0, 0x0D, 0x00, 0xCC, 0x0E, 0x30, 0x61, 0xC1,
  0x04, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x39, 0x9C, 0xE6, 0x33, 0x18,
  0xFF, 0xFF, 0x6F, 0xF7, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x00, 0x1E, 0x0F, 0xE6,
  0x1F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xCC, 0x73, 0x9C, 0x47, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x83, 0x7B, 0x8F, 0xC0, 0x0E, 0x03, 0xC0, 0xD8,
  0x73, 0x0C, 0x61, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0xF1,
  0x87, 0x60, 0x6C, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x70, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x7C, 0x1F, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0xF0, 0x3C, 0x0F, 0x07, 0x7F, 0x8F, 0xC0, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x30, 0xD8, 0x3E, 0x0F, 0x03,
  0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x7F, 0xDF, 0xF4, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x41, 0x7E, 0xF1, 0xF8, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x3C, 0x0F, 0x83, 0x7F, 0x8F, 0xC0, 0x03, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x38, 0x7F, 0x9C, 0x3B, 0x03, 0x60, 0x3C,
  0x07, 0x80, 0xF0, 0x37, 0x06, 0x7F, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x6C, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x1E, 0x0F, 0xE6,
  0x1F, 0x03, 0xC0, 0xF0, 0x36, 0x0C, 0xCE, 0x1F, 0x07, 0xC7, 0x1B, 0x83,
  0xC0, 0xF0, 0x1C, 0x0F, 0x83, 0x7F, 0x8F, 0xC0, 0x1E, 0x07, 0xF1, 0x87,
  0x60, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x06, 0xE0, 0xCE, 0x78, 0xFE, 0x00,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xFF, 0x70, 0x00,
  0x00, 0x00, 0x7F, 0x70, 0x7B, 0xCE, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x67,
  0x31, 0x88, 0xC0, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x0C, 0x0F, 0x0F, 0x0F, 0x0F, 0x03, 0x00, 0xF0, 0x7F, 0x01, 0xC0, 0x60,
  0x18, 0x0C, 0x06, 0x06, 0x07, 0x1F, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x78, 0x1C, 0x00, 0x07, 0x81, 0xFC, 0x30, 0x66, 0x03, 0x40, 0x3C,
  0x01, 0xC1, 0x9C, 0x7D, 0xC6, 0x3C, 0x61, 0xC6, 0x1C, 0x61, 0xC6, 0x1C,
  0x61, 0xC6, 0x3C, 0x7D, 0xC1, 0x8C, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x01,
  0xF8, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xD0, 0x0D, 0x80, 0x98, 0x19, 0x81,
  0x98, 0x18, 0xC1, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xE6, 0x06, 0x60, 0x66,
  0x02, 0x60, 0x3C, 0x03, 0xFC, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81,
  0xB0, 0x36, 0x0E, 0xFF, 0x1F, 0xF3, 0x03, 0x60, 0x6C, 0x07, 0x80, 0xF0,
  0x36, 0x06, 0xFF, 0x9F, 0xE0, 0x1E, 0x0F, 0xE6, 0x1F, 0x03, 0xC0, 0xF0,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x3C, 0x0D,
  0x83, 0x7F, 0x8F, 0xC0, 0xF8, 0x3F, 0xCC, 0x3B, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07,
  0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF,
  0xDF, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0x1E, 0x0F, 0xE6, 0x1F, 0x03, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x31, 0xFC, 0x7F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x83, 0x7F, 0x8F, 0xC0,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0xFF,
  0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x80, 0xF0, 0x1B, 0x06, 0x7B, 0xC7, 0xE0, 0xC0, 0x78, 0x1F,
  0x03, 0x60, 0xEC, 0x19, 0x87, 0x30, 0xC6, 0x30, 0xFE, 0x1F, 0xC3, 0x1C,
  0x61, 0x8C, 0x39, 0x83, 0x30, 0x76, 0x06, 0xC0, 0xF8, 0x0C, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0xF8, 0x3A,
  0x1E, 0xC7, 0xF1, 0x74, 0xDD, 0xB7, 0x69, 0xCE, 0x73, 0x9C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x10, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC3, 0xD0, 0xF6, 0x3D, 0x8F, 0x23, 0xCC, 0xF3, 0x3C, 0x6F, 0x1B, 0xC2,
  0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x70, 0x1E, 0x0F, 0xE6, 0x1F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0D, 0x83, 0x7F, 0x8F, 0xC0, 0xFC, 0x1F, 0xF3, 0x07, 0x60, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xDF, 0xF3, 0xF8, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x1E, 0x07, 0xF1, 0x87, 0x60,
  0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C,
  0x0D, 0x81, 0xB0, 0x33, 0x06, 0x7F, 0x87, 0xE0, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0xC0, 0xFC, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x07, 0x80, 0xF0, 0x1E,
  0x06, 0xC1, 0xDF, 0xF3, 0x18, 0x61, 0x8C, 0x31, 0x83, 0x30, 0x66, 0x06,
  0xC0, 0xD8, 0x1C, 0x1E, 0x07, 0xF1, 0x87, 0x60, 0x6C, 0x0D, 0x80, 0x18,
  0x03, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x60, 0x07, 0x80, 0xF0, 0x16,
  0x06, 0x7B, 0xC7, 0xE0, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0D, 0x83, 0x7F, 0x8F, 0xC0, 0xC0, 0x36, 0x03, 0x60, 0x36, 0x06,
  0x60, 0x63, 0x06, 0x30, 0x63, 0x0C, 0x30, 0xC1, 0x8C, 0x18, 0x81, 0x98,
  0x19, 0x80, 0xD8, 0x0D, 0x00, 0xF0, 0x07, 0x00, 0x70, 0xC6, 0x1E, 0x30,
  0xF1, 0xC5, 0x8E, 0x2C, 0x53, 0x62, 0x9B, 0x34, 0xC9, 0xA6, 0x49, 0x32,
  0x49, 0x9A, 0x4C, 0xD3, 0x46, 0x8A, 0x34, 0x51, 0xE3, 0x8F, 0x1C, 0x30,
  0xE1, 0x87, 0x00, 0xE0, 0x36, 0x06, 0x70, 0x63, 0x0C, 0x18, 0xC1, 0x98,
  0x0D, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xD8, 0x19, 0x81, 0x8C,
  0x30, 0xC7, 0x06, 0x60, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x36, 0x06,
  0x30, 0x63, 0x0C, 0x18, 0xC1, 0x98, 0x0D, 0x80, 0xF0, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xF0,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0xFF, 0xC0, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0xFF, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x0C, 0x03,
  0x81, 0xE0, 0x68, 0x33, 0x0C, 0x42, 0x19, 0x82, 0x40, 0xF0, 0x30, 0xFF,
  0xF0, 0xE1, 0x8C, 0x30, 0x3F, 0x9C, 0x6E, 0x0C, 0x03, 0x00, 0xC7, 0xF7,
  0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x8F, 0x7E, 0xC0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x37, 0xEF, 0x1B, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xDB, 0xB7, 0xC0, 0x3F, 0x9C, 0x7E, 0x0F,
  0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x36, 0x0D, 0xFE, 0x3F,
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF, 0xB7, 0x1F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x87, 0x7B, 0xCF, 0xB0,
  0x3F, 0x1C, 0x6E, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30,
  0x06, 0x0D, 0xCE, 0x3F, 0x00, 0x01, 0xE1, 0xFC, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x3F, 0xFF, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3E, 0xDC, 0x7E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x77, 0xFC, 0xFB, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x3F, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xEF,
  0x1B, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x30, 0x04, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x73, 0xF0, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x81, 0xF0, 0x36, 0x0C, 0xC3, 0x98, 0x63, 0xF8, 0x7F,
  0x0C, 0x71, 0x86, 0x30, 0x66, 0x0E, 0xC0, 0xD8, 0x0C, 0xFC, 0x0F, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x07, 0xF0, 0x3F,
  0xBB, 0xD9, 0x8E, 0x31, 0xC6, 0x38, 0xC7, 0x18, 0xE3, 0x1C, 0x63, 0x8C,
  0x71, 0x8E, 0x31, 0xC6, 0x38, 0xC6, 0xDF, 0xBC, 0x6E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x3F,
  0x1C, 0xEE, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36,
  0x0D, 0xFE, 0x3F, 0x00, 0xDF, 0xBC, 0x7E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x6E, 0xDF, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x3E, 0xDC, 0x7E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x36, 0x1D, 0xEF, 0x3E, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0xDF, 0x38, 0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3F, 0x9C, 0x76, 0x0F, 0x00, 0x60, 0x1F,
  0x01, 0xF8, 0x07, 0x00, 0xC0, 0x3C, 0x0D, 0xEF, 0x3F, 0x80, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x0F, 0xFF, 0xFF, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3F, 0x03, 0xE0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36, 0x0D,
  0xEE, 0x3F, 0x00, 0xE0, 0x36, 0x06, 0x60, 0x63, 0x06, 0x30, 0xC3, 0x0C,
  0x18, 0xC1, 0x98, 0x19, 0x80, 0xD8, 0x0D, 0x00, 0xF0, 0x07, 0x00, 0xC6,
  0x1C, 0x61, 0xC7, 0x34, 0x53, 0x4D, 0x34, 0xD3, 0x69, 0x26, 0x92, 0x69,
  0xA2, 0x8E, 0x38, 0xE3, 0x8C, 0x30, 0xC0, 0x60, 0x73, 0x0E, 0x38, 0xC1,
  0x98, 0x0D, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x1D, 0x81, 0x9C, 0x30, 0xC7,
  0x06, 0xE0, 0x70, 0xE0, 0x36, 0x06, 0x30, 0x63, 0x06, 0x30, 0xC1, 0x8C,
  0x19, 0x80, 0xD8, 0x0D, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xC0,
  0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x81, 0xC3,
  0xE0, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0x00, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3E, 0x01,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xE0, 0x1F,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x60, 0x18, 0x3E,
  0x0C, 0x00, 0x70, 0x7F, 0x0F, 0x31, 0xC3, 0xE8, 0x38,
};

const GFXglyph JetBrainsMono_Light24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 18, 14, 6, -18 },
  { 8, 7, 8, 14, 4, -18 },
  { 15, 13, 18, 14, 1, -18 },
  { 45, 11, 24, 14, 2, -21 },
  { 78, 14, 18, 14, 0, -18 },
  { 110, 13, 18, 14, 1, -18 },
  { 140, 2, 8, 14, 6, -18 },
  { 142, 7, 23, 14, 5, -20 },
  { 163, 7, 23, 14, 3, -20 },
  { 184, 13, 13, 14, 1, -15 },
  { 206, 11, 12, 14, 2, -14 },
  { 223, 5, 8, 14, 4, -4 },
  { 228, 8, 2, 14, 3, -9 },
  { 230, 4, 4, 14, 5, -4 },
  { 232, 10, 23, 14, 2, -20 },
  { 261, 10, 18, 14, 2, -18 },
  { 284, 11, 18, 14, 2, -18 },
  { 309, 11, 18, 14, 2, -18 },
  { 334, 10, 18, 14, 2, -18 },
  { 357, 10, 18, 14, 2, -18 },
  { 380, 10, 18, 14, 2, -18 },
  { 403, 11, 18, 14, 2, -18 },
  { 428, 11, 18, 14, 2, -18 },
  { 453, 10, 18, 14, 2, -18 },
  { 476, 11, 18, 14, 2, -18 },
  { 501, 4, 13, 14, 5, -13 },
  { 508, 5, 17, 14, 4, -13 },
  { 519, 10, 12, 14, 2, -14 },
  { 534, 10, 8, 14, 2, -12 },
  { 544, 10, 12, 14, 2, -14 },
  { 559, 9, 18, 14, 3, -18 },
  { 580, 12, 22, 14, 1, -18 },
  { 613, 12, 18, 14, 1, -18 },
  { 640, 11, 18, 14, 2, -18 },
  { 665, 10, 18, 14, 2, -18 },
  { 688, 10, 18, 14, 2, -18 },
  { 711, 9, 18, 14, 3, -18 },
  { 732, 11, 18, 14, 2, -18 },
  { 757, 10, 18, 14, 2, -18 },
  { 780, 10, 18, 14, 2, -18 },
  { 803, 9, 18, 14, 3, -18 },
  { 824, 11, 18, 14, 1, -18 },
  { 849, 11, 18, 14, 2, -18 },
  { 874, 10, 18, 14, 3, -18 },
  { 897, 10, 18, 14, 2, -18 },
  { 920, 10, 18, 14, 2, -18 },
  { 943, 10, 18, 14, 2, -18 },
  { 966, 11, 18, 14, 2, -18 },
  { 991, 11, 22, 14, 2, -18 },
  { 1022, 11, 18, 14, 2, -18 },
  { 1047, 11, 18, 14, 2, -18 },
  { 1072, 12, 18, 14, 1, -18 },
  { 1099, 10, 18, 14, 2, -18 },
  { 1122, 12, 18, 14, 1, -18 },
  { 1149, 13, 18, 14, 1, -18 },
  { 1179, 12, 18, 14, 1, -18 },
  { 1206, 12, 18, 14, 1, -18 },
  { 1233, 10, 18, 14, 2, -18 },
  { 1256, 6, 23, 14, 5, -20 },
  { 1274, 10, 23, 14, 2, -20 },
  { 1303, 5, 23, 14, 4, -20 },
  { 1318, 10, 10, 14, 2, -18 },
  { 1331, 12, 1, 14, 1, 1 },
  { 1333, 5, 4, 14, 4, -19 },
  { 1336, 10, 13, 14, 2, -13 },
  { 1353, 10, 18, 14, 2, -18 },
  { 1376, 10, 13, 14, 2, -13 },
  { 1393, 10, 18, 14, 2, -18 },
  { 1416, 10, 13, 14, 2, -13 },
  { 1433, 11, 18, 14, 2, -18 },
  { 1458, 10, 17, 14, 2, -13 },
  { 1480, 10, 18, 14, 2, -18 },
  { 1503, 11, 19, 14, 2, -19 },
  { 1530, 9, 23, 14, 2, -19 },
  { 1556, 11, 18, 14, 2, -18 },
  { 1581, 12, 18, 14, 1, -18 },
  { 1608, 11, 13, 14, 2, -13 },
  { 1626, 10, 13, 14, 2, -13 },
  { 1643, 10, 13, 14, 2, -13 },
  { 1660, 10, 17, 14, 2, -13 },
  { 1682, 10, 17, 14, 2, -13 },
  { 1704, 10, 13, 14, 3, -13 },
  { 1721, 10, 13, 14, 2, -13 },
  { 1738, 11, 17, 14, 1, -17 },
  { 1762, 10, 13, 14, 2, -13 },
  { 1779, 12, 13, 14, 1, -13 },
  { 1799, 12, 13, 14, 1, -13 },
  { 1819, 12, 13, 14, 1, -13 },
  { 1839, 12, 17, 14, 1, -13 },
  { 1865, 10, 13, 14, 2, -13 },
  { 1882, 10, 23, 14, 2, -20 },
  { 1911, 2, 23, 14, 6, -20 },
  { 1917, 10, 23, 14, 2, -20 },
  { 1946, 11, 5, 14, 2, -11 },
};

const GFXfont JetBrainsMono_Light24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_LIGHT24PT7B_H_
