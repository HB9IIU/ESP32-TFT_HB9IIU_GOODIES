#ifndef _JETBRAINSMONO_LIGHT45PT7B_H_
#define _JETBRAINSMONO_LIGHT45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xCF, 0xFF, 0xBF, 0x7C, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x38, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x30, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x18, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x18, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x1C, 0x03, 0x80, 0x38, 0x06, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x07,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xF9, 0x9F, 0x0F, 0x0C, 0x78, 0x70, 0x61, 0xE7,
  0x83, 0x0F, 0x3C, 0x18, 0x39, 0xE0, 0xC0, 0x0F, 0x06, 0x00, 0x78, 0x30,
  0x01, 0xE1, 0x80, 0x0F, 0x8C, 0x00, 0x3E, 0x60, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0x9F,
  0x00, 0x0C, 0x3C, 0x00, 0x61, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x3F, 0xC0,
  0xC1, 0xFE, 0x06, 0x0F, 0x70, 0x30, 0x73, 0xC1, 0x87, 0x9F, 0x0C, 0x3C,
  0x7C, 0x67, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x9F, 0xE0, 0x03, 0x9F, 0xF8, 0x01,
  0xDE, 0x1E, 0x01, 0xCE, 0x07, 0x01, 0xC7, 0x03, 0x80, 0xE3, 0x81, 0xC0,
  0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x70, 0x38, 0x1C,
  0x70, 0x1E, 0x1E, 0x70, 0x07, 0xFE, 0x38, 0x01, 0xFE, 0x38, 0x00, 0x7E,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x3F, 0xC0, 0x0E, 0x3F, 0xF0, 0x07, 0x3C, 0x3C,
  0x07, 0x1C, 0x0E, 0x07, 0x0E, 0x07, 0x03, 0x87, 0x03, 0x83, 0x83, 0x81,
  0xC3, 0x81, 0xC0, 0xE3, 0x80, 0xE0, 0x71, 0xC0, 0x70, 0x39, 0xC0, 0x3C,
  0x3D, 0xC0, 0x0F, 0xFC, 0xE0, 0x07, 0xFE, 0xE0, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xC7, 0x80,
  0xFF, 0x0F, 0x07, 0xB8, 0x1E, 0x1E, 0xE0, 0x78, 0xF3, 0x80, 0xF3, 0xCE,
  0x01, 0xFE, 0x38, 0x07, 0xF0, 0xE0, 0x0F, 0xC3, 0x80, 0x1E, 0x0E, 0x00,
  0x7C, 0x38, 0x03, 0xF0, 0xF0, 0x1F, 0xE3, 0xE0, 0xFB, 0xC7, 0xFF, 0xC7,
  0x8F, 0xFE, 0x1E, 0x1F, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77,
  0x77, 0x00, 0x08, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x0E, 0x80,
  0x07, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x10, 0x0E, 0x01, 0x7C, 0x1C, 0x1F, 0xFE, 0x38, 0xFF, 0xFF,
  0x67, 0xFC, 0x7F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x0D,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x0F, 0x0F,
  0x80, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x1F, 0x01, 0xC0, 0x1C,
  0x01, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1C,
  0x1E, 0x0F, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x07, 0xE7, 0x80, 0x3D, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x38, 0x3F, 0x0F, 0x87, 0xE1,
  0xF0, 0xFC, 0x3E, 0x1F, 0x83, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x3E, 0x78, 0x07, 0xC7, 0x80, 0xF8, 0x78, 0x0E, 0x07, 0x80,
  0xC0, 0x78, 0x08, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C,
  0x0F, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0xCE, 0x00, 0x1E,
  0xF0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70,
  0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x1C, 0x78, 0x07, 0x3C, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x18,
  0x07, 0x3F, 0xE0, 0xEF, 0xFE, 0x1D, 0xFF, 0xE3, 0xE0, 0x3E, 0x78, 0x03,
  0xCF, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xE7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x7F, 0x80, 0x77, 0xFE, 0x07, 0xFF, 0xF8, 0x3E, 0x03, 0xE3,
  0xE0, 0x0F, 0x9E, 0x00, 0x3C, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0x9C,
  0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE,
  0x00, 0x1C, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0x03, 0xE7, 0x80, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0x3C, 0x01, 0xE3, 0xC0, 0x78,
  0x3C, 0x3E, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xF7, 0xC0,
  0x78, 0x3C, 0x1E, 0x03, 0xC7, 0x80, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x3E, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0xC3, 0xC0,
  0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xB8, 0x00,
  0x39, 0xE0, 0x03, 0xCF, 0x80, 0x3E, 0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0x78, 0x0F, 0xF7, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xE1,
  0xF0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x07, 0xC3, 0xC0,
  0x03, 0x87, 0x80, 0x07, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3C, 0x7E, 0x01, 0xFE,
  0xFC, 0x07, 0xFD, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x0F, 0xE0, 0x70, 0x0F,
  0xC0, 0xE0, 0x1F, 0x81, 0xC0, 0x3F, 0x03, 0x80, 0x7E, 0x07, 0x00, 0xFC,
  0x0E, 0x01, 0xF8, 0x1C, 0x03, 0xF0, 0x38, 0x07, 0xE0, 0x70, 0x0F, 0xC0,
  0xE0, 0x3F, 0x81, 0xE0, 0x7F, 0x01, 0xE1, 0xFE, 0x03, 0xFE, 0xFE, 0x03,
  0xF9, 0xFC, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x8E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1C, 0x00, 0x70, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x9E,
  0x00, 0x0F, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0x03, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x01, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xB8,
  0x00, 0xF7, 0x80, 0x3C, 0x78, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x78, 0x3F, 0xCF,
  0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0,
  0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xB8,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x03, 0xE7, 0x80, 0x3C, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x3C, 0x78, 0x0F, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01,
  0xE3, 0xE0, 0x3E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1E,
  0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xEE, 0x01, 0xBD, 0xC0, 0x77, 0xB8, 0x0E, 0xF3,
  0x81, 0x9F, 0x70, 0x77, 0xEE, 0x0E, 0xFC, 0xE1, 0x9F, 0x9C, 0x73, 0xF3,
  0x8E, 0x7E, 0x39, 0x8F, 0xC7, 0x71, 0xF8, 0xEE, 0x3F, 0x0D, 0x87, 0xE1,
  0xF0, 0xFC, 0x3E, 0x1F, 0x83, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xE0, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xB8, 0x0F, 0xF7,
  0x01, 0xFE, 0xE0, 0x3F, 0xCE, 0x07, 0xF9, 0xC0, 0xFF, 0x3C, 0x1F, 0xE3,
  0x83, 0xFC, 0x70, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC1,
  0xC7, 0xF8, 0x38, 0xFF, 0x07, 0x9F, 0xE0, 0x73, 0xFC, 0x0E, 0x7F, 0x81,
  0xEF, 0xF0, 0x1D, 0xFE, 0x03, 0xBF, 0xC0, 0x3F, 0xF8, 0x07, 0x7F, 0x00,
  0xEF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x07, 0xC7, 0x80, 0x3C, 0xF0,
  0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xE0, 0x3F, 0xCF, 0x00, 0x3E, 0x78, 0x00, 0x7B, 0xC0, 0x03,
  0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0xFC,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x07, 0xC7, 0x80, 0x3D, 0xE0, 0x03, 0xBC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x01, 0xFC, 0xF0, 0x03, 0xEF,
  0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x03,
  0xEF, 0x01, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xC0, 0x1E, 0x1C,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xF0, 0x01, 0xE7,
  0xC0, 0x0F, 0x1F, 0x01, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x01, 0xE7, 0x80,
  0x3C, 0x78, 0x0F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE3, 0x80,
  0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1C, 0x00,
  0x70, 0x3C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x01, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x1E,
  0x07, 0xF8, 0x0F, 0x03, 0xDC, 0x0F, 0x81, 0xCE, 0x07, 0xC0, 0xE7, 0x03,
  0x60, 0x73, 0x81, 0xB0, 0x39, 0xC0, 0xD8, 0x1C, 0xE0, 0x6C, 0x0E, 0x78,
  0x37, 0x07, 0x3C, 0x3B, 0x87, 0x8E, 0x1C, 0xC3, 0x87, 0x0E, 0x61, 0xC3,
  0x86, 0x30, 0xE1, 0xC3, 0x18, 0x70, 0xE1, 0x8C, 0x38, 0x70, 0xC6, 0x1C,
  0x38, 0x63, 0x8E, 0x1E, 0x71, 0xC7, 0x0F, 0x38, 0xE7, 0x83, 0x9C, 0x33,
  0x81, 0xCC, 0x19, 0xC0, 0xE6, 0x0C, 0xE0, 0x73, 0x06, 0x70, 0x39, 0x83,
  0x38, 0x1C, 0xC1, 0x9C, 0x0E, 0xE0, 0xEE, 0x07, 0xF0, 0x77, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1C, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x1C, 0x07,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x78, 0xF0, 0x00, 0x71, 0xC0,
  0x00, 0xF7, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0F,
  0x38, 0x01, 0xC7, 0x00, 0x78, 0xF0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x38, 0x70, 0x07, 0x1E, 0x00, 0xF3, 0x80,
  0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF8, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x01, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0xC1, 0xF0, 0x7E, 0x3C, 0x01, 0xE3, 0x80, 0x0E,
  0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF0, 0x0F, 0x78, 0x00, 0xF7, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xF7, 0xC0, 0x3F, 0x3F, 0xBE, 0xF3, 0xFF, 0xEF, 0x0F, 0xF8, 0xF0,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF1, 0xFC, 0x1E, 0x7F, 0xE3,
  0xDF, 0xFE, 0x7F, 0x07, 0xEF, 0xC0, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xF8, 0x0F, 0xBD,
  0xFF, 0xE7, 0xBF, 0xF8, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0x07, 0xE7, 0x80, 0x3C, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x07, 0xF1, 0xE3, 0xFF, 0x3C, 0xFF, 0xF7, 0xBF, 0x07, 0xF7,
  0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x0F, 0xCF, 0xFF, 0x78, 0xFF, 0xEF, 0x0F,
  0xF1, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1E, 0x03, 0xC7,
  0x80, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF1, 0xE3, 0xFF, 0x3C, 0xFF, 0xF7,
  0xBF, 0x07, 0xF7, 0x80, 0x7E, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x7D,
  0xE0, 0x0F, 0xBE, 0x03, 0xF3, 0xFF, 0xDE, 0x3F, 0xFB, 0xC3, 0xFC, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF1, 0xFC, 0x1E, 0x7F, 0xE3,
  0xDF, 0xFE, 0x7F, 0x07, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x07,
  0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0,
  0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0xF8, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0xE7, 0xC3, 0xE7, 0x7F, 0x3F,
  0xBB, 0xFB, 0xFD, 0xE1, 0xF0, 0xFF, 0x07, 0x07, 0xF0, 0x38, 0x1F, 0x81,
  0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F,
  0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E,
  0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E,
  0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70,
  0x38, 0xF1, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7F, 0x07, 0xEF, 0x80,
  0x3D, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x07, 0xC7, 0x80,
  0x3C, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00,
  0xE7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0xF1, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7F, 0x07, 0xEF, 0xC0,
  0x3D, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3D, 0xF8, 0x0F, 0xBD, 0xFF, 0xE7, 0xBF, 0xF8, 0xF1, 0xFE,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF1, 0xE3, 0xFF,
  0x3C, 0xFF, 0xF7, 0xBF, 0x07, 0xF7, 0x80, 0x7E, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x0F,
  0xCF, 0xFF, 0x78, 0xFF, 0xEF, 0x0F, 0xF1, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0xF1, 0xFC, 0x1E, 0xFF, 0xE3, 0xDF, 0xFE, 0x7F, 0x07,
  0xCF, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3E, 0x03,
  0xE7, 0x80, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1E, 0xF8, 0x07, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x3C, 0x01, 0xE7, 0x80,
  0x3C, 0x78, 0x0F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x80, 0x0F,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x83, 0xC0,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x80, 0x07, 0xBC, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0x60, 0x7F, 0x06, 0xC0, 0xEE, 0x0D, 0x83, 0x9C, 0x1B,
  0x07, 0x38, 0x36, 0x0E, 0x70, 0xEE, 0x1C, 0xE1, 0x8C, 0x39, 0xC3, 0x18,
  0x71, 0xC6, 0x31, 0xC3, 0x8C, 0x63, 0x87, 0x18, 0xC7, 0x0E, 0x71, 0xCE,
  0x1C, 0xC3, 0x9C, 0x39, 0x83, 0x38, 0x3B, 0x06, 0x60, 0x76, 0x0D, 0xC0,
  0xEC, 0x1B, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x8F, 0x00,
  0x78, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00,
  0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7B, 0xC0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x1E, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x1E, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0xE0, 0x1E, 0x0F, 0x00, 0x70, 0x78, 0x03, 0xC3, 0x80,
  0x1E, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x77,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x7B, 0xFE, 0x03, 0xDF, 0xF8, 0x1F, 0xE1, 0xE0,
  0xFF, 0x07, 0x87, 0xF8, 0x1E, 0x7B, 0xC0, 0xFF, 0xDE, 0x01, 0xFC, 0x00,
  0x03, 0x00,
};

const GFXglyph JetBrainsMono_Light45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 33, 27, 10, -33 },
  { 30, 13, 14, 27, 7, -33 },
  { 53, 23, 33, 27, 2, -33 },
  { 148, 21, 45, 27, 3, -39 },
  { 267, 25, 33, 27, 1, -33 },
  { 371, 22, 33, 27, 3, -33 },
  { 462, 4, 14, 27, 11, -33 },
  { 469, 13, 43, 27, 9, -38 },
  { 539, 13, 43, 27, 5, -38 },
  { 609, 23, 23, 27, 2, -27 },
  { 676, 21, 21, 27, 3, -25 },
  { 732, 9, 14, 27, 8, -7 },
  { 748, 15, 3, 27, 6, -16 },
  { 754, 7, 7, 27, 10, -7 },
  { 761, 19, 42, 27, 4, -37 },
  { 861, 19, 33, 27, 4, -33 },
  { 940, 20, 33, 27, 4, -33 },
  { 1023, 21, 33, 27, 3, -33 },
  { 1110, 20, 33, 27, 3, -33 },
  { 1193, 18, 33, 27, 4, -33 },
  { 1268, 19, 33, 27, 4, -33 },
  { 1347, 21, 33, 27, 3, -33 },
  { 1434, 20, 33, 27, 4, -33 },
  { 1517, 19, 33, 27, 4, -33 },
  { 1596, 21, 33, 27, 3, -33 },
  { 1683, 7, 25, 27, 10, -25 },
  { 1705, 9, 32, 27, 8, -25 },
  { 1741, 19, 24, 27, 4, -27 },
  { 1798, 19, 14, 27, 4, -22 },
  { 1832, 19, 24, 27, 4, -27 },
  { 1889, 16, 33, 27, 6, -33 },
  { 1955, 23, 41, 27, 2, -33 },
  { 2073, 23, 33, 27, 2, -33 },
  { 2168, 20, 33, 27, 4, -33 },
  { 2251, 19, 33, 27, 4, -33 },
  { 2330, 19, 33, 27, 4, -33 },
  { 2409, 18, 33, 27, 5, -33 },
  { 2484, 20, 33, 27, 4, -33 },
  { 2567, 19, 33, 27, 4, -33 },
  { 2646, 19, 33, 27, 4, -33 },
  { 2725, 17, 33, 27, 5, -33 },
  { 2796, 20, 33, 27, 2, -33 },
  { 2879, 21, 33, 27, 4, -33 },
  { 2966, 19, 33, 27, 5, -33 },
  { 3045, 19, 33, 27, 4, -33 },
  { 3124, 19, 33, 27, 4, -33 },
  { 3203, 19, 33, 27, 4, -33 },
  { 3282, 21, 33, 27, 4, -33 },
  { 3369, 19, 41, 27, 4, -33 },
  { 3467, 20, 33, 27, 4, -33 },
  { 3550, 21, 33, 27, 3, -33 },
  { 3637, 21, 33, 27, 3, -33 },
  { 3724, 19, 33, 27, 4, -33 },
  { 3803, 23, 33, 27, 2, -33 },
  { 3898, 25, 33, 27, 1, -33 },
  { 4002, 23, 33, 27, 2, -33 },
  { 4097, 23, 33, 27, 2, -33 },
  { 4192, 19, 33, 27, 4, -33 },
  { 4271, 11, 42, 27, 9, -37 },
  { 4329, 19, 42, 27, 4, -37 },
  { 4429, 11, 42, 27, 7, -37 },
  { 4487, 19, 18, 27, 4, -33 },
  { 4530, 21, 3, 27, 3, 1 },
  { 4538, 9, 6, 27, 8, -35 },
  { 4545, 20, 25, 27, 3, -25 },
  { 4608, 19, 33, 27, 4, -33 },
  { 4687, 19, 25, 27, 4, -25 },
  { 4747, 19, 33, 27, 4, -33 },
  { 4826, 19, 25, 27, 4, -25 },
  { 4886, 21, 33, 27, 3, -33 },
  { 4973, 19, 33, 27, 4, -25 },
  { 5052, 19, 33, 27, 4, -33 },
  { 5131, 21, 35, 27, 4, -35 },
  { 5223, 16, 43, 27, 4, -35 },
  { 5309, 21, 33, 27, 4, -33 },
  { 5396, 23, 33, 27, 2, -33 },
  { 5491, 21, 25, 27, 3, -25 },
  { 5557, 19, 25, 27, 4, -25 },
  { 5617, 19, 25, 27, 4, -25 },
  { 5677, 19, 33, 27, 4, -25 },
  { 5756, 19, 33, 27, 4, -25 },
  { 5835, 19, 25, 27, 5, -25 },
  { 5895, 19, 25, 27, 4, -25 },
  { 5955, 20, 32, 27, 3, -32 },
  { 6035, 19, 25, 27, 4, -25 },
  { 6095, 21, 25, 27, 3, -25 },
  { 6161, 23, 25, 27, 2, -25 },
  { 6233, 21, 25, 27, 3, -25 },
  { 6299, 21, 33, 27, 3, -25 },
  { 6386, 19, 25, 27, 4, -25 },
  { 6446, 19, 42, 27, 4, -37 },
  { 6546, 3, 42, 27, 12, -37 },
  { 6562, 19, 42, 27, 4, -37 },
  { 6662, 21, 9, 27, 3, -20 },
};

const GFXfont JetBrainsMono_Light45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_LIGHT45PT7B_H_
