#ifndef _JETBRAINSMONO_LIGHT30PT7B_H_
#define _JETBRAINSMONO_LIGHT30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light30pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x0F, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x03, 0x0C, 0x06,
  0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x08, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x30, 0x18, 0x30, 0x18,
  0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30,
  0x60, 0x30, 0x60, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x0F, 0xC0, 0xFF, 0xC3, 0xB7, 0x9C, 0xCE, 0x63, 0x19, 0x8C, 0x66, 0x30,
  0x1C, 0xC0, 0x3B, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0C,
  0xE0, 0x31, 0x80, 0xC7, 0xE3, 0x1F, 0x8C, 0x76, 0x31, 0x9C, 0xCE, 0x3F,
  0xF0, 0x7F, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x01,
  0xDF, 0xC0, 0x66, 0x38, 0x31, 0x86, 0x18, 0x61, 0x84, 0x18, 0x63, 0x06,
  0x19, 0x81, 0x8E, 0xC0, 0x7F, 0x30, 0x0F, 0x98, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x9E, 0x00, 0xCF, 0xE0, 0x37, 0x18, 0x19, 0x86, 0x0C, 0x61,
  0x83, 0x18, 0x61, 0x86, 0x18, 0xC1, 0xC6, 0x20, 0x3F, 0xB8, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0xC1, 0xC3, 0x83, 0x83, 0x86, 0x07, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x01, 0xF8, 0x07, 0x30, 0x7C, 0x70,
  0xD8, 0x73, 0x30, 0x6E, 0x60, 0x78, 0xC0, 0xF1, 0x80, 0xE3, 0x03, 0xC7,
  0x0F, 0xC7, 0xF9, 0xC7, 0xE1, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0x83, 0xC7,
  0x87, 0x83, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0,
  0x38, 0x0F, 0x03, 0xE0, 0x70, 0x08, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x60,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x1E, 0x3E,
  0x1C, 0x08, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x41,
  0x82, 0xF9, 0x9F, 0x7F, 0xFE, 0x0F, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x06,
  0x60, 0x0E, 0x70, 0x1C, 0x38, 0x38, 0x1C, 0x18, 0x18, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0xF3,
  0x8E, 0x71, 0xC7, 0x18, 0xE3, 0x00, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0xF0,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0x60, 0x1B, 0x80, 0x6E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x8C, 0x7E, 0x79, 0xF9, 0xE7, 0xE3, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x19, 0x80, 0x67, 0x03, 0x9E, 0x1E,
  0x3F, 0xF0, 0x3F, 0x00, 0x0F, 0x00, 0xF8, 0x0E, 0xC1, 0xE6, 0x0E, 0x30,
  0x41, 0x82, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x18, 0x0E, 0xE0,
  0x1B, 0x80, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x00,
  0x3C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xE0, 0x1F, 0x00,
  0xD8, 0x0E, 0xE0, 0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x83, 0x70, 0x36,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xEF, 0xCF, 0xFE, 0xF0, 0x7E, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x7E, 0x0E, 0x7F, 0xE3,
  0xFC, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x39, 0x00, 0xDF, 0x87, 0xFF, 0x1C, 0x0E, 0x60, 0x1B,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x76, 0x03, 0x9E, 0x1E,
  0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xE0,
  0x1B, 0x80, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0xFF, 0xC3, 0x87,
  0x1C, 0x0E, 0x60, 0x19, 0x80, 0x66, 0x01, 0x9C, 0x0E, 0x38, 0x70, 0x7F,
  0x80, 0x78, 0x07, 0xF8, 0x38, 0x71, 0xC0, 0xE6, 0x01, 0x98, 0x06, 0xE0,
  0x1D, 0x80, 0x66, 0x01, 0x9C, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0xC0,
  0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1D, 0x80, 0x67, 0x03, 0x8F, 0x3E, 0x1F, 0xB0, 0x19, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x18, 0xF3,
  0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xF3, 0x8E, 0x39, 0xC7,
  0x18, 0x63, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x0E, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x30, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x00, 0xC0, 0x08, 0x00, 0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x3E, 0x0F, 0x81, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x70,
  0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x38, 0x1C, 0x30, 0x0E, 0x70, 0x06, 0x60,
  0x07, 0x60, 0x07, 0x60, 0x23, 0xE1, 0xFB, 0xE1, 0xCF, 0xE3, 0x87, 0xE3,
  0x07, 0xE3, 0x03, 0xE3, 0x03, 0xE3, 0x03, 0xE3, 0x07, 0xE3, 0x07, 0xE3,
  0x87, 0xE1, 0xCB, 0x60, 0xFB, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x38, 0x1C, 0xE0, 0x61,
  0x81, 0x86, 0x0E, 0x1C, 0x30, 0x30, 0xC0, 0xC3, 0xFF, 0x1F, 0xFE, 0x60,
  0x19, 0x80, 0x66, 0x01, 0xB8, 0x07, 0xC0, 0x0F, 0x00, 0x30, 0xFF, 0x87,
  0xFE, 0x30, 0x39, 0x80, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x76, 0x0F, 0x3F, 0xE1, 0xFF, 0xCC, 0x07, 0x60, 0x1B, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0D, 0x81, 0xEF, 0xFE, 0x7F, 0xC0, 0x1F, 0x87,
  0xFE, 0x70, 0xFE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3C,
  0x03, 0xE0, 0x77, 0x07, 0x7F, 0xE1, 0xFC, 0xFF, 0x0F, 0xFC, 0xC1, 0xEC,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x1E, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0x3F, 0xF9, 0xFF, 0xCE,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFD, 0xFF, 0xEC,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x00, 0x1F, 0x87, 0xFE, 0x70, 0xFE, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x7F, 0xC7, 0xFC,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x77, 0x07, 0x7F, 0xE1,
  0xFC, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x0D, 0xE0, 0xE7, 0xFE, 0x0F, 0xE0, 0xC0, 0x1B, 0x00, 0xEC, 0x07,
  0x30, 0x1C, 0xC0, 0xE3, 0x03, 0x8C, 0x1C, 0x30, 0x70, 0xC3, 0x83, 0x0E,
  0x0F, 0xF0, 0x3F, 0xC0, 0xC3, 0x83, 0x06, 0x0C, 0x1C, 0x30, 0x30, 0xC0,
  0xE3, 0x01, 0x8C, 0x07, 0x30, 0x0C, 0xC0, 0x3B, 0x00, 0x70, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF6, 0x1B, 0xD8, 0x6F, 0x61, 0xBC, 0xCC, 0xFB, 0x37,
  0xEC, 0xDF, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x70, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xD8, 0x3D, 0x83, 0xD8, 0x3C,
  0xC3, 0xCC, 0x3C, 0xE3, 0xC6, 0x3C, 0x63, 0xC7, 0x3C, 0x33, 0xC3, 0x3C,
  0x1B, 0xC1, 0xBC, 0x1B, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0x1F, 0x87,
  0xFE, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x77, 0x0E, 0x7F, 0xE1, 0xF8, 0xFF, 0x87, 0xFF, 0x30, 0x3D,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x3D, 0xFF, 0xCF, 0xF8, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x1F, 0x83, 0xFF, 0x1C, 0x39,
  0xC0, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0,
  0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01,
  0xB8, 0x1D, 0xE1, 0xE7, 0xFE, 0x0F, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1E, 0xFF, 0x87, 0xFF, 0x30, 0x3D, 0x80, 0x6C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xBF, 0xFD, 0xFF, 0x8F, 0xF8,
  0x61, 0xC3, 0x07, 0x18, 0x38, 0xC0, 0xE6, 0x07, 0x30, 0x1D, 0x80, 0xEC,
  0x03, 0xE0, 0x1C, 0x0F, 0xE0, 0xFF, 0xC3, 0x87, 0x9C, 0x06, 0x60, 0x19,
  0x80, 0x66, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x76, 0x01,
  0x9C, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x77, 0x0E, 0x7F, 0xE1, 0xFC, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xD8,
  0x06, 0x60, 0x19, 0xC0, 0x67, 0x03, 0x8C, 0x0C, 0x30, 0x30, 0xE0, 0xC3,
  0x87, 0x06, 0x18, 0x18, 0x60, 0x71, 0x81, 0xCE, 0x03, 0x30, 0x0C, 0xC0,
  0x3B, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xC1, 0x83, 0xC1,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xC7, 0x63, 0xC6, 0x63, 0x46, 0x62,
  0x46, 0x62, 0x46, 0x62, 0x46, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x76,
  0x6E, 0x34, 0x2C, 0x34, 0x2C, 0x34, 0x2C, 0x34, 0x2C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x18,
  0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0x70, 0x0C,
  0x70, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x18,
  0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFC, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x06, 0x00, 0xF0,
  0x0F, 0x01, 0x98, 0x19, 0x83, 0x9C, 0x30, 0xC3, 0x0E, 0x60, 0x66, 0x06,
  0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x87, 0x0E, 0x1C, 0x07,
  0x80, 0xFF, 0x0F, 0x3C, 0xE0, 0x76, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xFF,
  0x3F, 0xFB, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1D, 0x81, 0xEF,
  0xFB, 0x3F, 0x98, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x70,
  0xDF, 0xCD, 0x9E, 0xE0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7F, 0x0F, 0xDF, 0xEC, 0xFC,
  0x0F, 0x03, 0xFC, 0x79, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3E, 0x07, 0x70, 0x77, 0xFE,
  0x1F, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xE3, 0x3F,
  0xB7, 0x9B, 0xE0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7F, 0x0F, 0x7F, 0xB3, 0xF3, 0x0F,
  0x03, 0xFC, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x03, 0x60, 0x77, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x3F, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x0E, 0x33, 0xFB, 0x79, 0xBE, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x77,
  0x0B, 0x7F, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x3F, 0xE3,
  0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x70, 0xDF, 0xCD,
  0x0E, 0xE0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x07, 0x00,
  0x3E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF3, 0xFE, 0x7F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x73, 0xFC, 0x7F, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x6C, 0x03, 0xB0, 0x1C, 0xC0, 0x63, 0x03, 0x8C,
  0x1C, 0x30, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x30, 0xE0, 0xC1, 0xC3,
  0x03, 0x8C, 0x0E, 0x30, 0x1C, 0xC0, 0x3B, 0x00, 0xF0, 0xFF, 0x01, 0xFE,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0xCC, 0x73, 0x7B, 0xEE, 0x79, 0xF0, 0xC3, 0xC3, 0x0F,
  0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3,
  0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0C, 0xC7, 0x0D, 0xFC,
  0xD9, 0xEE, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x0F,
  0x03, 0xFC, 0x79, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0x70, 0xE7, 0xFE, 0x1F,
  0x80, 0xC7, 0x0D, 0xFC, 0xD9, 0xEE, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0xFD,
  0xFE, 0xCF, 0xCC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x33,
  0xFB, 0x79, 0xBE, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0xF7, 0xFB, 0x3F, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xE7, 0x87, 0x7F, 0x3E, 0x3D,
  0xE0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1F,
  0x83, 0xFF, 0x1C, 0x3D, 0xC0, 0x6E, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x1C, 0x00, 0x60, 0x03, 0xE0, 0x1B, 0x81, 0xCF,
  0xFE, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xF0,
  0x3F, 0x80, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0x70,
  0xE7, 0xFE, 0x1F, 0x80, 0xC0, 0x0F, 0x80, 0x76, 0x01, 0xD8, 0x06, 0x70,
  0x38, 0xC0, 0xC3, 0x03, 0x0E, 0x1C, 0x18, 0x60, 0x61, 0x81, 0xCE, 0x03,
  0x30, 0x0C, 0xC0, 0x3B, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xC1, 0x83,
  0xC1, 0x83, 0xE1, 0x87, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0x46, 0x62, 0x46,
  0x62, 0x46, 0x62, 0x64, 0x36, 0x6C, 0x36, 0x6C, 0x34, 0x6C, 0x34, 0x2C,
  0x34, 0x2C, 0x3C, 0x28, 0x1C, 0x38, 0x1C, 0x38, 0xE0, 0x1D, 0xC0, 0x67,
  0x03, 0x8E, 0x1C, 0x18, 0x60, 0x73, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0xFC, 0x07, 0x38, 0x18, 0x60, 0xE1, 0xC7, 0x03, 0x98, 0x06,
  0xE0, 0x1C, 0xC0, 0x0F, 0x80, 0x76, 0x01, 0x9C, 0x06, 0x70, 0x38, 0xC0,
  0xC3, 0x87, 0x06, 0x1C, 0x1C, 0x60, 0x73, 0x80, 0xCC, 0x03, 0xB0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x1F, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x0F, 0xE0, 0xFC, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0x7F, 0x03, 0xF0, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0xFC,
  0x0F, 0x00, 0x10, 0x01, 0xF8, 0x3F, 0xF0, 0xF0, 0xC3, 0xC1, 0xFF, 0x03,
  0xE0,
};

const GFXglyph JetBrainsMono_Light30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 22, 18, 7, -22 },
  { 12, 8, 9, 18, 5, -22 },
  { 21, 16, 22, 18, 1, -22 },
  { 65, 14, 30, 18, 2, -26 },
  { 118, 18, 22, 18, 0, -22 },
  { 168, 15, 22, 18, 2, -22 },
  { 210, 2, 9, 18, 8, -22 },
  { 213, 9, 29, 18, 6, -25 },
  { 246, 9, 29, 18, 3, -25 },
  { 279, 16, 15, 18, 1, -18 },
  { 309, 14, 14, 18, 2, -17 },
  { 334, 6, 10, 18, 5, -5 },
  { 342, 10, 2, 18, 4, -11 },
  { 345, 4, 5, 18, 7, -5 },
  { 348, 14, 28, 18, 2, -25 },
  { 397, 14, 22, 18, 2, -22 },
  { 436, 13, 22, 18, 3, -22 },
  { 472, 14, 22, 18, 2, -22 },
  { 511, 13, 22, 18, 2, -22 },
  { 547, 12, 22, 18, 3, -22 },
  { 580, 12, 22, 18, 3, -22 },
  { 613, 14, 22, 18, 2, -22 },
  { 652, 14, 22, 18, 2, -22 },
  { 691, 14, 22, 18, 2, -22 },
  { 730, 14, 22, 18, 2, -22 },
  { 769, 4, 17, 18, 7, -17 },
  { 778, 6, 22, 18, 5, -17 },
  { 795, 12, 16, 18, 3, -18 },
  { 819, 12, 10, 18, 3, -15 },
  { 834, 12, 16, 18, 3, -18 },
  { 858, 11, 22, 18, 4, -22 },
  { 889, 16, 27, 18, 1, -22 },
  { 943, 14, 22, 18, 2, -22 },
  { 982, 13, 22, 18, 3, -22 },
  { 1018, 12, 22, 18, 3, -22 },
  { 1051, 12, 22, 18, 3, -22 },
  { 1084, 13, 22, 18, 3, -22 },
  { 1120, 13, 22, 18, 3, -22 },
  { 1156, 12, 22, 18, 3, -22 },
  { 1189, 12, 22, 18, 3, -22 },
  { 1222, 12, 22, 18, 3, -22 },
  { 1255, 13, 22, 18, 2, -22 },
  { 1291, 14, 22, 18, 3, -22 },
  { 1330, 13, 22, 18, 3, -22 },
  { 1366, 14, 22, 18, 2, -22 },
  { 1405, 12, 22, 18, 3, -22 },
  { 1438, 12, 22, 18, 3, -22 },
  { 1471, 13, 22, 18, 3, -22 },
  { 1507, 13, 27, 18, 3, -22 },
  { 1551, 13, 22, 18, 3, -22 },
  { 1587, 14, 22, 18, 2, -22 },
  { 1626, 14, 22, 18, 2, -22 },
  { 1665, 12, 22, 18, 3, -22 },
  { 1698, 14, 22, 18, 2, -22 },
  { 1737, 16, 22, 18, 1, -22 },
  { 1781, 16, 22, 18, 1, -22 },
  { 1825, 16, 22, 18, 1, -22 },
  { 1869, 12, 22, 18, 3, -22 },
  { 1902, 7, 28, 18, 6, -25 },
  { 1927, 14, 28, 18, 2, -25 },
  { 1976, 7, 28, 18, 5, -25 },
  { 2001, 12, 12, 18, 3, -22 },
  { 2019, 14, 2, 18, 2, 1 },
  { 2023, 6, 5, 18, 6, -24 },
  { 2027, 13, 17, 18, 2, -17 },
  { 2055, 12, 22, 18, 3, -22 },
  { 2088, 12, 17, 18, 3, -17 },
  { 2114, 12, 22, 18, 3, -22 },
  { 2147, 12, 17, 18, 3, -17 },
  { 2173, 14, 22, 18, 2, -22 },
  { 2212, 12, 22, 18, 3, -17 },
  { 2245, 12, 22, 18, 3, -22 },
  { 2278, 14, 23, 18, 3, -23 },
  { 2319, 11, 28, 18, 3, -23 },
  { 2358, 14, 22, 18, 3, -22 },
  { 2397, 15, 22, 18, 1, -22 },
  { 2439, 14, 17, 18, 2, -17 },
  { 2469, 12, 17, 18, 3, -17 },
  { 2495, 12, 17, 18, 3, -17 },
  { 2521, 12, 22, 18, 3, -17 },
  { 2554, 12, 22, 18, 3, -17 },
  { 2587, 13, 17, 18, 3, -17 },
  { 2615, 13, 17, 18, 3, -17 },
  { 2643, 13, 21, 18, 2, -21 },
  { 2678, 12, 17, 18, 3, -17 },
  { 2704, 14, 17, 18, 2, -17 },
  { 2734, 16, 17, 18, 1, -17 },
  { 2768, 14, 17, 18, 2, -17 },
  { 2798, 14, 22, 18, 2, -17 },
  { 2837, 12, 17, 18, 3, -17 },
  { 2863, 12, 28, 18, 3, -25 },
  { 2905, 2, 28, 18, 8, -25 },
  { 2912, 12, 28, 18, 3, -25 },
  { 2954, 14, 6, 18, 2, -14 },
};

const GFXfont JetBrainsMono_Light30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_LIGHT30PT7B_H_
