#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/JetBrainsMono_Light
// Headers: 67

#include "JetBrainsMono_Light6pt7b.h"
#include "JetBrainsMono_Light7pt7b.h"
#include "JetBrainsMono_Light8pt7b.h"
#include "JetBrainsMono_Light9pt7b.h"
#include "JetBrainsMono_Light10pt7b.h"
#include "JetBrainsMono_Light11pt7b.h"
#include "JetBrainsMono_Light12pt7b.h"
#include "JetBrainsMono_Light13pt7b.h"
#include "JetBrainsMono_Light14pt7b.h"
#include "JetBrainsMono_Light15pt7b.h"
#include "JetBrainsMono_Light16pt7b.h"
#include "JetBrainsMono_Light17pt7b.h"
#include "JetBrainsMono_Light18pt7b.h"
#include "JetBrainsMono_Light19pt7b.h"
#include "JetBrainsMono_Light20pt7b.h"
#include "JetBrainsMono_Light21pt7b.h"
#include "JetBrainsMono_Light22pt7b.h"
#include "JetBrainsMono_Light23pt7b.h"
#include "JetBrainsMono_Light24pt7b.h"
#include "JetBrainsMono_Light25pt7b.h"
#include "JetBrainsMono_Light26pt7b.h"
#include "JetBrainsMono_Light27pt7b.h"
#include "JetBrainsMono_Light28pt7b.h"
#include "JetBrainsMono_Light29pt7b.h"
#include "JetBrainsMono_Light30pt7b.h"
#include "JetBrainsMono_Light31pt7b.h"
#include "JetBrainsMono_Light32pt7b.h"
#include "JetBrainsMono_Light33pt7b.h"
#include "JetBrainsMono_Light34pt7b.h"
#include "JetBrainsMono_Light35pt7b.h"
#include "JetBrainsMono_Light36pt7b.h"
#include "JetBrainsMono_Light37pt7b.h"
#include "JetBrainsMono_Light38pt7b.h"
#include "JetBrainsMono_Light39pt7b.h"
#include "JetBrainsMono_Light40pt7b.h"
#include "JetBrainsMono_Light41pt7b.h"
#include "JetBrainsMono_Light42pt7b.h"
#include "JetBrainsMono_Light43pt7b.h"
#include "JetBrainsMono_Light44pt7b.h"
#include "JetBrainsMono_Light45pt7b.h"
#include "JetBrainsMono_Light46pt7b.h"
#include "JetBrainsMono_Light47pt7b.h"
#include "JetBrainsMono_Light48pt7b.h"
#include "JetBrainsMono_Light49pt7b.h"
#include "JetBrainsMono_Light50pt7b.h"
#include "JetBrainsMono_Light51pt7b.h"
#include "JetBrainsMono_Light52pt7b.h"
#include "JetBrainsMono_Light53pt7b.h"
#include "JetBrainsMono_Light54pt7b.h"
#include "JetBrainsMono_Light55pt7b.h"
#include "JetBrainsMono_Light56pt7b.h"
#include "JetBrainsMono_Light57pt7b.h"
#include "JetBrainsMono_Light58pt7b.h"
#include "JetBrainsMono_Light59pt7b.h"
#include "JetBrainsMono_Light60pt7b.h"
#include "JetBrainsMono_Light61pt7b.h"
#include "JetBrainsMono_Light62pt7b.h"
#include "JetBrainsMono_Light63pt7b.h"
#include "JetBrainsMono_Light64pt7b.h"
#include "JetBrainsMono_Light65pt7b.h"
#include "JetBrainsMono_Light66pt7b.h"
#include "JetBrainsMono_Light67pt7b.h"
#include "JetBrainsMono_Light68pt7b.h"
#include "JetBrainsMono_Light69pt7b.h"
#include "JetBrainsMono_Light70pt7b.h"
#include "JetBrainsMono_Light71pt7b.h"
#include "JetBrainsMono_Light72pt7b.h"
