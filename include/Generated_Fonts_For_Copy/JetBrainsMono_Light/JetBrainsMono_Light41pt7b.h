#ifndef _JETBRAINSMONO_LIGHT41PT7B_H_
#define _JETBRAINSMONO_LIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light41pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x30, 0x00, 0x00, 0x00, 0xC7, 0xFF, 0x7D, 0xF0,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x07,
  0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x01, 0xC0,
  0x0C, 0x07, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x18,
  0x0E, 0x00, 0x60, 0x38, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC0, 0xE0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x70, 0x18, 0x01,
  0xC0, 0x60, 0x07, 0x03, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x38, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x03, 0x01, 0xC0,
  0x0C, 0x07, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x18,
  0x0E, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0x9C, 0xF1, 0xE3, 0x8F, 0x38, 0x70, 0xE7, 0x0E, 0x1C,
  0xE1, 0xC3, 0x9C, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x07, 0x9C, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0x7C, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x87, 0x00, 0x70, 0xEE,
  0x0E, 0x1F, 0xC1, 0xC3, 0xBC, 0x38, 0x73, 0x87, 0x1E, 0x7C, 0xE7, 0x87,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0E,
  0xFF, 0x80, 0x3B, 0xCF, 0x00, 0x67, 0x07, 0x01, 0xCE, 0x0E, 0x07, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xE3, 0x81, 0xC1,
  0xC6, 0x03, 0x87, 0x9C, 0x03, 0xFE, 0x70, 0x03, 0xF8, 0xC0, 0x00, 0x83,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x40, 0x01, 0xC7,
  0xF0, 0x03, 0x1F, 0xF0, 0x0E, 0x70, 0xE0, 0x38, 0xE0, 0xE0, 0xE1, 0x81,
  0xC1, 0xC3, 0x03, 0x87, 0x06, 0x07, 0x1C, 0x0C, 0x0E, 0x30, 0x18, 0x1C,
  0xE0, 0x38, 0x3B, 0x80, 0x79, 0xE6, 0x00, 0x7F, 0x9C, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3C, 0x1E, 0x03, 0xC0,
  0x78, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0x3C, 0x0F, 0x70, 0xE0, 0x77, 0x87, 0x87, 0xBC,
  0x1E, 0x39, 0xE0, 0x73, 0xCF, 0x01, 0xDC, 0x78, 0x0F, 0xC3, 0xC0, 0x3E,
  0x1E, 0x00, 0xE0, 0xF0, 0x0F, 0x83, 0x80, 0x7E, 0x1E, 0x0F, 0x78, 0xFF,
  0xF9, 0xC3, 0xFF, 0x0F, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0x77, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x30,
  0xE0, 0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0xF8, 0x1F, 0x0F, 0xE0, 0xF8, 0x0F, 0x00, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x03, 0x01, 0xC0, 0xDF, 0x0E, 0x3F, 0xFE, 0x67, 0xFB, 0xFF,
  0x7F, 0x03, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00,
  0x0E, 0x78, 0x00, 0xF1, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x81,
  0xE0, 0x38, 0x07, 0x80, 0xC0, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x38,
  0x78, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x79,
  0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF0, 0xF0, 0x1E, 0x78, 0x03, 0x9C, 0x00, 0xF7, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x78, 0x7F, 0x1F, 0x1F, 0xC7, 0xC7, 0xF1, 0xE1, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1D, 0xC0, 0x07, 0x70, 0x03, 0xDE, 0x00, 0xE3, 0xC0, 0x78, 0xFE, 0xFC,
  0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0xFB, 0x80, 0x7C, 0xE0, 0x3C, 0x38, 0x0E, 0x0E, 0x03, 0x03, 0x80, 0x80,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3E, 0x03, 0xC7, 0x80,
  0x38, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0x9C, 0x01, 0xE7,
  0x80, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x1C, 0x78, 0x0E, 0x78, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDE, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x78,
  0x1E, 0xFF, 0x8F, 0xFF, 0xE7, 0xE1, 0xFB, 0xE0, 0x3D, 0xE0, 0x0F, 0xF0,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0x9E, 0x03, 0xCF, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xDF, 0xC0,
  0x77, 0xFE, 0x1F, 0xC7, 0xE3, 0xE0, 0x3C, 0x78, 0x03, 0xDE, 0x00, 0x3B,
  0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0E, 0x70, 0x01, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0,
  0xF0, 0x1E, 0x78, 0x03, 0x9C, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0F, 0x70,
  0x03, 0xDE, 0x00, 0xE3, 0x80, 0x78, 0x70, 0x3C, 0x0F, 0x1E, 0x01, 0xFF,
  0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0x1E, 0x0F, 0x03, 0xC7, 0x80, 0x79,
  0xC0, 0x0F, 0x70, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0x70,
  0x01, 0xDE, 0x00, 0xF7, 0xC0, 0x78, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1E, 0x03, 0xC7, 0x80,
  0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xEF, 0x00, 0x1C, 0xE0, 0x07, 0x9E, 0x01,
  0xF1, 0xF8, 0xFC, 0x1F, 0xFF, 0x81, 0xFE, 0xE0, 0x06, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x61, 0xF7, 0xEF, 0xFF, 0x9F, 0x00, 0x1E, 0x1F,
  0x8F, 0xE7, 0xF3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0,
  0x78, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x70, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x60, 0x00, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x03, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0x80,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xE1, 0xF0, 0x78, 0x03, 0xC3, 0x80, 0x0F,
  0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xCF, 0xC0, 0xFF, 0x7E, 0x07, 0xFF, 0xF0, 0x78, 0x3F,
  0x83, 0x80, 0xFC, 0x1C, 0x07, 0xE0, 0xE0, 0x3F, 0x07, 0x01, 0xF8, 0x38,
  0x0F, 0xC1, 0xC0, 0x7E, 0x0E, 0x03, 0xF0, 0x70, 0x1F, 0x83, 0x80, 0xFC,
  0x1C, 0x0F, 0xE0, 0xF0, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x1C,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xDC, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x0E, 0x07, 0x00, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x03,
  0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x38, 0x01, 0xC3, 0x80,
  0x1E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0F, 0x70,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80,
  0x7C, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03,
  0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x1E, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xF8, 0xE0, 0x1F, 0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x03,
  0xB8, 0x01, 0xEE, 0x01, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x01, 0xEF, 0x00, 0x77, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x03, 0xC7, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x07,
  0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x07, 0xB8,
  0x0F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0x01, 0xEF, 0x00, 0x77, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xDE, 0x03, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xDE, 0x00, 0xE7, 0xC0, 0x78, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00,
  0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0xF1,
  0xC0, 0x1E, 0x38, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x3C, 0x1C, 0x07, 0x83,
  0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x0F, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1E, 0x0E,
  0x03, 0xC1, 0xC0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0x78, 0xE0, 0x0F, 0x1C,
  0x00, 0xF3, 0x80, 0x1E, 0x70, 0x01, 0xCE, 0x00, 0x3D, 0xC0, 0x03, 0x80,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0E, 0xFB, 0x03, 0xBE, 0xE0, 0xEF, 0xB8, 0x33, 0xE6, 0x1C,
  0xF9, 0xC7, 0x7E, 0x71, 0x9F, 0x8C, 0xE7, 0xE3, 0xB9, 0xF8, 0xEC, 0x7E,
  0x1F, 0x1F, 0x87, 0xC7, 0xE0, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xB8, 0x0F, 0xDC, 0x07, 0xEE, 0x03, 0xF3, 0x81, 0xF9, 0xC0, 0xFC,
  0x60, 0x7E, 0x38, 0x3F, 0x1C, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3,
  0xF0, 0x71, 0xF8, 0x38, 0xFC, 0x1C, 0x7E, 0x07, 0x3F, 0x03, 0x9F, 0x80,
  0xCF, 0xC0, 0x77, 0xE0, 0x3B, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7C, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x01,
  0xEF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0x78, 0x03, 0x9E,
  0x03, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0x80, 0x3E, 0xE0, 0x07, 0xB8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0x01,
  0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0x9E,
  0x03, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x07, 0xB8, 0x00,
  0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x03, 0xCF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0x81, 0xE0, 0xE0, 0x3C, 0x38, 0x0F,
  0x0E, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x00, 0x73,
  0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1E, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x07, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xB8,
  0x00, 0x7F, 0x00, 0x0E, 0xF0, 0x01, 0xCE, 0x00, 0x79, 0xF0, 0x1E, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0x78, 0x03, 0x9E, 0x03, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0,
  0x7F, 0xC0, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0E,
  0x78, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x01,
  0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x80, 0xF0, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07,
  0x0F, 0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00,
  0x3D, 0xC0, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x01, 0xD8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0xE0, 0x38, 0x1F, 0x81, 0xE0, 0x7F, 0x07,
  0x81, 0xDC, 0x1B, 0x07, 0x70, 0x6C, 0x1D, 0xC1, 0xB0, 0x77, 0x06, 0xC1,
  0xDC, 0x1B, 0x07, 0x70, 0x6C, 0x19, 0xC3, 0xB0, 0xE7, 0x0C, 0xC3, 0x8E,
  0x33, 0x8E, 0x38, 0xC6, 0x38, 0xE3, 0x18, 0xE3, 0x8C, 0x63, 0x8E, 0x31,
  0x8E, 0x38, 0xC6, 0x30, 0xE7, 0x18, 0xC3, 0x98, 0x67, 0x0E, 0x61, 0x9C,
  0x1D, 0x83, 0x70, 0x76, 0x0D, 0xC1, 0xD8, 0x37, 0x07, 0x60, 0xDC, 0x1F,
  0x83, 0x70, 0x7C, 0x0D, 0x81, 0xF0, 0x36, 0x07, 0xC0, 0xF8, 0x0F, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x0E, 0x00, 0x78,
  0x78, 0x03, 0x81, 0xC0, 0x3C, 0x0F, 0x01, 0xC0, 0x38, 0x1E, 0x01, 0xE0,
  0xE0, 0x07, 0x0F, 0x00, 0x1C, 0x70, 0x00, 0xF7, 0x00, 0x03, 0xB8, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x3C, 0x00, 0x78, 0xF0, 0x03,
  0x83, 0x80, 0x38, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0xC1, 0xE0, 0x0E,
  0x0E, 0x00, 0x78, 0xF0, 0x01, 0xC7, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x80, 0x1E,
  0x1E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x78,
  0x38, 0x01, 0xC1, 0xC0, 0x0F, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00,
  0x07, 0x70, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x03, 0xB8, 0x01, 0xCE,
  0x00, 0x71, 0xC0, 0x38, 0x70, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70,
  0x70, 0x1C, 0x38, 0x07, 0x8E, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x1E,
  0x0F, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x07,
  0x9E, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0x7C, 0x3F,
  0xCF, 0xFE, 0xF1, 0xFF, 0x3C, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC3, 0xE0, 0xE7, 0xFC,
  0x77, 0xFF, 0x3F, 0x07, 0xDF, 0x01, 0xEF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xBE, 0x03, 0xDD, 0xEF, 0xCE, 0xFF, 0xE7, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xEF, 0x00, 0x77, 0x80, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0xFC,
  0x01, 0xEF, 0x01, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x1F, 0x8F, 0x1F, 0xF7, 0x9F, 0xFF, 0xDF, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xDE, 0x03, 0xEF, 0xEF, 0xF3, 0xFF, 0x78,
  0xFF, 0x3C, 0x07, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x03, 0xEF, 0x00,
  0xF7, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xE7, 0xE3, 0xE1, 0xFF,
  0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xC7, 0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0x83, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xBC, 0x07, 0xDF, 0x9F, 0xE7, 0xFE, 0xF1, 0xFE, 0x78,
  0x08, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC3, 0xE0,
  0xE7, 0xFC, 0x77, 0xFF, 0x3F, 0x07, 0xDE, 0x01, 0xEF, 0x00, 0x77, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3C, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xCF, 0xFF,
  0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E,
  0xE0, 0x03, 0xDC, 0x00, 0xF3, 0x80, 0x3C, 0x70, 0x07, 0x8E, 0x01, 0xE1,
  0xC0, 0x78, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x0E, 0x0F, 0x01, 0xC0, 0xF0, 0x38, 0x0F, 0x07,
  0x01, 0xE0, 0xE0, 0x1E, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x03, 0xCE,
  0x00, 0x3D, 0xC0, 0x07, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0xE7, 0x8F, 0x1D, 0xFB, 0xFB, 0xFF, 0x7F, 0x78, 0xF0, 0xEE, 0x0E, 0x0F,
  0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F,
  0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F,
  0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E,
  0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x38, 0xE1, 0xF0, 0x73, 0xFE, 0x3B,
  0xFF, 0x9F, 0x83, 0xEF, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1E, 0x07, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0x83, 0xEF, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xCF, 0x01, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xC0, 0xE1, 0xF0, 0x73,
  0xFE, 0x3B, 0xFF, 0x9F, 0x83, 0xEF, 0x80, 0xF7, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xDF, 0x01, 0xEE, 0xF7, 0xE7, 0x7F, 0xE3, 0x8F, 0xE1, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xC7, 0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0x83, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x03, 0xEF, 0x01, 0xF7, 0xF7, 0xF9, 0xFF, 0xBC,
  0x7F, 0x9E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0xE3, 0xF0, 0x73, 0xFE, 0x3B, 0xFF, 0x9F,
  0x03, 0xEF, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF,
  0xCF, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0xF7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFE, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xCF, 0x01, 0xE3, 0xF7,
  0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x78, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0,
  0x1C, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x70, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x07, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00,
  0x39, 0xC0, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x3C, 0x0F, 0xC1,
  0xE0, 0x6E, 0x0D, 0x83, 0x70, 0x6C, 0x39, 0x83, 0x61, 0xCE, 0x1B, 0x0E,
  0x71, 0x98, 0x73, 0x8C, 0xC3, 0x1C, 0x63, 0x18, 0xE3, 0x18, 0xC3, 0x18,
  0xCE, 0x18, 0xC6, 0x70, 0xEC, 0x33, 0x87, 0x61, 0x98, 0x3B, 0x0E, 0xC1,
  0xD8, 0x36, 0x06, 0xC1, 0xF0, 0x36, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x00, 0x78, 0x00, 0xF3, 0x80, 0x1E, 0x3C, 0x01, 0xC1,
  0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xF0, 0x70, 0x07, 0x8F, 0x00, 0x39, 0xE0,
  0x03, 0xDC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0x03, 0xDC, 0x00, 0x79, 0xE0, 0x07, 0x0F, 0x00, 0xF0,
  0x70, 0x1E, 0x07, 0x81, 0xC0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0x77, 0x80, 0x0F, 0x78, 0x00, 0xE3, 0x80, 0x0E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x1C, 0x03, 0xC1, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0x70, 0x70, 0x07, 0x8F, 0x00, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x3D, 0xE0, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x1D,
  0xFE, 0x03, 0xF9, 0xE0, 0x7E, 0x1E, 0x0F, 0xC1, 0xE3, 0xB8, 0x1F, 0xF7,
  0x01, 0xFC, 0xE0, 0x0C, 0x00,
};

const GFXglyph JetBrainsMono_Light41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 30, 25, 9, -30 },
  { 24, 12, 12, 25, 6, -30 },
  { 42, 22, 30, 25, 1, -30 },
  { 125, 19, 42, 25, 3, -36 },
  { 225, 23, 30, 25, 1, -30 },
  { 312, 21, 30, 25, 2, -30 },
  { 391, 4, 12, 25, 10, -30 },
  { 397, 12, 39, 25, 8, -34 },
  { 456, 12, 39, 25, 5, -34 },
  { 515, 21, 21, 25, 2, -25 },
  { 571, 19, 19, 25, 3, -23 },
  { 617, 8, 13, 25, 7, -6 },
  { 630, 13, 3, 25, 6, -15 },
  { 635, 7, 6, 25, 9, -6 },
  { 641, 18, 39, 25, 3, -34 },
  { 729, 18, 30, 25, 3, -30 },
  { 797, 18, 30, 25, 4, -30 },
  { 865, 19, 30, 25, 3, -30 },
  { 937, 18, 30, 25, 3, -30 },
  { 1005, 17, 30, 25, 3, -30 },
  { 1069, 17, 30, 25, 4, -30 },
  { 1133, 19, 30, 25, 3, -30 },
  { 1205, 19, 30, 25, 3, -30 },
  { 1277, 18, 30, 25, 3, -30 },
  { 1345, 19, 30, 25, 3, -30 },
  { 1417, 7, 23, 25, 9, -23 },
  { 1438, 9, 30, 25, 7, -23 },
  { 1472, 17, 21, 25, 4, -24 },
  { 1517, 17, 13, 25, 4, -20 },
  { 1545, 17, 21, 25, 4, -24 },
  { 1590, 14, 30, 25, 6, -30 },
  { 1643, 21, 37, 25, 2, -30 },
  { 1741, 20, 30, 25, 2, -30 },
  { 1816, 18, 30, 25, 4, -30 },
  { 1884, 17, 30, 25, 4, -30 },
  { 1948, 17, 30, 25, 4, -30 },
  { 2012, 17, 30, 25, 4, -30 },
  { 2076, 18, 30, 25, 4, -30 },
  { 2144, 17, 30, 25, 4, -30 },
  { 2208, 17, 30, 25, 4, -30 },
  { 2272, 16, 30, 25, 4, -30 },
  { 2332, 18, 30, 25, 2, -30 },
  { 2400, 19, 30, 25, 4, -30 },
  { 2472, 17, 30, 25, 5, -30 },
  { 2536, 18, 30, 25, 3, -30 },
  { 2604, 17, 30, 25, 4, -30 },
  { 2668, 17, 30, 25, 4, -30 },
  { 2732, 18, 30, 25, 4, -30 },
  { 2800, 17, 37, 25, 4, -30 },
  { 2879, 18, 30, 25, 4, -30 },
  { 2947, 19, 30, 25, 3, -30 },
  { 3019, 20, 30, 25, 2, -30 },
  { 3094, 17, 30, 25, 4, -30 },
  { 3158, 20, 30, 25, 2, -30 },
  { 3233, 22, 30, 25, 1, -30 },
  { 3316, 21, 30, 25, 2, -30 },
  { 3395, 21, 30, 25, 2, -30 },
  { 3474, 17, 30, 25, 4, -30 },
  { 3538, 9, 39, 25, 9, -34 },
  { 3582, 18, 39, 25, 3, -34 },
  { 3670, 10, 39, 25, 6, -34 },
  { 3719, 18, 16, 25, 3, -30 },
  { 3755, 20, 3, 25, 2, 1 },
  { 3763, 8, 6, 25, 8, -32 },
  { 3769, 18, 23, 25, 3, -23 },
  { 3821, 17, 30, 25, 4, -30 },
  { 3885, 17, 23, 25, 4, -23 },
  { 3934, 17, 30, 25, 4, -30 },
  { 3998, 17, 23, 25, 4, -23 },
  { 4047, 19, 30, 25, 3, -30 },
  { 4119, 17, 30, 25, 4, -23 },
  { 4183, 17, 30, 25, 4, -30 },
  { 4247, 19, 32, 25, 4, -32 },
  { 4323, 15, 39, 25, 4, -32 },
  { 4397, 19, 30, 25, 4, -30 },
  { 4469, 21, 30, 25, 1, -30 },
  { 4548, 19, 23, 25, 3, -23 },
  { 4603, 17, 23, 25, 4, -23 },
  { 4652, 17, 23, 25, 4, -23 },
  { 4701, 17, 30, 25, 4, -23 },
  { 4765, 17, 30, 25, 4, -23 },
  { 4829, 17, 23, 25, 5, -23 },
  { 4878, 17, 23, 25, 4, -23 },
  { 4927, 19, 29, 25, 2, -29 },
  { 4996, 17, 23, 25, 4, -23 },
  { 5045, 20, 23, 25, 2, -23 },
  { 5103, 21, 23, 25, 2, -23 },
  { 5164, 20, 23, 25, 2, -23 },
  { 5222, 20, 30, 25, 2, -23 },
  { 5297, 17, 23, 25, 4, -23 },
  { 5346, 17, 39, 25, 4, -34 },
  { 5429, 3, 39, 25, 11, -34 },
  { 5444, 17, 39, 25, 4, -34 },
  { 5527, 19, 9, 25, 3, -19 },
};

const GFXfont JetBrainsMono_Light41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_LIGHT41PT7B_H_
