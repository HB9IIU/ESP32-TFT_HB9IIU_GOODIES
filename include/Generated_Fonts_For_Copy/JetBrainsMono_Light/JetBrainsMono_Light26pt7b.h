#ifndef _JETBRAINSMONO_LIGHT26PT7B_H_
#define _JETBRAINSMONO_LIGHT26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light26pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0xEF, 0xE0, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC6, 0xC6, 0xC6, 0xC2, 0x04, 0x10, 0x30, 0xC0, 0xC3,
  0x03, 0x0C, 0x0C, 0x31, 0xFF, 0xF7, 0xFF, 0xC6, 0x18, 0x18, 0x60, 0x61,
  0x81, 0x04, 0x04, 0x10, 0xFF, 0xFB, 0xFF, 0xE3, 0x0C, 0x0C, 0x30, 0x20,
  0x81, 0x86, 0x06, 0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x1F,
  0x83, 0xFC, 0x66, 0xE6, 0x66, 0xE6, 0x66, 0x60, 0x66, 0x07, 0x60, 0x3E,
  0x01, 0xF8, 0x07, 0xC0, 0x6E, 0x06, 0x60, 0x67, 0xC6, 0x3C, 0x66, 0xE6,
  0x67, 0xFC, 0x1F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x06,
  0xFC, 0x19, 0x0C, 0x22, 0x18, 0xC4, 0x33, 0x08, 0x64, 0x19, 0x98, 0x3F,
  0x60, 0x18, 0x80, 0x03, 0x00, 0x0C, 0x40, 0x13, 0xE0, 0x6C, 0x61, 0x98,
  0xC6, 0x31, 0x8C, 0x63, 0x30, 0xC6, 0xC1, 0xFF, 0x01, 0xF0, 0x3F, 0x03,
  0xFC, 0x18, 0x70, 0xC1, 0x86, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x78,
  0x07, 0xE0, 0x73, 0x0D, 0x8C, 0xCC, 0x36, 0x61, 0xE3, 0x07, 0x18, 0x38,
  0xC3, 0xE7, 0xFB, 0x9F, 0x8E, 0xFF, 0xFF, 0x03, 0x0F, 0x1E, 0x38, 0x70,
  0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x18,
  0x0C, 0x0E, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x06, 0x06, 0x0C, 0x1C, 0x38, 0xF0, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0xC3, 0x1B, 0xE9, 0xF3, 0xFF, 0x00, 0xC0, 0x07,
  0x80, 0x37, 0x01, 0xCC, 0x0E, 0x18, 0x30, 0x70, 0x01, 0x00, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0xE3, 0x8C, 0x71, 0x86, 0x38,
  0xFF, 0x6F, 0xFE, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x00, 0x1F, 0x8F, 0xF9, 0x83, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC6, 0x79, 0xCF, 0x19, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0x03, 0x60, 0xEF, 0xF8, 0x7E, 0x00, 0x0F, 0x01, 0xF0, 0x3B,
  0x0E, 0x30, 0xC3, 0x08, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0x87, 0xFC, 0x60, 0xEC, 0x06, 0xC0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x78, 0x0F, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xF0, 0x1E, 0x03, 0x60, 0xEF, 0xF8, 0xFE, 0x00, 0x01, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x6E, 0x0D, 0x81,
  0xF0, 0x3C, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x7F, 0xEF, 0xFD, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFE, 0x79,
  0xCC, 0x1D, 0x81, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0x03, 0x60, 0xEF,
  0xF8, 0x7E, 0x00, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x30, 0x7F, 0xC7, 0x0E, 0xE0, 0x6C, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x06, 0x60, 0xE7, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3C, 0x06, 0xC0, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0x1F, 0x87, 0xF9, 0x83, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x39, 0x8E,
  0x1F, 0x83, 0xE0, 0xE7, 0x30, 0x7E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x60,
  0xEF, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xFC, 0x60, 0xEE, 0x06, 0xC0, 0x7C,
  0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x67, 0x0E, 0x3F, 0xE1, 0xEC, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0x4F, 0xFF, 0x00,
  0x00, 0x00, 0x06, 0xFF, 0xF0, 0x33, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF7, 0x39, 0x9C, 0xC6, 0x30, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x30, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x02, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x08, 0x07, 0x03, 0x81, 0xE0,
  0xF0, 0x78, 0x0C, 0x00, 0xFC, 0x7F, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x06,
  0x06, 0x07, 0x1F, 0x0F, 0x06, 0x03, 0x01, 0x80, 0x00, 0x00, 0x70, 0x3C,
  0x1C, 0x00, 0x0F, 0xC1, 0xF7, 0x8C, 0x0E, 0xC0, 0x36, 0x01, 0xE0, 0x07,
  0x03, 0x38, 0x7D, 0xC3, 0x1E, 0x30, 0xF1, 0x83, 0x8C, 0x1C, 0x60, 0xE3,
  0x07, 0x18, 0x78, 0x63, 0xC3, 0xEE, 0x04, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0B, 0x00,
  0xD8, 0x06, 0x60, 0x33, 0x03, 0x18, 0x18, 0xC0, 0xC3, 0x06, 0x18, 0x60,
  0xC3, 0xFE, 0x1F, 0xF8, 0xC0, 0xCC, 0x06, 0x60, 0x3B, 0x00, 0xF8, 0x06,
  0xFE, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0E, 0xFF,
  0x9F, 0xE3, 0x07, 0x60, 0x6C, 0x0F, 0x80, 0xF0, 0x1E, 0x06, 0xC1, 0xDF,
  0xF3, 0xFC, 0x00, 0x1F, 0x87, 0xF9, 0x83, 0xB0, 0x3E, 0x07, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x1B,
  0x03, 0x60, 0xE7, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0xCC, 0x1B, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xBF, 0xEF, 0xE0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x1F, 0x87, 0xF9,
  0x83, 0xB0, 0x3E, 0x07, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0xFF, 0x1F,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1B, 0x03, 0x60, 0xE7, 0xF8, 0x7E, 0x00,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC,
  0x07, 0xF0, 0x7F, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x36, 0x07,
  0x60, 0x63, 0xFC, 0x1F, 0x80, 0xC0, 0x78, 0x1B, 0x03, 0x60, 0xCC, 0x19,
  0x86, 0x30, 0xC6, 0x30, 0xFE, 0x1F, 0xC3, 0x18, 0x63, 0x8C, 0x31, 0x87,
  0x30, 0x66, 0x0E, 0xC0, 0xD8, 0x1F, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xE0,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0B, 0xD1, 0xBD, 0x9B, 0xD9, 0x3C, 0xB3, 0xCF,
  0x3C, 0xE7, 0xC6, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x70, 0xE0, 0x7E, 0x0F, 0xC1, 0xE8, 0x3D, 0x87, 0xB0,
  0xF3, 0x1E, 0x63, 0xC4, 0x78, 0xCF, 0x19, 0xE1, 0x3C, 0x37, 0x86, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0x80, 0x1F, 0x87, 0xF9, 0x83, 0xB0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1B, 0x03, 0x60, 0xE7, 0xF8, 0x7E, 0x00, 0xFF, 0x1F,
  0xFB, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xDF, 0xFB,
  0xFC, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x00, 0x1F, 0x87, 0xFC, 0x60, 0xEE, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6E,
  0x06, 0x60, 0xE7, 0xFC, 0x1F, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0xFF, 0x1F, 0xF3, 0x07, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x06,
  0xC1, 0xDF, 0xF3, 0xF8, 0x63, 0x0C, 0x31, 0x86, 0x30, 0x66, 0x0C, 0xC1,
  0xD8, 0x1B, 0x03, 0x80, 0x1F, 0x83, 0xFC, 0x60, 0xE6, 0x06, 0xE0, 0x66,
  0x00, 0x60, 0x07, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0xC0, 0x3C, 0x07, 0xE0, 0x67, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1B, 0x03, 0x60, 0xE7, 0xF8, 0x7E, 0x00, 0xE0, 0x1B, 0x00, 0xD8, 0x0E,
  0xC0, 0x63, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3, 0x06,
  0x30, 0x39, 0x80, 0xCC, 0x06, 0x60, 0x36, 0x01, 0xB0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0xC3, 0x0F, 0x0C, 0x3C, 0x70, 0xF1, 0xC2, 0xC7, 0x9B, 0x16,
  0x64, 0x59, 0x99, 0x26, 0x64, 0x99, 0x92, 0x66, 0xC9, 0x9B, 0x24, 0x68,
  0x91, 0xA3, 0xC6, 0x8F, 0x0A, 0x1C, 0x28, 0x70, 0xE1, 0xC3, 0x87, 0x00,
  0xE0, 0x1B, 0x81, 0x8C, 0x0C, 0x70, 0xC1, 0x8E, 0x0E, 0x60, 0x36, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1B, 0x00, 0xCC, 0x0C, 0x60, 0x61,
  0x86, 0x0E, 0x30, 0x33, 0x01, 0xF8, 0x06, 0xC0, 0x1D, 0x80, 0x66, 0x03,
  0x0C, 0x0C, 0x30, 0x60, 0x61, 0x81, 0x8C, 0x03, 0x30, 0x0D, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFE, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0xFF, 0xF0, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xFF, 0xFC, 0x06, 0x01, 0xC0, 0x3C, 0x0C, 0x81, 0x98, 0x63, 0x0C,
  0x33, 0x06, 0x60, 0x78, 0x0C, 0xFF, 0xF0, 0xE3, 0x8E, 0x04, 0x07, 0xF1,
  0xC7, 0x30, 0x30, 0x06, 0x00, 0xC0, 0x19, 0xFF, 0x70, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0E, 0xE7, 0xCF, 0xD8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC4,
  0x37, 0xEE, 0x3B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xFF, 0xED, 0xF0, 0x04, 0x07, 0xF1, 0xE7, 0x30, 0x3E,
  0x07, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x01, 0xB0, 0x36, 0x0E,
  0x7F, 0x87, 0xE0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x46, 0x7E, 0xDC,
  0x7B, 0x07, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0x03, 0x60, 0xEF, 0xFC, 0xFD, 0x80, 0x04, 0x07, 0xF1, 0xC7, 0x30, 0x3E,
  0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x36, 0x06,
  0x7F, 0x87, 0xE0, 0x03, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x07, 0xED, 0xC7,
  0xB0, 0x7E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0D, 0x81, 0xB8,
  0x73, 0xFE, 0x3C, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0xFF, 0x1F, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC4, 0x3F, 0xEE, 0x3B, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C,
  0x07, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0xF0, 0x18, 0x00, 0x00,
  0x00, 0x07, 0xF9, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x73, 0xF8,
  0xF8, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xF0, 0x36,
  0x0C, 0xC3, 0x98, 0xE3, 0x18, 0x7E, 0x0F, 0xE1, 0x8E, 0x30, 0xC6, 0x0C,
  0xC1, 0xD8, 0x1B, 0x01, 0x80, 0xFE, 0x07, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xC0, 0xFE,
  0x08, 0x8F, 0xDE, 0xCE, 0x7C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x30, 0x04,
  0x3F, 0xEE, 0x3B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x06, 0x07, 0xF1, 0xE7, 0x30, 0x7E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x36, 0x0E,
  0x7F, 0x87, 0xE0, 0x04, 0x37, 0xEF, 0x3B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xFF, 0xED, 0xF3, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x04, 0x07, 0xED, 0xC7, 0xB0, 0x7E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x36, 0x0E, 0xFF, 0xCF,
  0xD8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x1B, 0xF3, 0xC7,
  0x70, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x00, 0x06, 0x07, 0xF9, 0xC7, 0xB0, 0x36, 0x00,
  0xC0, 0x1E, 0x01, 0xFC, 0x07, 0xE0, 0x0C, 0x01, 0xE0, 0x36, 0x06, 0xFF,
  0xCF, 0xF0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F, 0xFF, 0xFF, 0xC3, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0F, 0xE0, 0xFC, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0x81, 0xB0, 0x73, 0xFC, 0x3F, 0x00, 0xC0,
  0x3C, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x19,
  0x81, 0x98, 0x1B, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xC3, 0x0F, 0x1C, 0x2C,
  0x71, 0x91, 0x46, 0x65, 0x99, 0x96, 0x66, 0x49, 0x1B, 0x24, 0x6C, 0xB0,
  0xA2, 0xC2, 0x8F, 0x0E, 0x3C, 0x38, 0x60, 0xE1, 0x80, 0x70, 0x39, 0x83,
  0x86, 0x18, 0x39, 0x80, 0xDC, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x0F, 0x80,
  0x66, 0x06, 0x38, 0x70, 0xC3, 0x03, 0x70, 0x1C, 0xC0, 0x7E, 0x06, 0x60,
  0x66, 0x0E, 0x70, 0xC3, 0x0C, 0x31, 0xC1, 0x98, 0x19, 0x81, 0xF0, 0x0F,
  0x00, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x3C,
  0x0E, 0x01, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x0F, 0xC1, 0xFC, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x1F, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x3E, 0x0F, 0xC3, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x07, 0xC0,
  0xE0, 0x00, 0x30, 0x3F, 0xC3, 0xCE, 0x3C, 0x77, 0xC3, 0xE0,
};

const GFXglyph JetBrainsMono_Light26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 8, 8, 16, 4, -19 },
  { 19, 14, 19, 16, 1, -19 },
  { 53, 12, 27, 16, 2, -23 },
  { 94, 15, 19, 16, 0, -19 },
  { 130, 13, 19, 16, 2, -19 },
  { 161, 2, 8, 16, 7, -19 },
  { 163, 8, 25, 16, 5, -22 },
  { 188, 8, 25, 16, 3, -22 },
  { 213, 14, 14, 16, 1, -16 },
  { 238, 12, 13, 16, 2, -15 },
  { 258, 6, 8, 16, 4, -4 },
  { 264, 8, 1, 16, 4, -9 },
  { 265, 4, 4, 16, 6, -4 },
  { 267, 12, 25, 16, 2, -22 },
  { 305, 11, 19, 16, 2, -19 },
  { 332, 12, 19, 16, 2, -19 },
  { 361, 12, 19, 16, 2, -19 },
  { 390, 11, 19, 16, 2, -19 },
  { 417, 11, 19, 16, 2, -19 },
  { 444, 11, 19, 16, 2, -19 },
  { 471, 12, 19, 16, 2, -19 },
  { 500, 12, 19, 16, 2, -19 },
  { 529, 11, 19, 16, 2, -19 },
  { 556, 12, 19, 16, 2, -19 },
  { 585, 4, 15, 16, 6, -15 },
  { 593, 5, 19, 16, 5, -15 },
  { 605, 11, 13, 16, 2, -15 },
  { 623, 11, 8, 16, 2, -13 },
  { 634, 11, 13, 16, 2, -15 },
  { 652, 9, 19, 16, 4, -19 },
  { 674, 13, 24, 16, 1, -19 },
  { 713, 13, 19, 16, 1, -19 },
  { 744, 11, 19, 16, 3, -19 },
  { 771, 11, 19, 16, 2, -19 },
  { 798, 10, 19, 16, 3, -19 },
  { 822, 10, 19, 16, 3, -19 },
  { 846, 11, 19, 16, 3, -19 },
  { 873, 11, 19, 16, 2, -19 },
  { 900, 10, 19, 16, 3, -19 },
  { 924, 10, 19, 16, 3, -19 },
  { 948, 12, 19, 16, 1, -19 },
  { 977, 11, 19, 16, 3, -19 },
  { 1004, 11, 19, 16, 3, -19 },
  { 1031, 12, 19, 16, 2, -19 },
  { 1060, 11, 19, 16, 2, -19 },
  { 1087, 11, 19, 16, 2, -19 },
  { 1114, 11, 19, 16, 3, -19 },
  { 1141, 12, 24, 16, 2, -19 },
  { 1177, 11, 19, 16, 3, -19 },
  { 1204, 12, 19, 16, 2, -19 },
  { 1233, 13, 19, 16, 1, -19 },
  { 1264, 11, 19, 16, 2, -19 },
  { 1291, 13, 19, 16, 1, -19 },
  { 1322, 14, 19, 16, 1, -19 },
  { 1356, 13, 19, 16, 1, -19 },
  { 1387, 14, 19, 16, 1, -19 },
  { 1421, 11, 19, 16, 2, -19 },
  { 1448, 7, 25, 16, 5, -22 },
  { 1470, 12, 25, 16, 2, -22 },
  { 1508, 6, 25, 16, 4, -22 },
  { 1527, 11, 10, 16, 2, -19 },
  { 1541, 12, 1, 16, 2, 1 },
  { 1543, 5, 3, 16, 5, -20 },
  { 1545, 11, 15, 16, 2, -15 },
  { 1566, 10, 19, 16, 3, -19 },
  { 1590, 11, 15, 16, 2, -15 },
  { 1611, 11, 19, 16, 2, -19 },
  { 1638, 11, 15, 16, 2, -15 },
  { 1659, 12, 19, 16, 2, -19 },
  { 1688, 11, 20, 16, 2, -15 },
  { 1716, 10, 19, 16, 3, -19 },
  { 1740, 12, 20, 16, 2, -20 },
  { 1770, 10, 25, 16, 2, -20 },
  { 1802, 11, 19, 16, 3, -19 },
  { 1829, 13, 19, 16, 1, -19 },
  { 1860, 12, 15, 16, 2, -15 },
  { 1883, 10, 15, 16, 3, -15 },
  { 1902, 11, 15, 16, 2, -15 },
  { 1923, 10, 20, 16, 3, -15 },
  { 1948, 11, 20, 16, 2, -15 },
  { 1976, 11, 15, 16, 3, -15 },
  { 1997, 11, 15, 16, 2, -15 },
  { 2018, 11, 18, 16, 2, -18 },
  { 2043, 11, 14, 16, 2, -14 },
  { 2063, 12, 14, 16, 2, -14 },
  { 2084, 14, 14, 16, 1, -14 },
  { 2109, 13, 14, 16, 1, -14 },
  { 2132, 12, 19, 16, 2, -14 },
  { 2161, 11, 14, 16, 2, -14 },
  { 2181, 11, 25, 16, 2, -22 },
  { 2216, 2, 25, 16, 7, -22 },
  { 2223, 11, 25, 16, 2, -22 },
  { 2258, 12, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Light26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_LIGHT26PT7B_H_
