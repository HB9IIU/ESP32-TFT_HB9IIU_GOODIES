#ifndef _JETBRAINSMONO_LIGHT40PT7B_H_
#define _JETBRAINSMONO_LIGHT40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light40pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0x78, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0x76, 0x07, 0x60, 0x66, 0x06, 0x00, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x1C,
  0x06, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0x18, 0x0C,
  0x00, 0xE0, 0x30, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x30, 0x1C, 0x00,
  0xC0, 0x60, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0x80,
  0xE0, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0x30, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x1C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3E, 0xDF, 0x0E, 0x31, 0xE7,
  0x8C, 0x39, 0xC3, 0x0E, 0x70, 0xC3, 0xDC, 0x30, 0x07, 0x0C, 0x01, 0xE3,
  0x00, 0x78, 0xC0, 0x0F, 0xB0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x0D, 0xF0, 0x03, 0x1E, 0x00, 0xC3, 0x80, 0x30, 0xF0,
  0x0C, 0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xFC, 0x30, 0xF7, 0x0C, 0x39, 0xE3,
  0x1E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x80,
  0x1D, 0xFF, 0x00, 0x6F, 0x1C, 0x03, 0xB8, 0x38, 0x1C, 0xE0, 0xE0, 0xE3,
  0x03, 0x83, 0x0C, 0x0E, 0x1C, 0x30, 0x38, 0xE0, 0xE0, 0xE3, 0x03, 0x83,
  0x1C, 0x0F, 0xBC, 0xE0, 0x1F, 0xE3, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE3, 0xF0, 0x03, 0x1F, 0xE0,
  0x1C, 0xE3, 0xC0, 0xE7, 0x07, 0x07, 0x1C, 0x1C, 0x18, 0x70, 0x30, 0xE1,
  0xC0, 0xC7, 0x07, 0x03, 0x18, 0x1C, 0x1C, 0xE0, 0x70, 0x77, 0x00, 0xE3,
  0xD8, 0x01, 0xFE, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x80, 0x3E, 0x3C, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x71, 0xE0, 0x77, 0x87, 0x07, 0x3C, 0x1C, 0x79, 0xC0, 0xF3, 0x8E, 0x03,
  0xFC, 0x70, 0x0F, 0xC3, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0xF0, 0x0F, 0x87,
  0x80, 0xFC, 0x1C, 0x0F, 0x70, 0xFD, 0xF3, 0xC3, 0xFF, 0x0F, 0x0F, 0xF0,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x00, 0x20, 0x1C, 0x0F, 0x83,
  0xF0, 0xF8, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xF0, 0x3E, 0x01, 0xC0,
  0x08, 0x80, 0x1C, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0,
  0x78, 0x7E, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x00, 0xC0, 0x27,
  0x83, 0x07, 0x9F, 0x8C, 0x7E, 0xFF, 0xB7, 0xFC, 0x3F, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0,
  0x01, 0xE1, 0xC0, 0x07, 0x87, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x1C, 0x01,
  0x80, 0x60, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0x1E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x30, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0x70, 0x03, 0x9E, 0x01, 0xE7, 0xC0, 0xF8, 0xFC, 0xFC, 0x1F, 0xFE,
  0x01, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0x9C, 0x0F,
  0x8E, 0x07, 0x87, 0x03, 0x03, 0x81, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xF8, 0x7C, 0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0x70, 0x07, 0xBC, 0x07, 0x8F, 0xDF, 0x83, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0xF0, 0x1C, 0xF0, 0x0E, 0x70,
  0x07, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE3, 0xF8, 0xEF, 0xFC, 0xEF, 0xFE, 0xF8, 0x1E, 0xF0, 0x0F, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x7E, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x73, 0xE0, 0x3B, 0xFE, 0x1F, 0xFF, 0xC7, 0xC0,
  0xF9, 0xE0, 0x1E, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0x70, 0x03, 0x9E,
  0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C,
  0x38, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C,
  0x00, 0xE3, 0x80, 0x78, 0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x0F, 0x3C, 0x0F, 0x03, 0xC3, 0x80, 0x71, 0xC0, 0x0E,
  0x70, 0x03, 0xBC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xDC,
  0x00, 0xE7, 0x80, 0x78, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x78, 0x07, 0x9C, 0x00,
  0xEF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x79, 0xF0, 0x3E, 0x3F,
  0xFF, 0x07, 0xFD, 0xC0, 0x7C, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0xFF, 0xFF, 0xFD, 0xE0,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x70, 0x70, 0xF0, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x0F, 0xC1, 0xFE, 0x07, 0xF0, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x81, 0xE0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00,
  0x77, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xF7, 0xE0, 0x7F, 0xBE, 0x0F, 0x0F, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0,
  0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x7E,
  0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0xFE, 0x0F, 0xFB,
  0xE0, 0x7F, 0xBE, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0,
  0x03, 0x9C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xC0,
  0x38, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C,
  0x03, 0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x03, 0xB8, 0x03, 0xDC, 0x03, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0xF1, 0xC0, 0x7C, 0xE0, 0x0F, 0x70, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x0F,
  0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0x80, 0x07, 0xFC, 0x0F,
  0xFF, 0x0F, 0xC7, 0xC7, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0x78, 0x03, 0x9E, 0x03, 0xCF, 0xEF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xC7, 0xC7, 0x00, 0xF7,
  0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x78, 0x03, 0x9E, 0x03, 0xCF, 0xEF,
  0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0E, 0x70, 0x07, 0x9E, 0x03, 0xC3,
  0xF7, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xE0, 0x03, 0xF8, 0x01, 0xEE,
  0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0x80,
  0xF0, 0xE0, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0x83, 0x80, 0xE0, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x83, 0x80, 0xE0, 0xE0, 0x3C, 0x38, 0x07, 0x0E, 0x01, 0xE3, 0x80,
  0x38, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03,
  0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x6F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFB, 0x03,
  0x7E, 0xE1, 0xDF, 0xB8, 0x77, 0xE6, 0x19, 0xF9, 0xCE, 0x7E, 0x73, 0x9F,
  0x8C, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xC0, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xEE, 0x07, 0xEE, 0x07, 0xEE, 0x07, 0xE7,
  0x07, 0xE7, 0x07, 0xE3, 0x07, 0xE3, 0x87, 0xE3, 0x87, 0xE1, 0x87, 0xE1,
  0xC7, 0xE1, 0xC7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0x77, 0xE0,
  0x77, 0xE0, 0x37, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0x01, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x70,
  0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0x80, 0x3E,
  0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x07, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3D, 0xC0, 0x0E, 0x70, 0x03, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E,
  0xE0, 0x0F, 0x38, 0x1F, 0x8F, 0xFF, 0xE3, 0xFF, 0xE0, 0xE0, 0xF0, 0x38,
  0x1C, 0x0E, 0x07, 0x83, 0x81, 0xE0, 0xE0, 0x38, 0x38, 0x0F, 0x0E, 0x01,
  0xC3, 0x80, 0x78, 0xE0, 0x0E, 0x38, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1E,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C,
  0x38, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0F, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xDC,
  0x00, 0xE7, 0x80, 0x78, 0xFE, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x00,
  0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00,
  0xF0, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0xE0,
  0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0xE0,
  0x78, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x81, 0xDC, 0x1E, 0x06, 0x70, 0x78,
  0x39, 0xC1, 0xE0, 0xE7, 0x06, 0xC3, 0x9C, 0x33, 0x0E, 0x70, 0xCC, 0x39,
  0xC3, 0x30, 0xE7, 0x0C, 0xC3, 0x8C, 0x33, 0x0C, 0x38, 0xCC, 0x30, 0xE3,
  0x31, 0xC3, 0x9C, 0x67, 0x0E, 0x61, 0x9C, 0x39, 0x86, 0x70, 0xE6, 0x19,
  0xC3, 0x98, 0x67, 0x0E, 0x61, 0x9C, 0x19, 0x86, 0x60, 0x76, 0x19, 0x81,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0xF7, 0x80, 0x1E,
  0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xE0, 0x78, 0x0E, 0x07,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x39, 0xC0, 0x03, 0xDC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3B, 0xC0, 0x03, 0x9C, 0x00, 0x71, 0xE0, 0x07, 0x0F, 0x00,
  0xE0, 0x70, 0x1E, 0x07, 0x81, 0xC0, 0x38, 0x3C, 0x03, 0xC3, 0x80, 0x1C,
  0x78, 0x01, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1C,
  0x03, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xF0, 0xF0, 0x07, 0x0E, 0x00,
  0x78, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF,
  0xFF, 0xC0, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0E, 0xC0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x0C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0xEF, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3C, 0x1C, 0x0E, 0x0F,
  0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xCF, 0xC7, 0x00, 0xE7, 0x80, 0x7B, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x81, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xFC, 0x03, 0xEF, 0x87, 0xF3, 0xFF, 0xB8, 0xFF, 0x1C, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE7, 0xF8, 0xEF, 0xFC, 0xEE, 0x7E, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFE, 0x7E, 0xEF, 0xFC, 0xE7, 0xF8, 0x0F, 0xF0, 0x1F,
  0xFE, 0x1F, 0xDF, 0x8F, 0x01, 0xEF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0x78, 0x03, 0x9E,
  0x03, 0xCF, 0xEF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x1F, 0xE7,
  0x3F, 0xF7, 0x7E, 0x77, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0x7E, 0x77, 0x3F, 0xF7, 0x1F, 0xE7, 0x0F, 0xF0, 0x3F, 0xFC, 0x7E, 0x7E,
  0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x7E, 0x3E, 0x3F, 0xFC,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE7, 0x3F, 0xF7,
  0x7E, 0x77, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x7C, 0x3F, 0x3F, 0xF7, 0x1F, 0xE7,
  0x02, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE7, 0xF8, 0xEF, 0xFC,
  0xEE, 0x7E, 0xF8, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x0F, 0xE0, 0x07, 0xB8, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x78,
  0xE0, 0x3C, 0x38, 0x0E, 0x0E, 0x07, 0x83, 0x83, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0E, 0x03,
  0xC3, 0x80, 0x70, 0xE0, 0x1E, 0x38, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1E,
  0xE0, 0x03, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xEF, 0x9F, 0xBF, 0xF7,
  0xEF, 0x1E, 0x3F, 0x87, 0x87, 0xE0, 0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F,
  0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0,
  0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30,
  0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x70, 0xE7, 0xF8,
  0xEF, 0xFC, 0xEE, 0x7E, 0xF8, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE,
  0x78, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0xE7, 0xF8, 0xEF, 0xFC, 0xFE, 0x7E, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x0F, 0xEE, 0x7E, 0xEF, 0xFC, 0xE7, 0xF8, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x1F, 0xE7, 0x3F, 0xF7, 0x7E, 0x77, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0x70, 0x1F, 0x7E, 0x77, 0x3F, 0xF7, 0x1F, 0xE7, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE7, 0xF0,
  0xEF, 0xFC, 0xFE, 0x7E, 0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0x1F, 0x9F,
  0x9E, 0x01, 0xEF, 0x00, 0x77, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xCF, 0xCF,
  0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0x78, 0x1E, 0x7E, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x00, 0xF7, 0x00,
  0x0E, 0x78, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0xC0, 0x1C, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00,
  0xF0, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x8E, 0x00, 0x39, 0xC0,
  0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0xC0, 0xF0, 0x3E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F,
  0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0x61, 0x98, 0x67, 0x19, 0x86, 0x71,
  0x98, 0xE7, 0x19, 0x8E, 0x71, 0x98, 0xE7, 0x19, 0x8E, 0x33, 0x0C, 0xC3,
  0x30, 0xCC, 0x3B, 0x0D, 0xC3, 0xB0, 0xDC, 0x3B, 0x0D, 0xC3, 0xB0, 0xDC,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x78, 0x01,
  0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0x70,
  0xF0, 0x07, 0x9E, 0x00, 0x39, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00,
  0x70, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x3C,
  0x78, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0E, 0x78, 0x01,
  0xE3, 0x80, 0x1C, 0x3C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xE0,
  0x78, 0x0E, 0x07, 0x00, 0xF0, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07,
  0x8E, 0x00, 0x39, 0xE0, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0x01, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x3E, 0x01, 0xDF, 0xE0, 0x7F, 0xFC, 0x1F, 0x87, 0x07, 0xE0, 0xE1,
  0xF8, 0x1F, 0xFE, 0x07, 0xFB, 0x80, 0x78,
};

const GFXglyph JetBrainsMono_Light40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 29, 24, 9, -29 },
  { 23, 12, 12, 24, 6, -29 },
  { 41, 22, 29, 24, 1, -29 },
  { 121, 18, 41, 24, 3, -35 },
  { 214, 22, 29, 24, 1, -29 },
  { 294, 21, 30, 24, 2, -30 },
  { 373, 4, 12, 24, 10, -29 },
  { 379, 11, 39, 24, 8, -34 },
  { 433, 11, 39, 24, 5, -34 },
  { 487, 22, 20, 24, 1, -24 },
  { 542, 18, 19, 24, 3, -23 },
  { 585, 8, 12, 24, 7, -6 },
  { 597, 12, 3, 24, 6, -15 },
  { 602, 6, 6, 24, 9, -6 },
  { 607, 18, 37, 24, 3, -33 },
  { 691, 18, 30, 24, 3, -30 },
  { 759, 17, 29, 24, 4, -29 },
  { 821, 18, 30, 24, 3, -30 },
  { 889, 17, 29, 24, 3, -29 },
  { 951, 17, 29, 24, 3, -29 },
  { 1013, 16, 29, 24, 4, -29 },
  { 1071, 18, 29, 24, 3, -29 },
  { 1137, 18, 29, 24, 3, -29 },
  { 1203, 18, 30, 24, 3, -30 },
  { 1271, 18, 30, 24, 3, -30 },
  { 1339, 6, 22, 24, 9, -22 },
  { 1356, 8, 28, 24, 7, -22 },
  { 1384, 18, 21, 24, 3, -24 },
  { 1432, 16, 12, 24, 4, -19 },
  { 1456, 18, 21, 24, 3, -24 },
  { 1504, 14, 29, 24, 6, -29 },
  { 1555, 20, 37, 24, 2, -30 },
  { 1648, 20, 29, 24, 2, -29 },
  { 1721, 17, 29, 24, 4, -29 },
  { 1783, 17, 30, 24, 4, -30 },
  { 1847, 16, 29, 24, 4, -29 },
  { 1905, 17, 29, 24, 4, -29 },
  { 1967, 17, 29, 24, 4, -29 },
  { 2029, 17, 30, 24, 4, -30 },
  { 2093, 16, 29, 24, 4, -29 },
  { 2151, 16, 29, 24, 4, -29 },
  { 2209, 18, 29, 24, 2, -29 },
  { 2275, 18, 29, 24, 4, -29 },
  { 2341, 16, 29, 24, 5, -29 },
  { 2399, 18, 29, 24, 3, -29 },
  { 2465, 16, 29, 24, 4, -29 },
  { 2523, 16, 30, 24, 4, -30 },
  { 2583, 18, 29, 24, 4, -29 },
  { 2649, 18, 37, 24, 3, -30 },
  { 2733, 18, 29, 24, 4, -29 },
  { 2799, 18, 30, 24, 3, -30 },
  { 2867, 20, 29, 24, 2, -29 },
  { 2940, 16, 29, 24, 4, -29 },
  { 2998, 20, 29, 24, 2, -29 },
  { 3071, 22, 29, 24, 1, -29 },
  { 3151, 20, 29, 24, 2, -29 },
  { 3224, 20, 29, 24, 2, -29 },
  { 3297, 18, 29, 24, 3, -29 },
  { 3363, 10, 37, 24, 8, -33 },
  { 3410, 18, 37, 24, 3, -33 },
  { 3494, 10, 37, 24, 6, -33 },
  { 3541, 18, 15, 24, 3, -29 },
  { 3575, 20, 3, 24, 2, 1 },
  { 3583, 8, 5, 24, 7, -31 },
  { 3588, 17, 22, 24, 3, -22 },
  { 3635, 16, 29, 24, 4, -29 },
  { 3693, 17, 22, 24, 4, -22 },
  { 3740, 16, 29, 24, 4, -29 },
  { 3798, 16, 22, 24, 4, -22 },
  { 3842, 18, 29, 24, 3, -29 },
  { 3908, 16, 29, 24, 4, -22 },
  { 3966, 16, 29, 24, 4, -29 },
  { 4024, 18, 31, 24, 4, -31 },
  { 4094, 14, 38, 24, 4, -31 },
  { 4161, 18, 29, 24, 4, -29 },
  { 4227, 21, 29, 24, 1, -29 },
  { 4304, 18, 22, 24, 3, -22 },
  { 4354, 16, 22, 24, 4, -22 },
  { 4398, 16, 22, 24, 4, -22 },
  { 4442, 16, 29, 24, 4, -22 },
  { 4500, 16, 29, 24, 4, -22 },
  { 4558, 16, 22, 24, 5, -22 },
  { 4602, 17, 22, 24, 4, -22 },
  { 4649, 19, 28, 24, 2, -28 },
  { 4716, 16, 22, 24, 4, -22 },
  { 4760, 20, 22, 24, 2, -22 },
  { 4815, 20, 22, 24, 2, -22 },
  { 4870, 20, 22, 24, 2, -22 },
  { 4925, 20, 29, 24, 2, -22 },
  { 4998, 16, 22, 24, 4, -22 },
  { 5042, 16, 37, 24, 4, -33 },
  { 5116, 4, 37, 24, 10, -33 },
  { 5135, 16, 37, 24, 4, -33 },
  { 5209, 18, 8, 24, 3, -18 },
};

const GFXfont JetBrainsMono_Light40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_LIGHT40PT7B_H_
