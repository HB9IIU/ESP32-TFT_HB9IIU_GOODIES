#ifndef _JETBRAINSMONO_LIGHT22PT7B_H_
#define _JETBRAINSMONO_LIGHT22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light22pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0x92, 0x49, 0x00, 0x3F, 0xC7, 0x8F, 0x1E, 0x34, 0x68,
  0xD1, 0x80, 0x08, 0x41, 0x08, 0x63, 0x0C, 0x67, 0xFE, 0xFF, 0xC4, 0x21,
  0x84, 0x31, 0x84, 0x33, 0xFF, 0xFF, 0xF2, 0x10, 0xC6, 0x18, 0xC2, 0x10,
  0x08, 0x02, 0x00, 0x80, 0xFC, 0x6B, 0xB2, 0x6C, 0x8B, 0x20, 0xC8, 0x1E,
  0x03, 0xE0, 0x3C, 0x09, 0x82, 0x60, 0x8E, 0x23, 0xC9, 0x9A, 0xE3, 0xF0,
  0x20, 0x08, 0x02, 0x00, 0x78, 0x1A, 0x21, 0xB1, 0x09, 0x88, 0x8C, 0x4C,
  0x22, 0x41, 0xF4, 0x00, 0x60, 0x02, 0x00, 0x27, 0x83, 0x66, 0x32, 0x31,
  0x11, 0x98, 0x8D, 0x86, 0x58, 0x1E, 0x1F, 0x06, 0x71, 0x86, 0x30, 0x06,
  0x00, 0x60, 0x04, 0x03, 0xC0, 0x4C, 0x78, 0xCB, 0x1B, 0x61, 0xCC, 0x19,
  0x87, 0x99, 0xB1, 0xE3, 0xFE, 0x0E, 0x38, 0xC3, 0x06, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0x70, 0x20,
  0xC1, 0x83, 0x06, 0x08, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC2,
  0x18, 0xC7, 0x30, 0x80, 0x04, 0x00, 0x80, 0x10, 0x72, 0x3F, 0x5E, 0x3E,
  0x02, 0x80, 0xD8, 0x39, 0x8E, 0x38, 0x82, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x0F, 0xFF, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x76, 0x66,
  0xCC, 0x80, 0xFF, 0xFC, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30,
  0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x30, 0x18, 0x00, 0x3E, 0x31, 0xF0, 0x78, 0x1C, 0x0E, 0x07,
  0x03, 0xB9, 0xDC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0D, 0x8C, 0x7C, 0x1C,
  0x0F, 0x0E, 0xC3, 0x30, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x3E, 0x18, 0xEC, 0x1A, 0x06,
  0x00, 0x80, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x78, 0x0E,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x1E, 0x0D, 0x9C, 0x7C, 0x03, 0x03, 0x01,
  0x01, 0x81, 0x80, 0xC0, 0xC0, 0xC3, 0x61, 0xE0, 0xF0, 0x7F, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x63, 0xFD, 0xC7,
  0xC1, 0x80, 0xC0, 0x60, 0x3C, 0x1E, 0x0D, 0x8C, 0x7C, 0x06, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x08, 0x06, 0xE3, 0xFC, 0xC1, 0xB0, 0x28, 0x0E, 0x03,
  0xC0, 0xB0, 0x67, 0x30, 0xF8, 0xFF, 0xFF, 0xFC, 0x0B, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0xC0, 0x3E, 0x31, 0xB0, 0x78, 0x3C, 0x1A, 0x0D, 0xCC, 0x38, 0x36, 0x30,
  0xF0, 0x78, 0x1C, 0x0E, 0x0D, 0x8E, 0x7E, 0x3E, 0x18, 0xEC, 0x1B, 0x02,
  0x80, 0xE0, 0x3C, 0x0B, 0x06, 0x7F, 0x8F, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x77, 0x70, 0x00, 0x00,
  0x07, 0x66, 0x6C, 0xC8, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x06, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x60, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0C, 0x0E, 0x1E, 0x3C, 0x78,
  0x30, 0x00, 0xF8, 0xFE, 0x06, 0x03, 0x03, 0x03, 0x06, 0x0E, 0x3C, 0x30,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x70, 0x1F, 0x86, 0x19, 0x81, 0xE0, 0x3C,
  0x03, 0x86, 0x71, 0xEE, 0x63, 0xCC, 0x39, 0x87, 0x30, 0xE6, 0x1C, 0xC7,
  0x8F, 0xF0, 0xEE, 0x00, 0x40, 0x0C, 0x00, 0xFC, 0x07, 0x80, 0x0E, 0x01,
  0xC0, 0x28, 0x05, 0x81, 0xB0, 0x32, 0x04, 0x41, 0x8C, 0x31, 0x86, 0x10,
  0xFF, 0x3F, 0xE6, 0x0C, 0xC0, 0x90, 0x1E, 0x03, 0xFE, 0x3F, 0xCC, 0x1B,
  0x06, 0xC1, 0xB0, 0x6C, 0x33, 0xF8, 0xC7, 0x30, 0x6C, 0x0B, 0x03, 0xC0,
  0xF0, 0x6F, 0xFB, 0xF8, 0x3F, 0x31, 0xF0, 0x78, 0x1C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x0D, 0xCC, 0x7C, 0xFE, 0x7F,
  0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0xFD, 0xFC, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x3F, 0x31, 0xF0, 0x78, 0x1C, 0x06,
  0x03, 0x01, 0x80, 0xCF, 0xE7, 0xF0, 0x38, 0x1C, 0x0E, 0x0D, 0xCC, 0x7C,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x63, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0F, 0x03, 0xC0, 0xF0, 0x67, 0x38, 0xFC, 0xC0, 0xF0, 0x6C, 0x1B,
  0x0C, 0xC3, 0x31, 0x8C, 0x63, 0xF0, 0xCC, 0x31, 0x8C, 0x63, 0x0C, 0xC3,
  0x30, 0x6C, 0x1B, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFF, 0xFF, 0xC1, 0xF0,
  0xE8, 0xF4, 0x5B, 0x2C, 0xB6, 0x53, 0x39, 0x8C, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xE1, 0xF0, 0xF8, 0x7E, 0x3D, 0x1E, 0x8F, 0x67,
  0x93, 0xCD, 0xE6, 0xF1, 0x78, 0xFC, 0x6E, 0x17, 0x0F, 0x83, 0x3E, 0x31,
  0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0D, 0xCC, 0x7C, 0xFF, 0x3F, 0xEC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x0E, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x3E, 0x31, 0xB0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x1E, 0x0D, 0xCC, 0x7C, 0x06, 0x01, 0x80, 0x60, 0x30, 0xFE,
  0x3F, 0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0xFE, 0xFE, 0x31, 0x8C,
  0x63, 0x0C, 0xC3, 0x30, 0x6C, 0x1B, 0x03, 0x3F, 0x18, 0xEC, 0x1B, 0x02,
  0xC0, 0x30, 0x07, 0x00, 0xF8, 0x0F, 0x00, 0x60, 0x18, 0x03, 0x80, 0xF0,
  0x66, 0x38, 0xFC, 0xFF, 0xFF, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0xCC, 0x7C, 0xC0, 0x68, 0x0D, 0x81, 0x30,
  0x66, 0x0C, 0x41, 0x8C, 0x21, 0x8C, 0x31, 0x82, 0x20, 0x64, 0x0D, 0x81,
  0xB0, 0x14, 0x03, 0x80, 0x70, 0x86, 0x38, 0x62, 0xCA, 0x2C, 0xA2, 0xCA,
  0x6C, 0xA6, 0xCA, 0x64, 0xA6, 0x49, 0x65, 0x94, 0x51, 0x47, 0x14, 0x71,
  0x47, 0x1C, 0x71, 0xC7, 0x1C, 0xE0, 0x6C, 0x18, 0xC3, 0x18, 0xC1, 0x90,
  0x36, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x60, 0x6C, 0x08, 0xC3, 0x18, 0xC1,
  0x98, 0x36, 0x03, 0xC0, 0x68, 0x0D, 0x83, 0x10, 0x63, 0x18, 0x23, 0x06,
  0xC0, 0x58, 0x0E, 0x01, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x04, 0x06, 0x06, 0x03, 0xFF, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0xC0, 0x60, 0x18, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x30,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0x0C, 0x0E,
  0x05, 0x86, 0x42, 0x33, 0x19, 0x05, 0x83, 0xC0, 0x80, 0xFF, 0xE0, 0xE2,
  0x30, 0x3F, 0x31, 0xF0, 0x60, 0x30, 0x1B, 0xFF, 0x87, 0x03, 0x81, 0xC0,
  0xF8, 0xEF, 0xB0, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xF7, 0x1F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x8F, 0xBE, 0x3F, 0x31, 0xF0,
  0x78, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0xDC, 0xE7, 0xC0, 0x01,
  0x80, 0xC0, 0x60, 0x33, 0xDB, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0D, 0x8E, 0x7B, 0x3E, 0x31, 0xB0, 0x78, 0x3C, 0x1F, 0xFF,
  0x01, 0x80, 0xC0, 0x60, 0xD8, 0xE7, 0xC0, 0x07, 0xE1, 0xFC, 0x30, 0x06,
  0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x3D, 0xB1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xB1, 0xCF, 0x60, 0x30, 0x18, 0x0C, 0xFE, 0x7C, 0xC0,
  0x60, 0x30, 0x18, 0x0D, 0xF7, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x0C, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3,
  0xFF, 0xFF, 0xC0, 0x07, 0x07, 0x02, 0x00, 0x00, 0x7F, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0xFC, 0xF8,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x6C, 0x33, 0x18, 0xC6, 0x3F,
  0x0F, 0xE3, 0x18, 0xC3, 0x30, 0xCC, 0x1B, 0x03, 0xFC, 0x1F, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0xF8, 0x3F, 0xBB, 0xB3, 0x38, 0x8E, 0x23, 0x88,
  0xE2, 0x38, 0x8E, 0x23, 0x88, 0xE2, 0x38, 0x8E, 0x23, 0xDF, 0x71, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x3E,
  0x31, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xDC, 0xC7,
  0xC0, 0xDF, 0x71, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFC, 0xDB, 0xEC, 0x06, 0x03, 0x01, 0x80, 0x3D, 0xB1, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xD8, 0xE7, 0xB0, 0x18, 0x0C, 0x06,
  0x03, 0xBE, 0x71, 0xB0, 0x50, 0x38, 0x1C, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x00, 0x7F, 0x31, 0xF0, 0x78, 0x06, 0x03, 0xF0, 0x3E, 0x03,
  0x00, 0xE0, 0xD8, 0xE7, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xFC,
  0x1F, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xD8, 0xC7, 0xC0, 0xC0, 0x6C, 0x09, 0x83, 0x10, 0x63, 0x08, 0x63, 0x04,
  0x60, 0xC8, 0x1B, 0x01, 0x60, 0x38, 0x07, 0x00, 0xC6, 0x39, 0xC7, 0x29,
  0xE5, 0x34, 0xA6, 0x94, 0x92, 0xD3, 0xCA, 0x71, 0x4E, 0x38, 0xC7, 0x18,
  0xC0, 0x60, 0xE6, 0x18, 0xC6, 0x0D, 0x80, 0xB0, 0x1C, 0x03, 0x80, 0xD8,
  0x19, 0x86, 0x31, 0x83, 0x70, 0x30, 0xE0, 0x6C, 0x19, 0x83, 0x18, 0x63,
  0x18, 0x23, 0x06, 0x40, 0xD8, 0x0B, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0xFF, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x30, 0x3F, 0xFF, 0xF0, 0x07, 0x83, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x08, 0x0C, 0x7C, 0x3E, 0x01, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x06, 0x01, 0x80, 0xF0, 0xFF, 0xFF, 0xF0, 0xF0, 0x1C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x07, 0xC3, 0xE3, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0E, 0x1E, 0x00, 0x70, 0xFE, 0x38, 0xCE, 0x1E,
};

const GFXglyph JetBrainsMono_Light22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 7, 7, 13, 3, -16 },
  { 14, 11, 16, 13, 1, -16 },
  { 36, 10, 22, 13, 2, -19 },
  { 64, 13, 16, 13, 0, -16 },
  { 90, 11, 16, 13, 1, -16 },
  { 112, 1, 7, 13, 6, -16 },
  { 113, 7, 21, 13, 4, -18 },
  { 132, 6, 21, 13, 3, -18 },
  { 148, 11, 11, 13, 1, -13 },
  { 164, 11, 10, 13, 1, -12 },
  { 178, 4, 7, 13, 4, -3 },
  { 182, 7, 2, 13, 3, -8 },
  { 184, 3, 3, 13, 5, -3 },
  { 186, 9, 20, 13, 2, -18 },
  { 209, 9, 16, 13, 2, -16 },
  { 227, 10, 16, 13, 2, -16 },
  { 247, 10, 16, 13, 2, -16 },
  { 267, 9, 16, 13, 2, -16 },
  { 285, 9, 16, 13, 2, -16 },
  { 303, 9, 16, 13, 2, -16 },
  { 321, 10, 16, 13, 2, -16 },
  { 341, 10, 16, 13, 2, -16 },
  { 361, 9, 16, 13, 2, -16 },
  { 379, 10, 16, 13, 2, -16 },
  { 399, 3, 12, 13, 5, -12 },
  { 404, 4, 16, 13, 4, -12 },
  { 412, 9, 11, 13, 2, -13 },
  { 425, 9, 7, 13, 2, -11 },
  { 433, 9, 11, 13, 2, -13 },
  { 446, 8, 16, 13, 3, -16 },
  { 462, 11, 20, 13, 1, -16 },
  { 490, 11, 16, 13, 1, -16 },
  { 512, 10, 16, 13, 2, -16 },
  { 532, 9, 16, 13, 2, -16 },
  { 550, 9, 16, 13, 2, -16 },
  { 568, 9, 16, 13, 2, -16 },
  { 586, 10, 16, 13, 2, -16 },
  { 606, 9, 16, 13, 2, -16 },
  { 624, 9, 16, 13, 2, -16 },
  { 642, 9, 16, 13, 2, -16 },
  { 660, 10, 16, 13, 1, -16 },
  { 680, 10, 16, 13, 2, -16 },
  { 700, 9, 16, 13, 3, -16 },
  { 718, 9, 16, 13, 2, -16 },
  { 736, 9, 16, 13, 2, -16 },
  { 754, 9, 16, 13, 2, -16 },
  { 772, 10, 16, 13, 2, -16 },
  { 792, 9, 20, 13, 2, -16 },
  { 815, 10, 16, 13, 2, -16 },
  { 835, 10, 16, 13, 2, -16 },
  { 855, 11, 16, 13, 1, -16 },
  { 877, 9, 16, 13, 2, -16 },
  { 895, 11, 16, 13, 1, -16 },
  { 917, 12, 16, 13, 1, -16 },
  { 941, 11, 16, 13, 1, -16 },
  { 963, 11, 16, 13, 1, -16 },
  { 985, 9, 16, 13, 2, -16 },
  { 1003, 5, 20, 13, 5, -18 },
  { 1016, 9, 20, 13, 2, -18 },
  { 1039, 6, 20, 13, 3, -18 },
  { 1054, 9, 9, 13, 2, -16 },
  { 1065, 11, 1, 13, 1, 1 },
  { 1067, 4, 3, 13, 4, -17 },
  { 1069, 9, 12, 13, 2, -12 },
  { 1083, 9, 16, 13, 2, -16 },
  { 1101, 9, 12, 13, 2, -12 },
  { 1115, 9, 16, 13, 2, -16 },
  { 1133, 9, 12, 13, 2, -12 },
  { 1147, 11, 16, 13, 1, -16 },
  { 1169, 9, 16, 13, 2, -12 },
  { 1187, 9, 16, 13, 2, -16 },
  { 1205, 10, 17, 13, 2, -17 },
  { 1227, 8, 21, 13, 2, -17 },
  { 1248, 10, 16, 13, 2, -16 },
  { 1268, 11, 16, 13, 1, -16 },
  { 1290, 10, 12, 13, 2, -12 },
  { 1305, 9, 12, 13, 2, -12 },
  { 1319, 9, 12, 13, 2, -12 },
  { 1333, 9, 16, 13, 2, -12 },
  { 1351, 9, 16, 13, 2, -12 },
  { 1369, 9, 12, 13, 3, -12 },
  { 1383, 9, 12, 13, 2, -12 },
  { 1397, 10, 16, 13, 1, -16 },
  { 1417, 9, 12, 13, 2, -12 },
  { 1431, 11, 12, 13, 1, -12 },
  { 1448, 11, 12, 13, 1, -12 },
  { 1465, 11, 12, 13, 1, -12 },
  { 1482, 11, 16, 13, 1, -12 },
  { 1504, 9, 12, 13, 2, -12 },
  { 1518, 9, 20, 13, 2, -18 },
  { 1541, 1, 20, 13, 6, -18 },
  { 1544, 9, 20, 13, 2, -18 },
  { 1567, 10, 4, 13, 2, -10 },
};

const GFXfont JetBrainsMono_Light22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_LIGHT22PT7B_H_
