#ifndef _JETBRAINSMONO_LIGHT23PT7B_H_
#define _JETBRAINSMONO_LIGHT23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light23pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0x60, 0xCF, 0x3C,
  0xF3, 0x8E, 0x38, 0xC0, 0x0C, 0x60, 0x86, 0x08, 0x41, 0x84, 0x18, 0x47,
  0xFF, 0x10, 0xC1, 0x08, 0x10, 0x83, 0x08, 0x31, 0x8F, 0xFE, 0x21, 0x82,
  0x10, 0x61, 0x06, 0x10, 0x63, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x7C, 0x7F,
  0x9B, 0x6C, 0xCF, 0x30, 0xCC, 0x1B, 0x07, 0xC0, 0x7C, 0x0F, 0x83, 0x70,
  0xCC, 0x33, 0xCC, 0xF3, 0x37, 0xF8, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x38,
  0x0B, 0xE0, 0xD1, 0x8D, 0x8C, 0x4C, 0x64, 0x23, 0x61, 0xF2, 0x07, 0x20,
  0x03, 0x00, 0x13, 0x01, 0x3E, 0x1B, 0x11, 0x98, 0x88, 0xC4, 0xC6, 0x2C,
  0x33, 0xC0, 0xF0, 0x1F, 0x03, 0xF8, 0x21, 0x86, 0x0C, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x80, 0x7C, 0x0C, 0xE3, 0xC6, 0x6C, 0x3C, 0xC1, 0xCC, 0x18,
  0xC1, 0xC7, 0x76, 0x3E, 0x30, 0xFF, 0xFC, 0x06, 0x3C, 0xE1, 0x86, 0x0C,
  0x10, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xE0, 0xC0,
  0xE0, 0xE0, 0x40, 0xC3, 0x83, 0x06, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x41,
  0x04, 0x10, 0xC3, 0x0C, 0x63, 0x9C, 0xE2, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x08, 0x61, 0xF6, 0xF7, 0xDE, 0x06, 0x00, 0xF0, 0x19, 0x83, 0x98, 0x30,
  0xC2, 0x08, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x3B, 0x98, 0xC4, 0x63, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x00, 0x3E, 0x1F, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x33, 0xCC, 0xF3, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x19, 0xCE,
  0x3F, 0x00, 0x0E, 0x0F, 0x87, 0x63, 0x18, 0x86, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x63, 0xFF, 0xFF, 0xC0,
  0x3E, 0x1F, 0xEC, 0x1B, 0x03, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x81,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF,
  0xE0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x7C, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0xC0, 0xF0, 0x3C, 0x19, 0xCE, 0x3E, 0x00, 0x03, 0x81, 0x81, 0x81,
  0x80, 0xC0, 0xC0, 0xE0, 0x61, 0x60, 0xF0, 0x70, 0x38, 0x1F, 0xF8, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0D,
  0xF3, 0xFE, 0xE1, 0xB0, 0x30, 0x0C, 0x03, 0x00, 0xF0, 0x3C, 0x19, 0xCE,
  0x3F, 0x00, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0xFC,
  0xE3, 0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1D, 0xCE, 0x3F, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC1, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x00, 0x3E, 0x1F,
  0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x66, 0x18, 0xFC, 0x1E, 0x1C, 0xC6, 0x1B,
  0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0xCE, 0x3F, 0x00, 0x3E, 0x1F, 0xEE, 0x1B,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xDF, 0xE1, 0x90, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x00, 0x6F, 0xF4, 0x00, 0x00, 0x00, 0xEF,
  0xE0, 0x33, 0xDE, 0x40, 0x00, 0x00, 0x00, 0x4C, 0xE6, 0x31, 0x98, 0xC0,
  0x00, 0x40, 0x30, 0x38, 0x38, 0x38, 0x38, 0x0C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x80, 0x30, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0C, 0x0F, 0x0F, 0x0F,
  0x0F, 0x03, 0x00, 0xF8, 0xFE, 0x07, 0x03, 0x03, 0x03, 0x03, 0x07, 0x3E,
  0x38, 0x30, 0x30, 0x00, 0x00, 0x30, 0x78, 0x70, 0x0F, 0x83, 0x9C, 0x60,
  0x64, 0x02, 0xC0, 0x3C, 0x03, 0xC3, 0xFC, 0x67, 0xC4, 0x3C, 0x43, 0xC4,
  0x3C, 0x43, 0xC4, 0x3C, 0x43, 0xC7, 0xFC, 0x3B, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x80, 0x1F, 0x00, 0x06, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x09, 0x01,
  0x98, 0x19, 0x81, 0x98, 0x10, 0x83, 0x0C, 0x30, 0xC3, 0xFC, 0x60, 0x46,
  0x06, 0x60, 0x66, 0x06, 0xC0, 0x30, 0xFE, 0x3F, 0xEC, 0x1B, 0x03, 0xC0,
  0xF0, 0x3C, 0x1B, 0xFC, 0xFF, 0x30, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1F, 0xFE, 0xFF, 0x00, 0x1E, 0x1F, 0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x3E, 0x19, 0xCE,
  0x3F, 0x00, 0xFC, 0x3F, 0xCC, 0x1B, 0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x2C, 0x1B, 0xFC, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xB0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1E, 0x1F, 0xE6, 0x1B,
  0x03, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0x19, 0xCE, 0x3F, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xC0, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x31, 0xFF, 0xFF, 0x80,
  0x0F, 0xC3, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0xC0, 0xF0, 0x36, 0x0D, 0xCE, 0x3F, 0x00, 0xC0, 0xF8,
  0x1B, 0x06, 0x60, 0xCC, 0x31, 0x86, 0x31, 0x87, 0xF0, 0xFE, 0x18, 0xC3,
  0x1C, 0x61, 0x8C, 0x39, 0x83, 0x30, 0x76, 0x06, 0xC0, 0xE0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0xC1, 0xF8, 0x7A, 0x16, 0x8D, 0xB3,
  0xE4, 0xBD, 0x6F, 0x7B, 0xCC, 0xF3, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xC0, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xD0, 0xF6, 0x3D,
  0x8F, 0x23, 0xCC, 0xF3, 0x3C, 0x4F, 0x1B, 0xC2, 0xF0, 0xFC, 0x3F, 0x07,
  0xC1, 0xC0, 0x3E, 0x1F, 0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x19, 0xCE, 0x3F, 0x00,
  0xFE, 0x1F, 0xF3, 0x03, 0x60, 0x6C, 0x07, 0x80, 0xF0, 0x36, 0x06, 0xFF,
  0x9F, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00,
  0x3E, 0x1F, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x19, 0xCE, 0x3F, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0xFE, 0x3F, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0xFF, 0xBF, 0x8C, 0x63, 0x0C, 0xC3, 0x30, 0x6C, 0x1B, 0x03, 0xC0,
  0xC0, 0x3F, 0x1F, 0xE6, 0x1B, 0x03, 0xC0, 0x30, 0x06, 0x01, 0xE0, 0x1F,
  0x01, 0xE0, 0x1C, 0x03, 0x00, 0xF0, 0x3C, 0x0D, 0xCE, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36, 0x19, 0xCE, 0x3F, 0x00, 0xC0,
  0x34, 0x06, 0x60, 0x66, 0x06, 0x60, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x81, 0x98, 0x19, 0x81, 0x98, 0x19, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x06,
  0x00, 0x86, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xCE, 0x3C, 0xB3, 0xC9, 0x24,
  0x92, 0x49, 0x24, 0x96, 0x69, 0x66, 0x96, 0x79, 0x67, 0x1E, 0x71, 0xC7,
  0x0C, 0x30, 0xC0, 0xE0, 0x76, 0x06, 0x30, 0xC3, 0x0C, 0x19, 0x81, 0x98,
  0x0F, 0x00, 0xE0, 0x06, 0x00, 0xF0, 0x0F, 0x01, 0x98, 0x11, 0x83, 0x0C,
  0x60, 0xC6, 0x06, 0xC0, 0x70, 0xC0, 0x34, 0x06, 0x60, 0x66, 0x0C, 0x30,
  0xC3, 0x18, 0x19, 0x81, 0x90, 0x0F, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18,
  0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x30, 0xFF,
  0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0xFF, 0xF0, 0x0C, 0x07, 0x01, 0xE0, 0x48, 0x33, 0x08, 0x46,
  0x19, 0x06, 0xC0, 0xC0, 0xFF, 0xE0, 0xE1, 0x8E, 0x1E, 0x1F, 0xE6, 0x1B,
  0x03, 0x00, 0xC0, 0x37, 0xFF, 0x03, 0xC0, 0xE0, 0x3C, 0x1F, 0x8F, 0x7E,
  0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCE, 0x37, 0xEE, 0x1B, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1B, 0xCE, 0xDF, 0x00, 0x1E,
  0x1F, 0xE6, 0x1B, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x3E,
  0x1D, 0xCE, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x3C, 0xDF, 0xBE,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1D, 0xCF,
  0x3E, 0xC0, 0x1E, 0x1F, 0xC6, 0x1B, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0x00,
  0xC0, 0x30, 0x0C, 0x0D, 0xCE, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x3F, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x3C, 0xDF, 0xB6, 0x1F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x77, 0x2C, 0xFB, 0x00, 0xC0,
  0x30, 0x08, 0xFE, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCE, 0x3F,
  0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0xFF, 0xFF, 0xFC, 0x03, 0x07, 0x03, 0x00, 0x00, 0x7F, 0x7F, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07,
  0xFE, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x0F, 0x81, 0xB0, 0x66,
  0x18, 0xC3, 0x18, 0xC3, 0xF0, 0x63, 0x0C, 0x31, 0x86, 0x30, 0x66, 0x06,
  0xC0, 0xE0, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x7F, 0x03, 0xF0, 0xBB, 0xBE, 0xF8, 0xCE, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x40, 0xCE, 0x3F, 0xEE,
  0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xC0, 0x1E, 0x1F, 0xC6, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x19, 0xCE, 0x3F, 0x00, 0xCE, 0x37, 0xEE, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1B, 0xCE, 0xDF, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3C, 0xDF, 0xB6, 0x1F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1D, 0xCF, 0x3E, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x9E, 0x5F, 0xB0, 0x78, 0x38, 0x1C, 0x0E, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0x3F, 0x1F, 0xE6, 0x0F, 0x00, 0xC0,
  0x1C, 0x03, 0xF0, 0x0E, 0x00, 0xC0, 0x3C, 0x0D, 0xCE, 0x3F, 0x00, 0x0C,
  0x01, 0x80, 0x30, 0x7F, 0xFF, 0xFE, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x3F, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36, 0x19, 0xCE,
  0x3F, 0x00, 0xC0, 0x2C, 0x0D, 0x81, 0xB0, 0x23, 0x0C, 0x61, 0x8C, 0x20,
  0xCC, 0x19, 0x81, 0x20, 0x3C, 0x07, 0x80, 0x60, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x62, 0x4A, 0x24, 0x92, 0x49, 0x66, 0x96, 0x69, 0x66, 0x94, 0x31,
  0x43, 0x1C, 0x30, 0xC0, 0x60, 0x6C, 0x18, 0xC3, 0x0C, 0xC1, 0xB0, 0x1E,
  0x01, 0x80, 0x78, 0x1B, 0x03, 0x30, 0xC3, 0x30, 0x6E, 0x06, 0xC0, 0x6C,
  0x0D, 0x81, 0x98, 0x63, 0x0C, 0x61, 0x06, 0x60, 0xCC, 0x0D, 0x01, 0xE0,
  0x3C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x00, 0xFF, 0xBF,
  0xE0, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xC1, 0xF0, 0x60, 0x10, 0x04, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x0F, 0x83, 0xF0, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x18, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x3E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0x7C, 0x3F, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0xF0, 0x30, 0x00, 0xF8, 0xF7, 0x38, 0xEE, 0x1E,
};

const GFXglyph JetBrainsMono_Light23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 6, 7, 14, 4, -17 },
  { 16, 12, 17, 14, 1, -17 },
  { 42, 10, 23, 14, 2, -20 },
  { 71, 13, 17, 14, 0, -17 },
  { 99, 12, 17, 14, 1, -17 },
  { 125, 2, 7, 14, 6, -17 },
  { 127, 7, 22, 14, 4, -19 },
  { 147, 6, 22, 14, 3, -19 },
  { 164, 12, 12, 14, 1, -14 },
  { 182, 10, 11, 14, 2, -13 },
  { 196, 5, 7, 14, 4, -3 },
  { 201, 8, 1, 14, 3, -8 },
  { 202, 4, 3, 14, 5, -3 },
  { 204, 10, 22, 14, 2, -19 },
  { 232, 10, 17, 14, 2, -17 },
  { 254, 10, 17, 14, 2, -17 },
  { 276, 10, 17, 14, 2, -17 },
  { 298, 10, 17, 14, 2, -17 },
  { 320, 9, 17, 14, 2, -17 },
  { 340, 10, 17, 14, 2, -17 },
  { 362, 10, 17, 14, 2, -17 },
  { 384, 10, 17, 14, 2, -17 },
  { 406, 10, 17, 14, 2, -17 },
  { 428, 10, 17, 14, 2, -17 },
  { 450, 4, 13, 14, 5, -13 },
  { 457, 5, 17, 14, 4, -13 },
  { 468, 10, 12, 14, 2, -14 },
  { 483, 10, 7, 14, 2, -11 },
  { 492, 10, 12, 14, 2, -14 },
  { 507, 8, 17, 14, 3, -17 },
  { 524, 12, 21, 14, 1, -17 },
  { 556, 12, 17, 14, 1, -17 },
  { 582, 10, 17, 14, 2, -17 },
  { 604, 10, 17, 14, 2, -17 },
  { 626, 10, 17, 14, 2, -17 },
  { 648, 10, 17, 14, 2, -17 },
  { 670, 10, 17, 14, 2, -17 },
  { 692, 10, 17, 14, 2, -17 },
  { 714, 10, 17, 14, 2, -17 },
  { 736, 9, 17, 14, 2, -17 },
  { 756, 10, 17, 14, 1, -17 },
  { 778, 11, 17, 14, 2, -17 },
  { 802, 9, 17, 14, 3, -17 },
  { 822, 10, 17, 14, 2, -17 },
  { 844, 10, 17, 14, 2, -17 },
  { 866, 10, 17, 14, 2, -17 },
  { 888, 11, 17, 14, 2, -17 },
  { 912, 10, 21, 14, 2, -17 },
  { 939, 10, 17, 14, 2, -17 },
  { 961, 10, 17, 14, 2, -17 },
  { 983, 12, 17, 14, 1, -17 },
  { 1009, 10, 17, 14, 2, -17 },
  { 1031, 12, 17, 14, 1, -17 },
  { 1057, 12, 17, 14, 1, -17 },
  { 1083, 12, 17, 14, 1, -17 },
  { 1109, 12, 17, 14, 1, -17 },
  { 1135, 10, 17, 14, 2, -17 },
  { 1157, 5, 22, 14, 5, -19 },
  { 1171, 10, 22, 14, 2, -19 },
  { 1199, 6, 22, 14, 3, -19 },
  { 1216, 10, 9, 14, 2, -17 },
  { 1228, 11, 1, 14, 1, 1 },
  { 1230, 5, 3, 14, 4, -18 },
  { 1232, 10, 13, 14, 2, -13 },
  { 1249, 10, 17, 14, 2, -17 },
  { 1271, 10, 13, 14, 2, -13 },
  { 1288, 10, 17, 14, 2, -17 },
  { 1310, 10, 13, 14, 2, -13 },
  { 1327, 11, 17, 14, 1, -17 },
  { 1351, 10, 17, 14, 2, -13 },
  { 1373, 10, 17, 14, 2, -17 },
  { 1395, 11, 18, 14, 2, -18 },
  { 1420, 8, 22, 14, 2, -18 },
  { 1442, 11, 17, 14, 2, -17 },
  { 1466, 12, 17, 14, 1, -17 },
  { 1492, 10, 13, 14, 2, -13 },
  { 1509, 10, 13, 14, 2, -13 },
  { 1526, 10, 13, 14, 2, -13 },
  { 1543, 10, 17, 14, 2, -13 },
  { 1565, 10, 17, 14, 2, -13 },
  { 1587, 9, 13, 14, 3, -13 },
  { 1602, 10, 13, 14, 2, -13 },
  { 1619, 11, 16, 14, 1, -16 },
  { 1641, 10, 13, 14, 2, -13 },
  { 1658, 11, 13, 14, 1, -13 },
  { 1676, 12, 13, 14, 1, -13 },
  { 1696, 11, 13, 14, 1, -13 },
  { 1714, 11, 17, 14, 1, -13 },
  { 1738, 10, 13, 14, 2, -13 },
  { 1755, 10, 22, 14, 2, -19 },
  { 1783, 2, 22, 14, 6, -19 },
  { 1789, 10, 22, 14, 2, -19 },
  { 1817, 10, 4, 14, 2, -10 },
};

const GFXfont JetBrainsMono_Light23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_LIGHT23PT7B_H_
