#ifndef _JETBRAINSMONO_LIGHT52PT7B_H_
#define _JETBRAINSMONO_LIGHT52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xEE,
  0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x78, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x38, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x38,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0xEF, 0xE1, 0xF1, 0xC7,
  0xE3, 0xC3, 0x87, 0xCF, 0x87, 0x07, 0x9E, 0x0E, 0x0F, 0xBC, 0x1C, 0x0F,
  0x78, 0x38, 0x1E, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0xE1, 0xC0, 0x03,
  0xE3, 0x80, 0x07, 0xE7, 0x00, 0x07, 0xEE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xBF, 0x80, 0x07, 0x1F, 0x80, 0x0E, 0x1F, 0x00, 0x1C, 0x1F, 0x00, 0x38,
  0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81,
  0xFE, 0x07, 0x03, 0xFE, 0x0E, 0x0F, 0xBE, 0x1C, 0x1E, 0x7E, 0x38, 0x7C,
  0x7F, 0x73, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x39,
  0xFF, 0x80, 0x03, 0x9F, 0xFE, 0x00, 0x3C, 0xF0, 0xF8, 0x01, 0xCF, 0x03,
  0xC0, 0x1C, 0x78, 0x0E, 0x01, 0xE3, 0xC0, 0x70, 0x1E, 0x1E, 0x03, 0x80,
  0xE0, 0xF0, 0x1C, 0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x3C, 0x07, 0x07, 0x01,
  0xE0, 0x38, 0x78, 0x0F, 0x03, 0xC7, 0x80, 0x3C, 0x3E, 0x38, 0x01, 0xFF,
  0xE3, 0x80, 0x07, 0xFE, 0x3C, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x0F, 0xC0, 0x00, 0xF1, 0xFF, 0x80, 0x07, 0x1F, 0xFE, 0x00,
  0x78, 0xF0, 0xF0, 0x07, 0x8F, 0x03, 0xC0, 0x38, 0x78, 0x0E, 0x03, 0xC3,
  0x80, 0x70, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x1C, 0x07, 0x00,
  0xE1, 0xE0, 0x38, 0x07, 0x0E, 0x01, 0xE0, 0x78, 0xE0, 0x0F, 0x03, 0xCF,
  0x00, 0x3C, 0x3C, 0x70, 0x01, 0xFF, 0xE7, 0x00, 0x07, 0xFE, 0x78, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x07,
  0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xF3, 0xE0, 0x0F, 0x78, 0x7C, 0x07, 0xBC, 0x0F,
  0x01, 0xEF, 0x03, 0xE0, 0xF3, 0xC0, 0x7C, 0x7C, 0xF0, 0x0F, 0x9E, 0x3C,
  0x01, 0xEF, 0x8F, 0x00, 0x7F, 0xC3, 0xC0, 0x0F, 0xE0, 0xF0, 0x01, 0xF8,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x07, 0xF0, 0xF8, 0x03,
  0xFC, 0x1E, 0x01, 0xFF, 0x87, 0xE1, 0xF9, 0xF0, 0xFF, 0xFC, 0x3E, 0x1F,
  0xFE, 0x07, 0x83, 0xFE, 0x01, 0xF0, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x39, 0xCE, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x3E, 0x00, 0x0C, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x0E, 0x00, 0xCF, 0x81, 0xC0,
  0xFF, 0xFE, 0x38, 0x7F, 0xFF, 0xE7, 0x3F, 0xF3, 0xFF, 0x7F, 0xF8, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xE0, 0x03, 0x80, 0x04, 0x00, 0x20, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x07,
  0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFB, 0xFD, 0xFC,
  0x7E, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3,
  0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x38,
  0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF8, 0x7F, 0x83, 0xF0, 0xFF, 0x07, 0xC1,
  0xFE, 0x07, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x7C, 0x00, 0x7C, 0x7C,
  0x01, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFB, 0xC0, 0x0F, 0xE7, 0x80, 0x3F, 0x0F,
  0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0x80, 0x78, 0x02, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x0F,
  0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0x7C, 0x00, 0x79, 0xF8, 0x03, 0xE3, 0xF8, 0x7F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF1, 0xF0,
  0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x0F, 0x9F, 0xF8, 0x3E,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00,
  0xF9, 0xF0, 0x07, 0xC7, 0xF0, 0x7F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xBF, 0xE0, 0x3E, 0xFF, 0xE0, 0x7B, 0xFF, 0xE1, 0xFE, 0x0F,
  0xE3, 0xF0, 0x07, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xBC,
  0x00, 0x1E, 0x7C, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x0F, 0x00,
  0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0xDF, 0x80, 0x07, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFD, 0xFC, 0x07, 0xE0, 0xFC, 0x1F,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF1, 0xFC, 0x1F,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3,
  0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xF1, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xF8, 0xFC, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xE3, 0xF0, 0x40,
  0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F, 0x87, 0xF0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x7F, 0xF7, 0xE0, 0x3E,
  0x0F, 0xF8, 0x0F, 0x01, 0xFE, 0x03, 0xC0, 0x3F, 0x80, 0xE0, 0x0F, 0xE0,
  0x38, 0x03, 0xF8, 0x0E, 0x00, 0xFE, 0x03, 0x80, 0x3F, 0x80, 0xE0, 0x0F,
  0xE0, 0x38, 0x03, 0xF8, 0x0E, 0x00, 0xFE, 0x03, 0x80, 0x3F, 0x80, 0xE0,
  0x0F, 0xE0, 0x38, 0x03, 0xF8, 0x0F, 0x00, 0xFE, 0x03, 0xC0, 0x7F, 0x80,
  0xF8, 0x3F, 0xE0, 0x1F, 0xFD, 0xF8, 0x03, 0xFE, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3C, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xF0, 0x03, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x1F,
  0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xF0, 0x07, 0xF3,
  0xC0, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x7C, 0x01,
  0xF1, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1E, 0x78, 0x00, 0xF9, 0xF0, 0x07, 0xC3, 0xF8, 0x7F, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0x7E,
  0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0,
  0x01, 0xF7, 0x80, 0x3F, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x7C, 0x01, 0xF1, 0xE0,
  0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1E, 0x78, 0x00, 0xF9, 0xF0, 0x07, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xFC,
  0x01, 0xF0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0,
  0x07, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0,
  0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0xE0, 0x0E, 0xFD, 0xE0,
  0x1D, 0xFB, 0xC0, 0x7B, 0xFB, 0x80, 0xE7, 0xF7, 0x81, 0xCF, 0xE7, 0x07,
  0x9F, 0xCE, 0x0E, 0x3F, 0x9E, 0x1C, 0xFF, 0x3C, 0x79, 0xFE, 0x38, 0xE3,
  0xFC, 0x79, 0xC7, 0xF8, 0x73, 0x8F, 0xF0, 0xEE, 0x1F, 0xE1, 0xDC, 0x3F,
  0xC1, 0xF8, 0x7F, 0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFE, 0xE0, 0x0F, 0xF7, 0x80, 0x7F, 0xBC, 0x03,
  0xFC, 0xE0, 0x1F, 0xE7, 0x80, 0xFF, 0x3C, 0x07, 0xF8, 0xE0, 0x3F, 0xC7,
  0x81, 0xFE, 0x3C, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x1C, 0x1F,
  0xE0, 0xF0, 0xFF, 0x07, 0x87, 0xF8, 0x1C, 0x3F, 0xC0, 0xF1, 0xFE, 0x07,
  0x8F, 0xF0, 0x1C, 0x7F, 0x80, 0xF3, 0xFC, 0x07, 0x9F, 0xE0, 0x1E, 0xFF,
  0x00, 0xF7, 0xF8, 0x03, 0xBF, 0xC0, 0x1E, 0xFE, 0x00, 0xF7, 0xF0, 0x03,
  0xBF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0x1F,
  0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0x78, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0xE1, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0x00, 0x1F, 0xDE,
  0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x01,
  0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x7C, 0x01,
  0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xBE, 0x00, 0x1E, 0xF8, 0x00, 0xF9, 0xF0, 0x07, 0xC3, 0xF0, 0x7F, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x06, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00, 0x1F, 0x9E,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0, 0x07,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x03,
  0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xF3, 0xC0,
  0x01, 0xE7, 0x80, 0x03, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xC0, 0x00,
  0x10, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFC,
  0x3F, 0x87, 0xC0, 0x1F, 0x8F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x79, 0xF8, 0x01, 0xF1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x8F, 0xE1,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xE0,
  0x1F, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0x00, 0xEF, 0x01, 0xF0,
  0x1E, 0xF0, 0x1F, 0x01, 0xEF, 0x01, 0xB8, 0x1E, 0xF0, 0x1B, 0x81, 0xEF,
  0x01, 0xB8, 0x1E, 0x70, 0x3B, 0x81, 0xE7, 0x03, 0xB8, 0x1E, 0x78, 0x39,
  0x81, 0xC7, 0x83, 0x98, 0x1C, 0x78, 0x39, 0x81, 0xC7, 0x83, 0x1C, 0x3C,
  0x78, 0x31, 0xC3, 0xC7, 0x87, 0x1C, 0x3C, 0x78, 0x71, 0xC3, 0xC3, 0x87,
  0x1C, 0x3C, 0x38, 0x70, 0xC3, 0xC3, 0xC7, 0x0C, 0x38, 0x3C, 0x70, 0xC3,
  0x83, 0xC6, 0x0E, 0x38, 0x3C, 0x60, 0xE7, 0x83, 0xCE, 0x0E, 0x78, 0x3C,
  0xE0, 0xE7, 0x81, 0xCE, 0x0E, 0x78, 0x1C, 0xE0, 0xE7, 0x81, 0xCE, 0x06,
  0x70, 0x1C, 0xC0, 0x67, 0x01, 0xEC, 0x06, 0x70, 0x1E, 0xC0, 0x77, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00,
  0x07, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3C,
  0x07, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0xF0,
  0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0xF8,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x3E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0x71, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x00,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0x00, 0xF8, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7C, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFD, 0xF8, 0x0F, 0xF3,
  0xFF, 0xFB, 0xC7, 0xFF, 0xCF, 0x0F, 0xFE, 0x3C, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC3, 0xFC, 0x0F, 0x1F, 0xFC, 0x3C, 0xFF, 0xF8, 0xF7, 0xFF, 0xF3, 0xF8,
  0x07, 0xCF, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x80, 0x07,
  0xBE, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xF0, 0x07, 0xCF, 0x70, 0x7F, 0x3D,
  0xFF, 0xF8, 0xF3, 0xFF, 0xC3, 0xC7, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7E, 0x01,
  0xF1, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF,
  0x80, 0x07, 0x9E, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0xC3,
  0xC3, 0xFF, 0x9E, 0x7F, 0xFE, 0xF3, 0xFD, 0xF7, 0xBF, 0x01, 0xFD, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFB, 0xE0, 0x0F, 0xDF, 0xC1, 0xFE, 0x7F, 0xFE, 0xF1, 0xFF, 0xE7, 0x83,
  0xFE, 0x3C, 0x01, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xF7, 0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x7C,
  0x00, 0xF8, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xF3, 0xC7, 0xFF, 0xDE, 0x7F,
  0xBE, 0xF7, 0xE0, 0x3F, 0xBE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xBE, 0x00,
  0xFD, 0xF8, 0x0F, 0xE7, 0xFB, 0xEF, 0x1F, 0xFF, 0x78, 0x7F, 0xF3, 0xC0,
  0xFE, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0xF8, 0x3C, 0x7F, 0xE1,
  0xEF, 0xFF, 0xCF, 0x7C, 0xFE, 0x7F, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0,
  0x07, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0xE3, 0xE1, 0xF8, 0xE7, 0xF3, 0xFC,
  0xEF, 0xF3, 0xFE, 0xE8, 0xFE, 0x3E, 0xF0, 0x7C, 0x1E, 0xF0, 0x3C, 0x0F,
  0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F,
  0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F,
  0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F,
  0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F,
  0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F,
  0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xF0, 0xFF, 0x07,
  0x8F, 0xFC, 0x3C, 0xFF, 0xF9, 0xEF, 0xFF, 0xCF, 0xE0, 0x1F, 0x7E, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xEF, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xFE,
  0x3F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xF0, 0xFF,
  0x03, 0xC7, 0xFF, 0x0F, 0x3F, 0xFE, 0x3D, 0xFF, 0xFC, 0xFE, 0x01, 0xF3,
  0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xBE, 0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xDC, 0x1F, 0xCF, 0x7F, 0xFE,
  0x3C, 0xFF, 0xF0, 0xF0, 0xFF, 0x83, 0xC0, 0x20, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xF3,
  0xC7, 0xFF, 0xDE, 0x7F, 0xBE, 0xF7, 0xE0, 0x3F, 0xBE, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x01,
  0xFB, 0xF8, 0x3F, 0xCF, 0xFF, 0xDE, 0x3F, 0xFC, 0xF0, 0x7F, 0xC7, 0x80,
  0x20, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0xF0,
  0xFF, 0x03, 0xCF, 0xFE, 0x0F, 0x7F, 0xFE, 0x3D, 0xF3, 0xFC, 0xFE, 0x01,
  0xF3, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7C, 0x00, 0xF9, 0xE0, 0x01, 0xEF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0xF9, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x7C, 0x01, 0xF1,
  0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x30,
  0x00, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xFE,
  0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xB8, 0x0F, 0x80, 0xF7, 0x01, 0xB0,
  0x1C, 0xE0, 0x36, 0x03, 0x9E, 0x06, 0xE0, 0x73, 0xC1, 0xDC, 0x0E, 0x78,
  0x3B, 0x83, 0xC7, 0x07, 0x30, 0x78, 0xE0, 0xC6, 0x0E, 0x1C, 0x18, 0xC1,
  0xC3, 0xC3, 0x1C, 0x38, 0x78, 0xE3, 0x87, 0x0F, 0x1C, 0x71, 0xE1, 0xE3,
  0x86, 0x3C, 0x1C, 0x60, 0xC7, 0x03, 0x8C, 0x18, 0xE0, 0x71, 0x83, 0x9C,
  0x0F, 0x70, 0x73, 0x81, 0xEE, 0x0E, 0x70, 0x3D, 0xC1, 0xDE, 0x03, 0xB0,
  0x1B, 0x80, 0x76, 0x03, 0x70, 0x0E, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x78, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x03,
  0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xCF, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x07, 0x80, 0x3E,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0x7F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0x7C, 0x0E, 0xF0, 0x3E,
  0x1E, 0xF0, 0x1F, 0xFE, 0xF0, 0x0F, 0xFC, 0xF0, 0x07, 0xF8, 0xF0, 0x01,
  0xE0,
};

const GFXglyph JetBrainsMono_Light52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 38, 31, 12, -38 },
  { 35, 15, 16, 31, 8, -38 },
  { 65, 27, 38, 31, 2, -38 },
  { 194, 23, 52, 31, 4, -45 },
  { 344, 29, 38, 31, 1, -38 },
  { 482, 26, 39, 31, 3, -38 },
  { 609, 5, 16, 31, 13, -38 },
  { 619, 15, 50, 31, 10, -44 },
  { 713, 15, 50, 31, 6, -44 },
  { 807, 27, 27, 31, 2, -32 },
  { 899, 24, 24, 31, 4, -29 },
  { 971, 10, 16, 31, 9, -8 },
  { 991, 17, 4, 31, 7, -19 },
  { 1000, 9, 9, 31, 11, -8 },
  { 1011, 23, 49, 31, 4, -43 },
  { 1152, 23, 39, 31, 4, -38 },
  { 1265, 23, 38, 31, 5, -38 },
  { 1375, 23, 38, 31, 4, -38 },
  { 1485, 22, 39, 31, 4, -38 },
  { 1593, 22, 38, 31, 4, -38 },
  { 1698, 22, 39, 31, 5, -38 },
  { 1806, 23, 39, 31, 4, -38 },
  { 1919, 24, 38, 31, 4, -38 },
  { 2033, 23, 40, 31, 4, -39 },
  { 2148, 23, 38, 31, 4, -38 },
  { 2258, 9, 30, 31, 11, -29 },
  { 2292, 11, 37, 31, 9, -29 },
  { 2343, 23, 27, 31, 4, -31 },
  { 2421, 22, 16, 31, 5, -25 },
  { 2465, 23, 27, 31, 4, -31 },
  { 2543, 19, 38, 31, 7, -38 },
  { 2634, 26, 47, 31, 3, -38 },
  { 2787, 25, 38, 31, 3, -38 },
  { 2906, 22, 38, 31, 5, -38 },
  { 3011, 22, 39, 31, 5, -38 },
  { 3119, 21, 38, 31, 5, -38 },
  { 3219, 22, 38, 31, 5, -38 },
  { 3324, 22, 38, 31, 5, -38 },
  { 3429, 22, 39, 31, 5, -38 },
  { 3537, 21, 38, 31, 5, -38 },
  { 3637, 20, 38, 31, 6, -38 },
  { 3732, 23, 39, 31, 3, -38 },
  { 3845, 24, 38, 31, 5, -38 },
  { 3959, 22, 38, 31, 6, -38 },
  { 4064, 23, 38, 31, 4, -38 },
  { 4174, 21, 38, 31, 5, -38 },
  { 4274, 21, 39, 31, 5, -38 },
  { 4377, 23, 38, 31, 5, -38 },
  { 4487, 22, 47, 31, 5, -38 },
  { 4617, 23, 38, 31, 5, -38 },
  { 4727, 23, 40, 31, 4, -39 },
  { 4842, 25, 38, 31, 3, -38 },
  { 4961, 21, 39, 31, 5, -38 },
  { 5064, 25, 38, 31, 3, -38 },
  { 5183, 28, 38, 31, 2, -38 },
  { 5316, 27, 38, 31, 2, -38 },
  { 5445, 27, 38, 31, 2, -38 },
  { 5574, 22, 38, 31, 5, -38 },
  { 5679, 12, 49, 31, 11, -43 },
  { 5753, 23, 49, 31, 4, -43 },
  { 5894, 12, 49, 31, 8, -43 },
  { 5968, 23, 20, 31, 4, -38 },
  { 6026, 25, 4, 31, 3, 1 },
  { 6039, 10, 7, 31, 10, -41 },
  { 6048, 22, 30, 31, 4, -29 },
  { 6131, 22, 39, 31, 5, -38 },
  { 6239, 22, 30, 31, 5, -29 },
  { 6322, 21, 39, 31, 5, -38 },
  { 6425, 22, 30, 31, 5, -29 },
  { 6508, 25, 38, 31, 3, -38 },
  { 6627, 21, 38, 31, 5, -29 },
  { 6727, 21, 38, 31, 5, -38 },
  { 6827, 24, 40, 31, 5, -40 },
  { 6947, 19, 49, 31, 5, -40 },
  { 7064, 24, 38, 31, 5, -38 },
  { 7178, 26, 38, 31, 2, -38 },
  { 7302, 24, 29, 31, 4, -29 },
  { 7389, 21, 29, 31, 5, -29 },
  { 7466, 22, 29, 31, 5, -29 },
  { 7546, 22, 38, 31, 5, -29 },
  { 7651, 21, 38, 31, 5, -29 },
  { 7751, 22, 29, 31, 6, -29 },
  { 7831, 22, 29, 31, 5, -29 },
  { 7911, 24, 37, 31, 3, -37 },
  { 8022, 21, 30, 31, 5, -29 },
  { 8101, 25, 29, 31, 3, -29 },
  { 8192, 27, 29, 31, 2, -29 },
  { 8290, 25, 29, 31, 3, -29 },
  { 8381, 25, 38, 31, 3, -29 },
  { 8500, 21, 29, 31, 5, -29 },
  { 8577, 22, 49, 31, 5, -43 },
  { 8712, 4, 49, 31, 14, -43 },
  { 8737, 22, 49, 31, 5, -43 },
  { 8872, 24, 11, 31, 4, -24 },
};

const GFXfont JetBrainsMono_Light52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_LIGHT52PT7B_H_
