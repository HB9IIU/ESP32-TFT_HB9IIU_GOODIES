#ifndef _JETBRAINSMONO_LIGHT38PT7B_H_
#define _JETBRAINSMONO_LIGHT38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light38pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x70,
  0x01, 0xC0, 0xE0, 0x1C, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x81,
  0xC0, 0x38, 0x1C, 0x03, 0x81, 0x80, 0x30, 0x18, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x07, 0x03, 0x80, 0x70, 0x30, 0x07, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x07, 0x00, 0x60, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x0C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0C, 0x01, 0xC0, 0xC0,
  0x18, 0x0C, 0x01, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0x7F,
  0xF0, 0x7F, 0xFC, 0x78, 0xCF, 0x38, 0x63, 0x9C, 0x31, 0xCE, 0x18, 0x77,
  0x0C, 0x03, 0x86, 0x01, 0xC3, 0x00, 0xF1, 0x80, 0x3E, 0xC0, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x06, 0xF8, 0x03, 0x1C, 0x01,
  0x8F, 0x00, 0xC3, 0x80, 0x61, 0xF8, 0x30, 0xFC, 0x18, 0x7F, 0x0C, 0x7B,
  0xC6, 0x79, 0xFB, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x1B, 0xFC, 0x01,
  0xBC, 0xE0, 0x1D, 0xC3, 0x81, 0xCC, 0x0C, 0x0C, 0x60, 0x60, 0xE3, 0x03,
  0x0E, 0x18, 0x18, 0x60, 0xC0, 0xC7, 0x07, 0x0E, 0x70, 0x3F, 0xE3, 0x00,
  0xFF, 0x30, 0x01, 0xE3, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x20, 0x00, 0xCF, 0xE0, 0x0C, 0x7F, 0x80, 0xE7, 0x0E, 0x0E, 0x30, 0x70,
  0x61, 0x83, 0x87, 0x0C, 0x1C, 0x70, 0x60, 0xE3, 0x03, 0x07, 0x38, 0x18,
  0x3B, 0x80, 0xE3, 0xD8, 0x03, 0xFD, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1E, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1E, 0xF0, 0x3F, 0x8E, 0x0F, 0xE0,
  0xE1, 0xDC, 0x1E, 0x73, 0x81, 0xEE, 0x70, 0x1F, 0x8E, 0x01, 0xF1, 0xC0,
  0x3C, 0x38, 0x03, 0x87, 0x00, 0xF8, 0x70, 0x3B, 0x8F, 0x9F, 0x78, 0xFF,
  0xC7, 0x0F, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x1C,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x70, 0x02,
  0xC0, 0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x1F, 0x07, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x04, 0x07, 0x01, 0x78,
  0x70, 0xFF, 0xE6, 0x3F, 0x7F, 0xAF, 0xE0, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x0D, 0x80, 0x01, 0xDC, 0x00, 0x39, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xF0,
  0x0F, 0x07, 0x81, 0xE0, 0x3C, 0x04, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x3E, 0x7C, 0xF1,
  0xE7, 0x8F, 0x1C, 0x38, 0xF1, 0xC3, 0x86, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x39, 0xFF, 0xFF, 0x7D, 0xF0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x80, 0x3B,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x1C, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0xC3, 0x87, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1C,
  0xE0, 0x0E, 0x78, 0x0F, 0x1F, 0x1F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x03,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3D, 0xC0, 0xF9, 0xC0, 0xF1, 0xC0, 0xC1,
  0xC0, 0x81, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x7E, 0x7E, 0x3F,
  0xFC, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x73, 0xF8, 0x77, 0xFC, 0x7F,
  0x7E, 0x78, 0x0F, 0x78, 0x07, 0x70, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78,
  0x0F, 0x3E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x3F, 0x03, 0xFF, 0xC3, 0xFB,
  0xF1, 0xE0, 0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1E, 0xE0, 0x0E, 0x78, 0x0F,
  0x1F, 0x3F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x07, 0x8E, 0x03, 0x83, 0xC7, 0x80, 0xFF, 0x80, 0x1F,
  0x00, 0x3F, 0xE0, 0x3C, 0x78, 0x38, 0x1E, 0x38, 0x07, 0x9C, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0E, 0x78, 0x0F,
  0x3F, 0x1F, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7B, 0xC0,
  0x79, 0xF0, 0xFC, 0x7F, 0xFC, 0x0F, 0xEE, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x7D, 0xFF, 0xFF, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0x7C, 0x3E,
  0x7E, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xE0,
  0xE0, 0xE0, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x7F, 0xC1, 0xFE,
  0x07, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x7C, 0x3E, 0x1E, 0x01, 0xE7, 0x80, 0x1C, 0xE0,
  0x01, 0xD8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81,
  0xF9, 0xF0, 0x7F, 0xBE, 0x0E, 0x1F, 0xC3, 0x81, 0xF8, 0x70, 0x3F, 0x0E,
  0x07, 0xE1, 0xC0, 0xFC, 0x38, 0x1F, 0x87, 0x03, 0xF0, 0xE0, 0x7E, 0x1C,
  0x0F, 0xC3, 0x81, 0xF8, 0x78, 0x3F, 0x07, 0x9B, 0xE0, 0x7F, 0x7C, 0x07,
  0x8F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x3B, 0xC0, 0x07, 0x70, 0x00, 0x70, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFC,
  0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8,
  0xE0, 0x3C, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x70, 0x1E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0xE0, 0x0E, 0xF0, 0x1E, 0x7C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0E, 0xE0, 0x3D, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x70, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1,
  0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x1E, 0x7C, 0x7C, 0x3F,
  0xF8, 0x1F, 0xF0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1D, 0xE0, 0x0E, 0x78, 0x0F, 0x1F, 0x3F, 0x07, 0xFF, 0x01, 0xFE,
  0x00, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x01, 0xE7,
  0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x38, 0x38, 0x38,
  0x1C, 0x1C, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xC3, 0xC0, 0xE0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0F, 0x0E, 0x03, 0x87, 0x01, 0xE3,
  0x80, 0x71, 0xC0, 0x3C, 0xE0, 0x0E, 0x70, 0x07, 0xB8, 0x01, 0xDC, 0x00,
  0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC,
  0x07, 0xFE, 0x03, 0x7B, 0x01, 0xBD, 0xC1, 0xFE, 0xE0, 0xDF, 0xB0, 0x6F,
  0xDC, 0x77, 0xEE, 0x33, 0xF3, 0x19, 0xF9, 0xDC, 0xFC, 0xEC, 0x7E, 0x36,
  0x3F, 0x1B, 0x1F, 0x8F, 0x0F, 0xC3, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x70, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7D, 0x80, 0xFB, 0x81, 0xF7, 0x03, 0xE6, 0x07,
  0xCE, 0x0F, 0xDC, 0x1F, 0x98, 0x3F, 0x38, 0x7E, 0x70, 0xFC, 0x71, 0xF8,
  0xE3, 0xF0, 0xC7, 0xE1, 0xCF, 0xC3, 0x9F, 0x83, 0x3F, 0x07, 0x7E, 0x0E,
  0xFC, 0x0D, 0xF8, 0x1F, 0xF0, 0x3B, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF7, 0x81, 0xEE, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x1C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x9C, 0x03, 0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0xF7, 0x03,
  0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x03, 0xC7, 0x00, 0x73, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x78, 0x0F,
  0x1F, 0x3F, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xFF, 0xC0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x07, 0xCE, 0x00, 0xE7, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xEE,
  0x01, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xF1, 0xC0,
  0x38, 0xE0, 0x1E, 0x70, 0x07, 0x38, 0x03, 0xDC, 0x00, 0xF0, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x0E, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x0F, 0x78, 0x0F, 0x3F, 0x1F, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x1C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0x60, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70,
  0x0E, 0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C,
  0x0D, 0xC1, 0xB0, 0x66, 0x0D, 0x87, 0x38, 0x6C, 0x39, 0xC3, 0x61, 0xCE,
  0x1B, 0x0E, 0x70, 0xD8, 0x73, 0x86, 0xC3, 0x9C, 0x26, 0x18, 0xE3, 0x10,
  0xC3, 0x18, 0xC6, 0x18, 0xC6, 0x70, 0xE6, 0x33, 0x87, 0x31, 0x9C, 0x39,
  0x8C, 0xE1, 0xCC, 0x67, 0x0E, 0xC3, 0x38, 0x76, 0x19, 0x83, 0xB0, 0x6C,
  0x0D, 0x83, 0x60, 0x6C, 0x1B, 0x03, 0x60, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x39,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x83, 0x80,
  0x70, 0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xB8, 0x00,
  0x77, 0x00, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE0, 0xE0, 0x3C, 0x1E, 0x07,
  0x01, 0xC1, 0xC0, 0x3C, 0x38, 0x03, 0x8E, 0x00, 0x7B, 0xC0, 0x07, 0x70,
  0x00, 0xF0, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0xDC, 0x00, 0x1D,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00,
  0x77, 0x00, 0x31, 0x80, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x1C, 0x0E, 0x0E,
  0x0E, 0x03, 0x07, 0x01, 0xC7, 0x00, 0x63, 0x80, 0x3B, 0x80, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x78, 0x38, 0x1C, 0x0F,
  0x07, 0xF0, 0x1F, 0xFC, 0x3E, 0x7E, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x1F, 0xFF, 0x3F, 0xFF, 0x78, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0x78, 0x3F, 0x7F, 0xF7, 0x1F, 0xE7, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x73, 0xF8, 0xEF, 0xF9, 0xFD,
  0xFB, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0xFB, 0xBF, 0xE7, 0x3F, 0x80, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xDF, 0x8F, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x3B,
  0xC0, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0xE0, 0x0E, 0x70, 0x07, 0x3C,
  0x07, 0x8F, 0x8F, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x0F, 0xE7,
  0x1F, 0xF7, 0x3E, 0x7F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x3E, 0x3F,
  0x1F, 0xF7, 0x0F, 0xE7, 0x07, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E, 0x78, 0x0E,
  0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x07, 0x78, 0x0F, 0x3C, 0x1E, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x1F, 0xCE, 0x7F, 0xDD, 0xF3, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0x78, 0x3E, 0xFF, 0xDC, 0xFF,
  0x38, 0x30, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x73, 0xF8, 0xEF, 0xF9, 0xF8,
  0xFB, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x0F, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x07, 0x87,
  0x03, 0x83, 0x83, 0xC1, 0xC3, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1C, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0xC3, 0x80, 0xE1, 0xC0, 0x78, 0xE0,
  0x1E, 0x70, 0x07, 0x38, 0x03, 0xDC, 0x00, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0x1E, 0x6F, 0xDF, 0xB8, 0xE9,
  0xFC, 0x38, 0x7C, 0x1C, 0x3E, 0x0E, 0x1F, 0x07, 0x0F, 0x83, 0x87, 0xC1,
  0xC3, 0xE0, 0xE1, 0xF0, 0x70, 0xF8, 0x38, 0x7C, 0x1C, 0x3E, 0x0E, 0x1F,
  0x07, 0x0F, 0x83, 0x87, 0xC1, 0xC3, 0xE0, 0xE1, 0xF0, 0x70, 0xF8, 0x38,
  0x7C, 0x1C, 0x38, 0xE7, 0xF1, 0xDF, 0xF3, 0xFB, 0xF7, 0x80, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F,
  0x7E, 0x78, 0x0E, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x0E, 0x3F, 0x7E, 0x1F, 0xFC, 0x0F,
  0xF0, 0xE7, 0xF1, 0xDF, 0xF3, 0xFB, 0xF7, 0x80, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xF1,
  0xF7, 0x7F, 0xCE, 0x7F, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1F, 0xCE, 0x7F, 0xDD, 0xF3, 0xFF,
  0x80, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xE0, 0x3D, 0xF1, 0xF9, 0xFF, 0x71, 0xFC, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0xE3,
  0xF0, 0xEF, 0xFC, 0xEE, 0x3E, 0xF8, 0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xCF, 0x8F,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1F, 0x00, 0x07, 0x70, 0x07, 0xB8, 0x03, 0x9F, 0x07, 0xC7, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xF8, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xE0,
  0x39, 0xF1, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x1D, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0xC0, 0x70, 0x70,
  0x1C, 0x1C, 0x07, 0x07, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xE0, 0x70, 0x36, 0x07, 0x03,
  0x70, 0x70, 0x77, 0x0D, 0x07, 0x70, 0xD8, 0x77, 0x0D, 0x86, 0x30, 0xD8,
  0x63, 0x0D, 0x86, 0x30, 0x98, 0xE3, 0x98, 0x8E, 0x39, 0x8C, 0xE3, 0x98,
  0xCC, 0x39, 0x8C, 0xC1, 0x98, 0xCC, 0x19, 0x0C, 0xC1, 0xB0, 0xDC, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0E, 0x07, 0x80,
  0x70, 0x03, 0xC7, 0x00, 0x70, 0xF0, 0x1E, 0x0E, 0x07, 0x80, 0xE0, 0xE0,
  0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x1D, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x01, 0xC7, 0x00,
  0x70, 0xF0, 0x1E, 0x0F, 0x03, 0x80, 0xE0, 0xE0, 0x1E, 0x3C, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xDC, 0x00, 0x77, 0x80, 0x3C, 0xE0, 0x0E, 0x38,
  0x03, 0x8F, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x0E, 0x0E, 0x03, 0x83,
  0x80, 0xF0, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0xEF, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3E,
  0x03, 0xBF, 0x81, 0xFD, 0xE0, 0xFC, 0x38, 0x7E, 0x1E, 0x3F, 0x07, 0xFB,
  0x81, 0xF8,
};

const GFXglyph JetBrainsMono_Light38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 28, 23, 9, -28 },
  { 19, 11, 12, 23, 6, -28 },
  { 36, 20, 28, 23, 1, -28 },
  { 106, 17, 38, 23, 3, -33 },
  { 187, 21, 28, 23, 1, -28 },
  { 261, 19, 28, 23, 2, -28 },
  { 328, 3, 12, 23, 10, -28 },
  { 333, 11, 37, 23, 7, -32 },
  { 384, 12, 37, 23, 4, -32 },
  { 440, 20, 19, 23, 1, -23 },
  { 488, 17, 17, 23, 3, -21 },
  { 525, 7, 12, 23, 7, -6 },
  { 536, 12, 3, 23, 5, -14 },
  { 541, 6, 6, 23, 8, -6 },
  { 546, 17, 36, 23, 3, -32 },
  { 623, 17, 28, 23, 3, -28 },
  { 683, 16, 28, 23, 4, -28 },
  { 739, 17, 28, 23, 3, -28 },
  { 799, 16, 28, 23, 3, -28 },
  { 855, 16, 28, 23, 3, -28 },
  { 911, 16, 28, 23, 3, -28 },
  { 967, 17, 28, 23, 3, -28 },
  { 1027, 17, 28, 23, 3, -28 },
  { 1087, 17, 28, 23, 3, -28 },
  { 1147, 17, 28, 23, 3, -28 },
  { 1207, 6, 21, 23, 8, -21 },
  { 1223, 8, 27, 23, 7, -21 },
  { 1250, 17, 19, 23, 3, -22 },
  { 1291, 16, 11, 23, 3, -18 },
  { 1313, 17, 19, 23, 3, -22 },
  { 1354, 14, 28, 23, 5, -28 },
  { 1403, 19, 35, 23, 2, -28 },
  { 1487, 19, 28, 23, 2, -28 },
  { 1554, 16, 28, 23, 4, -28 },
  { 1610, 16, 28, 23, 4, -28 },
  { 1666, 15, 28, 23, 4, -28 },
  { 1719, 16, 28, 23, 4, -28 },
  { 1775, 16, 28, 23, 4, -28 },
  { 1831, 16, 28, 23, 4, -28 },
  { 1887, 15, 28, 23, 4, -28 },
  { 1940, 15, 28, 23, 4, -28 },
  { 1993, 17, 28, 23, 2, -28 },
  { 2053, 17, 28, 23, 4, -28 },
  { 2113, 16, 28, 23, 4, -28 },
  { 2169, 17, 28, 23, 3, -28 },
  { 2229, 15, 28, 23, 4, -28 },
  { 2282, 15, 28, 23, 4, -28 },
  { 2335, 17, 28, 23, 4, -28 },
  { 2395, 17, 35, 23, 3, -28 },
  { 2470, 17, 28, 23, 4, -28 },
  { 2530, 17, 28, 23, 3, -28 },
  { 2590, 19, 28, 23, 2, -28 },
  { 2657, 15, 28, 23, 4, -28 },
  { 2710, 19, 28, 23, 2, -28 },
  { 2777, 21, 28, 23, 1, -28 },
  { 2851, 19, 28, 23, 2, -28 },
  { 2918, 20, 28, 23, 1, -28 },
  { 2988, 17, 28, 23, 3, -28 },
  { 3048, 9, 36, 23, 8, -32 },
  { 3089, 17, 36, 23, 3, -32 },
  { 3166, 9, 36, 23, 6, -32 },
  { 3207, 17, 15, 23, 3, -28 },
  { 3239, 19, 3, 23, 2, 1 },
  { 3247, 8, 5, 23, 7, -30 },
  { 3252, 16, 21, 23, 3, -21 },
  { 3294, 15, 28, 23, 4, -28 },
  { 3347, 17, 21, 23, 3, -21 },
  { 3392, 16, 28, 23, 3, -28 },
  { 3448, 16, 21, 23, 3, -21 },
  { 3490, 18, 28, 23, 2, -28 },
  { 3553, 15, 28, 23, 4, -21 },
  { 3606, 15, 28, 23, 4, -28 },
  { 3659, 18, 29, 23, 3, -29 },
  { 3725, 14, 36, 23, 3, -29 },
  { 3788, 17, 28, 23, 4, -28 },
  { 3848, 20, 28, 23, 1, -28 },
  { 3918, 17, 21, 23, 3, -21 },
  { 3963, 15, 21, 23, 4, -21 },
  { 4003, 16, 21, 23, 3, -21 },
  { 4045, 15, 28, 23, 4, -21 },
  { 4098, 15, 28, 23, 4, -21 },
  { 4151, 16, 21, 23, 4, -21 },
  { 4193, 17, 21, 23, 3, -21 },
  { 4238, 18, 27, 23, 2, -27 },
  { 4299, 15, 21, 23, 4, -21 },
  { 4339, 18, 21, 23, 2, -21 },
  { 4387, 20, 21, 23, 1, -21 },
  { 4440, 19, 21, 23, 2, -21 },
  { 4490, 18, 28, 23, 2, -21 },
  { 4553, 15, 21, 23, 4, -21 },
  { 4593, 16, 36, 23, 3, -32 },
  { 4665, 3, 36, 23, 10, -32 },
  { 4679, 16, 36, 23, 3, -32 },
  { 4751, 17, 7, 23, 3, -17 },
};

const GFXfont JetBrainsMono_Light38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_LIGHT38PT7B_H_
