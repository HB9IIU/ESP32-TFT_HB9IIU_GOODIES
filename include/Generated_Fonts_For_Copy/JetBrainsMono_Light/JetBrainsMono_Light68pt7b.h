#ifndef _JETBRAINSMONO_LIGHT68PT7B_H_
#define _JETBRAINSMONO_LIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x0F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0xF1, 0xFC, 0x0F, 0xC1, 0xE1, 0xFC, 0x3F,
  0x03, 0xC1, 0xF8, 0x7E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x03, 0xF1, 0xF0,
  0x1E, 0x07, 0xE7, 0xE0, 0x3C, 0x07, 0xCF, 0xC0, 0x78, 0x0F, 0x9F, 0x80,
  0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7E, 0x07,
  0x80, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x01, 0xFC, 0x3C,
  0x00, 0x01, 0xFE, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7B, 0xFE,
  0x00, 0x00, 0xF1, 0xFE, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x03, 0xC1, 0xFC,
  0x00, 0x07, 0x81, 0xF8, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x3C, 0x07, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0x00, 0xF0, 0x1F, 0xFE,
  0x01, 0xE0, 0x3F, 0xFC, 0x03, 0xC0, 0x7F, 0xF8, 0x07, 0x80, 0xF9, 0xF8,
  0x0F, 0x03, 0xF3, 0xF0, 0x1E, 0x07, 0xE3, 0xF0, 0x3C, 0x1F, 0x87, 0xF8,
  0x78, 0xFF, 0x07, 0xFC, 0xF7, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x7F,
  0xFC, 0x00, 0x01, 0xE1, 0xFF, 0xFC, 0x00, 0x07, 0xC7, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0x80, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0,
  0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x0F, 0x87, 0xC0, 0x01, 0xFE, 0x7F, 0x0F, 0x00, 0x01, 0xFF, 0xFC,
  0x3E, 0x00, 0x01, 0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0xE0, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xFC, 0x00, 0x00,
  0x7C, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xC3, 0xFF,
  0xFC, 0x00, 0x0F, 0x87, 0xC0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x00,
  0x78, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0xF0,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x01, 0xE0,
  0xF0, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x8F, 0x80, 0x01,
  0xFF, 0xFE, 0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x7C, 0x00, 0x01, 0xFF, 0xE1,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x17, 0xE1, 0xF8, 0x00, 0xFB,
  0xF0, 0x3F, 0x00, 0x7E, 0xFC, 0x07, 0xE0, 0x1F, 0x3E, 0x01, 0xF8, 0x0F,
  0xCF, 0x80, 0x3F, 0x03, 0xE3, 0xE0, 0x07, 0xE1, 0xF8, 0xF8, 0x00, 0xFC,
  0xFC, 0x3E, 0x00, 0x3F, 0x3F, 0x0F, 0x80, 0x07, 0xFF, 0x83, 0xE0, 0x00,
  0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x07, 0xF8, 0x0F, 0x80,
  0x00, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x07, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xF0,
  0x7E, 0x00, 0xFE, 0xFC, 0x1F, 0xF0, 0xFF, 0x1F, 0x83, 0xFF, 0xFF, 0x83,
  0xF0, 0x7F, 0xFF, 0xC0, 0x7E, 0x0F, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0xE0,
  0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x78, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x09, 0xE0, 0x07, 0xC0, 0x0F,
  0x3F, 0x80, 0xF8, 0x0F, 0xEF, 0xFC, 0x1E, 0x07, 0xFF, 0xFF, 0xE1, 0xC3,
  0xFF, 0xFF, 0xFF, 0x39, 0xFF, 0xF8, 0xFF, 0xF7, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x0F, 0xF9, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xDF, 0xFC, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x07, 0x80, 0x7F, 0xE0, 0x7F, 0x03, 0xFF, 0x03, 0xF8, 0x1F, 0xF8,
  0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x3F, 0xF0, 0x3F,
  0x81, 0xFF, 0x80, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x7C, 0x00,
  0x03, 0xFC, 0xF8, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x7F, 0x83, 0xE0, 0x01,
  0xFE, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x1F, 0x8F,
  0xFF, 0x00, 0xF8, 0xFF, 0xFE, 0x07, 0xCF, 0xFF, 0xF8, 0x3E, 0xFF, 0xFF,
  0xE1, 0xF7, 0xC1, 0xFF, 0x8F, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE,
  0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x02, 0x00, 0x00, 0xFC, 0xFF, 0xE0, 0x01, 0xF3, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0x9F, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x3E, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x3F,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xBE, 0x00, 0x3F, 0xFC,
  0xFC, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xF9, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xC3, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x1F, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0x03,
  0x80, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0xE0,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0xBF,
  0xF0, 0x03, 0xF0, 0x3B, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0x00,
  0x3F, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0x00, 0x0F, 0xFC, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x3F, 0xF0,
  0x0F, 0x80, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x1F,
  0xF8, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0x00,
  0x0F, 0xFC, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x3F, 0xF0, 0x0F,
  0x80, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x3F, 0xF8,
  0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xEF,
  0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0x3E, 0xF8, 0x00, 0x7F,
  0xC7, 0xDF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7C, 0x00, 0x7F,
  0xC3, 0xE0, 0x00, 0x7F, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x7F, 0x83, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0xFE,
  0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE,
  0x00, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xF0, 0x03, 0xFE, 0x3E, 0x00, 0x1F, 0xE7, 0xC0, 0x00,
  0xFE, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0x7C,
  0x00, 0x1F, 0xCF, 0x80, 0x0F, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x3F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF8, 0x0F, 0x80, 0x03,
  0xF0, 0x1F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F,
  0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF7, 0x80, 0x03, 0xDF, 0xDE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0xF0, 0x01, 0xEF, 0xFB, 0xC0, 0x0F, 0xBF, 0xEF, 0x80, 0x3E,
  0xFF, 0x9E, 0x00, 0xF3, 0xFE, 0x78, 0x03, 0xCF, 0xF9, 0xF0, 0x1F, 0x3F,
  0xE3, 0xC0, 0x78, 0xFF, 0x8F, 0x01, 0xE3, 0xFE, 0x3E, 0x0F, 0x8F, 0xF8,
  0x78, 0x3C, 0x3F, 0xE1, 0xE0, 0xF1, 0xFF, 0x87, 0xC7, 0xC7, 0xFE, 0x0F,
  0x1E, 0x1F, 0xF8, 0x3C, 0x78, 0x7F, 0xF0, 0xFB, 0xE1, 0xFF, 0xC1, 0xEF,
  0x07, 0xFF, 0x07, 0xBC, 0x1F, 0xFC, 0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0x81,
  0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xBC, 0x00, 0x1F, 0xFB,
  0xE0, 0x01, 0xFF, 0xBE, 0x00, 0x1F, 0xF9, 0xE0, 0x01, 0xFF, 0x9F, 0x00,
  0x1F, 0xF9, 0xF0, 0x01, 0xFF, 0xCF, 0x80, 0x1F, 0xFC, 0xF8, 0x01, 0xFF,
  0xCF, 0x80, 0x1F, 0xFC, 0x7C, 0x01, 0xFF, 0xC7, 0xC0, 0x1F, 0xFC, 0x3C,
  0x01, 0xFF, 0xC3, 0xE0, 0x1F, 0xFC, 0x3E, 0x01, 0xFF, 0xC1, 0xE0, 0x1F,
  0xFC, 0x1F, 0x01, 0xFF, 0xC1, 0xF0, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0,
  0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0x7C, 0x1F, 0xFC, 0x07, 0xC1,
  0xFF, 0xC0, 0x3C, 0x1F, 0xFC, 0x03, 0xE1, 0xFF, 0xC0, 0x3E, 0x1F, 0xFC,
  0x01, 0xE1, 0xFF, 0xC0, 0x1F, 0x1F, 0xFC, 0x01, 0xF1, 0xFF, 0xC0, 0x0F,
  0x9F, 0xFC, 0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0x9F, 0xFC, 0x00, 0x7D, 0xFF,
  0xC0, 0x07, 0xDF, 0xFC, 0x00, 0x3D, 0xFF, 0xC0, 0x03, 0xEF, 0xFC, 0x00,
  0x3E, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E,
  0x3F, 0x80, 0x0F, 0xE1, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0xFF, 0x8F,
  0x80, 0x00, 0xFF, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xEF,
  0x80, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x01, 0xFF,
  0x0F, 0x80, 0x00, 0xFE, 0x3E, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F,
  0xCF, 0x80, 0x01, 0xFE, 0x3E, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F,
  0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF8, 0xF8,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFE, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F,
  0xC3, 0xFC, 0x00, 0x7F, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC1, 0xFF, 0x07, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0,
  0x03, 0xF8, 0x01, 0xEF, 0xC0, 0x1F, 0xC0, 0x1F, 0x3E, 0x00, 0xEE, 0x00,
  0xF9, 0xF0, 0x07, 0x70, 0x07, 0xCF, 0x80, 0x3B, 0x80, 0x3E, 0x7C, 0x01,
  0xDC, 0x01, 0xF3, 0xE0, 0x1E, 0xF0, 0x0F, 0x9F, 0x00, 0xF7, 0x80, 0x7C,
  0xF8, 0x07, 0xBC, 0x03, 0xE7, 0xC0, 0x3D, 0xE0, 0x1E, 0x1F, 0x01, 0xC7,
  0x01, 0xF0, 0xF8, 0x0E, 0x38, 0x0F, 0x87, 0xC0, 0x71, 0xC0, 0x7C, 0x3E,
  0x03, 0x8E, 0x03, 0xE1, 0xF0, 0x3C, 0x78, 0x1F, 0x0F, 0x81, 0xE3, 0xC0,
  0xF8, 0x7C, 0x0F, 0x1E, 0x07, 0xC3, 0xE0, 0x78, 0xF0, 0x3C, 0x1F, 0x03,
  0x83, 0x81, 0xE0, 0x78, 0x1C, 0x1C, 0x1F, 0x03, 0xE0, 0xE0, 0xE0, 0xF8,
  0x1F, 0x07, 0x07, 0x07, 0xC0, 0xF8, 0x78, 0x38, 0x3E, 0x07, 0xC3, 0xC1,
  0xE1, 0xF0, 0x3E, 0x1E, 0x0F, 0x0F, 0x81, 0xF0, 0xE0, 0x78, 0x78, 0x0F,
  0x87, 0x01, 0xC3, 0xC0, 0x3C, 0x38, 0x0E, 0x1E, 0x01, 0xE1, 0xC0, 0x70,
  0xF0, 0x0F, 0x8E, 0x03, 0x8F, 0x80, 0x7C, 0xF0, 0x1C, 0x7C, 0x03, 0xE7,
  0x80, 0xF3, 0xE0, 0x1F, 0x3C, 0x07, 0x9F, 0x00, 0xF9, 0xC0, 0x3C, 0xF8,
  0x07, 0xCE, 0x01, 0xE7, 0x80, 0x3E, 0x70, 0x07, 0x3C, 0x00, 0xF3, 0x80,
  0x39, 0xE0, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0x3F, 0xE0, 0x0E, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7E, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x7F, 0x3F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xBF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0xF7, 0xCF,
  0xFF, 0xFF, 0xBE, 0x3F, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0x8F, 0x81, 0xFF,
  0xF0, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x1F, 0xE0, 0x0F, 0x87, 0xFF, 0xC0, 0xF8, 0xFF, 0xFE, 0x0F, 0x9F,
  0xFF, 0xF0, 0xFB, 0xFF, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xBC, 0x07, 0xF8, 0xFB,
  0xFF, 0xFF, 0x8F, 0x9F, 0xFF, 0xF0, 0xF8, 0xFF, 0xFE, 0x0F, 0x83, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x81,
  0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0x9F, 0x1F,
  0xFF, 0xFD, 0xF3, 0xFC, 0x03, 0xDF, 0x3F, 0x00, 0x0F, 0xF7, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xF3, 0xFE, 0x07, 0xDF, 0x1F, 0xFF, 0xFD, 0xF0,
  0xFF, 0xFF, 0x9F, 0x07, 0xFF, 0xF1, 0xF0, 0x1F, 0xFC, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xBE,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x80,
  0x07, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFE, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF,
  0xFD, 0xF3, 0xFC, 0x03, 0xDF, 0x3F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x3F, 0x00,
  0x0F, 0xF3, 0xF8, 0x01, 0xDF, 0x1F, 0xF0, 0x7D, 0xF1, 0xFF, 0xFF, 0x9F,
  0x0F, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0x1F, 0x01, 0xFF, 0xC1, 0xF0, 0x00,
  0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x01, 0xF0,
  0xFF, 0xF8, 0x3E, 0x3F, 0xFF, 0x87, 0xCF, 0xFF, 0xF8, 0xFB, 0xFB, 0xFF,
  0x9F, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x3F, 0x8F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F,
  0x83, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x80,
  0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x3E,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x1F,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xFC,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0xC0,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x01, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE1, 0xE3, 0xFC, 0x3F,
  0xE3, 0xCF, 0xFC, 0x7F, 0xE7, 0xBF, 0xFD, 0xFF, 0xEF, 0x61, 0xFB, 0x0F,
  0xDF, 0x81, 0xFC, 0x0F, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF,
  0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0,
  0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80,
  0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F,
  0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8,
  0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01,
  0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0xE0,
  0x1F, 0x0F, 0xFF, 0x83, 0xE3, 0xFF, 0xF8, 0x7C, 0xFF, 0xFF, 0x8F, 0xBF,
  0xFF, 0xF9, 0xF7, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0x87, 0xFF, 0xC0, 0xF8,
  0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF0, 0xFB, 0xFF, 0xFF, 0x8F, 0xFC, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x1F, 0xCF,
  0xBE, 0x07, 0xF8, 0xFB, 0xFF, 0xFF, 0x8F, 0x9F, 0xFF, 0xF0, 0xF8, 0xFF,
  0xFC, 0x0F, 0x83, 0xFF, 0x80, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF,
  0x9F, 0x1F, 0xFF, 0xFD, 0xF3, 0xFC, 0x03, 0xDF, 0x3F, 0x80, 0x0F, 0xF7,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xF1, 0xFE, 0x07, 0xDF, 0x1F, 0xFF,
  0xFD, 0xF0, 0xFF, 0xFF, 0x9F, 0x07, 0xFF, 0xF1, 0xF0, 0x1F, 0xFC, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0x87, 0xFF,
  0xC0, 0xF8, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF0, 0xFB, 0xFF, 0xFF, 0x8F,
  0xBC, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3,
  0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x0F, 0xFC, 0x01,
  0xFC, 0x01, 0xEF, 0x80, 0x3F, 0x80, 0x3C, 0xF0, 0x07, 0x70, 0x07, 0x9F,
  0x00, 0xEE, 0x01, 0xF3, 0xE0, 0x3D, 0xC0, 0x3E, 0x7C, 0x07, 0xBC, 0x07,
  0xCF, 0x80, 0xE7, 0x80, 0xF1, 0xF0, 0x1C, 0xF0, 0x1E, 0x1E, 0x03, 0x8E,
  0x03, 0xC3, 0xC0, 0x71, 0xC0, 0x78, 0x7C, 0x1E, 0x38, 0x1F, 0x0F, 0x83,
  0xC7, 0x83, 0xE1, 0xF0, 0x78, 0xF0, 0x78, 0x3E, 0x0E, 0x1E, 0x0F, 0x03,
  0xC1, 0xC1, 0xC1, 0xE0, 0x78, 0x38, 0x38, 0x3C, 0x0F, 0x0F, 0x07, 0x0F,
  0x81, 0xF1, 0xE0, 0xF1, 0xF0, 0x3E, 0x38, 0x1E, 0x3C, 0x07, 0xC7, 0x03,
  0xC7, 0x80, 0x78, 0xE0, 0x38, 0xF0, 0x0F, 0x1C, 0x07, 0x1E, 0x01, 0xE7,
  0x80, 0xE3, 0xC0, 0x3C, 0xF0, 0x1E, 0xF8, 0x07, 0xDC, 0x03, 0xDE, 0x00,
  0xFB, 0x80, 0x7B, 0xC0, 0x1F, 0x70, 0x07, 0x78, 0x01, 0xEE, 0x00, 0xEF,
  0x00, 0x3F, 0xC0, 0x1D, 0xE0, 0x07, 0xF8, 0x03, 0xBC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF8,
  0x7C, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x3F, 0xF0, 0x00, 0x7C, 0xFF,
  0xF0, 0x00, 0xFB, 0xFF, 0xF8, 0x01, 0xF7, 0xFF, 0xF0, 0x03, 0xFF, 0x83,
  0xF0, 0x07, 0xFE, 0x03, 0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0x1F, 0xF8, 0x03,
  0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0xFB, 0xE0, 0x07, 0xFF, 0xF7, 0xC0, 0x07,
  0xFF, 0xCF, 0x80, 0x03, 0xFF, 0x1F, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_Light68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 9, 50, 41, 16, -50 },
  { 58, 19, 21, 41, 11, -50 },
  { 108, 36, 50, 41, 2, -50 },
  { 333, 31, 69, 41, 5, -59 },
  { 601, 39, 50, 41, 1, -50 },
  { 845, 34, 51, 41, 4, -50 },
  { 1062, 6, 21, 41, 17, -50 },
  { 1078, 20, 65, 41, 13, -57 },
  { 1241, 20, 65, 41, 8, -57 },
  { 1404, 35, 34, 41, 3, -41 },
  { 1553, 31, 31, 41, 5, -38 },
  { 1674, 13, 21, 41, 12, -10 },
  { 1709, 21, 5, 41, 10, -25 },
  { 1723, 11, 11, 41, 15, -10 },
  { 1739, 30, 63, 41, 5, -56 },
  { 1976, 29, 51, 41, 6, -50 },
  { 2161, 31, 50, 41, 6, -50 },
  { 2355, 31, 50, 41, 5, -50 },
  { 2549, 29, 51, 41, 5, -50 },
  { 2734, 28, 50, 41, 6, -50 },
  { 2909, 29, 51, 41, 6, -50 },
  { 3094, 31, 51, 41, 5, -50 },
  { 3292, 30, 50, 41, 6, -50 },
  { 3480, 29, 51, 41, 6, -50 },
  { 3665, 31, 50, 41, 5, -50 },
  { 3859, 11, 39, 41, 15, -38 },
  { 3913, 14, 49, 41, 12, -38 },
  { 3999, 29, 35, 41, 6, -40 },
  { 4126, 29, 21, 41, 6, -33 },
  { 4203, 29, 35, 41, 6, -40 },
  { 4330, 24, 50, 41, 10, -50 },
  { 4480, 35, 62, 41, 3, -50 },
  { 4752, 33, 50, 41, 4, -50 },
  { 4959, 29, 50, 41, 7, -50 },
  { 5141, 29, 51, 41, 6, -50 },
  { 5326, 27, 50, 41, 7, -50 },
  { 5495, 28, 50, 41, 7, -50 },
  { 5670, 29, 50, 41, 7, -50 },
  { 5852, 29, 51, 41, 6, -50 },
  { 6037, 27, 50, 41, 7, -50 },
  { 6206, 26, 50, 41, 7, -50 },
  { 6369, 29, 51, 41, 4, -50 },
  { 6554, 31, 50, 41, 7, -50 },
  { 6748, 28, 50, 41, 8, -50 },
  { 6923, 30, 50, 41, 5, -50 },
  { 7111, 28, 50, 41, 6, -50 },
  { 7286, 28, 51, 41, 6, -50 },
  { 7465, 30, 50, 41, 7, -50 },
  { 7653, 30, 62, 41, 6, -50 },
  { 7886, 30, 50, 41, 7, -50 },
  { 8074, 31, 51, 41, 5, -50 },
  { 8272, 33, 50, 41, 4, -50 },
  { 8479, 28, 51, 41, 6, -50 },
  { 8658, 33, 50, 41, 4, -50 },
  { 8865, 37, 50, 41, 2, -50 },
  { 9097, 35, 50, 41, 3, -50 },
  { 9316, 35, 50, 41, 3, -50 },
  { 9535, 29, 50, 41, 6, -50 },
  { 9717, 17, 63, 41, 14, -56 },
  { 9851, 30, 63, 41, 5, -56 },
  { 10088, 17, 63, 41, 10, -56 },
  { 10222, 29, 27, 41, 6, -50 },
  { 10320, 33, 4, 41, 4, 2 },
  { 10337, 13, 9, 41, 13, -53 },
  { 10352, 29, 39, 41, 5, -38 },
  { 10494, 28, 51, 41, 7, -50 },
  { 10673, 29, 39, 41, 6, -38 },
  { 10815, 28, 51, 41, 6, -50 },
  { 10994, 29, 39, 41, 6, -38 },
  { 11136, 32, 50, 41, 4, -50 },
  { 11336, 28, 50, 41, 6, -38 },
  { 11511, 27, 50, 41, 7, -50 },
  { 11680, 31, 53, 41, 6, -53 },
  { 11886, 25, 65, 41, 6, -53 },
  { 12090, 30, 50, 41, 7, -50 },
  { 12278, 35, 50, 41, 2, -50 },
  { 12497, 31, 38, 41, 5, -38 },
  { 12645, 27, 38, 41, 7, -38 },
  { 12774, 29, 39, 41, 6, -38 },
  { 12916, 28, 50, 41, 7, -38 },
  { 13091, 28, 50, 41, 6, -38 },
  { 13266, 28, 38, 41, 8, -38 },
  { 13399, 29, 39, 41, 6, -38 },
  { 13541, 31, 48, 41, 4, -48 },
  { 13727, 28, 38, 41, 6, -37 },
  { 13860, 33, 37, 41, 4, -37 },
  { 14013, 35, 37, 41, 3, -37 },
  { 14175, 33, 37, 41, 4, -37 },
  { 14328, 33, 49, 41, 4, -37 },
  { 14531, 28, 37, 41, 6, -37 },
  { 14661, 29, 63, 41, 6, -56 },
  { 14890, 5, 63, 41, 18, -56 },
  { 14930, 29, 63, 41, 6, -56 },
  { 15159, 31, 14, 41, 5, -31 },
};

const GFXfont JetBrainsMono_Light68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_LIGHT68PT7B_H_
