#ifndef _JETBRAINSMONO_LIGHT50PT7B_H_
#define _JETBRAINSMONO_LIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light50pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x30, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0xFD, 0xFB, 0xFF, 0xEF, 0xC0, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xE0,
  0x03, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x01,
  0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1C,
  0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1E,
  0x00, 0x38, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x38, 0x03, 0x80, 0x0E, 0x01, 0xE0,
  0x03, 0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0x8E, 0x7C,
  0x3C, 0x38, 0xF9, 0xE0, 0xE1, 0xE7, 0x83, 0x87, 0xDE, 0x0E, 0x0F, 0x78,
  0x38, 0x3D, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1F, 0x0E, 0x00, 0x7C, 0x38,
  0x00, 0xF8, 0xE0, 0x03, 0xFB, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3B, 0xF0, 0x00,
  0xE3, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0,
  0xF0, 0x03, 0x83, 0xFC, 0x0E, 0x0F, 0xF0, 0x38, 0x3F, 0xC0, 0xE0, 0xF7,
  0x83, 0x87, 0xDF, 0x0E, 0x3E, 0x3F, 0x3B, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x71, 0xFE, 0x00, 0x0F, 0x7F, 0xF0, 0x00, 0xE7, 0x8F,
  0x80, 0x1C, 0xF0, 0x38, 0x03, 0x8F, 0x03, 0x80, 0x78, 0xE0, 0x3C, 0x07,
  0x0E, 0x03, 0xC0, 0xE0, 0xE0, 0x3C, 0x1E, 0x0E, 0x03, 0xC1, 0xC0, 0xE0,
  0x3C, 0x38, 0x0E, 0x03, 0xC7, 0x80, 0xF0, 0x38, 0x70, 0x07, 0x87, 0x8E,
  0x00, 0x7F, 0xF1, 0xE0, 0x03, 0xFE, 0x1C, 0x00, 0x0F, 0xC3, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x04, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x38, 0xFF, 0xC0, 0x07, 0x1F, 0xFE,
  0x00, 0xF1, 0xE0, 0xF0, 0x0E, 0x1C, 0x0F, 0x01, 0xC3, 0xC0, 0x70, 0x3C,
  0x3C, 0x07, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x3C, 0x07, 0x0F, 0x03, 0xC0,
  0x70, 0xE0, 0x3C, 0x07, 0x1C, 0x01, 0xC0, 0xF3, 0xC0, 0x1E, 0x1E, 0x38,
  0x01, 0xFF, 0xE7, 0x00, 0x0F, 0xFC, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xF0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x1E, 0x01,
  0xFF, 0x07, 0x80, 0xF7, 0x83, 0xE0, 0xFB, 0xC0, 0xF8, 0x79, 0xE0, 0x3C,
  0x78, 0xF0, 0x0F, 0x3C, 0x78, 0x07, 0xFC, 0x3C, 0x01, 0xFE, 0x1E, 0x00,
  0x7E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0xC1, 0xE0,
  0x07, 0xF0, 0xF8, 0x0F, 0xBC, 0x3E, 0x0F, 0x9F, 0x1F, 0xFF, 0x87, 0x87,
  0xFF, 0x81, 0xE0, 0xFF, 0x80, 0x78, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0x80, 0x3C, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x1E, 0x01, 0x9F, 0x07,
  0x83, 0xEF, 0xF0, 0xC3, 0xFF, 0xFF, 0x33, 0xFF, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x3C, 0x00, 0x80, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x10, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x78,
  0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xF0, 0x78, 0x3F,
  0xC0, 0x40, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xF7, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xBC,
  0x01, 0xF8, 0xF0, 0x0F, 0xC3, 0xC0, 0x3E, 0x0F, 0x00, 0xE0, 0x3C, 0x03,
  0x00, 0xF0, 0x08, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xEF, 0x80, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x7C,
  0x01, 0xF1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE1, 0xFC, 0x07, 0x9F, 0xFC, 0x1E, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x1E,
  0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0x3C, 0x01, 0xF0,
  0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x80, 0x07, 0xBF, 0xE0, 0x3D, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0x1F, 0x00, 0x3E, 0xF8, 0x00, 0x7B,
  0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xFC, 0x0F, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3E, 0x01, 0xF0,
  0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC1, 0xF0, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0x83, 0xC0,
  0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xDE,
  0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7,
  0x80, 0x07, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x8F,
  0xE1, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x0F, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C,
  0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0x80, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xFC, 0x01, 0xFC,
  0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xF7, 0xF0, 0x1E, 0x07, 0xFC, 0x0F,
  0x00, 0xFF, 0x03, 0xC0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x3C, 0x03, 0xFC,
  0x0F, 0x00, 0xFF, 0x03, 0xC0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x3C, 0x03,
  0xFC, 0x0F, 0x00, 0xFF, 0x03, 0xC0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x3C,
  0x03, 0xFC, 0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x7F, 0xC0, 0x7F, 0xF7, 0x70,
  0x0F, 0xF9, 0xDC, 0x01, 0xFC, 0x77, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x80, 0x01, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x01, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00,
  0x7E, 0x78, 0x01, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xFB, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1E,
  0xF0, 0x03, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xC0, 0x3E, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xDF,
  0x00, 0x1E, 0x7C, 0x01, 0xF3, 0xF0, 0x3F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x0F, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3E, 0xF0, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xC0, 0x3E, 0x3C, 0x00, 0xFB, 0xE0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0x7C, 0x01, 0xF3, 0xF0, 0x3F,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBE, 0x00, 0x3E, 0x7C, 0x01, 0xF0,
  0xFC, 0x1F, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7, 0x80,
  0x07, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x01,
  0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x7C,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x1F, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF0, 0x00,
  0xF9, 0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xB8, 0x07, 0x7E, 0xE0, 0x1D, 0xFB, 0xC0,
  0xF7, 0xE7, 0x03, 0x9F, 0x9C, 0x0E, 0x7E, 0x78, 0x79, 0xFC, 0xE1, 0xC7,
  0xF3, 0x87, 0x3F, 0xCF, 0x3C, 0xFF, 0x1C, 0xE3, 0xFC, 0x73, 0x8F, 0xF1,
  0xEE, 0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xF0, 0x78,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xEE, 0x00, 0xFE, 0xF0, 0x0F, 0xEF, 0x00, 0xFE, 0x70, 0x0F, 0xE7, 0x80,
  0xFF, 0x38, 0x0F, 0xF3, 0x80, 0xFF, 0x3C, 0x0F, 0xF1, 0xC0, 0xFF, 0x1E,
  0x0F, 0xF1, 0xE0, 0xFF, 0x0E, 0x0F, 0xF0, 0xF0, 0xFF, 0x07, 0x0F, 0xF0,
  0x70, 0xFF, 0x07, 0x8F, 0xF0, 0x38, 0xFF, 0x03, 0xCF, 0xF0, 0x3C, 0xFF,
  0x01, 0xCF, 0xF0, 0x1E, 0xFF, 0x01, 0xE7, 0xF0, 0x0E, 0x7F, 0x00, 0xF7,
  0xF0, 0x07, 0x7F, 0x00, 0x77, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x03, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x0F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3E, 0x01,
  0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x07, 0xF3, 0xC0, 0x07, 0xCF, 0x00,
  0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC,
  0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x3F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7C,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3E,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0xFC, 0x0F, 0xC3, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xE0,
  0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xE7, 0x80, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x00,
  0xE7, 0x80, 0xF8, 0x0E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x78,
  0x1F, 0x81, 0xE7, 0x81, 0xD8, 0x1E, 0x78, 0x1D, 0x81, 0xE3, 0x81, 0x98,
  0x1C, 0x38, 0x19, 0x81, 0xC3, 0x81, 0x9C, 0x1C, 0x3C, 0x39, 0xC1, 0xC3,
  0xC3, 0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x8C, 0x3C, 0x3C, 0x30,
  0xC3, 0xC3, 0xC3, 0x0C, 0x3C, 0x1C, 0x30, 0xC3, 0x81, 0xC3, 0x0E, 0x38,
  0x1C, 0x70, 0xE3, 0x81, 0xE7, 0x0E, 0x38, 0x1E, 0x70, 0xE3, 0x81, 0xE7,
  0x0E, 0x78, 0x1E, 0x60, 0x67, 0x81, 0xE6, 0x06, 0x78, 0x0E, 0x60, 0x67,
  0x00, 0xEE, 0x07, 0x70, 0x0E, 0xE0, 0x77, 0x00, 0xEE, 0x07, 0x70, 0x0E,
  0xE0, 0x77, 0x00, 0xFE, 0x07, 0x70, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x78, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF8, 0x00,
  0x7C, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x38,
  0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x70, 0x38, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x07, 0x81, 0xC0,
  0x0E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0xBC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xC0, 0x0F, 0x7C, 0x00, 0x3D, 0xE0,
  0x00, 0xF7, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0xF7, 0x80, 0x07, 0xDF, 0x00, 0x3F, 0x3E, 0x01, 0xFC, 0xFF, 0xFE, 0xF1,
  0xFF, 0xF3, 0xC1, 0xFF, 0x8F, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0xF0, 0x3C, 0xFF,
  0xE1, 0xEF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x01, 0xF3, 0xE0, 0x07, 0xDF,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x3E, 0xFC, 0x01, 0xE7, 0xF0,
  0x3F, 0x3D, 0xFF, 0xF1, 0xE7, 0xFF, 0x0F, 0x1F, 0xF0, 0x00, 0x08, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3E,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xE0, 0x01,
  0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x3E, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0xC3, 0xC3, 0xFF,
  0x9E, 0x3F, 0xFE, 0xF3, 0xFF, 0xFF, 0x9F, 0x00, 0xFD, 0xF0, 0x03, 0xEF,
  0x00, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xF9, 0xF8,
  0x1F, 0xC7, 0xFF, 0xDE, 0x1F, 0xFC, 0xF0, 0x7F, 0xC7, 0x80, 0x20, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xF3, 0xF8, 0x3E,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3E, 0x3F, 0x01, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xF0, 0xF1, 0xFF, 0xCF, 0x3F, 0xFE, 0xF7, 0xFF, 0xFF, 0x7C, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3F, 0x7F, 0x1F, 0xF3, 0xFF, 0xEF, 0x1F,
  0xFC, 0xF0, 0x7F, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0xC0, 0xF3, 0xFF, 0x8F,
  0x7F, 0xFC, 0xFF, 0x9F, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3E,
  0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xE0, 0x7C, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xE7, 0x80, 0x03, 0xEF, 0x00, 0x03, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0xF1, 0xE0, 0xF0, 0xF7, 0xF1, 0xFC, 0xF7, 0xFB, 0xFC,
  0xFC, 0x7A, 0x3E, 0xF8, 0x3C, 0x1E, 0xF0, 0x3C, 0x0E, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0xFC, 0x0F, 0x3F, 0xF8, 0xF7, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x3F, 0x03, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xF0, 0xFE, 0x07, 0x9F, 0xFC, 0x3D,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xC0, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x03,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x80, 0x3C, 0xFE, 0x07, 0xE7,
  0xBF, 0xFE, 0x3C, 0xFF, 0xE1, 0xE3, 0xFE, 0x0F, 0x01, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xF1, 0xFF,
  0xCF, 0x3F, 0xFE, 0xF7, 0xFF, 0xFF, 0x7C, 0x03, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF3, 0xFF,
  0xEF, 0x1F, 0xFC, 0xF0, 0xFF, 0x8F, 0x00, 0x80, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0xFC, 0x07, 0x9F, 0xF8, 0x3D, 0xFF,
  0xF1, 0xFF, 0x3F, 0xCF, 0xC0, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0x7C, 0x00, 0x7B, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1E, 0x7C, 0x03,
  0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7,
  0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80,
  0x00, 0xF7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xF0, 0x1E, 0x01, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0,
  0x3F, 0xC0, 0x78, 0x0F, 0x70, 0x3F, 0x03, 0x9C, 0x0F, 0xC0, 0xE7, 0x03,
  0xF0, 0x39, 0xE0, 0xCC, 0x0E, 0x78, 0x33, 0x07, 0x9E, 0x0C, 0xC1, 0xE3,
  0x87, 0x38, 0x70, 0xE1, 0xCE, 0x1C, 0x38, 0x73, 0x87, 0x0E, 0x18, 0x61,
  0xC3, 0xC6, 0x18, 0x70, 0xF1, 0x86, 0x3C, 0x1C, 0xE1, 0xCE, 0x07, 0x38,
  0x73, 0x81, 0xCE, 0x1C, 0xE0, 0x73, 0x03, 0x38, 0x1C, 0xC0, 0xCE, 0x07,
  0xB0, 0x37, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00,
  0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xC3,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x81,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x81,
  0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE3,
  0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0x3F, 0xF0, 0x0F, 0x7F, 0xF8, 0x0F, 0x78,
  0x7C, 0x0E, 0x70, 0x3C, 0x0E, 0xF0, 0x1F, 0x1E, 0xF0, 0x0F, 0xFE, 0xF0,
  0x0F, 0xFC, 0xF0, 0x03, 0xF8,
};

const GFXglyph JetBrainsMono_Light50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 7, 37, 30, 12, -37 },
  { 34, 14, 16, 30, 8, -37 },
  { 62, 26, 37, 30, 2, -37 },
  { 183, 22, 51, 30, 4, -44 },
  { 324, 28, 37, 30, 1, -37 },
  { 454, 25, 38, 30, 3, -37 },
  { 573, 4, 16, 30, 13, -37 },
  { 581, 15, 48, 30, 9, -42 },
  { 671, 15, 48, 30, 6, -42 },
  { 761, 26, 26, 30, 2, -31 },
  { 846, 24, 23, 30, 3, -28 },
  { 915, 10, 16, 30, 9, -8 },
  { 935, 16, 3, 30, 7, -18 },
  { 941, 8, 9, 30, 11, -8 },
  { 950, 22, 48, 30, 4, -42 },
  { 1082, 22, 38, 30, 4, -37 },
  { 1187, 22, 37, 30, 5, -37 },
  { 1289, 22, 37, 30, 4, -37 },
  { 1391, 21, 38, 30, 4, -37 },
  { 1491, 21, 37, 30, 4, -37 },
  { 1589, 22, 38, 30, 4, -37 },
  { 1694, 22, 38, 30, 4, -37 },
  { 1799, 23, 37, 30, 4, -37 },
  { 1906, 22, 38, 30, 4, -37 },
  { 2011, 22, 37, 30, 4, -37 },
  { 2113, 8, 29, 30, 11, -28 },
  { 2142, 10, 36, 30, 9, -28 },
  { 2187, 22, 27, 30, 4, -30 },
  { 2262, 22, 15, 30, 4, -24 },
  { 2304, 22, 27, 30, 4, -30 },
  { 2379, 18, 37, 30, 7, -37 },
  { 2463, 26, 46, 30, 2, -37 },
  { 2613, 24, 37, 30, 3, -37 },
  { 2724, 21, 37, 30, 5, -37 },
  { 2822, 21, 38, 30, 5, -37 },
  { 2922, 20, 37, 30, 5, -37 },
  { 3015, 21, 37, 30, 5, -37 },
  { 3113, 21, 37, 30, 5, -37 },
  { 3211, 21, 38, 30, 5, -37 },
  { 3311, 20, 37, 30, 5, -37 },
  { 3404, 20, 37, 30, 5, -37 },
  { 3497, 22, 38, 30, 3, -37 },
  { 3602, 23, 37, 30, 5, -37 },
  { 3709, 21, 37, 30, 6, -37 },
  { 3807, 22, 37, 30, 4, -37 },
  { 3909, 20, 37, 30, 5, -37 },
  { 4002, 20, 38, 30, 5, -37 },
  { 4097, 22, 37, 30, 5, -37 },
  { 4199, 22, 46, 30, 4, -37 },
  { 4326, 22, 37, 30, 5, -37 },
  { 4428, 22, 38, 30, 4, -37 },
  { 4533, 24, 37, 30, 3, -37 },
  { 4644, 20, 38, 30, 5, -37 },
  { 4739, 24, 37, 30, 3, -37 },
  { 4850, 28, 37, 30, 1, -37 },
  { 4980, 26, 37, 30, 2, -37 },
  { 5101, 26, 37, 30, 2, -37 },
  { 5222, 22, 37, 30, 4, -37 },
  { 5324, 12, 48, 30, 10, -42 },
  { 5396, 22, 48, 30, 4, -42 },
  { 5528, 12, 48, 30, 8, -42 },
  { 5600, 22, 20, 30, 4, -37 },
  { 5655, 24, 4, 30, 3, 1 },
  { 5667, 10, 7, 30, 9, -39 },
  { 5676, 22, 29, 30, 3, -28 },
  { 5756, 21, 38, 30, 5, -37 },
  { 5856, 22, 29, 30, 4, -28 },
  { 5936, 21, 38, 30, 4, -37 },
  { 6036, 22, 29, 30, 4, -28 },
  { 6116, 24, 37, 30, 3, -37 },
  { 6227, 20, 37, 30, 5, -28 },
  { 6320, 20, 37, 30, 5, -37 },
  { 6413, 24, 39, 30, 4, -39 },
  { 6530, 19, 48, 30, 4, -39 },
  { 6644, 23, 37, 30, 5, -37 },
  { 6751, 25, 37, 30, 2, -37 },
  { 6867, 24, 28, 30, 3, -28 },
  { 6951, 20, 28, 30, 5, -28 },
  { 7021, 22, 28, 30, 4, -28 },
  { 7098, 21, 37, 30, 5, -28 },
  { 7196, 20, 37, 30, 5, -28 },
  { 7289, 21, 28, 30, 6, -28 },
  { 7363, 21, 28, 30, 5, -28 },
  { 7437, 23, 35, 30, 3, -35 },
  { 7538, 20, 29, 30, 5, -28 },
  { 7611, 24, 28, 30, 3, -28 },
  { 7695, 26, 28, 30, 2, -28 },
  { 7786, 24, 28, 30, 3, -28 },
  { 7870, 24, 37, 30, 3, -28 },
  { 7981, 20, 28, 30, 5, -28 },
  { 8051, 22, 48, 30, 4, -42 },
  { 8183, 4, 48, 30, 13, -42 },
  { 8207, 22, 48, 30, 4, -42 },
  { 8339, 24, 10, 30, 3, -23 },
};

const GFXfont JetBrainsMono_Light50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_LIGHT50PT7B_H_
