#ifndef _JETBRAINSMONO_LIGHT53PT7B_H_
#define _JETBRAINSMONO_LIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light53pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFE, 0x7E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E,
  0x00, 0x38, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0xE0, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80,
  0x3C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x78, 0x03, 0x80,
  0x07, 0x80, 0x78, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1E,
  0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x1C, 0xFC, 0x3E, 0x1C, 0x7C, 0x3C, 0x1C, 0x3E, 0x7C,
  0x1C, 0x1E, 0x78, 0x1C, 0x1E, 0x78, 0x1C, 0x1E, 0x78, 0x1C, 0x00, 0x7C,
  0x1C, 0x00, 0x7C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3E, 0x1C, 0x00, 0x3F,
  0x1C, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1D, 0xFC, 0x00,
  0x1C, 0x7C, 0x00, 0x1C, 0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1F, 0x00,
  0x1C, 0x1F, 0x00, 0x1C, 0x0F, 0xF0, 0x1C, 0x0F, 0xF0, 0x1C, 0x1F, 0xF8,
  0x1C, 0x1F, 0x78, 0x1C, 0x1E, 0x7C, 0x1C, 0x3E, 0x7E, 0x1C, 0x7C, 0x3F,
  0xDD, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x7F, 0xC0, 0x00, 0xE3, 0xFF, 0x80, 0x07, 0x1F, 0x1F, 0x00, 0x3C, 0xF0,
  0x3C, 0x00, 0xE3, 0xC0, 0x70, 0x07, 0x0F, 0x01, 0xC0, 0x3C, 0x3C, 0x07,
  0x01, 0xE0, 0xF0, 0x1C, 0x07, 0x03, 0xC0, 0x70, 0x3C, 0x0F, 0x01, 0xC1,
  0xE0, 0x3C, 0x07, 0x07, 0x00, 0xF0, 0x1C, 0x3C, 0x01, 0xC0, 0xF1, 0xE0,
  0x07, 0xEF, 0xC7, 0x00, 0x0F, 0xFE, 0x3C, 0x00, 0x1F, 0xF1, 0xE0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE3, 0xFE, 0x00, 0x0F,
  0x1F, 0xFC, 0x00, 0x38, 0xFF, 0xF8, 0x01, 0xE3, 0xC1, 0xE0, 0x0F, 0x0E,
  0x03, 0x80, 0x38, 0x78, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x0F, 0x07, 0x80,
  0xF0, 0x38, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x3C,
  0x38, 0x07, 0x80, 0xF1, 0xC0, 0x0E, 0x03, 0x8F, 0x00, 0x3C, 0x1E, 0x38,
  0x00, 0x7F, 0xF9, 0xC0, 0x01, 0xFF, 0xCF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xF8,
  0x01, 0xF0, 0x1F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xF0,
  0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x17, 0xC7, 0x80, 0x3D, 0xF0, 0xF8,
  0x0F, 0xBE, 0x0F, 0x81, 0xE7, 0x80, 0xF8, 0x7C, 0xF0, 0x0F, 0x0F, 0x1E,
  0x01, 0xF3, 0xC3, 0xC0, 0x1F, 0x78, 0x78, 0x01, 0xFE, 0x0F, 0x00, 0x1F,
  0xC1, 0xE0, 0x03, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0,
  0x01, 0xFC, 0x1F, 0x00, 0x7F, 0xC1, 0xF0, 0x1F, 0x7C, 0x3F, 0x8F, 0xC7,
  0x83, 0xFF, 0xF0, 0xF8, 0x3F, 0xFC, 0x0F, 0x83, 0xFF, 0x00, 0xF8, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x04, 0x00, 0xF0, 0x02, 0x78, 0x0F, 0x01, 0xE7, 0xF0, 0xF0, 0xFE, 0xFF,
  0x86, 0x3F, 0xF7, 0xFE, 0x67, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1,
  0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F,
  0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x10, 0x1F, 0xF0,
  0x78, 0x3F, 0xE1, 0xF8, 0x7F, 0xC3, 0xF0, 0xFF, 0x87, 0xE1, 0xFF, 0x0F,
  0x83, 0xFE, 0x06, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF8,
  0xF8, 0x03, 0xF0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFD, 0xE0, 0x07, 0xE3, 0xC0, 0x1F, 0x87,
  0x80, 0x7E, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x00, 0x78,
  0x04, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00,
  0xFC, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xE1,
  0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x0F, 0x3E, 0x00, 0x3C,
  0xF8, 0x00, 0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x8F, 0xF8, 0x1E, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF1, 0xFE, 0x3F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x78, 0x00, 0x7D,
  0xE0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xE0, 0x03, 0xE7,
  0xC0, 0x1F, 0x8F, 0xE3, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x1F, 0x00, 0x1E, 0x7F, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x3E, 0x00,
  0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x07,
  0xC7, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0x7E, 0x1F, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x7E,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0xC3, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0x78, 0x03, 0xFC, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0x07, 0x01, 0xF8, 0x7F, 0x8F, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0x81, 0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x7E,
  0x00, 0x7F, 0x9F, 0x80, 0x7F, 0xF7, 0xE0, 0x1F, 0x9D, 0xF8, 0x0F, 0x81,
  0xFE, 0x03, 0xC0, 0x3F, 0x80, 0xF0, 0x0F, 0xE0, 0x3C, 0x01, 0xF8, 0x0F,
  0x00, 0x7E, 0x03, 0xC0, 0x1F, 0x80, 0xF0, 0x07, 0xE0, 0x3C, 0x01, 0xF8,
  0x0F, 0x00, 0x7E, 0x03, 0xC0, 0x1F, 0x80, 0xF0, 0x07, 0xE0, 0x3C, 0x01,
  0xF8, 0x0F, 0x00, 0xFE, 0x03, 0xC0, 0x3F, 0x80, 0xF8, 0x0F, 0xE0, 0x1F,
  0x0F, 0xF8, 0x07, 0xFF, 0x7F, 0x00, 0xFF, 0x9F, 0xC0, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0B, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0xF0,
  0x0F, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF9,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3C, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x8F, 0x00, 0x7F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0,
  0x03, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D,
  0xE0, 0x01, 0xFB, 0xC0, 0x07, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3E, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7D, 0xF0, 0x01, 0xE7, 0xE0, 0x0F, 0x8F, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xF0, 0x07, 0xF3, 0xC0, 0x07,
  0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E,
  0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xCF, 0x00, 0x3F, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3E, 0x01, 0xF9, 0xF0, 0x03,
  0xE7, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xE0, 0x0F, 0x8F, 0xF1, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0xF8,
  0x00, 0xF9, 0xF8, 0x03, 0xE1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07,
  0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x1F,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x07,
  0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xEE, 0x00, 0x77, 0xEE, 0x00, 0x7F, 0xEF, 0x00, 0xFF, 0xF7, 0x00,
  0xEF, 0xF7, 0x00, 0xEF, 0xF7, 0x81, 0xEF, 0xF3, 0x81, 0xCF, 0xF3, 0x81,
  0xCF, 0xF3, 0xC3, 0xCF, 0xF1, 0xC3, 0x8F, 0xF1, 0xC3, 0x8F, 0xF1, 0xE7,
  0x8F, 0xF0, 0xE7, 0x0F, 0xF0, 0xE7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E,
  0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFD, 0xC0, 0x0F, 0xF7,
  0x80, 0x3F, 0xDE, 0x00, 0xFF, 0x38, 0x03, 0xFC, 0xF0, 0x0F, 0xF3, 0xC0,
  0x3F, 0xC7, 0x80, 0xFF, 0x1E, 0x03, 0xFC, 0x38, 0x0F, 0xF0, 0xF0, 0x3F,
  0xC3, 0xC0, 0xFF, 0x07, 0x03, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC0,
  0xE0, 0xFF, 0x03, 0xC3, 0xFC, 0x0F, 0x0F, 0xF0, 0x1E, 0x3F, 0xC0, 0x78,
  0xFF, 0x00, 0xE3, 0xFC, 0x03, 0xCF, 0xF0, 0x0F, 0x3F, 0xC0, 0x1C, 0xFF,
  0x00, 0x7B, 0xFC, 0x01, 0xEF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x7E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xE0,
  0x1F, 0x8F, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x08, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8,
  0x01, 0xF1, 0xF8, 0x07, 0xE1, 0xFC, 0x3F, 0x81, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xF8,
  0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x7C, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xE0,
  0x1F, 0x0F, 0xE3, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x18, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x01,
  0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0F,
  0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x01,
  0xF8, 0x0E, 0xF0, 0x19, 0x81, 0xE7, 0x81, 0x98, 0x1E, 0x78, 0x39, 0xC1,
  0xE7, 0x83, 0x9C, 0x1E, 0x78, 0x39, 0xC1, 0xE7, 0x83, 0x9C, 0x1E, 0x78,
  0x39, 0xC1, 0xE7, 0x83, 0x9C, 0x1C, 0x78, 0x30, 0xC1, 0xC3, 0x83, 0x0C,
  0x1C, 0x38, 0x70, 0xC3, 0xC3, 0xC7, 0x0E, 0x3C, 0x3C, 0x70, 0xE3, 0xC3,
  0xC7, 0x0E, 0x3C, 0x3C, 0x70, 0xE3, 0xC3, 0xC6, 0x0E, 0x3C, 0x3C, 0x60,
  0x63, 0x83, 0xCE, 0x06, 0x38, 0x1C, 0xE0, 0x63, 0x81, 0xCE, 0x07, 0x78,
  0x1E, 0xE0, 0x77, 0x81, 0xEE, 0x07, 0x78, 0x1E, 0xE0, 0x77, 0x81, 0xEC,
  0x07, 0x78, 0x1E, 0xC0, 0x77, 0x01, 0xFC, 0x03, 0x70, 0x0F, 0xC0, 0x37,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x7C,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x79, 0xE0, 0x00,
  0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x1C, 0x0F, 0x00,
  0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3E,
  0x00, 0x1E, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x7F, 0x80, 0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xBD, 0xF8, 0x0F, 0x79, 0xFF, 0xFC, 0xF1,
  0xFF, 0xF1, 0xE1, 0xFF, 0xC3, 0xC0, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xF0,
  0x0F, 0x0F, 0xF8, 0x3C, 0xFF, 0xF8, 0xF7, 0xFF, 0xF3, 0xDC, 0x0F, 0xCF,
  0xE0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0xE0, 0x1F, 0xBD, 0xE1, 0xFC,
  0xF7, 0xFF, 0xE3, 0xCF, 0xFF, 0x0F, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0x03,
  0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x79, 0xF8, 0x03, 0xE3, 0xF8,
  0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x7F, 0xC7, 0xC7, 0xFF, 0xCF, 0x3F, 0xFF,
  0x3D, 0xFC, 0x0E, 0xF7, 0xC0, 0x1B, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xF7, 0xC0,
  0x1F, 0xCF, 0xE1, 0xFF, 0x3F, 0xFF, 0x7C, 0x7F, 0xF9, 0xF0, 0x7F, 0xC7,
  0xC0, 0x18, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00,
  0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x78, 0x00, 0x79,
  0xF0, 0x03, 0xE3, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF1,
  0xF1, 0xFF, 0xF7, 0xCF, 0xFF, 0xDF, 0x3F, 0x03, 0xFD, 0xF0, 0x07, 0xF7,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF7, 0xC0, 0x0B, 0xDF, 0x80,
  0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF0, 0xFF, 0xE7, 0xC0, 0xFE, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xF0,
  0x0F, 0x1F, 0xF8, 0x3C, 0xFF, 0xF8, 0xF7, 0xFF, 0xF3, 0xDC, 0x0F, 0xCF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x3F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0,
  0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0,
  0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x01,
  0x80, 0x70, 0xE7, 0xF1, 0xFC, 0xEF, 0xFB, 0xFE, 0xEF, 0xFB, 0xFE, 0xF8,
  0x7E, 0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x00, 0x3C, 0x03, 0xC7, 0xFE, 0x0F, 0x3F,
  0xFE, 0x3D, 0xFF, 0xFC, 0xF7, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xC0, 0x0F,
  0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF1, 0xF0, 0x07, 0xE7, 0x80, 0x0F, 0xBE,
  0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1E, 0x7C, 0x00,
  0xF9, 0xF8, 0x07, 0xE3, 0xFC, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xC3, 0xFE, 0x0F, 0x3F, 0xFE, 0x3D,
  0xFF, 0xFC, 0xF7, 0x03, 0xF3, 0xF8, 0x03, 0xEF, 0xC0, 0x07, 0xBE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFB,
  0xF8, 0x07, 0xEF, 0x78, 0x7F, 0x3D, 0xFF, 0xF8, 0xF3, 0xFF, 0xC3, 0xC3,
  0xFE, 0x0F, 0x01, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF1, 0xF1, 0xFF,
  0xF7, 0xCF, 0xFF, 0xDF, 0x3F, 0x03, 0xFD, 0xF0, 0x07, 0xF7, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x78,
  0x00, 0xFD, 0xF0, 0x06, 0xF3, 0xF8, 0x7F, 0xCF, 0xFF, 0xDF, 0x1F, 0xFE,
  0x7C, 0x1F, 0xF1, 0xF0, 0x04, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x03, 0xC7, 0xFE,
  0x0F, 0x3F, 0xFE, 0x3D, 0xFF, 0xFC, 0xF7, 0x03, 0xF3, 0xF0, 0x03, 0xEF,
  0xC0, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x01, 0xF9, 0xF0, 0x01, 0xE7, 0x80,
  0x07, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9F,
  0x00, 0x3E, 0x7E, 0x01, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x0E, 0xF0, 0x1F, 0x00, 0xE7, 0x01, 0xF8, 0x0E, 0x78, 0x1F, 0x81, 0xE7,
  0x81, 0xF8, 0x1E, 0x78, 0x1B, 0x81, 0xE7, 0x81, 0x98, 0x1C, 0x78, 0x39,
  0x81, 0xC3, 0x83, 0x9C, 0x1C, 0x38, 0x39, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C,
  0x3C, 0x31, 0xC3, 0xC3, 0xC3, 0x0C, 0x38, 0x3C, 0x70, 0xC3, 0x81, 0xC7,
  0x0E, 0x38, 0x1C, 0x70, 0xE3, 0x81, 0xC7, 0x0E, 0x78, 0x1E, 0x60, 0xE7,
  0x81, 0xE6, 0x06, 0x70, 0x1E, 0xE0, 0x67, 0x00, 0xEE, 0x07, 0x70, 0x0E,
  0xE0, 0x77, 0x00, 0xEE, 0x07, 0x70, 0x0E, 0xC0, 0x7F, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x7C, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0x83, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x7C, 0x00,
  0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x3F, 0xE0, 0x0F, 0x7F, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3F, 0x1F,
  0xF0, 0x1F, 0xFE, 0xF0, 0x0F, 0xFE, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x40,
};

const GFXglyph JetBrainsMono_Light53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 39, 32, 12, -39 },
  { 40, 16, 16, 32, 8, -39 },
  { 72, 28, 39, 32, 2, -39 },
  { 209, 24, 53, 32, 4, -46 },
  { 368, 30, 39, 32, 1, -39 },
  { 515, 27, 40, 32, 3, -39 },
  { 650, 5, 16, 32, 13, -39 },
  { 660, 16, 51, 32, 10, -45 },
  { 762, 16, 51, 32, 6, -45 },
  { 864, 28, 27, 32, 2, -32 },
  { 959, 24, 25, 32, 4, -30 },
  { 1034, 11, 16, 32, 9, -8 },
  { 1056, 17, 3, 32, 7, -19 },
  { 1063, 8, 9, 32, 12, -8 },
  { 1072, 24, 50, 32, 4, -44 },
  { 1222, 23, 40, 32, 4, -39 },
  { 1337, 23, 39, 32, 5, -39 },
  { 1450, 24, 39, 32, 4, -39 },
  { 1567, 23, 40, 32, 4, -39 },
  { 1682, 22, 39, 32, 4, -39 },
  { 1790, 22, 40, 32, 5, -39 },
  { 1900, 24, 40, 32, 4, -39 },
  { 2020, 24, 39, 32, 4, -39 },
  { 2137, 23, 40, 32, 4, -39 },
  { 2252, 24, 39, 32, 4, -39 },
  { 2369, 8, 31, 32, 12, -30 },
  { 2400, 11, 38, 32, 9, -30 },
  { 2453, 22, 27, 32, 5, -31 },
  { 2528, 22, 17, 32, 5, -26 },
  { 2575, 22, 27, 32, 5, -31 },
  { 2650, 18, 39, 32, 8, -39 },
  { 2738, 26, 49, 32, 3, -39 },
  { 2898, 26, 39, 32, 3, -39 },
  { 3025, 23, 39, 32, 5, -39 },
  { 3138, 22, 40, 32, 5, -39 },
  { 3248, 22, 39, 32, 5, -39 },
  { 3356, 21, 39, 32, 6, -39 },
  { 3459, 23, 39, 32, 5, -39 },
  { 3572, 22, 40, 32, 5, -39 },
  { 3682, 22, 39, 32, 5, -39 },
  { 3790, 20, 39, 32, 6, -39 },
  { 3888, 23, 40, 32, 3, -39 },
  { 4003, 24, 39, 32, 5, -39 },
  { 4120, 22, 39, 32, 6, -39 },
  { 4228, 24, 39, 32, 4, -39 },
  { 4345, 22, 39, 32, 5, -39 },
  { 4453, 22, 40, 32, 5, -39 },
  { 4563, 24, 39, 32, 5, -39 },
  { 4680, 23, 49, 32, 5, -39 },
  { 4821, 24, 39, 32, 5, -39 },
  { 4938, 24, 40, 32, 4, -39 },
  { 5058, 26, 39, 32, 3, -39 },
  { 5185, 22, 40, 32, 5, -39 },
  { 5295, 26, 39, 32, 3, -39 },
  { 5422, 28, 39, 32, 2, -39 },
  { 5559, 28, 39, 32, 2, -39 },
  { 5696, 28, 39, 32, 2, -39 },
  { 5833, 22, 39, 32, 5, -39 },
  { 5941, 13, 50, 32, 11, -44 },
  { 6023, 24, 50, 32, 4, -44 },
  { 6173, 13, 50, 32, 8, -44 },
  { 6255, 23, 21, 32, 4, -39 },
  { 6316, 26, 4, 32, 3, 1 },
  { 6329, 10, 8, 32, 10, -42 },
  { 6339, 23, 31, 32, 4, -30 },
  { 6429, 22, 40, 32, 5, -39 },
  { 6539, 22, 31, 32, 5, -30 },
  { 6625, 22, 40, 32, 5, -39 },
  { 6735, 22, 31, 32, 5, -30 },
  { 6821, 25, 39, 32, 3, -39 },
  { 6943, 22, 40, 32, 5, -30 },
  { 7053, 22, 39, 32, 5, -39 },
  { 7161, 24, 41, 32, 5, -41 },
  { 7284, 19, 51, 32, 5, -41 },
  { 7406, 24, 39, 32, 5, -39 },
  { 7523, 27, 39, 32, 2, -39 },
  { 7655, 24, 30, 32, 4, -30 },
  { 7745, 22, 30, 32, 5, -30 },
  { 7828, 22, 30, 32, 5, -30 },
  { 7911, 22, 40, 32, 5, -30 },
  { 8021, 22, 40, 32, 5, -30 },
  { 8131, 22, 30, 32, 6, -30 },
  { 8214, 22, 30, 32, 5, -30 },
  { 8297, 24, 37, 32, 3, -37 },
  { 8408, 22, 30, 32, 5, -29 },
  { 8491, 26, 29, 32, 3, -29 },
  { 8586, 28, 29, 32, 2, -29 },
  { 8688, 26, 29, 32, 3, -29 },
  { 8783, 26, 39, 32, 3, -29 },
  { 8910, 22, 29, 32, 5, -29 },
  { 8990, 22, 50, 32, 5, -44 },
  { 9128, 4, 50, 32, 14, -44 },
  { 9153, 22, 50, 32, 5, -44 },
  { 9291, 24, 11, 32, 4, -24 },
};

const GFXfont JetBrainsMono_Light53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_LIGHT53PT7B_H_
