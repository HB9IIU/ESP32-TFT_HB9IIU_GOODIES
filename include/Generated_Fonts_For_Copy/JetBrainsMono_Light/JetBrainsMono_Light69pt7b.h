#ifndef _JETBRAINSMONO_LIGHT69PT7B_H_
#define _JETBRAINSMONO_LIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x9F, 0xC0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0xF3, 0xFC, 0x0F, 0xE1, 0xE1, 0xFC,
  0x1F, 0x83, 0xC1, 0xF8, 0x7E, 0x07, 0x81, 0xF8, 0xFC, 0x0F, 0x03, 0xF1,
  0xF0, 0x1E, 0x03, 0xE3, 0xE0, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0xCF,
  0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7E,
  0x07, 0x80, 0x00, 0xFC, 0x0F, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x01, 0xFC,
  0x3C, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x03, 0xFE, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x03, 0xC1,
  0xFC, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x1E, 0x03,
  0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x0F,
  0xFE, 0x01, 0xE0, 0x1F, 0xFC, 0x03, 0xC0, 0x3F, 0xF8, 0x07, 0x80, 0xFD,
  0xF0, 0x0F, 0x01, 0xFB, 0xF0, 0x1E, 0x03, 0xF7, 0xF0, 0x3C, 0x0F, 0xC7,
  0xF0, 0x78, 0x3F, 0x8F, 0xF0, 0xF0, 0xFE, 0x0F, 0xFD, 0xEF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7C, 0x7F, 0xFC, 0x00, 0x01, 0xF1, 0xFF, 0xFC, 0x00,
  0x03, 0xC3, 0xFF, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0xF8, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x07,
  0xC0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0x3C,
  0x07, 0x80, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x7C, 0x00,
  0x78, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x1F,
  0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x7C, 0x00,
  0x01, 0xFF, 0xE1, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x7F,
  0xFC, 0x00, 0x03, 0xE1, 0xFF, 0xFC, 0x00, 0x07, 0x87, 0xFB, 0xFC, 0x00,
  0x1F, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x03, 0xE1, 0xE0, 0x00,
  0xF8, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x3F, 0x1F, 0x00, 0x01, 0xFF, 0xFE,
  0x3C, 0x00, 0x03, 0xFF, 0xF8, 0xF8, 0x00, 0x03, 0xFF, 0xE3, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x1F, 0xBF, 0x07, 0xE0, 0x07, 0xEF, 0xC0, 0xFE, 0x00, 0xF9, 0xF8, 0x0F,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0x0F, 0xC7, 0xC0, 0x0F, 0xC1, 0xF8, 0xF8,
  0x01, 0xF8, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0x83, 0xE0, 0x01, 0xFB, 0xF0,
  0x7C, 0x00, 0x1F, 0xFC, 0x0F, 0x80, 0x03, 0xFF, 0x81, 0xF0, 0x00, 0x3F,
  0xE0, 0x3E, 0x00, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x7E,
  0x00, 0x0F, 0xFE, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0xFE, 0x01, 0xFC, 0xFC,
  0x1F, 0xF0, 0xFF, 0x0F, 0xC1, 0xFF, 0xFF, 0xE1, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0x81, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x01, 0xF0,
  0x00, 0xC7, 0xC0, 0x1F, 0x00, 0x7E, 0xFF, 0x80, 0xF0, 0x1F, 0xEF, 0xFE,
  0x0F, 0x0F, 0xFE, 0xFF, 0xF8, 0xE1, 0xFF, 0xF7, 0xFF, 0xCE, 0x7F, 0xFC,
  0x0F, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x7F, 0xC7, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE,
  0x07, 0xF0, 0x3F, 0xF8, 0x1F, 0xE0, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0x81,
  0xFE, 0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0x0C,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x7E, 0x00, 0x07,
  0xF8, 0xFC, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0x80, 0x1F, 0x80, 0x06, 0x00,
  0x3F, 0x00, 0x08, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0x07, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x1F, 0x7E, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x1F, 0x8F, 0xFF, 0x80,
  0xFC, 0xFF, 0xFF, 0x07, 0xEF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0x80, 0x7F, 0x8F, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x1F,
  0xE0, 0x00, 0xFC, 0xFF, 0xF0, 0x01, 0xF7, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xEF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0x80, 0x7F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7E, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0x07, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x7E, 0x00, 0x3F, 0xF9, 0xF8, 0x00, 0x07, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x06, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x7F, 0xC7, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x0F, 0xE3, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x70, 0x01, 0xC0, 0x1F, 0xE0,
  0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8,
  0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xFC,
  0xFF, 0x80, 0x0F, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFB, 0xFE, 0x00, 0x7E,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0x00,
  0x7C, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x0F, 0xFC, 0x01, 0xF0, 0x01, 0xFF,
  0x80, 0x3E, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0x00, 0x1F, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x0F, 0xFC, 0x01, 0xF0, 0x01, 0xFF, 0x80,
  0x3E, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x1F, 0x00, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0x00,
  0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0x0F,
  0xFF, 0x9E, 0xF8, 0x00, 0xFF, 0xE3, 0xDF, 0x00, 0x07, 0xF8, 0x7B, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7C, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF8, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x3F, 0xF1, 0xF0, 0x00, 0x3F, 0xCF,
  0x80, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xBE, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0xEF, 0x80, 0x03,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFF, 0x00, 0x3F,
  0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xF8, 0xF8, 0x00, 0x1F, 0xCF,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFE, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xFC, 0xF8, 0x00, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFF,
  0x00, 0x3F, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFE, 0x01, 0xF0,
  0x00, 0xFC, 0x03, 0xE0, 0x01, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80,
  0x03, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0x7C, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x1F, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x9F, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xBF, 0xFE, 0x00, 0x1E, 0xFF, 0x78, 0x00, 0xFB, 0xFD, 0xF0, 0x03,
  0xCF, 0xF7, 0xC0, 0x0F, 0x3F, 0xCF, 0x00, 0x7C, 0xFF, 0x3E, 0x01, 0xE7,
  0xFC, 0xF8, 0x07, 0x9F, 0xF1, 0xE0, 0x3E, 0x7F, 0xC7, 0xC0, 0xF1, 0xFF,
  0x1F, 0x03, 0xC7, 0xFC, 0x3C, 0x1F, 0x1F, 0xF0, 0xF8, 0x78, 0x7F, 0xE3,
  0xE1, 0xE1, 0xFF, 0x87, 0x8F, 0x87, 0xFE, 0x1F, 0x3C, 0x1F, 0xF8, 0x7C,
  0xF0, 0x7F, 0xE0, 0xF3, 0xC1, 0xFF, 0x83, 0xDE, 0x07, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x01, 0xFF, 0x81, 0xFC, 0x0F,
  0xFE, 0x03, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xF7, 0x80, 0x01, 0xFF, 0x7C, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xBE,
  0x00, 0x1F, 0xFB, 0xE0, 0x01, 0xFF, 0xBE, 0x00, 0x1F, 0xF9, 0xF0, 0x01,
  0xFF, 0x9F, 0x00, 0x1F, 0xF9, 0xF0, 0x01, 0xFF, 0x8F, 0x80, 0x1F, 0xF8,
  0xF8, 0x01, 0xFF, 0x87, 0x80, 0x1F, 0xF8, 0x7C, 0x01, 0xFF, 0x87, 0xC0,
  0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x3E, 0x01, 0xFF,
  0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F,
  0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x07, 0xC1, 0xFF, 0x80, 0x7C, 0x1F,
  0xF8, 0x07, 0xC1, 0xFF, 0x80, 0x3E, 0x1F, 0xF8, 0x03, 0xE1, 0xFF, 0x80,
  0x3E, 0x1F, 0xF8, 0x01, 0xF1, 0xFF, 0x80, 0x1F, 0x1F, 0xF8, 0x00, 0xF1,
  0xFF, 0x80, 0x0F, 0x9F, 0xF8, 0x00, 0xF9, 0xFF, 0x80, 0x07, 0xDF, 0xF8,
  0x00, 0x7D, 0xFF, 0x80, 0x07, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7C,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0x00, 0x01, 0xFE, 0x3E, 0x00, 0x00, 0xFE, 0x7C, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x1F, 0xDF, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x01, 0xFC,
  0x7C, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x3F, 0x81, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE3, 0xE0, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFE, 0x3E,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x3F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFE,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0xC0, 0x0F, 0xBE, 0x00, 0xFF, 0x00, 0x7D, 0xF0, 0x07, 0xF8,
  0x03, 0xEF, 0x80, 0x3B, 0xC0, 0x1E, 0x7C, 0x01, 0xDE, 0x01, 0xF3, 0xE0,
  0x0E, 0x70, 0x0F, 0x9F, 0x00, 0x73, 0x80, 0x7C, 0xF8, 0x07, 0x9C, 0x03,
  0xE3, 0xE0, 0x3C, 0xE0, 0x1F, 0x1F, 0x01, 0xE7, 0x00, 0xF8, 0xF8, 0x0F,
  0x3C, 0x07, 0xC7, 0xC0, 0x71, 0xE0, 0x3E, 0x3E, 0x03, 0x8F, 0x01, 0xE1,
  0xF0, 0x1C, 0x78, 0x1F, 0x0F, 0x81, 0xE1, 0xC0, 0xF8, 0x7C, 0x0F, 0x0E,
  0x07, 0xC3, 0xE0, 0x78, 0x70, 0x3E, 0x0F, 0x83, 0xC3, 0x81, 0xF0, 0x7C,
  0x1C, 0x1E, 0x0F, 0x83, 0xE0, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0x07, 0x83,
  0xC0, 0xF8, 0x38, 0x3C, 0x1E, 0x07, 0xC3, 0xC0, 0xE1, 0xF0, 0x3E, 0x1E,
  0x07, 0x0F, 0x81, 0xF0, 0xF0, 0x38, 0x7C, 0x07, 0x87, 0x81, 0xC3, 0xE0,
  0x3E, 0x38, 0x0F, 0x1F, 0x01, 0xF1, 0xC0, 0x78, 0xF8, 0x0F, 0x8E, 0x03,
  0xC7, 0x80, 0x7C, 0x70, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x71, 0xE0, 0x1F,
  0x3C, 0x03, 0x9F, 0x00, 0xF9, 0xE0, 0x1C, 0xF8, 0x07, 0xCF, 0x00, 0xE7,
  0xC0, 0x1E, 0x70, 0x07, 0xBE, 0x00, 0xFB, 0x80, 0x3D, 0xF0, 0x07, 0xDC,
  0x01, 0xEF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x7B, 0xC0,
  0x0F, 0xF8, 0x01, 0xDE, 0x00, 0x7F, 0xC0, 0x0E, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0x1F, 0xFF, 0xFC, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x3F, 0xFE, 0x0F,
  0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x00, 0xF8, 0x3F,
  0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xF9, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0xF8,
  0xFB, 0xE0, 0x7F, 0xCF, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0xFE, 0xFF, 0x80, 0x1F, 0xCF, 0xBE, 0x07, 0xFC, 0xFB, 0xFF, 0xFF,
  0x8F, 0x9F, 0xFF, 0xF0, 0xF8, 0xFF, 0xFE, 0x0F, 0x83, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x3F,
  0x00, 0x03, 0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3C, 0x03, 0xF0,
  0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xF8, 0xFC, 0x3F, 0xFF, 0xE7, 0xE3, 0xFF,
  0xFF, 0xBF, 0x1F, 0xF0, 0x7D, 0xF9, 0xFC, 0x00, 0x7F, 0xDF, 0xC0, 0x01,
  0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x8F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFF, 0xF7, 0xE1, 0xFF, 0xFF, 0x3F, 0x07, 0xFF,
  0xF1, 0xF8, 0x0F, 0xFF, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x3F,
  0x87, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0xFF, 0xFC, 0x7E,
  0x1F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0xDF, 0x8F, 0xF8, 0x3F, 0xFC, 0xFE,
  0x00, 0x3F, 0xE7, 0xE0, 0x00, 0xFF, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x0F, 0xBF, 0x0F, 0xFF, 0xFD,
  0xF8, 0x3F, 0xFF, 0xCF, 0xC0, 0xFF, 0xFC, 0x7E, 0x01, 0xFF, 0x83, 0xF0,
  0x00, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x3F, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xF9, 0xFF, 0xFF, 0x0F, 0xBF,
  0xFF, 0xF8, 0xFB, 0xE0, 0x7F, 0xCF, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x07, 0xF1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0xC0,
  0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7F, 0x0F,
  0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFE, 0x7C,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFC, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0,
  0xF9, 0xFE, 0x0F, 0xF0, 0xFB, 0xFF, 0x1F, 0xF8, 0xFB, 0xFF, 0x9F, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFE, 0x0F, 0xB0, 0x7E, 0xFC, 0x07, 0xE0, 0x3E,
  0xF8, 0x07, 0xC0, 0x3E, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F,
  0x83, 0xFF, 0x80, 0xF8, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF0, 0xFB, 0xFF,
  0xFF, 0x8F, 0xBE, 0x07, 0xFC, 0xFB, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x02, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x83, 0xFF, 0x80, 0xF8, 0xFF, 0xFE,
  0x0F, 0x9F, 0xFF, 0xF0, 0xFB, 0xFF, 0xFF, 0x8F, 0xBE, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xEF, 0xF8, 0x01,
  0xFC, 0xFB, 0xE0, 0x7F, 0xCF, 0xBF, 0xFF, 0xF8, 0xF9, 0xFF, 0xFF, 0x0F,
  0x8F, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0xFF, 0xFC, 0x7E,
  0x1F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0xDF, 0x8F, 0xF8, 0x3F, 0xFC, 0xFE,
  0x00, 0x3F, 0xE7, 0xE0, 0x00, 0xFF, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFB, 0xF0,
  0xFF, 0xFF, 0x9F, 0x83, 0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0x07, 0xE0, 0x03,
  0xC0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x07, 0xC1, 0xFF,
  0xC0, 0x3E, 0x1F, 0xFF, 0x81, 0xF1, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF8,
  0x7D, 0xF0, 0x3F, 0xE3, 0xEE, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xE3,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFE, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0x80, 0x1E, 0xF8, 0x01, 0xF8, 0x01, 0xEF, 0x80, 0x3F,
  0x80, 0x3E, 0xF8, 0x03, 0xF8, 0x03, 0xE7, 0x80, 0x3F, 0x80, 0x3E, 0x7C,
  0x03, 0xB8, 0x03, 0xE7, 0xC0, 0x3B, 0xC0, 0x3C, 0x7C, 0x03, 0xBC, 0x03,
  0xC7, 0xC0, 0x79, 0xC0, 0x3C, 0x7C, 0x07, 0x9C, 0x07, 0xC3, 0xC0, 0x79,
  0xC0, 0x7C, 0x3C, 0x07, 0x1C, 0x07, 0xC3, 0xE0, 0x71, 0xE0, 0x78, 0x3E,
  0x07, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0xE0, 0x78, 0x3E, 0x0F, 0x0E, 0x07,
  0x81, 0xE0, 0xF0, 0xE0, 0xF8, 0x1E, 0x0E, 0x0E, 0x0F, 0x81, 0xE0, 0xE0,
  0xF0, 0xF0, 0x1F, 0x0E, 0x0F, 0x0F, 0x01, 0xF1, 0xE0, 0xF0, 0xF0, 0x1F,
  0x1E, 0x07, 0x0F, 0x01, 0xF1, 0xE0, 0x71, 0xF0, 0x0F, 0x1C, 0x07, 0x1F,
  0x00, 0xF1, 0xC0, 0x79, 0xE0, 0x0F, 0x9C, 0x07, 0x9E, 0x00, 0xFB, 0xC0,
  0x79, 0xE0, 0x0F, 0xBC, 0x03, 0x9E, 0x00, 0xFB, 0xC0, 0x39, 0xE0, 0x07,
  0xB8, 0x03, 0xBE, 0x00, 0x7B, 0x80, 0x3F, 0xC0, 0x07, 0xB8, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x1F, 0xFC,
  0x00, 0x3F, 0x3F, 0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0x00, 0x3F, 0x7F, 0x7F,
  0x80, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xF8, 0x0F, 0xE0, 0x3E, 0xF8, 0x07,
  0xF0, 0x3E, 0xF8, 0x03, 0xF8, 0x7E, 0xF8, 0x01, 0xFF, 0xFE, 0xF8, 0x00,
  0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0x00,
};

const GFXglyph JetBrainsMono_Light69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 10, 50, 41, 16, -50 },
  { 64, 20, 20, 41, 11, -50 },
  { 114, 37, 50, 41, 2, -50 },
  { 346, 31, 70, 41, 5, -60 },
  { 618, 39, 51, 41, 1, -51 },
  { 867, 35, 52, 41, 4, -51 },
  { 1095, 6, 20, 41, 17, -50 },
  { 1110, 20, 66, 41, 13, -58 },
  { 1275, 20, 66, 41, 8, -58 },
  { 1440, 36, 35, 41, 3, -42 },
  { 1598, 32, 32, 41, 5, -39 },
  { 1726, 14, 21, 41, 12, -10 },
  { 1763, 22, 5, 41, 10, -25 },
  { 1777, 11, 11, 41, 15, -10 },
  { 1793, 30, 65, 41, 6, -57 },
  { 2037, 30, 52, 41, 6, -51 },
  { 2232, 31, 50, 41, 6, -50 },
  { 2426, 31, 51, 41, 5, -51 },
  { 2624, 30, 51, 41, 5, -50 },
  { 2816, 28, 50, 41, 6, -50 },
  { 2991, 29, 51, 41, 6, -50 },
  { 3176, 31, 51, 41, 5, -50 },
  { 3374, 31, 50, 41, 6, -50 },
  { 3568, 30, 52, 41, 6, -51 },
  { 3763, 31, 51, 41, 5, -51 },
  { 3961, 11, 40, 41, 15, -39 },
  { 4016, 14, 50, 41, 12, -39 },
  { 4104, 29, 36, 41, 6, -41 },
  { 4235, 29, 21, 41, 6, -33 },
  { 4312, 29, 36, 41, 6, -41 },
  { 4443, 24, 50, 41, 10, -50 },
  { 4593, 35, 63, 41, 3, -51 },
  { 4869, 34, 50, 41, 4, -50 },
  { 5082, 29, 50, 41, 7, -50 },
  { 5264, 30, 52, 41, 6, -51 },
  { 5459, 28, 50, 41, 7, -50 },
  { 5634, 29, 50, 41, 7, -50 },
  { 5816, 29, 50, 41, 7, -50 },
  { 5998, 30, 52, 41, 6, -51 },
  { 6193, 28, 50, 41, 7, -50 },
  { 6368, 26, 50, 41, 8, -50 },
  { 6531, 30, 51, 41, 4, -50 },
  { 6723, 31, 50, 41, 7, -50 },
  { 6917, 29, 50, 41, 8, -50 },
  { 7099, 30, 50, 41, 6, -50 },
  { 7287, 28, 50, 41, 7, -50 },
  { 7462, 29, 52, 41, 6, -51 },
  { 7651, 31, 50, 41, 7, -50 },
  { 7845, 30, 63, 41, 6, -51 },
  { 8082, 30, 50, 41, 7, -50 },
  { 8270, 31, 52, 41, 5, -51 },
  { 8472, 34, 50, 41, 4, -50 },
  { 8685, 28, 51, 41, 7, -50 },
  { 8864, 34, 50, 41, 4, -50 },
  { 9077, 37, 50, 41, 2, -50 },
  { 9309, 35, 50, 41, 3, -50 },
  { 9528, 36, 50, 41, 3, -50 },
  { 9753, 29, 50, 41, 6, -50 },
  { 9935, 17, 65, 41, 14, -57 },
  { 10074, 30, 65, 41, 6, -57 },
  { 10318, 17, 65, 41, 10, -57 },
  { 10457, 30, 27, 41, 6, -50 },
  { 10559, 33, 4, 41, 4, 2 },
  { 10576, 14, 10, 41, 13, -54 },
  { 10594, 30, 40, 41, 5, -39 },
  { 10744, 28, 51, 41, 7, -50 },
  { 10923, 29, 40, 41, 6, -39 },
  { 11068, 29, 51, 41, 6, -50 },
  { 11253, 29, 40, 41, 6, -39 },
  { 11398, 33, 50, 41, 4, -50 },
  { 11605, 29, 51, 41, 6, -39 },
  { 11790, 28, 50, 41, 7, -50 },
  { 11965, 32, 53, 41, 6, -53 },
  { 12177, 25, 65, 41, 6, -53 },
  { 12381, 31, 50, 41, 7, -50 },
  { 12575, 36, 50, 41, 2, -50 },
  { 12800, 32, 39, 41, 5, -39 },
  { 12956, 28, 39, 41, 7, -39 },
  { 13093, 29, 40, 41, 6, -39 },
  { 13238, 28, 51, 41, 7, -39 },
  { 13417, 29, 51, 41, 6, -39 },
  { 13602, 29, 39, 41, 8, -39 },
  { 13744, 30, 40, 41, 6, -39 },
  { 13894, 32, 49, 41, 4, -49 },
  { 14090, 28, 39, 41, 7, -38 },
  { 14227, 33, 38, 41, 4, -38 },
  { 14384, 36, 38, 41, 3, -38 },
  { 14555, 33, 38, 41, 4, -38 },
  { 14712, 33, 50, 41, 4, -38 },
  { 14919, 29, 38, 41, 6, -38 },
  { 15057, 29, 65, 41, 6, -57 },
  { 15293, 5, 65, 41, 18, -57 },
  { 15334, 29, 65, 41, 6, -57 },
  { 15570, 32, 14, 41, 5, -31 },
};

const GFXfont JetBrainsMono_Light69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_LIGHT69PT7B_H_
