#ifndef _NOTOSANS_ITALIC50PT7B_H_
#define _NOTOSANS_ITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07,
  0x00, 0x00, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C,
  0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x70, 0x38, 0x70, 0x78,
  0x70, 0x70, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xE7, 0x1E, 0x07, 0xC7, 0x02, 0x0F, 0x87,
  0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x8E, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x38, 0xF8, 0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0xF8, 0xC0, 0xF1,
  0xF0, 0xF8, 0xF7, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x01,
  0xFF, 0x00, 0x07, 0x80, 0xFF, 0xC0, 0x01, 0xC0, 0x7C, 0x78, 0x00, 0xF0,
  0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x03, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x0E,
  0x01, 0xE0, 0x38, 0x07, 0x80, 0x78, 0x0E, 0x03, 0xC0, 0x1C, 0x03, 0x81,
  0xE0, 0x0F, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x78, 0x3C, 0x00, 0xF0, 0x1E,
  0x1E, 0x00, 0x3C, 0x07, 0x0F, 0x00, 0x0F, 0x03, 0xC3, 0xC7, 0xC3, 0xC0,
  0xF1, 0xE7, 0xFC, 0xF0, 0x78, 0xF3, 0xFF, 0xBC, 0x1E, 0x79, 0xFB, 0xE7,
  0x8F, 0x1E, 0x78, 0x39, 0xFF, 0x8F, 0x3C, 0x0F, 0x3F, 0xC7, 0x8F, 0x03,
  0xC7, 0xE3, 0xC3, 0x80, 0xF0, 0x00, 0xF1, 0xE0, 0x3C, 0x00, 0x78, 0x78,
  0x0F, 0x00, 0x3C, 0x1E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0xE0, 0x07, 0x83,
  0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x70, 0x78, 0x0F,
  0x00, 0x1E, 0x3E, 0x03, 0x80, 0x07, 0xFF, 0x01, 0xE0, 0x00, 0xFF, 0x80,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xCF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x0F,
  0x1F, 0x0F, 0x80, 0x7C, 0xF8, 0x1F, 0x01, 0xE7, 0xC0, 0x7C, 0x0F, 0xBE,
  0x00, 0xF8, 0x3C, 0xF0, 0x01, 0xF1, 0xE3, 0xC0, 0x03, 0xEF, 0x8F, 0x00,
  0x0F, 0xFC, 0x3C, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x3F, 0x03, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0x0F, 0xF7,
  0xC1, 0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0xF8, 0x3E, 0x03, 0xFF, 0x80, 0x7C,
  0x00, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x9E, 0x3C, 0x78,
  0xE1, 0xC3, 0x8E, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x08, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x3F, 0x0E, 0x00, 0xFF,
  0x98, 0x00, 0x7F, 0xF0, 0x04, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xBF, 0xE0, 0x3F, 0x80, 0x40, 0xF7, 0x00, 0x03, 0xC7, 0x00, 0x0F, 0x0E,
  0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0xC0, 0x78,
  0x01, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFD, 0xFF, 0xE0, 0x39, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1E, 0x1F,
  0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFF, 0x8F, 0xEF, 0x7F, 0x3E, 0x7C, 0x78, 0xE0, 0xF0, 0x81, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xF0, 0x0F, 0xC0, 0x30, 0x01, 0xF0, 0x08, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3E, 0x01, 0xF8, 0x0C,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x21, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE2, 0x00, 0x03, 0xE1, 0xC0, 0x03, 0xF0, 0xFC,
  0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9,
  0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x1E,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xC0,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3D, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC2, 0x00, 0x07, 0xE1, 0x80, 0x07, 0xE0, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x3F, 0xC0, 0x3C, 0xFF,
  0xE0, 0x7D, 0xFF, 0xF0, 0x7F, 0xC1, 0xF8, 0x7F, 0x00, 0xF8, 0x7E, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x00, 0x3E, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC0,
  0xF0, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x01, 0xF0,
  0x07, 0xE3, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x7C, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3F,
  0x1E, 0x00, 0x3F, 0x1F, 0x00, 0x7E, 0x1F, 0x81, 0xFE, 0x0F, 0xFF, 0xDE,
  0x07, 0xFF, 0xBE, 0x03, 0xFF, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xE0, 0x70, 0x00, 0x00, 0x20, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0x80, 0x7C, 0x40, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x03, 0xF8, 0x03, 0x87, 0x80,
  0x3F, 0xFC, 0x0F, 0x3C, 0x03, 0xFF, 0xF0, 0x3C, 0xF0, 0x1F, 0x87, 0xC0,
  0xF7, 0x80, 0xF8, 0x0F, 0x03, 0xDE, 0x07, 0xC0, 0x38, 0x0F, 0x70, 0x1E,
  0x01, 0xE0, 0x3F, 0xC0, 0xF0, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x1E, 0x03,
  0xFC, 0x1E, 0x00, 0x70, 0x0F, 0xF0, 0x78, 0x03, 0xC0, 0x3F, 0x81, 0xE0,
  0x0F, 0x00, 0xEE, 0x07, 0x80, 0x7C, 0x07, 0xB8, 0x1E, 0x01, 0xE0, 0x1E,
  0xE0, 0x78, 0x0F, 0x80, 0xF3, 0x81, 0xE0, 0x3E, 0x07, 0xCF, 0x07, 0xC1,
  0xFC, 0x1E, 0x3C, 0x0F, 0xFE, 0xFB, 0xF0, 0xF0, 0x3F, 0xF1, 0xFF, 0x83,
  0xC0, 0x7F, 0x83, 0xFC, 0x07, 0x80, 0x30, 0x03, 0x80, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x07, 0xF0, 0x01,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80,
  0x3E, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1E, 0x01,
  0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x07, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0x80, 0x7F, 0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xC0, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFC, 0x01, 0xC0, 0x3F, 0x00, 0x04, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x80, 0x1F, 0xFB, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xE0, 0x3F, 0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x7E, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFE,
  0x07, 0xC0, 0x07, 0xF0, 0x1E, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x0F, 0x01,
  0xF8, 0x00, 0x08, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x3E, 0x00,
  0x3F, 0xF9, 0xF0, 0x03, 0xFF, 0xCF, 0x00, 0x1F, 0xFE, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3C, 0x07, 0xF0, 0x01,
  0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xBF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x78, 0x7E, 0x00, 0x00,
  0xF1, 0xF8, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x0F,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xDC, 0x00, 0x03,
  0xFE, 0x03, 0xDE, 0x00, 0x03, 0xDE, 0x03, 0xDE, 0x00, 0x07, 0xFE, 0x03,
  0xDE, 0x00, 0x07, 0xBE, 0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x07, 0x9E, 0x00,
  0x0F, 0x3C, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x07, 0x9E, 0x00, 0x1E, 0x7C,
  0x07, 0x8E, 0x00, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x0F, 0x8F,
  0x00, 0x78, 0x78, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x0F, 0x0F, 0x00, 0xF0,
  0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x1F,
  0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0x07,
  0x81, 0xF0, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0x3E, 0x07, 0x8F, 0x01, 0xE0,
  0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x9E, 0x03, 0xE0, 0x3C, 0x07,
  0x9E, 0x03, 0xE0, 0x3C, 0x07, 0xBC, 0x03, 0xC0, 0x7C, 0x03, 0xF8, 0x03,
  0xC0, 0x78, 0x03, 0xF8, 0x07, 0xC0, 0x78, 0x03, 0xF0, 0x07, 0xC0, 0x78,
  0x03, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x1E,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xE0, 0x00,
  0xF0, 0x0F, 0x78, 0x00, 0x3C, 0x03, 0xDE, 0x00, 0x0F, 0x00, 0xF7, 0xC0,
  0x07, 0xC0, 0x78, 0xF0, 0x01, 0xE0, 0x1E, 0x3C, 0x00, 0x78, 0x07, 0x87,
  0x80, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xE0, 0x3E,
  0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x00,
  0xF0, 0x1E, 0x07, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x1E, 0x00, 0xF0, 0x78,
  0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x0F, 0x87, 0x80, 0x78, 0x01, 0xE3,
  0xE0, 0x3E, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x1F, 0x3C, 0x03, 0xC0, 0x03,
  0xCF, 0x00, 0xF0, 0x00, 0xF3, 0xC0, 0x3C, 0x00, 0x3E, 0xF0, 0x1F, 0x00,
  0x07, 0xF8, 0x07, 0x80, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x78,
  0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xFB, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xE0, 0x3F, 0x80, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xE0,
  0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83,
  0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0x7C,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xE0, 0x3F,
  0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x7E,
  0x0F, 0x80, 0x3F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0x81, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0x00, 0xF0, 0x3F, 0x00, 0x08,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC2, 0x00, 0x07, 0xC1, 0x80, 0x0F, 0xE0, 0xFE, 0x7F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x78,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x81, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xE0,
  0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFC, 0x00, 0x3E,
  0x78, 0x00, 0x7F, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xBC, 0x00, 0xF8, 0x78, 0x01, 0xEF,
  0x00, 0x3C, 0x1E, 0x00, 0x7B, 0xC0, 0x1F, 0x07, 0x80, 0x3C, 0xF0, 0x07,
  0xC1, 0xE0, 0x0F, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x8F, 0x00, 0xF8, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x1F, 0x01, 0xE0, 0x3C,
  0x3C, 0x07, 0x80, 0x78, 0x1E, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x07, 0x83, 0xE0, 0x70, 0x3C, 0x01, 0xE0, 0xF0, 0x1C, 0x1E, 0x00,
  0x78, 0x3C, 0x07, 0x07, 0x80, 0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x07, 0x87,
  0x80, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x00, 0x78, 0xF0, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x07, 0xB8, 0x00, 0x0E,
  0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xC7, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0xF8,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x07,
  0x9C, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x07,
  0x00, 0x3F, 0x83, 0xC0, 0x3F, 0xF0, 0xE0, 0x3F, 0xFE, 0x78, 0x1F, 0xEF,
  0xDE, 0x07, 0xE0, 0x7F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE1,
  0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0x78, 0x01, 0xF8, 0x1E, 0x00, 0xFE, 0x07,
  0xC0, 0x77, 0x81, 0xF8, 0x79, 0xE0, 0x3F, 0xFC, 0x70, 0x07, 0xFE, 0x3C,
  0x00, 0xFF, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x03, 0xC7,
  0xFE, 0x00, 0xF3, 0xFF, 0xC0, 0x7D, 0xF7, 0xF0, 0x1E, 0xF0, 0x3E, 0x07,
  0xF0, 0x0F, 0x81, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x78, 0x3F, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0xC0, 0x3F, 0x07, 0xBC, 0x3F,
  0x81, 0xE7, 0xFF, 0xC0, 0x71, 0xFF, 0xE0, 0x3C, 0x1F, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFB,
  0xE0, 0x7E, 0x01, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x02, 0x07, 0xF0, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x78, 0x00, 0xFF,
  0xC7, 0x80, 0x3F, 0xFE, 0x78, 0x07, 0xFB, 0xF7, 0x80, 0x7C, 0x07, 0xF8,
  0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0xC0, 0xF8, 0x01, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0x78, 0x03, 0xF8, 0x07,
  0xC0, 0x77, 0x80, 0x7E, 0x1E, 0x78, 0x03, 0xFF, 0xCF, 0x00, 0x1F, 0xF8,
  0xF0, 0x00, 0xFF, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xF3, 0xF0, 0x7C, 0x07, 0x87, 0xC0,
  0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x07, 0xDF,
  0x00, 0xFC, 0xF8, 0x7F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0x07, 0xF0, 0x78,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xE6, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xE0, 0x0F, 0xFC,
  0x38, 0x07, 0xFF, 0xCF, 0x01, 0xFE, 0xFD, 0xE0, 0x3F, 0x03, 0xFC, 0x0F,
  0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0,
  0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x7E, 0x03, 0xC0, 0x0F, 0xC0, 0x78, 0x03, 0xF8, 0x0F, 0x80, 0xEF, 0x01,
  0xF8, 0x7B, 0xE0, 0x1F, 0xFE, 0x78, 0x01, 0xFF, 0x8F, 0x00, 0x1F, 0xE1,
  0xE0, 0x00, 0x40, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x7C,
  0x03, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x3C, 0x7F, 0xE0, 0x1E,
  0x7F, 0xF8, 0x1F, 0x7E, 0xFE, 0x0F, 0x78, 0x1F, 0x07, 0xF0, 0x07, 0x83,
  0xF0, 0x03, 0xC1, 0xF8, 0x01, 0xE1, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x01,
  0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80,
  0x07, 0x87, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x03, 0xC1, 0xF0, 0x03,
  0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0x79, 0xF0, 0x00,
  0x3D, 0xF0, 0x00, 0x3D, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x00, 0x03, 0xC1, 0xF8, 0x03, 0xF8, 0x03, 0xC7, 0xFC,
  0x0F, 0xFC, 0x03, 0x8F, 0xFE, 0x1F, 0xFE, 0x07, 0x9F, 0x7F, 0x3E, 0x7F,
  0x07, 0xB8, 0x1F, 0x78, 0x1F, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC3, 0xFC, 0x01, 0xE3,
  0xFF, 0x81, 0xF3, 0xFF, 0xC0, 0xF3, 0xFF, 0xF0, 0x7B, 0xC0, 0xF8, 0x3F,
  0xC0, 0x7C, 0x1F, 0x80, 0x1E, 0x1F, 0xC0, 0x0F, 0x0F, 0xC0, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00,
  0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0x7C, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x3F, 0x8F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x0F, 0x1F, 0xF8,
  0x00, 0xE3, 0xFF, 0xC0, 0x1E, 0x7D, 0xFC, 0x01, 0xEF, 0x03, 0xE0, 0x1F,
  0xC0, 0x3E, 0x01, 0xF8, 0x01, 0xE0, 0x1F, 0x80, 0x1E, 0x03, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0xC0,
  0x3F, 0x01, 0xEF, 0x0F, 0xE0, 0x1E, 0x7F, 0xFC, 0x01, 0xE7, 0xFF, 0x80,
  0x1E, 0x1F, 0xE0, 0x03, 0xE0, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x83, 0xC0, 0x3F, 0xF0, 0xE0, 0x3F, 0xFE, 0x78, 0x1F, 0xEF, 0xDE, 0x07,
  0xE0, 0x7F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x00,
  0x78, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3,
  0xE0, 0x07, 0xE0, 0x78, 0x01, 0xF8, 0x1E, 0x00, 0xFE, 0x07, 0xC0, 0x77,
  0x81, 0xF8, 0x7B, 0xE0, 0x3F, 0xFC, 0xF0, 0x07, 0xFE, 0x3C, 0x00, 0xFF,
  0x0F, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC3, 0xF0, 0x3C, 0x7F, 0x03, 0x8F,
  0xF0, 0x79, 0xFF, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xE7, 0xE0,
  0xF8, 0x02, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE3, 0x00,
  0x3F, 0x1E, 0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x20, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0x00, 0x0F,
  0x00, 0x0F, 0x87, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x7E, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x3F, 0x07, 0x80, 0x3F, 0x83, 0xE0, 0x3B, 0xC1, 0xF8,
  0x79, 0xE0, 0x7F, 0xF9, 0xE0, 0x3F, 0xF8, 0xF0, 0x0F, 0xF8, 0x78, 0x00,
  0x40, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x1F, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7B, 0xC0, 0x0F, 0xC0,
  0x1F, 0x78, 0x03, 0xF8, 0x03, 0xEF, 0x00, 0x77, 0x00, 0xF9, 0xE0, 0x1E,
  0xE0, 0x1F, 0x3C, 0x03, 0xDC, 0x03, 0xC7, 0x80, 0xF7, 0x80, 0xF8, 0xF0,
  0x1E, 0xF0, 0x1E, 0x1E, 0x07, 0x9E, 0x07, 0xC3, 0xC0, 0xF1, 0xC0, 0xF0,
  0x78, 0x1C, 0x38, 0x3E, 0x0F, 0x07, 0x87, 0x07, 0x81, 0xF0, 0xE0, 0xE1,
  0xF0, 0x3E, 0x3C, 0x1C, 0x3C, 0x07, 0xC7, 0x83, 0x87, 0x80, 0x79, 0xE0,
  0x71, 0xF0, 0x0F, 0x3C, 0x0F, 0x3C, 0x01, 0xEF, 0x01, 0xEF, 0x80, 0x3D,
  0xE0, 0x3D, 0xE0, 0x07, 0xB8, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0xFF, 0x00,
  0x1D, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xBC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80,
  0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x3F, 0xF8,
  0x03, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xC0, 0x0F,
  0xFC, 0x80, 0x00, 0x60,
};

const GFXglyph NotoSans_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 37, 13, 1, -36 },
  { 62, 16, 13, 20, 5, -36 },
  { 88, 32, 36, 32, 1, -36 },
  { 232, 24, 41, 28, 2, -38 },
  { 355, 34, 37, 40, 4, -36 },
  { 513, 30, 37, 34, 2, -36 },
  { 652, 7, 13, 11, 5, -36 },
  { 664, 16, 44, 15, 2, -36 },
  { 752, 16, 44, 15, -4, -36 },
  { 840, 23, 23, 28, 5, -38 },
  { 907, 24, 24, 29, 3, -30 },
  { 979, 10, 12, 13, -2, -6 },
  { 994, 13, 4, 16, 1, -15 },
  { 1001, 6, 7, 13, 1, -6 },
  { 1007, 24, 36, 18, -2, -36 },
  { 1115, 24, 37, 28, 3, -36 },
  { 1226, 15, 36, 28, 7, -36 },
  { 1294, 26, 36, 28, 0, -36 },
  { 1411, 25, 37, 28, 1, -36 },
  { 1527, 27, 36, 28, 0, -36 },
  { 1649, 25, 37, 28, 2, -36 },
  { 1765, 24, 37, 28, 3, -36 },
  { 1876, 24, 36, 28, 4, -36 },
  { 1984, 25, 37, 28, 2, -36 },
  { 2100, 24, 37, 28, 2, -36 },
  { 2211, 10, 29, 13, 1, -28 },
  { 2248, 13, 34, 13, -2, -28 },
  { 2304, 24, 24, 29, 3, -30 },
  { 2376, 23, 13, 29, 4, -24 },
  { 2414, 24, 24, 29, 3, -30 },
  { 2486, 19, 37, 22, 4, -36 },
  { 2574, 38, 41, 42, 3, -36 },
  { 2769, 29, 36, 28, -3, -36 },
  { 2900, 27, 36, 30, 2, -36 },
  { 3022, 28, 37, 29, 4, -36 },
  { 3152, 30, 36, 33, 2, -36 },
  { 3287, 26, 36, 26, 2, -36 },
  { 3404, 26, 36, 24, 2, -36 },
  { 3521, 29, 37, 34, 4, -36 },
  { 3656, 32, 36, 34, 2, -36 },
  { 3800, 20, 36, 16, -1, -36 },
  { 3890, 22, 46, 14, -8, -36 },
  { 4017, 31, 36, 28, 2, -36 },
  { 4157, 19, 36, 24, 2, -36 },
  { 4243, 40, 36, 42, 2, -36 },
  { 4423, 34, 36, 35, 2, -36 },
  { 4576, 31, 37, 36, 4, -36 },
  { 4720, 26, 36, 28, 2, -36 },
  { 4837, 31, 45, 36, 4, -36 },
  { 5012, 26, 36, 29, 2, -36 },
  { 5129, 25, 37, 25, 1, -36 },
  { 5245, 25, 36, 25, 4, -36 },
  { 5358, 30, 37, 34, 4, -36 },
  { 5497, 27, 36, 28, 5, -36 },
  { 5619, 42, 36, 43, 5, -36 },
  { 5808, 33, 36, 26, -3, -36 },
  { 5957, 25, 36, 25, 5, -36 },
  { 6070, 30, 36, 27, -1, -36 },
  { 6205, 19, 44, 15, 0, -36 },
  { 6310, 10, 36, 18, 5, -36 },
  { 6355, 19, 44, 15, -4, -36 },
  { 6460, 25, 23, 29, 2, -36 },
  { 6532, 21, 4, 20, -5, 4 },
  { 6543, 9, 8, 14, 7, -38 },
  { 6552, 26, 28, 28, 2, -27 },
  { 6643, 26, 39, 29, 1, -38 },
  { 6770, 21, 28, 23, 2, -27 },
  { 6844, 28, 39, 29, 2, -38 },
  { 6981, 21, 28, 25, 2, -27 },
  { 7055, 28, 50, 16, -6, -38 },
  { 7230, 27, 39, 29, 1, -27 },
  { 7362, 25, 38, 29, 1, -38 },
  { 7481, 13, 37, 13, 1, -37 },
  { 7542, 19, 49, 13, -6, -37 },
  { 7659, 25, 38, 25, 1, -38 },
  { 7778, 13, 38, 13, 1, -38 },
  { 7840, 40, 27, 44, 1, -27 },
  { 7975, 25, 27, 29, 1, -27 },
  { 8060, 24, 27, 28, 2, -27 },
  { 8141, 28, 39, 29, -1, -27 },
  { 8278, 26, 39, 29, 2, -27 },
  { 8405, 20, 27, 20, 1, -27 },
  { 8473, 21, 28, 22, 0, -27 },
  { 8547, 16, 34, 17, 2, -33 },
  { 8615, 25, 28, 29, 3, -27 },
  { 8703, 24, 27, 23, 2, -27 },
  { 8784, 35, 27, 36, 3, -27 },
  { 8903, 28, 27, 24, -2, -27 },
  { 8998, 31, 39, 23, -5, -27 },
  { 9150, 23, 27, 22, -1, -27 },
  { 9228, 19, 44, 18, 1, -36 },
  { 9333, 4, 50, 28, 13, -38 },
  { 9358, 19, 44, 18, -2, -36 },
  { 9463, 24, 7, 29, 3, -21 },
};

const GFXfont NotoSans_Italic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic50pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_ITALIC50PT7B_H_
