#ifndef _NOTOSANS_ITALIC21PT7B_H_
#define _NOTOSANS_ITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x82, 0x00, 0x41, 0x8E,
  0x00, 0x66, 0xD9, 0x32, 0x6C, 0x80, 0x06, 0x20, 0x23, 0x01, 0x18, 0x18,
  0x87, 0xFF, 0xBF, 0xFC, 0x62, 0x03, 0x10, 0x11, 0x87, 0xFF, 0xBF, 0xF8,
  0x62, 0x02, 0x30, 0x31, 0x01, 0x98, 0x00, 0x03, 0x00, 0x81, 0xFC, 0xFB,
  0x26, 0x19, 0x02, 0x40, 0xF0, 0x1E, 0x03, 0xC0, 0x98, 0x26, 0x1B, 0x3F,
  0xCF, 0xC0, 0x40, 0x30, 0x00, 0x38, 0x19, 0xB0, 0xCC, 0x42, 0x31, 0x18,
  0x8C, 0xC2, 0x36, 0x08, 0x97, 0xB6, 0xD3, 0xF6, 0xCC, 0x32, 0x30, 0x88,
  0xC6, 0x62, 0x31, 0x89, 0x82, 0x6C, 0x0F, 0x00, 0x0F, 0x80, 0xC6, 0x06,
  0x30, 0x21, 0x81, 0x9C, 0x0D, 0xC0, 0x38, 0x07, 0x81, 0x66, 0x36, 0x19,
  0xB0, 0xD9, 0x83, 0x8C, 0x1C, 0x73, 0xF1, 0xF9, 0xC0, 0x6D, 0x2C, 0x06,
  0x10, 0x61, 0x83, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x40, 0xC0, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0xC1, 0x86, 0x08, 0x31, 0xC0, 0x06, 0x01, 0x04, 0x43, 0x90,
  0x1F, 0xC7, 0x33, 0x41, 0x98, 0x26, 0x00, 0xC0, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x36, 0x64,
  0xC0, 0xF8, 0x4F, 0x80, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0F,
  0x87, 0x73, 0x0C, 0xC3, 0x60, 0xD8, 0x34, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1B, 0x06, 0x43, 0x19, 0xC3, 0xC0, 0x0C, 0xF7, 0xF3, 0x08, 0x61, 0x86,
  0x18, 0xC3, 0x0C, 0x30, 0x86, 0x00, 0x0F, 0xC3, 0x9C, 0x41, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0xFF, 0xBF, 0xE0, 0x0F, 0xC3, 0x9C, 0x41, 0x80, 0x30, 0x06, 0x01, 0x83,
  0xE0, 0x78, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x19, 0xC7, 0x1F, 0xC0,
  0x00, 0xE0, 0x1C, 0x07, 0x81, 0xA0, 0x6C, 0x19, 0x86, 0x30, 0x84, 0x31,
  0x8C, 0x33, 0xFF, 0xFF, 0xF0, 0x10, 0x06, 0x00, 0xC0, 0x1F, 0xC7, 0xF1,
  0x00, 0xC0, 0x30, 0x08, 0x07, 0xF0, 0x8E, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0xB1, 0xCF, 0xE0, 0x07, 0xC3, 0x91, 0x80, 0xC0, 0x30, 0x18, 0x07,
  0xF9, 0xC6, 0xE0, 0xB0, 0x3C, 0x0B, 0x06, 0x61, 0x9D, 0xC3, 0xE0, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0F, 0x86, 0x73, 0x0C, 0xC1, 0x30,
  0xC6, 0x71, 0xF0, 0x78, 0x73, 0x30, 0x6C, 0x1B, 0x06, 0xC1, 0xB8, 0xC7,
  0xE0, 0x1F, 0x0E, 0x63, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x8F, 0x3E,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x23, 0x8F, 0xC0, 0x11, 0xCC, 0x00, 0x00,
  0x00, 0x02, 0x19, 0xC0, 0x08, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x18, 0x63, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x38, 0x38, 0x38, 0x38, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x30, 0x04, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x3C, 0x38, 0x78, 0x38,
  0x08, 0x00, 0x7C, 0xEE, 0x02, 0x03, 0x06, 0x06, 0x1C, 0x38, 0x60, 0x60,
  0x40, 0x00, 0x40, 0xC0, 0xC0, 0x01, 0xF8, 0x07, 0x1C, 0x1C, 0x06, 0x30,
  0x03, 0x21, 0xF3, 0x63, 0x31, 0x46, 0x31, 0xCC, 0x21, 0xCC, 0x23, 0xCC,
  0x63, 0xCC, 0x62, 0xCF, 0xBE, 0xC7, 0x38, 0x60, 0x00, 0x30, 0x00, 0x1F,
  0xF0, 0x0F, 0xC0, 0x00, 0xC0, 0x1C, 0x01, 0x40, 0x34, 0x02, 0x40, 0x66,
  0x0C, 0x60, 0xC6, 0x18, 0x61, 0xFE, 0x30, 0x63, 0x06, 0x60, 0x26, 0x03,
  0xC0, 0x30, 0x1F, 0xC3, 0xFC, 0x41, 0x98, 0x33, 0x06, 0x60, 0xCF, 0xF3,
  0xFC, 0x60, 0xCC, 0x19, 0x83, 0x20, 0x6C, 0x0D, 0xFF, 0x3F, 0xC0, 0x0F,
  0xE3, 0xDC, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xF7, 0x0F, 0xE0, 0x1F, 0x81, 0xFE, 0x10,
  0x73, 0x03, 0x30, 0x33, 0x03, 0x30, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60,
  0x64, 0x0E, 0xC1, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0F, 0xE3, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0xFC, 0x7F, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x00, 0x0F, 0xF1, 0xEF, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x3E, 0xC3, 0xEC, 0x06, 0xC0, 0x4C, 0x0C, 0xE0, 0xC7, 0xBC, 0x3F, 0x80,
  0x18, 0x18, 0xC0, 0xC4, 0x06, 0x60, 0x33, 0x01, 0x18, 0x18, 0xFF, 0xCF,
  0xFE, 0x60, 0x33, 0x03, 0x18, 0x18, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x03,
  0x00, 0x1F, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x20, 0xF8, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x7C,
  0x3C, 0x00, 0x18, 0x38, 0xC3, 0x04, 0x30, 0x63, 0x03, 0x30, 0x1B, 0x00,
  0xF0, 0x0F, 0xC0, 0x76, 0x03, 0x30, 0x18, 0xC0, 0x86, 0x0C, 0x18, 0x60,
  0xC3, 0x07, 0x00, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x40, 0xC0, 0xFF, 0xFF, 0x1C, 0x03, 0x8E, 0x03, 0x8F, 0x03,
  0xC7, 0x81, 0xE3, 0x41, 0xB1, 0xA0, 0xD8, 0x90, 0xC8, 0xCC, 0x4C, 0x66,
  0x66, 0x33, 0x23, 0x19, 0xB1, 0x88, 0xD1, 0x8C, 0x38, 0xC6, 0x18, 0x63,
  0x0C, 0x30, 0x18, 0x0C, 0x70, 0x33, 0xC0, 0x8F, 0x06, 0x36, 0x18, 0xD8,
  0x62, 0x21, 0x98, 0xC4, 0x63, 0x31, 0x86, 0xC6, 0x1B, 0x10, 0x6C, 0xC0,
  0xE3, 0x03, 0x8C, 0x06, 0x00, 0x0F, 0xC1, 0xCE, 0x30, 0x36, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xE0,
  0xE7, 0x3C, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x41, 0x98, 0x33, 0x06, 0x60,
  0xCC, 0x33, 0x1E, 0x7F, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x00, 0x0F, 0xC1, 0xCE, 0x30, 0x36, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xE0, 0xC7, 0x3C, 0x3F, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x1F, 0x83, 0xF8, 0x41, 0x98, 0x33,
  0x06, 0x60, 0xCC, 0x33, 0xFC, 0x7E, 0x0C, 0x61, 0x8C, 0x21, 0x8C, 0x19,
  0x83, 0x30, 0x70, 0x0F, 0xE3, 0x9C, 0x60, 0x18, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x19, 0xCE, 0x3F, 0x80,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x00, 0x30, 0x32, 0x03, 0x60, 0x36,
  0x03, 0x60, 0x26, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC,
  0x0C, 0xC1, 0x8F, 0x78, 0x7E, 0x00, 0xC0, 0x7C, 0x06, 0xC0, 0xCC, 0x0C,
  0xC1, 0x84, 0x18, 0x43, 0x06, 0x30, 0x66, 0x06, 0x40, 0x6C, 0x06, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x00, 0xC0, 0xC0, 0xF0, 0x70, 0x6C, 0x14, 0x1B,
  0x0D, 0x0C, 0xC3, 0x43, 0x31, 0x91, 0x84, 0x64, 0x61, 0x11, 0x10, 0x4C,
  0x4C, 0x12, 0x12, 0x05, 0x85, 0x81, 0x41, 0x60, 0x70, 0x50, 0x1C, 0x1C,
  0x06, 0x06, 0x00, 0x18, 0x1C, 0x30, 0x60, 0xC3, 0x01, 0x18, 0x06, 0xC0,
  0x1E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x80, 0x36, 0x01, 0x98, 0x06, 0x30,
  0x30, 0xC1, 0x83, 0x0C, 0x06, 0x00, 0xC0, 0xF8, 0x19, 0x06, 0x31, 0x86,
  0x30, 0xCC, 0x0B, 0x01, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0x1E, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xF0, 0xCC, 0x44, 0x66, 0x66,
  0x22, 0x33, 0x33, 0x30, 0x0F, 0x0F, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0xF8, 0x0C, 0x03,
  0x01, 0xE0, 0x48, 0x33, 0x08, 0x46, 0x19, 0x02, 0xC0, 0xC0, 0xFF, 0x80,
  0xC6, 0x30, 0x1F, 0x66, 0x39, 0x83, 0x30, 0x6C, 0x0D, 0x83, 0x30, 0x66,
  0x0C, 0xC3, 0x9C, 0xA1, 0xE4, 0x00, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x0D, 0xE2, 0x8D, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x03, 0xC1, 0xB8, 0x6F,
  0x72, 0x78, 0x1F, 0x98, 0x58, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x31, 0x0F, 0x80, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x61, 0xF4,
  0x31, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC1, 0x8C, 0x18, 0xC1, 0x8C, 0x38,
  0xE5, 0x07, 0x90, 0x1F, 0x18, 0xD8, 0x6C, 0x3C, 0xF7, 0xE3, 0x01, 0x80,
  0xC0, 0x31, 0x0F, 0x80, 0x01, 0xE0, 0x74, 0x0C, 0x01, 0x00, 0x64, 0x3F,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x78, 0x0E, 0x00, 0x1F, 0x66, 0x39,
  0x83, 0x30, 0x6C, 0x0D, 0x83, 0x30, 0x66, 0x0C, 0xC3, 0x9D, 0xA1, 0xEC,
  0x01, 0x80, 0x30, 0x0C, 0x3F, 0x87, 0xC0, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0D, 0xE2, 0x8D, 0xC3, 0x60, 0xD8, 0x36, 0x09, 0x06, 0xC1, 0xB0,
  0x6C, 0x1B, 0x0C, 0x38, 0x80, 0x03, 0x11, 0x8C, 0x63, 0x11, 0x8C, 0x63,
  0x00, 0x03, 0x80, 0x80, 0x00, 0x00, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x3C, 0x1E, 0x00,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x72, 0x31, 0x98, 0x6C, 0x1E,
  0x07, 0xC1, 0xB0, 0xC6, 0x31, 0x8C, 0x63, 0x0C, 0x18, 0xCC, 0x63, 0x18,
  0x8C, 0x63, 0x18, 0x8C, 0x63, 0x18, 0x37, 0x9F, 0x28, 0xB3, 0x70, 0xE3,
  0x60, 0xC3, 0x61, 0x83, 0x61, 0x83, 0x41, 0x82, 0xC1, 0x86, 0xC1, 0x06,
  0xC3, 0x06, 0xC3, 0x06, 0x08, 0x82, 0x7C, 0x51, 0x9C, 0x33, 0x06, 0x60,
  0xCC, 0x1B, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x70, 0xC0, 0x1F, 0x0C, 0x66,
  0x0D, 0x83, 0xC0, 0xF0, 0x3C, 0x0B, 0x06, 0xC1, 0x99, 0xC3, 0xE0, 0x1B,
  0xC2, 0x8C, 0xE1, 0x98, 0x33, 0x06, 0x60, 0xC8, 0x1B, 0x06, 0x70, 0xCF,
  0x71, 0xBC, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x1F, 0x66, 0x39,
  0x83, 0x30, 0x6C, 0x0D, 0x83, 0x30, 0x66, 0x0C, 0xC3, 0x9D, 0xA1, 0xEC,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x37, 0x28, 0x70, 0x60, 0x60,
  0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x98, 0x98, 0x06, 0x03, 0x80,
  0xE0, 0x18, 0x06, 0x03, 0x63, 0x3F, 0x00, 0x10, 0x20, 0xC7, 0xF2, 0x0C,
  0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x8F, 0x00, 0x30, 0x6C, 0x19, 0x83,
  0x30, 0x66, 0x0C, 0xC3, 0x30, 0x66, 0x0C, 0xC3, 0x9D, 0xA1, 0xE4, 0x00,
  0xC1, 0xF0, 0x6C, 0x33, 0x0C, 0x46, 0x11, 0x86, 0xC1, 0xB0, 0x78, 0x1E,
  0x07, 0x00, 0xC3, 0x87, 0x87, 0x1B, 0x1E, 0x36, 0x2C, 0xCC, 0xD9, 0x99,
  0x36, 0x36, 0x6C, 0x28, 0xD0, 0x51, 0xE0, 0xE3, 0x81, 0x83, 0x00, 0x18,
  0x71, 0x8C, 0x0D, 0x80, 0xD8, 0x07, 0x00, 0x60, 0x0F, 0x01, 0xB0, 0x31,
  0x07, 0x18, 0xE0, 0xC0, 0x18, 0x38, 0xC1, 0x86, 0x18, 0x10, 0xC0, 0x8C,
  0x06, 0x60, 0x36, 0x01, 0xB0, 0x0F, 0x00, 0x78, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x02, 0xE0, 0x1E, 0x00, 0x3F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x60, 0x3F, 0x80, 0x03, 0x07, 0x0C, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x70, 0xE0, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x30,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x1E, 0x06, 0x06, 0x06,
  0x04, 0x0C, 0x04, 0x07, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30,
  0xE0, 0x38, 0x7F, 0xF8, 0x3C,
};

const GFXglyph NotoSans_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 7, 5, 8, 2, -15 },
  { 18, 13, 15, 14, 1, -15 },
  { 43, 10, 17, 12, 1, -16 },
  { 65, 14, 15, 17, 2, -15 },
  { 92, 13, 15, 14, 1, -15 },
  { 117, 3, 5, 5, 2, -15 },
  { 119, 7, 18, 6, 1, -15 },
  { 135, 7, 18, 6, -2, -15 },
  { 151, 10, 10, 12, 2, -16 },
  { 164, 10, 11, 12, 1, -13 },
  { 178, 4, 5, 5, -1, -2 },
  { 181, 5, 1, 7, 1, -6 },
  { 182, 3, 3, 5, 0, -3 },
  { 184, 10, 15, 7, -1, -15 },
  { 203, 10, 15, 12, 1, -15 },
  { 222, 6, 15, 12, 3, -15 },
  { 234, 11, 15, 12, 0, -15 },
  { 255, 11, 15, 12, 0, -15 },
  { 276, 11, 15, 12, 0, -15 },
  { 297, 10, 15, 12, 1, -15 },
  { 316, 10, 15, 12, 1, -15 },
  { 335, 10, 15, 12, 2, -15 },
  { 354, 10, 15, 12, 1, -15 },
  { 373, 10, 15, 12, 1, -15 },
  { 392, 5, 12, 5, 0, -12 },
  { 400, 6, 15, 5, -1, -12 },
  { 412, 10, 11, 12, 1, -13 },
  { 426, 9, 5, 12, 2, -10 },
  { 432, 10, 11, 12, 1, -13 },
  { 446, 8, 15, 9, 2, -15 },
  { 461, 16, 17, 18, 1, -15 },
  { 495, 12, 15, 12, -1, -15 },
  { 518, 11, 15, 13, 1, -15 },
  { 539, 11, 15, 12, 2, -15 },
  { 560, 12, 15, 14, 1, -15 },
  { 583, 11, 15, 11, 1, -15 },
  { 604, 11, 15, 10, 1, -15 },
  { 625, 12, 15, 14, 2, -15 },
  { 648, 13, 15, 14, 1, -15 },
  { 673, 8, 15, 7, 0, -15 },
  { 688, 9, 19, 6, -3, -15 },
  { 710, 13, 15, 12, 1, -15 },
  { 735, 8, 15, 10, 1, -15 },
  { 750, 17, 15, 18, 1, -15 },
  { 782, 14, 15, 15, 1, -15 },
  { 809, 12, 15, 15, 2, -15 },
  { 832, 11, 15, 12, 1, -15 },
  { 853, 12, 19, 15, 2, -15 },
  { 882, 11, 15, 12, 1, -15 },
  { 903, 11, 15, 11, 0, -15 },
  { 924, 10, 15, 11, 2, -15 },
  { 943, 12, 15, 14, 2, -15 },
  { 966, 12, 15, 12, 2, -15 },
  { 989, 18, 15, 18, 2, -15 },
  { 1023, 14, 15, 11, -1, -15 },
  { 1050, 11, 15, 11, 2, -15 },
  { 1071, 12, 15, 11, 0, -15 },
  { 1094, 8, 18, 6, 0, -15 },
  { 1112, 4, 15, 7, 2, -15 },
  { 1120, 8, 18, 6, -2, -15 },
  { 1138, 10, 9, 12, 1, -15 },
  { 1150, 9, 1, 8, -2, 2 },
  { 1152, 4, 3, 6, 3, -16 },
  { 1154, 11, 11, 12, 1, -11 },
  { 1170, 10, 16, 12, 1, -16 },
  { 1190, 9, 11, 10, 1, -11 },
  { 1203, 12, 16, 12, 1, -16 },
  { 1227, 9, 11, 10, 1, -11 },
  { 1240, 11, 21, 7, -2, -16 },
  { 1269, 11, 16, 12, 1, -11 },
  { 1291, 10, 16, 12, 1, -16 },
  { 1311, 5, 15, 5, 1, -15 },
  { 1321, 9, 20, 5, -3, -15 },
  { 1344, 10, 16, 10, 1, -16 },
  { 1364, 5, 16, 5, 1, -16 },
  { 1374, 16, 11, 18, 1, -11 },
  { 1396, 11, 12, 12, 0, -12 },
  { 1413, 10, 11, 12, 1, -11 },
  { 1427, 11, 16, 12, 0, -11 },
  { 1449, 11, 16, 12, 1, -11 },
  { 1471, 8, 11, 8, 1, -11 },
  { 1482, 9, 11, 9, 0, -11 },
  { 1495, 7, 14, 7, 1, -14 },
  { 1508, 11, 11, 12, 1, -11 },
  { 1524, 10, 11, 10, 1, -11 },
  { 1538, 15, 11, 15, 1, -11 },
  { 1559, 12, 11, 10, -1, -11 },
  { 1576, 13, 16, 10, -2, -11 },
  { 1602, 9, 11, 9, 0, -11 },
  { 1615, 8, 18, 7, 0, -15 },
  { 1633, 2, 21, 12, 5, -16 },
  { 1639, 8, 18, 7, -1, -15 },
  { 1657, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_Italic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_ITALIC21PT7B_H_
