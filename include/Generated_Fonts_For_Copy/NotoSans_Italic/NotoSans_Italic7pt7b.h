#ifndef _NOTOSANS_ITALIC7PT7B_H_
#define _NOTOSANS_ITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xE0, 0x33, 0xD5, 0xE6, 0x00, 0x74, 0x66, 0xC0, 0xDE,
  0xF7, 0xB0, 0x72, 0x9B, 0x6F, 0x00, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x95,
  0x80, 0xCF, 0x00, 0x2F, 0x20, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x75, 0x99,
  0x60, 0x75, 0x80, 0x71, 0x24, 0xE0, 0x71, 0x62, 0xE0, 0x12, 0x6F, 0x20,
  0x74, 0x61, 0xE0, 0x34, 0x79, 0x60, 0xE9, 0x48, 0x75, 0x69, 0xE0, 0x79,
  0x72, 0xE0, 0x42, 0x42, 0x80, 0x3C, 0x30, 0xE0, 0xC3, 0xE0, 0xDA, 0x80,
  0x39, 0x5B, 0x75, 0xA9, 0xC0, 0x26, 0x69, 0x90, 0x75, 0x69, 0xE0, 0x34,
  0x88, 0x70, 0x75, 0x59, 0xE0, 0x74, 0x68, 0xE0, 0x74, 0x68, 0x80, 0x3A,
  0x25, 0x27, 0x00, 0x4A, 0x5D, 0x29, 0x00, 0x69, 0x2C, 0x24, 0xA5, 0x80,
  0x5B, 0x19, 0x49, 0x00, 0x49, 0x4E, 0x45, 0x37, 0x6E, 0xA8, 0x4B, 0x5B,
  0x69, 0x00, 0x32, 0x63, 0x17, 0x00, 0x75, 0x78, 0x80, 0x32, 0x63, 0x17,
  0x08, 0x75, 0x6A, 0x90, 0x74, 0x62, 0xE0, 0xEA, 0x48, 0x99, 0xAA, 0xE0,
  0xBA, 0xCC, 0x80, 0xA7, 0xAE, 0xA4, 0x90, 0x56, 0x46, 0xA0, 0xBA, 0x48,
  0x72, 0x44, 0xE0, 0x6A, 0x49, 0x00, 0xF8, 0x24, 0x95, 0x80, 0x46, 0x90,
  0xE0, 0x80, 0x79, 0x9E, 0x46, 0x59, 0xE0, 0x72, 0x70, 0x17, 0x99, 0xE0,
  0x77, 0x70, 0x37, 0x24, 0x44, 0x80, 0x79, 0x9E, 0x2C, 0x46, 0x59, 0xA0,
  0x56, 0x80, 0x24, 0xA4, 0xA0, 0x45, 0x6A, 0xA0, 0x56, 0x80, 0x6D, 0x5A,
  0x6A, 0x75, 0x9A, 0x69, 0x96, 0x65, 0x9E, 0x88, 0x79, 0x9E, 0x22, 0x6A,
  0x40, 0x71, 0xE0, 0x5D, 0x4C, 0x59, 0x9E, 0x9A, 0xA4, 0xAD, 0x74, 0xA0,
  0xB6, 0x4A, 0x4A, 0x94, 0x44, 0x60, 0x65, 0x60, 0x29, 0x69, 0x80, 0xFE,
  0x55, 0xA0, 0xF0,
};

const GFXglyph NotoSans_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 4, 5, 6, 1, -5 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 1, 2, 2, 1, -5 },
  { 19, 3, 6, 2, 0, -5 },
  { 22, 3, 6, 2, -1, -5 },
  { 25, 3, 3, 4, 1, -5 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 1, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -2 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 3, 5, 2, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 2, 5, 4, 1, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 3, 5, 4, 1, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 4, 3, 4, 0, -4 },
  { 67, 3, 1, 4, 1, -3 },
  { 68, 4, 3, 4, 0, -4 },
  { 70, 2, 5, 3, 1, -5 },
  { 72, 6, 6, 6, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 5, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 3, 0, -5 },
  { 95, 5, 5, 5, 0, -5 },
  { 99, 5, 5, 5, 0, -5 },
  { 103, 3, 5, 2, 0, -5 },
  { 105, 3, 6, 2, -1, -5 },
  { 108, 5, 5, 4, 0, -5 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 6, 5, 6, 0, -5 },
  { 118, 5, 5, 5, 0, -5 },
  { 122, 5, 5, 5, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 5, 6, 5, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 3, 5, 4, 1, -5 },
  { 141, 4, 5, 5, 1, -5 },
  { 144, 4, 5, 4, 1, -5 },
  { 147, 6, 5, 6, 1, -5 },
  { 151, 4, 5, 4, 0, -5 },
  { 154, 3, 5, 4, 1, -5 },
  { 156, 4, 5, 4, 0, -5 },
  { 159, 3, 6, 2, 0, -5 },
  { 162, 1, 5, 2, 1, -5 },
  { 163, 3, 6, 2, -1, -5 },
  { 166, 4, 3, 4, 0, -5 },
  { 168, 3, 1, 3, -1, 0 },
  { 169, 1, 1, 2, 1, -5 },
  { 170, 4, 4, 4, 0, -4 },
  { 172, 4, 5, 4, 0, -5 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 4, 5, 4, 0, -5 },
  { 180, 3, 4, 4, 0, -4 },
  { 182, 4, 7, 2, -1, -5 },
  { 186, 4, 6, 4, 0, -4 },
  { 189, 4, 5, 4, 0, -5 },
  { 192, 2, 5, 2, 0, -5 },
  { 194, 3, 7, 2, -1, -5 },
  { 197, 4, 5, 3, 0, -5 },
  { 200, 2, 5, 2, 0, -5 },
  { 202, 6, 4, 6, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 6, 4, 0, -4 },
  { 212, 4, 6, 4, 0, -4 },
  { 215, 3, 4, 3, 0, -4 },
  { 217, 3, 4, 3, 0, -4 },
  { 219, 3, 5, 2, 0, -5 },
  { 221, 4, 4, 4, 0, -4 },
  { 223, 4, 4, 3, 0, -4 },
  { 225, 5, 4, 5, 0, -4 },
  { 228, 4, 4, 3, 0, -4 },
  { 230, 5, 6, 3, -1, -4 },
  { 234, 3, 4, 3, 0, -4 },
  { 236, 3, 6, 2, 0, -5 },
  { 239, 1, 7, 4, 2, -5 },
  { 240, 2, 6, 2, 0, -5 },
  { 242, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Italic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_ITALIC7PT7B_H_
