#ifndef _NOTOSANS_ITALIC41PT7B_H_
#define _NOTOSANS_ITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x10, 0x00, 0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0xF1, 0xE7, 0x0F, 0x38,
  0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xC7, 0x06, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x18,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xB7, 0xC0, 0xF3, 0x84, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86, 0x00,
  0x1C, 0x70, 0x00, 0xF3, 0x80, 0x07, 0xDC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1D, 0xE0, 0x00, 0xC7, 0x80,
  0x06, 0x3C, 0x00, 0x70, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x78, 0x80, 0xC7,
  0x87, 0x8E, 0x7C, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x20, 0xFE, 0x00, 0x1C, 0x1F, 0xF0, 0x03, 0x81, 0xC7, 0x80, 0x78,
  0x38, 0x38, 0x07, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03,
  0x83, 0xC0, 0x70, 0x38, 0x38, 0x07, 0x03, 0x87, 0x00, 0xE0, 0x70, 0xE0,
  0x0E, 0x07, 0x1E, 0x00, 0xE0, 0x71, 0xC7, 0x8E, 0x0E, 0x39, 0xFE, 0xE0,
  0xE7, 0x3F, 0xE7, 0x1C, 0xF7, 0x8F, 0x7F, 0xCE, 0x70, 0x73, 0xF1, 0xC7,
  0x07, 0x1E, 0x38, 0xE0, 0x70, 0x07, 0x8E, 0x07, 0x00, 0x70, 0xE0, 0x70,
  0x0E, 0x0E, 0x0F, 0x01, 0xC1, 0xC0, 0xE0, 0x3C, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x1C, 0x1C, 0x0E, 0x01, 0xE1, 0xC1, 0xE0, 0x0E, 0x78,
  0x1C, 0x00, 0xFF, 0x03, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0xF8, 0x00, 0x70, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xBC, 0x03,
  0x9F, 0x0F, 0x03, 0xCF, 0x07, 0x81, 0xCF, 0x01, 0xE1, 0xE7, 0x00, 0x79,
  0xE7, 0x80, 0x3F, 0xE3, 0xC0, 0x0F, 0xF1, 0xE0, 0x03, 0xF0, 0xF0, 0x01,
  0xF0, 0x3C, 0x01, 0xF8, 0x1F, 0x03, 0xFE, 0x0F, 0xFF, 0xE7, 0x83, 0xFF,
  0xE3, 0xE0, 0x7F, 0xC0, 0xF8, 0x3C, 0xE3, 0x9E, 0x71, 0xC7, 0x1C, 0x63,
  0x80, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x04, 0x07, 0x00, 0xE0, 0xE0, 0x3F, 0x98, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0x87, 0x83, 0xB8, 0x00,
  0xF3, 0x00, 0x3C, 0x70, 0x1F, 0x0E, 0x01, 0xC1, 0xE0, 0x18, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x0F, 0x1F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70,
  0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x20, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3E, 0x7E, 0x07, 0x81, 0xE0,
  0xF0, 0x1E, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0xF7, 0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x00, 0x78, 0x78,
  0x07, 0x87, 0x80, 0xF0, 0x7C, 0x1E, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF1, 0xFE, 0x7E, 0xEF, 0xDE, 0xF1,
  0xE6, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFE, 0xFE, 0x03, 0x80, 0x78,
  0x04, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xC7, 0xE0, 0x70, 0x0F, 0x01, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC4, 0x00, 0x3C, 0x38, 0x03, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00,
  0x07, 0x9C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x78,
  0x38, 0x03, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x78, 0x1C, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x08,
  0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x80, 0x0F, 0x8C, 0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFE, 0x30, 0x7E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x9F, 0xC0, 0xE7, 0xFE, 0x3F, 0xFF,
  0xC7, 0xE0, 0x3C, 0xF8, 0x07, 0x9E, 0x00, 0x73, 0xC0, 0x0F, 0x70, 0x01,
  0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x00, 0x3C, 0xF0, 0x07,
  0x1E, 0x01, 0xE1, 0xE0, 0x78, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0x3E,
  0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xCF, 0x80, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0x9F, 0x03, 0xE0, 0xF8, 0x78,
  0x07, 0x87, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0x78, 0x0F, 0x87, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x07, 0xE3, 0xE0, 0xF0, 0x3E, 0x3C, 0x03, 0xC7, 0x00, 0x39, 0xE0, 0x07,
  0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x1E,
  0x70, 0x03, 0xCF, 0x00, 0xF9, 0xF0, 0x7F, 0x1F, 0xFD, 0xE1, 0xFF, 0x38,
  0x1F, 0xCF, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC2, 0x01, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x02, 0x0F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xF8, 0xF8, 0xF8, 0xF0, 0x40, 0x00, 0x40, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7E, 0x7E, 0x30, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x03, 0xFE,
  0x0E, 0x3C, 0x0F, 0xFF, 0x0E, 0x38, 0x1F, 0x1E, 0x07, 0x38, 0x3C, 0x0E,
  0x07, 0x70, 0x38, 0x0E, 0x07, 0x70, 0x70, 0x1E, 0x07, 0x70, 0x70, 0x1C,
  0x07, 0xF0, 0xE0, 0x1C, 0x0E, 0xE0, 0xE0, 0x1C, 0x0E, 0xE0, 0xE0, 0x3C,
  0x0E, 0xE0, 0xE0, 0x38, 0x1E, 0xE0, 0xE0, 0x78, 0x1C, 0xE0, 0xE0, 0x78,
  0x3C, 0xE0, 0xF0, 0xDC, 0x78, 0xF0, 0x7F, 0x9F, 0xF0, 0x70, 0x7F, 0x0F,
  0xE0, 0x70, 0x0C, 0x03, 0x80, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38,
  0x00, 0x1C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xF0,
  0x03, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x3C, 0x00,
  0x1C, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xE0, 0x3F,
  0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x80, 0x7C, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0x01, 0xF0, 0x3C, 0x01, 0xE0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x70, 0x03, 0xE3, 0xC0, 0x3F,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3E, 0x00, 0xC0,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0x80, 0xFC,
  0x07, 0x80, 0x3E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F,
  0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x3E,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0,
  0x70, 0x07, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xE0, 0x06, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07,
  0xFE, 0xF0, 0x07, 0xFC, 0xF0, 0x07, 0xFC, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x70, 0x3F, 0x00, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x81,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07,
  0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x01,
  0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x37, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x83,
  0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00,
  0x38, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x0F, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0E,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3B, 0x80, 0x07, 0x70, 0x3D,
  0xC0, 0x07, 0xB8, 0x1E, 0xE0, 0x03, 0xBC, 0x0E, 0x70, 0x03, 0xDE, 0x07,
  0x38, 0x01, 0xCF, 0x03, 0x9C, 0x01, 0xC7, 0x03, 0xCE, 0x00, 0xE3, 0x81,
  0xE7, 0x80, 0xE3, 0xC0, 0xE1, 0xC0, 0xF1, 0xE0, 0x70, 0xE0, 0x70, 0xF0,
  0x78, 0x70, 0x78, 0x70, 0x3C, 0x38, 0x38, 0x78, 0x1E, 0x1C, 0x3C, 0x3C,
  0x0E, 0x0E, 0x1C, 0x1E, 0x07, 0x07, 0x1E, 0x0F, 0x07, 0x83, 0x8E, 0x07,
  0x03, 0xC1, 0xEE, 0x07, 0x81, 0xC0, 0x77, 0x03, 0xC0, 0xE0, 0x3F, 0x01,
  0xE0, 0x70, 0x1F, 0x80, 0xE0, 0x78, 0x0F, 0x80, 0x70, 0x3C, 0x07, 0xC0,
  0x78, 0x1C, 0x03, 0xC0, 0x3C, 0x0E, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x07, 0x83, 0xF0, 0x00, 0xE0,
  0x7F, 0x00, 0x1C, 0x0F, 0xE0, 0x07, 0x83, 0xDC, 0x00, 0xF0, 0x7B, 0xC0,
  0x1E, 0x0E, 0x78, 0x03, 0x81, 0xC7, 0x00, 0x70, 0x38, 0xF0, 0x1E, 0x0F,
  0x0E, 0x03, 0xC1, 0xE1, 0xC0, 0x70, 0x38, 0x3C, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0x78, 0x78, 0x3C, 0x0F, 0x0F, 0x07, 0x80, 0xE1, 0xC0, 0xE0,
  0x1E, 0x38, 0x1C, 0x01, 0xC7, 0x07, 0x80, 0x39, 0xE0, 0xF0, 0x07, 0xBC,
  0x1C, 0x00, 0x77, 0x03, 0x80, 0x0F, 0xE0, 0x70, 0x01, 0xFC, 0x1E, 0x00,
  0x1F, 0x83, 0xC0, 0x03, 0xF0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7E, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7B, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0x03, 0xE0, 0x78, 0x07, 0x83,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03,
  0xC3, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x01, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7E, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x0F, 0xC0, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0x03, 0xF0, 0x78, 0x07,
  0x83, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x70,
  0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x07, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0x80, 0x70, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x1C, 0x0F,
  0x00, 0xF0, 0x70, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x8E, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0x80, 0x60, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x88, 0x00, 0xF8, 0xC0, 0x3F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01,
  0xE1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00,
  0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x1E, 0x07, 0x00, 0x78, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x38,
  0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0,
  0x00, 0xE7, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x79, 0xC0, 0x0F, 0xC0, 0x0E,
  0x38, 0x01, 0xF8, 0x03, 0xC7, 0x00, 0x77, 0x00, 0x70, 0xE0, 0x0E, 0xE0,
  0x1E, 0x1C, 0x03, 0xDC, 0x03, 0xC3, 0x80, 0x73, 0x80, 0xF0, 0x70, 0x0E,
  0x70, 0x1E, 0x0E, 0x03, 0x8E, 0x03, 0x81, 0xC0, 0x71, 0xC0, 0xF0, 0x38,
  0x1C, 0x38, 0x1C, 0x07, 0x03, 0x87, 0x07, 0x80, 0xE0, 0xF0, 0xE0, 0xE0,
  0x1C, 0x1C, 0x1C, 0x3C, 0x03, 0xC7, 0x83, 0x87, 0x80, 0x78, 0xE0, 0x71,
  0xE0, 0x0F, 0x3C, 0x0E, 0x3C, 0x01, 0xE7, 0x01, 0xC7, 0x00, 0x3D, 0xE0,
  0x39, 0xE0, 0x07, 0xB8, 0x07, 0x38, 0x00, 0xF7, 0x00, 0xE7, 0x00, 0x1F,
  0xC0, 0x1D, 0xC0, 0x03, 0xB8, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00,
  0x78, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00,
  0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0x3C, 0x00, 0x78, 0xE0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC0,
  0xE0, 0x3C, 0x07, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x1E,
  0x00, 0x38, 0xF0, 0x01, 0xCF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x04, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xF0, 0x70,
  0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F,
  0x0F, 0x07, 0x07, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xB8, 0x00, 0x73, 0x80, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x38, 0x03, 0x83, 0x80, 0x3C,
  0x70, 0x01, 0xC7, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0xF1, 0xE1, 0xC1, 0xC1, 0xC0, 0x01, 0xFC, 0x38,
  0x3F, 0xF3, 0x83, 0xFF, 0xDC, 0x3E, 0x07, 0xE1, 0xE0, 0x3F, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C,
  0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0xFC, 0x3E, 0x0F, 0xE0, 0xFF,
  0xEE, 0x03, 0xFE, 0x70, 0x0F, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0xFE, 0x03, 0xCF, 0xF8,
  0x1E, 0xFF, 0xE0, 0xEE, 0x0F, 0x07, 0xE0, 0x38, 0x3E, 0x01, 0xE3, 0xE0,
  0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xE3,
  0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xFC, 0x0F, 0x07, 0x7F, 0xF8, 0x71,
  0xFF, 0x03, 0x87, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC3,
  0xE0, 0x21, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xF1, 0xC0, 0x7F, 0xE7, 0x03, 0xFF,
  0xDC, 0x1F, 0x03, 0xF0, 0x78, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07,
  0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF8, 0x3E, 0x0F, 0xE0, 0x7F, 0xF7, 0x00,
  0xFF, 0x9C, 0x01, 0xF8, 0x70, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xE0, 0xF1, 0xE0, 0x39, 0xE0, 0x1C, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x1F, 0x3B, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0x8F, 0xFF,
  0xC3, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x11, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFE, 0x1C, 0x0F, 0xFC, 0xE0, 0x7F, 0xFB, 0x83,
  0xE0, 0x7E, 0x0F, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78,
  0x07, 0xC1, 0xE0, 0x3F, 0x07, 0xC1, 0xFC, 0x0F, 0xFE, 0xE0, 0x1F, 0xF3,
  0x80, 0x3F, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x20, 0x07, 0x80, 0xF0, 0x7C, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x71, 0xFC, 0x0F, 0x3F, 0xE0, 0xF7,
  0xFF, 0x0E, 0xE0, 0xF0, 0xFC, 0x07, 0x0F, 0x80, 0x71, 0xF0, 0x07, 0x1F,
  0x00, 0x71, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x3C, 0x00, 0xE3,
  0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1C,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x03,
  0x80, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x9F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x07, 0xC3, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x07, 0x80,
  0x38, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x80, 0x07, 0x78,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x07, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0xE0, 0x1E, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x00,
  0x07, 0x1F, 0xC0, 0xFE, 0x03, 0x9F, 0xF1, 0xFF, 0x83, 0xDF, 0xF9, 0xFF,
  0xC1, 0xDC, 0x1D, 0xE1, 0xE0, 0xFC, 0x0F, 0xC0, 0x78, 0x7C, 0x07, 0xC0,
  0x3C, 0x7C, 0x03, 0xE0, 0x1E, 0x3C, 0x01, 0xE0, 0x0E, 0x1E, 0x00, 0xF0,
  0x07, 0x0F, 0x00, 0x70, 0x07, 0x87, 0x00, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x00, 0xE1, 0xE0, 0x0E, 0x00, 0xF0, 0xE0, 0x0F,
  0x00, 0x78, 0x70, 0x07, 0x80, 0x3C, 0x78, 0x03, 0xC0, 0x1C, 0x3C, 0x01,
  0xC0, 0x0E, 0x1E, 0x00, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x38, 0xFF,
  0x03, 0xCF, 0xFC, 0x1E, 0xFF, 0xE0, 0xFE, 0x0F, 0x07, 0xE0, 0x3C, 0x7E,
  0x01, 0xE3, 0xE0, 0x0E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0x81, 0xE1, 0xE0, 0x1E, 0x78, 0x03, 0xCE, 0x00,
  0x7B, 0xC0, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07,
  0x8F, 0x01, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x01, 0xC3, 0xF0, 0x03, 0x9F, 0xF0, 0x0E, 0x7F, 0xF0, 0x1D, 0xC1,
  0xE0, 0x3F, 0x01, 0xC0, 0x7C, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x78, 0x00, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7E, 0x07, 0x80, 0xEF, 0xFF, 0x03, 0xCF,
  0xF8, 0x07, 0x8F, 0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x38,
  0x3F, 0xF3, 0x83, 0xFF, 0xDC, 0x3E, 0x07, 0xE1, 0xE0, 0x3F, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C,
  0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0xFC, 0x3E, 0x0F, 0xE0, 0xFF,
  0xEE, 0x03, 0xFE, 0x70, 0x0F, 0xC7, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x1F, 0x83,
  0x9F, 0x83, 0xDF, 0xC1, 0xDC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0xC3, 0xC0, 0x61, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x30, 0x0F,
  0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x38,
  0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x80, 0x3C,
  0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87,
  0x80, 0xFC, 0x3C, 0x0F, 0xE0, 0xFF, 0xEE, 0x07, 0xFE, 0x70, 0x1F, 0xC3,
  0x80, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00,
  0x78, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0xF0, 0x70, 0x1E, 0x0F, 0x07,
  0x81, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0x71, 0xE0, 0x0E, 0x38,
  0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C,
  0x03, 0xFC, 0x07, 0xE0, 0x3D, 0xE0, 0x3F, 0x01, 0xE7, 0x01, 0xF8, 0x1E,
  0x38, 0x1D, 0xC0, 0xF1, 0xC0, 0xEE, 0x0F, 0x0E, 0x0E, 0x70, 0x78, 0x70,
  0x73, 0x83, 0x83, 0x87, 0x1C, 0x3C, 0x1C, 0x38, 0xE1, 0xC0, 0xE3, 0x87,
  0x1E, 0x07, 0x1C, 0x38, 0xE0, 0x39, 0xC1, 0xCF, 0x01, 0xCE, 0x0E, 0x78,
  0x0E, 0xF0, 0x73, 0x80, 0x77, 0x03, 0xBC, 0x03, 0xB8, 0x1D, 0xC0, 0x1F,
  0x80, 0x6E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x0E,
  0x07, 0x80, 0x1E, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xE7, 0x80,
  0x07, 0x87, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x01,
  0xE0, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x7F,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xF8,
};

const GFXglyph NotoSans_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 30, 11, 1, -29 },
  { 39, 13, 10, 16, 4, -29 },
  { 56, 26, 29, 26, 1, -29 },
  { 151, 21, 33, 23, 1, -31 },
  { 238, 28, 30, 33, 3, -30 },
  { 343, 25, 30, 28, 1, -30 },
  { 437, 6, 10, 9, 4, -29 },
  { 445, 13, 35, 12, 2, -29 },
  { 502, 13, 35, 12, -3, -29 },
  { 559, 19, 19, 23, 4, -31 },
  { 605, 19, 19, 23, 3, -24 },
  { 651, 8, 10, 11, -2, -5 },
  { 661, 10, 4, 13, 1, -13 },
  { 666, 5, 6, 11, 1, -5 },
  { 670, 20, 29, 15, -2, -29 },
  { 743, 20, 30, 23, 2, -30 },
  { 818, 12, 29, 23, 6, -29 },
  { 862, 22, 30, 23, 0, -30 },
  { 945, 21, 30, 23, 1, -30 },
  { 1024, 22, 29, 23, 0, -29 },
  { 1104, 20, 29, 23, 2, -29 },
  { 1177, 19, 30, 23, 3, -30 },
  { 1249, 20, 29, 23, 3, -29 },
  { 1322, 20, 30, 23, 2, -30 },
  { 1397, 19, 30, 23, 2, -30 },
  { 1469, 8, 24, 11, 1, -23 },
  { 1493, 11, 28, 11, -2, -23 },
  { 1532, 19, 20, 23, 3, -25 },
  { 1580, 19, 11, 23, 3, -20 },
  { 1607, 19, 20, 23, 3, -25 },
  { 1655, 16, 31, 18, 3, -30 },
  { 1717, 32, 33, 35, 2, -29 },
  { 1849, 23, 29, 23, -2, -29 },
  { 1933, 22, 29, 25, 2, -29 },
  { 2013, 23, 30, 24, 3, -30 },
  { 2100, 24, 29, 27, 2, -29 },
  { 2187, 21, 29, 21, 2, -29 },
  { 2264, 21, 29, 20, 2, -29 },
  { 2341, 24, 30, 28, 3, -30 },
  { 2431, 26, 29, 28, 2, -29 },
  { 2526, 17, 29, 13, -1, -29 },
  { 2588, 18, 37, 11, -6, -29 },
  { 2672, 25, 29, 23, 2, -29 },
  { 2763, 15, 29, 20, 2, -29 },
  { 2818, 33, 29, 34, 2, -29 },
  { 2938, 27, 29, 29, 2, -29 },
  { 3036, 25, 30, 30, 3, -30 },
  { 3130, 21, 29, 23, 2, -29 },
  { 3207, 25, 37, 30, 3, -30 },
  { 3323, 21, 29, 24, 2, -29 },
  { 3400, 20, 30, 21, 1, -30 },
  { 3475, 20, 29, 21, 4, -29 },
  { 3548, 25, 29, 28, 3, -29 },
  { 3639, 22, 29, 23, 4, -29 },
  { 3719, 35, 29, 35, 4, -29 },
  { 3846, 27, 29, 22, -2, -29 },
  { 3944, 21, 29, 21, 4, -29 },
  { 4021, 24, 29, 22, 0, -29 },
  { 4108, 15, 35, 12, 0, -29 },
  { 4174, 8, 29, 15, 4, -29 },
  { 4203, 16, 35, 12, -3, -29 },
  { 4273, 20, 18, 23, 2, -29 },
  { 4318, 17, 2, 16, -4, 4 },
  { 4323, 7, 6, 11, 6, -31 },
  { 4329, 21, 22, 23, 2, -22 },
  { 4387, 21, 31, 24, 1, -31 },
  { 4469, 17, 22, 19, 2, -22 },
  { 4516, 22, 31, 24, 2, -31 },
  { 4602, 17, 22, 20, 2, -22 },
  { 4649, 23, 41, 13, -5, -31 },
  { 4767, 22, 32, 24, 1, -22 },
  { 4855, 20, 31, 24, 1, -31 },
  { 4933, 10, 30, 11, 1, -30 },
  { 4971, 16, 40, 11, -5, -30 },
  { 5051, 21, 31, 20, 1, -31 },
  { 5133, 10, 31, 11, 1, -31 },
  { 5172, 33, 22, 36, 1, -22 },
  { 5263, 21, 23, 24, 1, -23 },
  { 5324, 19, 22, 23, 2, -22 },
  { 5377, 23, 32, 24, -1, -22 },
  { 5469, 21, 32, 24, 2, -22 },
  { 5553, 17, 22, 16, 1, -22 },
  { 5600, 17, 22, 18, 0, -22 },
  { 5647, 13, 27, 14, 2, -27 },
  { 5691, 21, 22, 24, 2, -22 },
  { 5749, 19, 22, 19, 2, -22 },
  { 5802, 29, 22, 30, 2, -22 },
  { 5882, 23, 22, 20, -2, -22 },
  { 5946, 25, 32, 19, -4, -22 },
  { 6046, 19, 22, 18, -1, -22 },
  { 6099, 16, 35, 14, 0, -29 },
  { 6169, 3, 41, 23, 11, -31 },
  { 6185, 16, 35, 14, -2, -29 },
  { 6255, 19, 5, 23, 3, -17 },
};

const GFXfont NotoSans_Italic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_ITALIC41PT7B_H_
