#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Italic
// Headers: 67

#include "NotoSans_Italic6pt7b.h"
#include "NotoSans_Italic7pt7b.h"
#include "NotoSans_Italic8pt7b.h"
#include "NotoSans_Italic9pt7b.h"
#include "NotoSans_Italic10pt7b.h"
#include "NotoSans_Italic11pt7b.h"
#include "NotoSans_Italic12pt7b.h"
#include "NotoSans_Italic13pt7b.h"
#include "NotoSans_Italic14pt7b.h"
#include "NotoSans_Italic15pt7b.h"
#include "NotoSans_Italic16pt7b.h"
#include "NotoSans_Italic17pt7b.h"
#include "NotoSans_Italic18pt7b.h"
#include "NotoSans_Italic19pt7b.h"
#include "NotoSans_Italic20pt7b.h"
#include "NotoSans_Italic21pt7b.h"
#include "NotoSans_Italic22pt7b.h"
#include "NotoSans_Italic23pt7b.h"
#include "NotoSans_Italic24pt7b.h"
#include "NotoSans_Italic25pt7b.h"
#include "NotoSans_Italic26pt7b.h"
#include "NotoSans_Italic27pt7b.h"
#include "NotoSans_Italic28pt7b.h"
#include "NotoSans_Italic29pt7b.h"
#include "NotoSans_Italic30pt7b.h"
#include "NotoSans_Italic31pt7b.h"
#include "NotoSans_Italic32pt7b.h"
#include "NotoSans_Italic33pt7b.h"
#include "NotoSans_Italic34pt7b.h"
#include "NotoSans_Italic35pt7b.h"
#include "NotoSans_Italic36pt7b.h"
#include "NotoSans_Italic37pt7b.h"
#include "NotoSans_Italic38pt7b.h"
#include "NotoSans_Italic39pt7b.h"
#include "NotoSans_Italic40pt7b.h"
#include "NotoSans_Italic41pt7b.h"
#include "NotoSans_Italic42pt7b.h"
#include "NotoSans_Italic43pt7b.h"
#include "NotoSans_Italic44pt7b.h"
#include "NotoSans_Italic45pt7b.h"
#include "NotoSans_Italic46pt7b.h"
#include "NotoSans_Italic47pt7b.h"
#include "NotoSans_Italic48pt7b.h"
#include "NotoSans_Italic49pt7b.h"
#include "NotoSans_Italic50pt7b.h"
#include "NotoSans_Italic51pt7b.h"
#include "NotoSans_Italic52pt7b.h"
#include "NotoSans_Italic53pt7b.h"
#include "NotoSans_Italic54pt7b.h"
#include "NotoSans_Italic55pt7b.h"
#include "NotoSans_Italic56pt7b.h"
#include "NotoSans_Italic57pt7b.h"
#include "NotoSans_Italic58pt7b.h"
#include "NotoSans_Italic59pt7b.h"
#include "NotoSans_Italic60pt7b.h"
#include "NotoSans_Italic61pt7b.h"
#include "NotoSans_Italic62pt7b.h"
#include "NotoSans_Italic63pt7b.h"
#include "NotoSans_Italic64pt7b.h"
#include "NotoSans_Italic65pt7b.h"
#include "NotoSans_Italic66pt7b.h"
#include "NotoSans_Italic67pt7b.h"
#include "NotoSans_Italic68pt7b.h"
#include "NotoSans_Italic69pt7b.h"
#include "NotoSans_Italic70pt7b.h"
#include "NotoSans_Italic71pt7b.h"
#include "NotoSans_Italic72pt7b.h"
