#ifndef _NOTOSANS_ITALIC17PT7B_H_
#define _NOTOSANS_ITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x8C, 0x63, 0x10, 0x84, 0x60, 0x11, 0x80, 0xDE, 0xE5, 0x20,
  0x08, 0x82, 0x61, 0x91, 0xFF, 0x7F, 0xC4, 0x82, 0x23, 0xFE, 0x24, 0x19,
  0x04, 0x41, 0x30, 0x04, 0x0C, 0x3F, 0x68, 0x48, 0x68, 0x38, 0x1C, 0x16,
  0x16, 0x94, 0xF8, 0x20, 0x20, 0x38, 0x64, 0xC4, 0x4C, 0x8C, 0x98, 0xCB,
  0x0D, 0xAF, 0x75, 0x90, 0xD1, 0x09, 0x31, 0x12, 0x21, 0x26, 0x1C, 0x1E,
  0x0C, 0xC2, 0x30, 0x8C, 0x3C, 0x0E, 0x06, 0x8F, 0x32, 0x87, 0xA0, 0xCC,
  0x71, 0xE6, 0xFA, 0x19, 0x88, 0xC4, 0x63, 0x10, 0x84, 0x21, 0x08, 0x61,
  0x00, 0x10, 0xC2, 0x10, 0x84, 0x21, 0x18, 0x84, 0x66, 0x22, 0x00, 0x08,
  0x18, 0xD0, 0x7F, 0x33, 0x68, 0xC8, 0x0C, 0x08, 0x08, 0x08, 0xFF, 0xFF,
  0x08, 0x08, 0x08, 0x36, 0x4C, 0xF8, 0x70, 0x01, 0x81, 0x80, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x18, 0x00, 0x1E, 0x33, 0x63,
  0x41, 0xC1, 0xC3, 0xC3, 0x83, 0x82, 0xC6, 0xCC, 0x78, 0x1C, 0xEF, 0x86,
  0x18, 0x41, 0x0C, 0x30, 0x82, 0x18, 0x1F, 0x18, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x1F, 0xE0, 0x3F, 0x08, 0xC0, 0x60,
  0x30, 0x30, 0xF0, 0x18, 0x06, 0x03, 0x01, 0xA1, 0x9F, 0x80, 0x01, 0x81,
  0xC1, 0x41, 0xA1, 0x91, 0x98, 0x8C, 0x84, 0xFF, 0x83, 0x01, 0x80, 0x80,
  0x3F, 0x20, 0x20, 0x60, 0x60, 0x7C, 0x06, 0x02, 0x02, 0x06, 0x8C, 0xF8,
  0x0F, 0x30, 0x20, 0x60, 0x4C, 0xFE, 0xC2, 0xC3, 0xC2, 0xC2, 0xC6, 0x7C,
  0x7F, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18,
  0x18, 0x00, 0x1F, 0x33, 0x21, 0x23, 0x36, 0x1C, 0x6C, 0xC6, 0x82, 0x82,
  0xC6, 0x7C, 0x3E, 0x63, 0x43, 0x43, 0xC3, 0x43, 0x7E, 0x12, 0x06, 0x04,
  0x8C, 0xF0, 0x33, 0x00, 0x00, 0x04, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x06,
  0x62, 0x30, 0x01, 0x06, 0x18, 0x60, 0xE0, 0x38, 0x07, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0x1C, 0x70, 0x80, 0x7C, 0x8C,
  0x18, 0x30, 0xC3, 0x0C, 0x30, 0x40, 0x01, 0x06, 0x00, 0x07, 0xE0, 0xC1,
  0x88, 0x04, 0x87, 0x14, 0xCC, 0xC4, 0x46, 0x62, 0x32, 0x33, 0x91, 0x94,
  0x77, 0x30, 0x00, 0xC0, 0x03, 0xF8, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x78,
  0x16, 0x0D, 0x82, 0x61, 0x88, 0xFE, 0x30, 0x98, 0x24, 0x0F, 0x03, 0x3F,
  0x10, 0xC8, 0x6C, 0x36, 0x13, 0xF1, 0x0C, 0x82, 0xC1, 0x61, 0xB1, 0x9F,
  0x80, 0x0F, 0xCE, 0x13, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x10, 0x06, 0x10, 0xFC, 0x3F, 0x08, 0x62, 0x09, 0x83, 0x60, 0xD8, 0x34,
  0x0D, 0x02, 0xC1, 0xB0, 0xCC, 0xE3, 0xF0, 0x3F, 0x20, 0x20, 0x60, 0x60,
  0x7E, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xFC, 0x3F, 0x20, 0x20, 0x60, 0x60,
  0x60, 0x7E, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x0F, 0xCE, 0x13, 0x01, 0x80,
  0x40, 0x30, 0x1C, 0x7B, 0x02, 0xC0, 0x90, 0x66, 0x18, 0xFC, 0x30, 0x64,
  0x08, 0x81, 0x10, 0x66, 0x0C, 0xFF, 0x10, 0x22, 0x04, 0xC1, 0x98, 0x33,
  0x04, 0x40, 0x80, 0x3C, 0x61, 0x84, 0x10, 0xC3, 0x08, 0x20, 0x86, 0x3C,
  0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0xF0, 0x30, 0xC8, 0x42, 0x21, 0x90, 0x68, 0x1E, 0x06, 0x81,
  0x30, 0xC4, 0x31, 0x8C, 0x62, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x84, 0x10,
  0xC3, 0x0C, 0x3F, 0x30, 0x19, 0xC1, 0xCE, 0x0E, 0xD0, 0xB6, 0x8D, 0x24,
  0x49, 0x26, 0xC9, 0x26, 0xCB, 0x36, 0x71, 0x23, 0x89, 0x08, 0xC0, 0x30,
  0x26, 0x0C, 0xE1, 0xB4, 0x26, 0xC4, 0x99, 0x91, 0x32, 0x34, 0xC2, 0x98,
  0x52, 0x0E, 0x40, 0xC0, 0x1F, 0x86, 0x18, 0x81, 0x30, 0x34, 0x07, 0x80,
  0xF0, 0x1E, 0x02, 0xC0, 0xC8, 0x11, 0x8E, 0x1F, 0x00, 0x3F, 0x11, 0x88,
  0x6C, 0x36, 0x13, 0x19, 0xF8, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x1F,
  0x86, 0x18, 0x81, 0x30, 0x34, 0x07, 0x80, 0xF0, 0x1E, 0x02, 0xC0, 0xC8,
  0x11, 0x8E, 0x1F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3F, 0x11, 0x88, 0x6C,
  0x36, 0x13, 0x39, 0xF0, 0x98, 0xC4, 0x63, 0x31, 0x90, 0x60, 0x1F, 0x98,
  0x48, 0x04, 0x03, 0x00, 0xE0, 0x38, 0x04, 0x03, 0x01, 0x21, 0x9F, 0x80,
  0xFF, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40,
  0x30, 0x64, 0x08, 0x81, 0x30, 0x66, 0x0C, 0x81, 0x90, 0x26, 0x04, 0xC1,
  0x98, 0x21, 0x8C, 0x1F, 0x00, 0x81, 0xC1, 0xA0, 0xD0, 0xCC, 0x46, 0x63,
  0x21, 0xB0, 0xD0, 0x38, 0x18, 0x0C, 0x00, 0x83, 0x0E, 0x1C, 0x28, 0x51,
  0xA3, 0x44, 0x89, 0x32, 0x24, 0x8D, 0x12, 0x34, 0x58, 0xF1, 0x43, 0x87,
  0x0E, 0x18, 0x30, 0x60, 0x18, 0x61, 0x18, 0x22, 0x06, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x50, 0x13, 0x06, 0x21, 0x86, 0x60, 0xC0, 0x83, 0x86, 0xC4,
  0x4C, 0x58, 0x50, 0x70, 0x20, 0x60, 0x60, 0x40, 0x40, 0x3F, 0xC0, 0x60,
  0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x03, 0xFC,
  0x1C, 0x43, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x8E, 0x00,
  0x93, 0x64, 0x92, 0x4D, 0x90, 0x1C, 0x30, 0xC2, 0x08, 0x21, 0x86, 0x10,
  0x41, 0x0C, 0x33, 0x8E, 0x00, 0x10, 0x38, 0x2C, 0x24, 0x46, 0x42, 0x83,
  0xFE, 0xCC, 0x80, 0x3D, 0x63, 0x43, 0xC3, 0xC2, 0x86, 0x86, 0xCE, 0x76,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x71, 0x4C, 0xC6, 0x43, 0x61, 0xB0, 0xD8,
  0x4C, 0x6D, 0xE0, 0x3E, 0xC1, 0x06, 0x08, 0x10, 0x20, 0x62, 0x7C, 0x00,
  0x80, 0xC0, 0x60, 0x23, 0xD3, 0x19, 0x0D, 0x86, 0xC2, 0x43, 0x21, 0x99,
  0xC7, 0x60, 0x3E, 0xCD, 0x1E, 0x6F, 0x90, 0x20, 0x62, 0x7C, 0x03, 0xC1,
  0x80, 0x40, 0x10, 0x1F, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0xE0, 0x00, 0x1E, 0x98, 0xC8, 0x6C,
  0x36, 0x12, 0x19, 0x0C, 0xCE, 0x3B, 0x01, 0x00, 0x90, 0xCF, 0xC0, 0x18,
  0x08, 0x04, 0x06, 0x03, 0x71, 0x4C, 0xC6, 0x43, 0x61, 0x30, 0x98, 0x48,
  0x6C, 0x30, 0x10, 0xC0, 0x03, 0x18, 0x84, 0x63, 0x18, 0x8C, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C,
  0x10, 0xE0, 0x18, 0x08, 0x04, 0x06, 0x03, 0x19, 0x90, 0x90, 0x50, 0x78,
  0x36, 0x11, 0x08, 0xCC, 0x20, 0x18, 0x84, 0x63, 0x18, 0x84, 0x63, 0x10,
  0x8C, 0x00, 0x3F, 0x3C, 0xA5, 0x33, 0x18, 0xC8, 0x63, 0x61, 0x0D, 0x84,
  0x26, 0x30, 0x90, 0xC6, 0xC2, 0x18, 0x3F, 0x9C, 0xCC, 0x64, 0x36, 0x1B,
  0x09, 0x8C, 0x86, 0xC3, 0x00, 0x3E, 0x62, 0xC3, 0xC3, 0x83, 0x82, 0x86,
  0xC4, 0x78, 0x37, 0x14, 0xCC, 0x64, 0x36, 0x1B, 0x0D, 0x84, 0xC6, 0x5E,
  0x60, 0x30, 0x10, 0x08, 0x00, 0x3D, 0x63, 0x43, 0xC3, 0xC2, 0x86, 0x86,
  0xCE, 0x76, 0x04, 0x04, 0x0C, 0x0C, 0x3E, 0x50, 0xC1, 0x06, 0x0C, 0x18,
  0x20, 0xC0, 0x3E, 0xC5, 0x83, 0x81, 0x81, 0x81, 0x46, 0xF8, 0x21, 0x3E,
  0xC4, 0x23, 0x18, 0xC6, 0x3C, 0x61, 0x41, 0x43, 0x43, 0xC2, 0xC2, 0x86,
  0xCE, 0xF6, 0x83, 0x86, 0xC4, 0xCC, 0xC8, 0xD8, 0x50, 0x70, 0x60, 0x86,
  0x38, 0xE2, 0xCA, 0x6D, 0xA4, 0xD2, 0xCF, 0x28, 0xE3, 0x8E, 0x30, 0xC3,
  0x00, 0x31, 0xC6, 0x40, 0xA0, 0x38, 0x0C, 0x07, 0x03, 0x60, 0x88, 0xE3,
  0x00, 0x10, 0x63, 0x18, 0x62, 0x0C, 0xC1, 0x90, 0x16, 0x02, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x60, 0x08, 0x0E, 0x00, 0x3E, 0x0C, 0x30, 0x41, 0x06,
  0x18, 0x60, 0xFC, 0x0E, 0x10, 0x60, 0xC1, 0x02, 0x18, 0x70, 0x20, 0x40,
  0x83, 0x06, 0x0E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x18,
  0x30, 0x60, 0x81, 0x03, 0x07, 0x18, 0x20, 0x41, 0x83, 0x1C, 0x30, 0x00,
  0x79, 0x8F,
};

const GFXglyph NotoSans_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 4, 7, 2, -12 },
  { 12, 10, 12, 11, 1, -12 },
  { 27, 8, 14, 9, 1, -13 },
  { 41, 12, 12, 14, 1, -12 },
  { 59, 10, 12, 11, 1, -12 },
  { 74, 2, 4, 4, 2, -12 },
  { 75, 5, 15, 5, 1, -12 },
  { 85, 5, 15, 5, -1, -12 },
  { 95, 8, 8, 9, 2, -13 },
  { 103, 8, 8, 10, 1, -10 },
  { 111, 4, 4, 4, -1, -2 },
  { 113, 5, 1, 5, 0, -5 },
  { 114, 2, 2, 4, 0, -2 },
  { 115, 9, 12, 6, -1, -12 },
  { 129, 8, 12, 9, 1, -12 },
  { 141, 6, 12, 9, 2, -12 },
  { 150, 9, 12, 9, 0, -12 },
  { 164, 9, 12, 9, 0, -12 },
  { 178, 9, 12, 9, 0, -12 },
  { 192, 8, 12, 9, 1, -12 },
  { 204, 8, 12, 9, 1, -12 },
  { 216, 9, 12, 9, 1, -12 },
  { 230, 8, 12, 9, 1, -12 },
  { 242, 8, 12, 9, 1, -12 },
  { 254, 4, 9, 4, 0, -9 },
  { 259, 5, 11, 4, -1, -9 },
  { 266, 8, 8, 10, 1, -10 },
  { 274, 8, 4, 10, 1, -8 },
  { 278, 8, 8, 10, 1, -10 },
  { 286, 7, 12, 7, 1, -12 },
  { 297, 13, 14, 14, 1, -12 },
  { 320, 10, 12, 10, -1, -12 },
  { 335, 9, 12, 10, 1, -12 },
  { 349, 10, 12, 10, 1, -12 },
  { 364, 10, 12, 11, 1, -12 },
  { 379, 8, 12, 9, 1, -12 },
  { 391, 8, 12, 8, 1, -12 },
  { 403, 10, 12, 12, 1, -12 },
  { 418, 11, 12, 12, 1, -12 },
  { 435, 6, 12, 6, 0, -12 },
  { 444, 8, 15, 5, -3, -12 },
  { 459, 10, 12, 10, 1, -12 },
  { 474, 6, 12, 8, 1, -12 },
  { 483, 13, 12, 14, 1, -12 },
  { 503, 11, 12, 12, 1, -12 },
  { 520, 11, 12, 12, 1, -12 },
  { 537, 9, 12, 10, 1, -12 },
  { 551, 11, 15, 12, 1, -12 },
  { 572, 9, 12, 10, 1, -12 },
  { 586, 9, 12, 9, 0, -12 },
  { 600, 8, 12, 9, 2, -12 },
  { 612, 11, 12, 12, 1, -12 },
  { 629, 9, 12, 9, 2, -12 },
  { 643, 14, 12, 15, 2, -12 },
  { 664, 11, 12, 9, -1, -12 },
  { 681, 8, 12, 9, 2, -12 },
  { 693, 10, 12, 9, 0, -12 },
  { 708, 6, 15, 5, 0, -12 },
  { 720, 3, 12, 6, 2, -12 },
  { 725, 6, 15, 5, -1, -12 },
  { 737, 8, 7, 10, 1, -12 },
  { 744, 7, 1, 7, -2, 2 },
  { 745, 3, 3, 5, 2, -13 },
  { 747, 8, 9, 10, 1, -9 },
  { 756, 9, 13, 10, 0, -13 },
  { 771, 7, 9, 8, 1, -9 },
  { 779, 9, 13, 10, 1, -13 },
  { 794, 7, 9, 8, 1, -9 },
  { 802, 10, 17, 5, -2, -13 },
  { 824, 9, 13, 10, 0, -9 },
  { 839, 9, 13, 10, 0, -13 },
  { 854, 5, 13, 4, 0, -13 },
  { 863, 7, 17, 4, -2, -13 },
  { 878, 9, 13, 8, 0, -13 },
  { 893, 5, 13, 4, 0, -13 },
  { 902, 14, 9, 15, 0, -9 },
  { 918, 9, 9, 10, 0, -9 },
  { 929, 8, 9, 10, 1, -9 },
  { 938, 9, 13, 10, 0, -9 },
  { 953, 8, 13, 10, 1, -9 },
  { 966, 7, 9, 7, 0, -9 },
  { 974, 7, 9, 7, 0, -9 },
  { 982, 5, 11, 6, 1, -11 },
  { 989, 8, 9, 10, 1, -9 },
  { 998, 8, 9, 8, 1, -9 },
  { 1007, 12, 9, 12, 1, -9 },
  { 1021, 10, 9, 8, -1, -9 },
  { 1033, 11, 13, 8, -2, -9 },
  { 1051, 7, 9, 8, 0, -9 },
  { 1059, 7, 15, 6, 0, -12 },
  { 1073, 2, 17, 9, 4, -13 },
  { 1078, 7, 15, 6, -1, -12 },
  { 1092, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_Italic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_ITALIC17PT7B_H_
