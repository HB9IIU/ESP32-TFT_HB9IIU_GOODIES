#ifndef _NOTOSANS_ITALIC24PT7B_H_
#define _NOTOSANS_ITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x80,
  0x00, 0x18, 0x38, 0xE0, 0xEF, 0x9B, 0x36, 0x68, 0xD1, 0x00, 0x03, 0x18,
  0x04, 0x30, 0x18, 0x40, 0x31, 0x80, 0x63, 0x0F, 0xFF, 0xDF, 0xFF, 0x86,
  0x30, 0x08, 0x60, 0x30, 0x83, 0xFF, 0xE7, 0xFF, 0xC1, 0x08, 0x06, 0x30,
  0x0C, 0x60, 0x10, 0xC0, 0x63, 0x00, 0x01, 0x80, 0x10, 0x0F, 0xF1, 0xFE,
  0x33, 0x03, 0x30, 0x32, 0x03, 0x20, 0x1E, 0x00, 0xF8, 0x05, 0xC0, 0x4C,
  0x0C, 0xC0, 0xCC, 0x8D, 0xCF, 0xF8, 0x7E, 0x01, 0x80, 0x18, 0x00, 0x3E,
  0x06, 0x76, 0x0C, 0x62, 0x18, 0xC2, 0x18, 0xC6, 0x30, 0xC6, 0x60, 0xC6,
  0xC4, 0xC4, 0xDF, 0xCD, 0xB3, 0x7B, 0x63, 0x02, 0x63, 0x06, 0x63, 0x0C,
  0x63, 0x18, 0x42, 0x10, 0x66, 0x30, 0x6E, 0x60, 0x3C, 0x07, 0xE0, 0x39,
  0x81, 0x87, 0x06, 0x1C, 0x18, 0x60, 0x63, 0x80, 0xF8, 0x03, 0xC0, 0x1E,
  0x01, 0xCC, 0x3E, 0x38, 0xF0, 0x66, 0xC0, 0xF3, 0x01, 0x8C, 0x0F, 0x3F,
  0xEC, 0x7F, 0x1C, 0xFB, 0x69, 0x00, 0x07, 0x0C, 0x0C, 0x18, 0x30, 0x30,
  0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x20, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0,
  0x03, 0x00, 0x30, 0x42, 0x07, 0x20, 0xBE, 0xF0, 0x7E, 0x0A, 0x03, 0xB0,
  0x73, 0x02, 0x18, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC1,
  0xFF, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x39, 0x9C, 0xC6,
  0x60, 0xFF, 0xE0, 0x67, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x07, 0xC1, 0xEE, 0x18, 0x63,
  0x03, 0x30, 0x37, 0x03, 0x60, 0x36, 0x07, 0x60, 0x7E, 0x06, 0xE0, 0x6E,
  0x06, 0xE0, 0xE6, 0x0C, 0x61, 0x87, 0xF8, 0x3E, 0x00, 0x07, 0x1E, 0x3E,
  0xF6, 0x46, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x07, 0xE0, 0xF7, 0x82, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xC3, 0xEE, 0x10, 0x60, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xC1, 0xF8, 0x1F, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x81, 0xCF, 0xF8, 0xFF, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x3C, 0x03, 0x60, 0x33, 0x03, 0xB0, 0x39, 0x81, 0x8C, 0x18, 0x61, 0x83,
  0x18, 0x31, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0xF1, 0xFF, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0xF8,
  0x21, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x81, 0xCF, 0xF8,
  0xFE, 0x00, 0x07, 0xE1, 0xE4, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x39, 0xC6,
  0xFC, 0xF1, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x83, 0x30, 0x67, 0xF8,
  0x7E, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x00, 0x0F, 0xE1, 0xEF, 0x18, 0x31, 0x83, 0x18, 0x31, 0x87, 0x1C,
  0xE0, 0xF8, 0x1F, 0x83, 0x9C, 0x60, 0xCE, 0x0E, 0xC0, 0x6C, 0x0E, 0xE0,
  0xC7, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xFE, 0x30, 0x63, 0x06, 0x60, 0x76,
  0x07, 0x60, 0x66, 0x06, 0x31, 0xE3, 0xF6, 0x0C, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x8F, 0xF0, 0xFC, 0x00, 0x19, 0xC6, 0x00, 0x00, 0x00, 0x00,
  0x18, 0xEE, 0x00, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8C,
  0x71, 0x8C, 0x30, 0x00, 0x20, 0x0C, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x30,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x18, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x18, 0x0E, 0x0F, 0x07, 0x83, 0xC0, 0x40, 0x00, 0x7F,
  0x7B, 0x80, 0xE0, 0x30, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x0C,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x38, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x61, 0xF8, 0xD8, 0xE3, 0x1B,
  0x18, 0x63, 0x46, 0x18, 0x78, 0xC3, 0x0B, 0x18, 0x63, 0x63, 0x1C, 0x6C,
  0x67, 0x98, 0x8F, 0xBE, 0x18, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xEF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x60, 0x07, 0x00, 0x6C, 0x03, 0x60,
  0x3B, 0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x0C, 0x30, 0x61, 0x87, 0xFE, 0x3F,
  0xF3, 0x01, 0x98, 0x0D, 0x80, 0x7C, 0x03, 0xC0, 0x18, 0x1F, 0xE0, 0xFF,
  0x86, 0x0E, 0x30, 0x31, 0x81, 0x9C, 0x0C, 0xC0, 0xC7, 0xFC, 0x3F, 0xC1,
  0x83, 0x1C, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x39, 0x83, 0x9F, 0xF8, 0xFF,
  0x80, 0x07, 0xF8, 0x7F, 0xC7, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC1, 0x83, 0x86, 0x07,
  0x18, 0x0C, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x37, 0x01,
  0xD8, 0x06, 0x60, 0x39, 0x81, 0xC6, 0x0E, 0x3F, 0xF0, 0xFF, 0x00, 0x1F,
  0xF1, 0xFF, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0xFC, 0x3F,
  0xC3, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF1, 0xFF, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x3F, 0xC3, 0xFC, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF1, 0xC0, 0x4E, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC1, 0xFB, 0x07, 0xEC, 0x03, 0xB0, 0x0C,
  0xC0, 0x33, 0x80, 0xC7, 0x07, 0x1F, 0xF8, 0x1F, 0xE0, 0x1C, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0x1F, 0xFE,
  0x3F, 0xFC, 0x60, 0x31, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x07, 0x18,
  0x0C, 0x60, 0x18, 0xC0, 0x30, 0x1F, 0x83, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xF0, 0xFC,
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x4E, 0x0F, 0x80, 0x80, 0x00, 0x1C, 0x1E, 0x30, 0x70,
  0x61, 0xC0, 0xC7, 0x01, 0x9C, 0x07, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x3F,
  0x00, 0x66, 0x01, 0x8E, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x38, 0x18, 0x30,
  0x60, 0x70, 0xC0, 0x60, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xFF, 0xFF, 0x80,
  0x1E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x6C,
  0x6C, 0x0D, 0x8C, 0x83, 0x31, 0x98, 0x66, 0x33, 0x19, 0x86, 0x63, 0x31,
  0x8C, 0xC6, 0x31, 0x98, 0xC6, 0x36, 0x38, 0xC6, 0x86, 0x38, 0x70, 0xC6,
  0x0C, 0x18, 0xC1, 0x83, 0x00, 0x1C, 0x03, 0x1C, 0x03, 0x1E, 0x07, 0x1E,
  0x06, 0x1B, 0x06, 0x33, 0x06, 0x33, 0x06, 0x31, 0x8C, 0x31, 0x8C, 0x31,
  0x8C, 0x60, 0xCC, 0x60, 0xCC, 0x60, 0x78, 0x60, 0x78, 0xE0, 0x78, 0xC0,
  0x38, 0xC0, 0x38, 0x07, 0xF0, 0x3F, 0xF0, 0xE0, 0x71, 0x80, 0x66, 0x00,
  0xCC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36,
  0x00, 0xEC, 0x01, 0x9C, 0x07, 0x1C, 0x1C, 0x3F, 0xF0, 0x1F, 0x80, 0x1F,
  0xE0, 0xFF, 0x86, 0x0C, 0x30, 0x71, 0x83, 0x9C, 0x1C, 0xC0, 0xC6, 0x0E,
  0x3F, 0xE1, 0xFE, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0xE0, 0x71, 0x80, 0x66, 0x00,
  0xCC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36,
  0x00, 0xEC, 0x01, 0x9C, 0x07, 0x1C, 0x1C, 0x3F, 0xF0, 0x1F, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0xFF, 0x86, 0x0C,
  0x30, 0x71, 0x83, 0x9C, 0x1C, 0xC0, 0xC6, 0x0E, 0x3F, 0xE1, 0xF8, 0x18,
  0x60, 0xC3, 0x06, 0x1C, 0x30, 0x61, 0x83, 0x18, 0x1C, 0xC0, 0x60, 0x07,
  0xF0, 0xFF, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x81, 0xCF, 0xF8, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x00, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x67, 0x01,
  0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x19, 0x80, 0x63, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x18, 0x0C, 0x38, 0x38, 0x3F, 0xE0, 0x3F, 0x80, 0xC0,
  0x1E, 0x01, 0xF8, 0x0C, 0xC0, 0xE6, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x30,
  0x61, 0x83, 0x18, 0x18, 0xC0, 0xCC, 0x03, 0x60, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0xE0, 0x7C, 0x0E, 0x06, 0xC1, 0xE0, 0xCC, 0x1E,
  0x0C, 0xC3, 0x61, 0xCC, 0x36, 0x18, 0xC6, 0x63, 0x8C, 0x66, 0x30, 0xCC,
  0x63, 0x0C, 0xC6, 0x60, 0xCC, 0x66, 0x0D, 0x86, 0xC0, 0xD8, 0x6C, 0x0F,
  0x06, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x0C, 0x07,
  0x0C, 0x0C, 0x06, 0x1C, 0x06, 0x38, 0x06, 0x30, 0x03, 0x60, 0x03, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0x60,
  0x38, 0x60, 0x30, 0x60, 0x60, 0x30, 0xE0, 0x30, 0xE0, 0x36, 0x06, 0x60,
  0xE6, 0x0C, 0x61, 0x83, 0x38, 0x33, 0x03, 0x60, 0x3E, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x00, 0x1F, 0xFC,
  0x7F, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0x87, 0xC3, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70,
  0x30, 0x1F, 0x0F, 0x80, 0xCC, 0xCC, 0xCC, 0x66, 0x66, 0x66, 0x63, 0x33,
  0x30, 0x07, 0x87, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x0F, 0x0F,
  0x80, 0x06, 0x00, 0xE0, 0x0B, 0x01, 0xB0, 0x19, 0x83, 0x18, 0x30, 0xC6,
  0x0C, 0x60, 0x6C, 0x06, 0xC0, 0x30, 0xFF, 0xFF, 0xE0, 0xE3, 0x30, 0x0F,
  0x31, 0xFB, 0x38, 0xF7, 0x07, 0x60, 0x66, 0x06, 0xE0, 0x6C, 0x0E, 0xC0,
  0xCC, 0x1C, 0xE3, 0xC7, 0xEC, 0x7C, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x3C, 0x37, 0xE3, 0xC6, 0x38, 0x77, 0x03, 0x70, 0x76,
  0x07, 0x60, 0x66, 0x06, 0xE0, 0xEE, 0x1C, 0xFF, 0x89, 0xF0, 0x0F, 0xC7,
  0xF3, 0x81, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x07,
  0x98, 0x7E, 0xC7, 0x0E, 0x70, 0x63, 0x03, 0x18, 0x19, 0xC0, 0xCC, 0x0E,
  0x60, 0x63, 0x07, 0x1C, 0x78, 0x7E, 0xC3, 0xE6, 0x00, 0x0F, 0x87, 0xF3,
  0x0D, 0xC3, 0x60, 0xD9, 0xEF, 0xF3, 0x00, 0xC0, 0x30, 0x0E, 0x09, 0xFE,
  0x3F, 0x00, 0x00, 0x7C, 0x03, 0xA0, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x31, 0xFB, 0x38,
  0x77, 0x07, 0x60, 0x66, 0x06, 0xE0, 0x6C, 0x0E, 0xC0, 0xCC, 0x1C, 0xE3,
  0xC7, 0xEC, 0x7D, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x87, 0x0F, 0xE0, 0x7C,
  0x00, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x3C, 0x37, 0xE3,
  0xC6, 0x38, 0x77, 0x06, 0x70, 0x66, 0x06, 0x60, 0x66, 0x0E, 0xE0, 0xCC,
  0x0C, 0xC0, 0xCC, 0x1C, 0x08, 0xC6, 0x00, 0x1C, 0xC6, 0x33, 0x98, 0xC6,
  0x33, 0x98, 0xC6, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x01, 0x81, 0xC3, 0xC1, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x07, 0x30, 0xC3, 0x18, 0x33, 0x07, 0x60, 0x6C, 0x07,
  0xC0, 0x76, 0x06, 0x60, 0xE3, 0x0C, 0x30, 0xC1, 0x8C, 0x1C, 0x1C, 0x61,
  0x86, 0x18, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x00,
  0x33, 0xC7, 0xC6, 0xFD, 0xF8, 0xE1, 0xE3, 0x9C, 0x38, 0x37, 0x06, 0x0E,
  0xE0, 0xC1, 0x98, 0x18, 0x33, 0x06, 0x06, 0x60, 0xC0, 0xDC, 0x18, 0x33,
  0x03, 0x06, 0x60, 0xE0, 0xCC, 0x18, 0x18, 0x33, 0xE3, 0x7E, 0x3C, 0x73,
  0x87, 0x70, 0x67, 0x06, 0x60, 0x66, 0x06, 0x60, 0xEE, 0x0C, 0xC0, 0xCC,
  0x0C, 0xC1, 0xC0, 0x0F, 0x83, 0xF8, 0xC3, 0xB8, 0x36, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x19, 0x87, 0x3F, 0xC3, 0xF0, 0x0C, 0xF0, 0x37,
  0xE0, 0xF1, 0x83, 0x87, 0x1C, 0x0C, 0x70, 0x71, 0x81, 0xC6, 0x06, 0x18,
  0x18, 0xE0, 0xE3, 0x87, 0x0F, 0xF8, 0x37, 0xC0, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0xF7,
  0x07, 0x60, 0x66, 0x06, 0xE0, 0x6C, 0x0E, 0xC0, 0xCC, 0x1C, 0xE3, 0xC7,
  0xEC, 0x7D, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x33, 0x9B, 0xCF, 0x07, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x00, 0x1F, 0x8F, 0xF3, 0x00, 0xC0, 0x30, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x68, 0x3B, 0xFC, 0xFE, 0x00, 0x08, 0x18, 0x18, 0x7F,
  0xFE, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xF8, 0x78,
  0x30, 0x33, 0x03, 0x30, 0x33, 0x07, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0E,
  0xE0, 0xCC, 0x1C, 0xE3, 0xC7, 0xEC, 0x7C, 0xC0, 0xC0, 0x78, 0x1F, 0x03,
  0x30, 0xE6, 0x18, 0xC6, 0x18, 0xC3, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x3C,
  0x03, 0x80, 0xC1, 0xC1, 0xE0, 0xE1, 0xF8, 0xF0, 0xCC, 0x78, 0x66, 0x2C,
  0x63, 0x36, 0x31, 0x93, 0x30, 0xD9, 0x98, 0x6C, 0x58, 0x3C, 0x2C, 0x1E,
  0x14, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x18, 0x38, 0xE1, 0x83, 0x18, 0x19,
  0x80, 0x7C, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x0D, 0x80, 0xCC, 0x0E, 0x30,
  0xE1, 0x8E, 0x0E, 0x00, 0x18, 0x0C, 0x60, 0x71, 0xC1, 0x83, 0x0E, 0x0C,
  0x30, 0x31, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x16, 0x00, 0x58, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x03, 0xE0, 0x0E,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x7F, 0x8F, 0xF0, 0x03, 0xC1, 0xE0, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x1E, 0x0E, 0x00, 0xC0, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xF0, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0xC0, 0xE0, 0xE0, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x1E, 0x0E, 0x00, 0x78, 0x3F, 0xFE, 0x1F, 0x00,
};

const GFXglyph NotoSans_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 7, 6, 9, 3, -17 },
  { 22, 15, 17, 16, 1, -17 },
  { 54, 12, 19, 13, 1, -18 },
  { 83, 16, 17, 19, 2, -17 },
  { 117, 14, 17, 16, 1, -17 },
  { 147, 3, 6, 5, 3, -17 },
  { 150, 8, 21, 7, 1, -17 },
  { 171, 8, 21, 7, -2, -17 },
  { 192, 12, 11, 13, 2, -18 },
  { 209, 11, 11, 14, 2, -14 },
  { 225, 5, 6, 6, -1, -3 },
  { 229, 6, 2, 8, 1, -7 },
  { 231, 4, 3, 6, 0, -3 },
  { 233, 12, 17, 9, -1, -17 },
  { 259, 12, 17, 13, 1, -17 },
  { 285, 8, 17, 13, 3, -17 },
  { 302, 13, 17, 13, 0, -17 },
  { 330, 12, 17, 13, 1, -17 },
  { 356, 13, 17, 13, 0, -17 },
  { 384, 12, 17, 13, 1, -17 },
  { 410, 11, 17, 13, 2, -17 },
  { 434, 11, 17, 13, 2, -17 },
  { 458, 12, 17, 13, 1, -17 },
  { 484, 12, 17, 13, 1, -17 },
  { 510, 5, 13, 6, 0, -13 },
  { 519, 6, 16, 6, -1, -13 },
  { 531, 11, 12, 14, 2, -15 },
  { 548, 11, 7, 14, 2, -12 },
  { 558, 11, 12, 14, 2, -15 },
  { 575, 9, 17, 10, 2, -17 },
  { 595, 19, 19, 20, 1, -17 },
  { 641, 13, 17, 13, -1, -17 },
  { 669, 13, 17, 14, 1, -17 },
  { 697, 13, 17, 14, 2, -17 },
  { 725, 14, 17, 16, 1, -17 },
  { 755, 12, 17, 12, 1, -17 },
  { 781, 12, 17, 11, 1, -17 },
  { 807, 14, 17, 16, 2, -17 },
  { 837, 15, 17, 16, 1, -17 },
  { 869, 9, 17, 8, 0, -17 },
  { 889, 11, 22, 7, -4, -17 },
  { 920, 15, 17, 13, 1, -17 },
  { 952, 9, 17, 11, 1, -17 },
  { 972, 19, 17, 20, 1, -17 },
  { 1013, 16, 17, 17, 1, -17 },
  { 1047, 15, 17, 17, 2, -17 },
  { 1079, 13, 17, 14, 1, -17 },
  { 1107, 15, 21, 17, 2, -17 },
  { 1147, 13, 17, 14, 1, -17 },
  { 1175, 12, 17, 12, 0, -17 },
  { 1201, 12, 17, 12, 2, -17 },
  { 1227, 15, 17, 16, 2, -17 },
  { 1259, 13, 17, 13, 2, -17 },
  { 1287, 20, 17, 21, 3, -17 },
  { 1330, 16, 17, 13, -1, -17 },
  { 1364, 12, 17, 12, 2, -17 },
  { 1390, 14, 17, 13, 0, -17 },
  { 1420, 9, 21, 7, 0, -17 },
  { 1444, 4, 17, 9, 3, -17 },
  { 1453, 9, 21, 7, -2, -17 },
  { 1477, 12, 11, 14, 1, -17 },
  { 1494, 10, 2, 9, -2, 2 },
  { 1497, 4, 3, 7, 3, -18 },
  { 1499, 12, 13, 14, 1, -13 },
  { 1519, 12, 18, 14, 1, -18 },
  { 1546, 10, 13, 11, 1, -13 },
  { 1563, 13, 18, 14, 1, -18 },
  { 1593, 10, 13, 12, 1, -13 },
  { 1610, 14, 24, 8, -3, -18 },
  { 1652, 12, 19, 14, 1, -13 },
  { 1681, 12, 18, 14, 1, -18 },
  { 1708, 5, 18, 6, 1, -18 },
  { 1720, 9, 24, 6, -3, -18 },
  { 1747, 12, 18, 12, 1, -18 },
  { 1774, 6, 18, 6, 1, -18 },
  { 1788, 19, 13, 21, 1, -13 },
  { 1819, 12, 13, 14, 1, -13 },
  { 1839, 11, 13, 14, 1, -13 },
  { 1857, 14, 19, 14, -1, -13 },
  { 1891, 12, 19, 14, 1, -13 },
  { 1920, 9, 13, 10, 1, -13 },
  { 1935, 10, 13, 10, 0, -13 },
  { 1952, 8, 16, 8, 1, -16 },
  { 1968, 12, 13, 14, 1, -13 },
  { 1988, 11, 13, 11, 1, -13 },
  { 2006, 17, 13, 17, 1, -13 },
  { 2034, 13, 13, 12, -1, -13 },
  { 2056, 14, 19, 11, -2, -13 },
  { 2090, 11, 13, 11, 0, -13 },
  { 2108, 10, 21, 8, 0, -17 },
  { 2135, 2, 24, 13, 6, -18 },
  { 2141, 9, 21, 8, -1, -17 },
  { 2165, 11, 3, 14, 2, -10 },
};

const GFXfont NotoSans_Italic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_ITALIC24PT7B_H_
