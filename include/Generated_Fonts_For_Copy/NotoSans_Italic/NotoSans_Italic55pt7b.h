#ifndef _NOTOSANS_ITALIC55PT7B_H_
#define _NOTOSANS_ITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x0C, 0x00, 0x3E,
  0x1F, 0x9F, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3, 0xE0, 0xF1,
  0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07,
  0x0F, 0x03, 0x87, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x38,
  0xF8, 0x0F, 0x87, 0x02, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x9C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE1, 0xF0, 0x00, 0x38, 0x3E, 0x10, 0x07, 0x0F, 0x83, 0xC1, 0xE7,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x10, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x7F, 0xF0, 0x00,
  0x3C, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x07, 0x80, 0x78,
  0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x78, 0x00, 0x3C, 0x03,
  0xC3, 0xE0, 0x00, 0xF0, 0x0F, 0x0F, 0x0F, 0xC3, 0xC0, 0x78, 0x78, 0xFF,
  0xCF, 0x01, 0xE3, 0xC7, 0xFF, 0x1E, 0x0F, 0x1F, 0x3F, 0xFE, 0x78, 0x7C,
  0x78, 0xF0, 0x79, 0xFF, 0xE3, 0xC7, 0x81, 0xE3, 0xFF, 0x1F, 0x1E, 0x07,
  0xC7, 0xF8, 0xF8, 0xF0, 0x1F, 0x07, 0x83, 0xC3, 0xC0, 0x78, 0x00, 0x1E,
  0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x78, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x07, 0xC0,
  0x78, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0xF0, 0x07, 0x80, 0x07, 0xC7, 0xC0, 0x3C, 0x00, 0x0F, 0xFE, 0x01,
  0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x03, 0xE1, 0xFC, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0x7F, 0x1F, 0x80,
  0x3E, 0x7E, 0x07, 0xC0, 0x1F, 0x3E, 0x01, 0xF0, 0x1F, 0x3E, 0x00, 0xFC,
  0x0F, 0x1F, 0x00, 0x3E, 0x0F, 0x9F, 0x00, 0x0F, 0x8F, 0x8F, 0x80, 0x07,
  0xEF, 0xC7, 0xC0, 0x01, 0xFF, 0xC3, 0xE0, 0x00, 0x7F, 0xC1, 0xF0, 0x00,
  0x3F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0xF8, 0x0F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0x9F, 0x81, 0xFF,
  0xFF, 0x87, 0xC0, 0x7F, 0xFF, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x00,
  0xD0, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78,
  0xE3, 0xC7, 0x8F, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01,
  0x80, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0xFE, 0x1E, 0x00, 0x7F, 0xCE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xDC, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC7,
  0x80, 0x03, 0xE1, 0xC0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x78, 0x01, 0xE0,
  0x3E, 0x00, 0x70, 0x0F, 0x00, 0x10, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F,
  0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x18, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0xFE, 0x07,
  0xE0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0,
  0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x1F, 0xDE, 0x7F, 0xBE, 0xFF, 0x3E, 0xFC,
  0x3E, 0x78, 0x7C, 0x20, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x00, 0x7C, 0x01, 0xF8, 0x01,
  0xC0, 0x07, 0xE0, 0x08, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0x00, 0x7E, 0x00,
  0xC0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xFC,
  0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x10, 0x00, 0x1F, 0x83, 0xC0, 0x0F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x0C, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x1F, 0xF0,
  0x07, 0xCF, 0xFF, 0x80, 0xFB, 0xFF, 0xF8, 0x1E, 0xF8, 0x7F, 0x07, 0xFC,
  0x03, 0xF0, 0xFE, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0x7C, 0x00,
  0x07, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xF8, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0xFF, 0x87, 0xFF, 0xFB, 0xE0, 0xFF, 0xFC,
  0xF0, 0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x02, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x7E, 0x0F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xF8,
  0xFF, 0x1E, 0x00, 0xF8, 0x40, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x7F, 0xF0, 0x1F, 0x1F, 0x00, 0x7F, 0xFF, 0x03, 0xC7, 0x80, 0x3F, 0xFF,
  0x80, 0xF3, 0xC0, 0x3F, 0x01, 0xE0, 0x3C, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xDE, 0x03, 0xE0, 0x0F, 0x00, 0xF7, 0x80,
  0xF0, 0x03, 0xC0, 0x3D, 0xE0, 0x78, 0x01, 0xF0, 0x0F, 0xF8, 0x1E, 0x00,
  0x78, 0x03, 0xFC, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0x03, 0xE0, 0x07, 0x80,
  0x7B, 0xC0, 0xF0, 0x03, 0xE0, 0x1E, 0xF0, 0x3C, 0x00, 0xF0, 0x07, 0xBC,
  0x0F, 0x00, 0x7C, 0x03, 0xCF, 0x03, 0xC0, 0x1F, 0x00, 0xF3, 0xC0, 0xF8,
  0x0F, 0xC0, 0x78, 0xF0, 0x1E, 0x07, 0x70, 0x3E, 0x3C, 0x07, 0xE7, 0xDF,
  0x3F, 0x0F, 0x81, 0xFF, 0xE7, 0xFF, 0x81, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x7F, 0x07, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0,
  0x03, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F,
  0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x3F,
  0xE0, 0x1F, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xF0, 0x00,
  0x08, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0xC7, 0xC0,
  0x03, 0xFF, 0xE3, 0xE0, 0x01, 0xFF, 0xF1, 0xF0, 0x00, 0xFF, 0xF8, 0xF8,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7B, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x03, 0xF8, 0xF8,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xE0,
  0x1E, 0xF0, 0x00, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x00, 0xFB, 0xE0, 0x3E,
  0xF8, 0x00, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x01, 0xF7, 0xC0, 0x3E, 0x78,
  0x00, 0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x00,
  0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x7C, 0x78, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xF0, 0xF8,
  0x07, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F,
  0x83, 0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0x3C, 0x07, 0xC1, 0xF0, 0x0F, 0x03,
  0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xC1,
  0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xE3, 0xE0,
  0x3E, 0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE7, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xEF, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xFE, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0x3E, 0x01, 0xFC,
  0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x00, 0xF8,
  0x07, 0xFC, 0x00, 0x07, 0xC0, 0x3D, 0xF0, 0x00, 0x3E, 0x01, 0xEF, 0x80,
  0x01, 0xE0, 0x1F, 0x3C, 0x00, 0x1F, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0x07,
  0xCF, 0x80, 0x07, 0xC0, 0x3C, 0x3C, 0x00, 0x3C, 0x01, 0xE1, 0xF0, 0x01,
  0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x07, 0xC1,
  0xF0, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0xF8, 0x07, 0x80, 0x07, 0xC7,
  0xC0, 0x3C, 0x00, 0x3E, 0x3C, 0x03, 0xE0, 0x00, 0xF3, 0xE0, 0x1F, 0x00,
  0x07, 0xDF, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x07, 0x80, 0x00, 0xFF, 0x80,
  0x3C, 0x00, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x00,
  0xFF, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x3C,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFF, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x07,
  0xF0, 0x1F, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0xFF, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7F,
  0x01, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0x80, 0x1C, 0x03, 0xF0, 0x00, 0x40, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x80, 0x00, 0xFC, 0x0F, 0x00, 0x3F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8,
  0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0xF8, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xBC,
  0x00, 0x3E, 0x3E, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFB, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x3C, 0x00,
  0xF8, 0x3E, 0x00, 0x78, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE3, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x7C, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x01,
  0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x80, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0xF8, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x3C, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0,
  0x0F, 0x8F, 0x00, 0x07, 0xCF, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0xF9, 0xE0, 0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x80, 0x01, 0xE7, 0x80, 0x07,
  0xBC, 0x00, 0x07, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xF7,
  0x80, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x83, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0,
  0x3C, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xFC, 0x3C, 0x07, 0xFF, 0xC7, 0x81, 0xFF, 0xFD, 0xF0, 0x7F, 0x07, 0xBC,
  0x1F, 0x80, 0x7F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x0F, 0xC7, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x3F,
  0x87, 0xC0, 0x0F, 0xE0, 0xF8, 0x03, 0xFC, 0x1F, 0x80, 0xF7, 0x81, 0xFF,
  0xFC, 0xF0, 0x3F, 0xFF, 0x3E, 0x03, 0xFF, 0xC7, 0x80, 0x1F, 0xE0, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x07, 0x87, 0xFE, 0x01, 0xF1, 0xFF, 0xE0, 0x3E, 0x7F, 0xFE, 0x07, 0xDE,
  0x0F, 0xC0, 0xF7, 0x80, 0xF8, 0x1F, 0xC0, 0x0F, 0x87, 0xF8, 0x01, 0xF0,
  0xFE, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFF, 0x01, 0xFC,
  0x3E, 0xFD, 0xFF, 0x07, 0x9F, 0xFF, 0xC0, 0xF1, 0xFF, 0xE0, 0x1C, 0x0F,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF0, 0x38, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x03, 0x03, 0xFE, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xFF, 0x8F,
  0x80, 0x1F, 0xFF, 0x3E, 0x00, 0xFF, 0xFE, 0xF8, 0x07, 0xF0, 0x7B, 0xC0,
  0x3F, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0x00, 0xF8,
  0x03, 0xFC, 0x03, 0xF0, 0x3E, 0xF0, 0x07, 0xFB, 0xF7, 0xC0, 0x1F, 0xFF,
  0x9F, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x3F, 0xC1, 0xE0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0x07, 0xC1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x0F,
  0xC7, 0xC0, 0x7F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x20, 0xFC, 0x01, 0xC0, 0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7E, 0x08, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xC3, 0xC0, 0x1F, 0xFF, 0x1E, 0x01, 0xFF,
  0xFD, 0xF0, 0x1F, 0xC1, 0xEF, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0x80, 0x1F,
  0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFE, 0x07, 0xC0,
  0x0F, 0xE0, 0x3E, 0x00, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xFB, 0xF7,
  0xC0, 0x3F, 0xFF, 0x3E, 0x00, 0xFF, 0xF1, 0xE0, 0x01, 0xFE, 0x1F, 0x00,
  0x01, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x60, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0x87, 0xFE, 0x01, 0xF1,
  0xFF, 0xE0, 0x3E, 0x7F, 0xFE, 0x07, 0xDF, 0x0F, 0xC0, 0xF7, 0x80, 0xFC,
  0x1F, 0xC0, 0x0F, 0x87, 0xF0, 0x01, 0xF0, 0xFE, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x10, 0x1E, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x7C,
  0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0x8F, 0xC0,
  0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0x80, 0x01, 0xFC, 0xF8,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x78, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0x1F, 0xFC, 0x1F,
  0xFF, 0x03, 0xCF, 0xFF, 0xC7, 0xFF, 0xE0, 0x79, 0xE1, 0xF9, 0xF0, 0x7E,
  0x0F, 0x70, 0x1F, 0x7C, 0x07, 0xC1, 0xFC, 0x01, 0xFE, 0x00, 0xF8, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x7F, 0x00, 0x3E, 0x1F, 0xFC, 0x03, 0xE7,
  0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0x03, 0xDF, 0x87, 0xF0, 0x3D, 0xE0, 0x3F,
  0x07, 0xFC, 0x01, 0xF0, 0x7F, 0x80, 0x1F, 0x07, 0xF0, 0x01, 0xF0, 0x7E,
  0x00, 0x1F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xE1, 0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0x00, 0x3C, 0x7F,
  0xFE, 0x00, 0xF3, 0xC1, 0xF8, 0x03, 0xDE, 0x03, 0xE0, 0x0F, 0xE0, 0x07,
  0xC0, 0x7F, 0x80, 0x1F, 0x01, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E, 0x01,
  0xF7, 0xEF, 0xF8, 0x07, 0xCF, 0xFF, 0xC0, 0x1F, 0x3F, 0xFC, 0x00, 0x78,
  0x3F, 0xE0, 0x03, 0xE0, 0x10, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x3C, 0x07,
  0xFF, 0xC7, 0x81, 0xFF, 0xFD, 0xF0, 0x7F, 0x07, 0xBC, 0x1F, 0x80, 0x7F,
  0x87, 0xE0, 0x07, 0xF0, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC7, 0xC0,
  0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF9,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x0F,
  0xE0, 0xF8, 0x03, 0xFC, 0x1F, 0x81, 0xFF, 0x81, 0xFF, 0xFD, 0xF0, 0x3F,
  0xFF, 0x3E, 0x03, 0xFF, 0xC7, 0x80, 0x1F, 0xE1, 0xF0, 0x00, 0x40, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0x0F, 0xE0,
  0x7C, 0xFF, 0x81, 0xE7, 0xFE, 0x07, 0x9F, 0x98, 0x1E, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x01, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x80, 0x03, 0xF1, 0xC0, 0x0F, 0xC3, 0xF8, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xE8, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x38, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xE1, 0xF0, 0x01,
  0xFC, 0x3E, 0x00, 0x7F, 0x07, 0xC0, 0x1F, 0xE0, 0xFC, 0x0F, 0xBC, 0x0F,
  0xFF, 0xEF, 0x81, 0xFF, 0xF9, 0xF0, 0x1F, 0xFC, 0x3C, 0x01, 0xFF, 0x07,
  0x80, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3,
  0xE0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0xC0, 0x0F,
  0x9F, 0x00, 0x7F, 0x80, 0x3E, 0x3E, 0x01, 0xEF, 0x00, 0x7C, 0x7C, 0x03,
  0xDE, 0x01, 0xF0, 0x78, 0x0F, 0xBC, 0x03, 0xE0, 0xF0, 0x1E, 0x78, 0x0F,
  0x81, 0xE0, 0x3C, 0xF8, 0x1F, 0x03, 0xC0, 0xF1, 0xF0, 0x7C, 0x07, 0x81,
  0xE1, 0xE0, 0xF8, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1E, 0x0F, 0x07, 0x87,
  0xC0, 0x3C, 0x3C, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x1E, 0x3E, 0x00, 0xF1,
  0xE0, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x79, 0xF0, 0x03, 0xCF, 0x80, 0xF3,
  0xE0, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0x1E,
  0xF0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x01, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x40, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x5F, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xC8,
  0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 40, 14, 1, -39 },
  { 71, 17, 14, 22, 6, -39 },
  { 101, 34, 39, 36, 2, -39 },
  { 267, 27, 45, 30, 2, -42 },
  { 419, 38, 41, 44, 4, -40 },
  { 614, 33, 41, 37, 2, -40 },
  { 784, 7, 14, 12, 6, -39 },
  { 797, 18, 48, 16, 2, -39 },
  { 905, 18, 48, 16, -4, -39 },
  { 1013, 25, 26, 30, 6, -42 },
  { 1095, 26, 27, 31, 4, -33 },
  { 1183, 11, 13, 14, -2, -6 },
  { 1201, 14, 5, 17, 1, -17 },
  { 1210, 7, 8, 14, 1, -7 },
  { 1217, 27, 39, 20, -3, -39 },
  { 1349, 26, 41, 30, 3, -40 },
  { 1483, 16, 39, 30, 8, -39 },
  { 1561, 29, 40, 30, 0, -40 },
  { 1706, 28, 41, 30, 1, -40 },
  { 1850, 29, 39, 30, 0, -39 },
  { 1992, 27, 40, 30, 2, -39 },
  { 2127, 27, 41, 30, 3, -40 },
  { 2266, 27, 39, 30, 4, -39 },
  { 2398, 28, 41, 30, 2, -40 },
  { 2542, 26, 41, 30, 3, -40 },
  { 2676, 11, 31, 14, 1, -30 },
  { 2719, 15, 37, 14, -3, -30 },
  { 2789, 26, 27, 31, 4, -33 },
  { 2877, 25, 15, 31, 4, -27 },
  { 2924, 26, 27, 31, 4, -33 },
  { 3012, 21, 41, 24, 4, -40 },
  { 3120, 42, 44, 47, 3, -39 },
  { 3351, 31, 39, 31, -3, -39 },
  { 3503, 30, 39, 33, 2, -39 },
  { 3650, 31, 41, 32, 4, -40 },
  { 3809, 33, 39, 37, 2, -39 },
  { 3970, 28, 39, 28, 2, -39 },
  { 4107, 28, 39, 26, 2, -39 },
  { 4244, 33, 41, 37, 4, -40 },
  { 4414, 36, 39, 37, 2, -39 },
  { 4590, 22, 39, 18, -1, -39 },
  { 4698, 25, 49, 15, -9, -39 },
  { 4852, 34, 39, 31, 2, -39 },
  { 5018, 21, 39, 26, 2, -39 },
  { 5121, 44, 39, 46, 2, -39 },
  { 5336, 37, 39, 39, 2, -39 },
  { 5517, 34, 41, 40, 4, -40 },
  { 5692, 29, 39, 31, 2, -39 },
  { 5834, 34, 49, 40, 4, -40 },
  { 6043, 29, 39, 32, 2, -39 },
  { 6185, 28, 41, 28, 1, -40 },
  { 6329, 27, 39, 28, 5, -39 },
  { 6461, 34, 40, 37, 4, -39 },
  { 6631, 30, 39, 30, 5, -39 },
  { 6778, 46, 39, 47, 6, -39 },
  { 7003, 37, 39, 29, -3, -39 },
  { 7184, 28, 39, 28, 5, -39 },
  { 7321, 33, 39, 29, -1, -39 },
  { 7482, 21, 48, 16, -1, -39 },
  { 7608, 10, 39, 20, 6, -39 },
  { 7657, 21, 48, 16, -4, -39 },
  { 7783, 27, 25, 31, 2, -40 },
  { 7868, 23, 4, 22, -5, 5 },
  { 7880, 9, 9, 15, 8, -42 },
  { 7891, 27, 31, 31, 3, -30 },
  { 7996, 27, 43, 32, 2, -42 },
  { 8142, 22, 31, 25, 3, -30 },
  { 8228, 30, 43, 32, 3, -42 },
  { 8390, 23, 31, 27, 3, -30 },
  { 8480, 30, 55, 17, -6, -42 },
  { 8687, 29, 43, 32, 1, -30 },
  { 8843, 27, 42, 32, 2, -42 },
  { 8985, 13, 40, 14, 2, -40 },
  { 9050, 22, 53, 14, -7, -40 },
  { 9196, 28, 42, 27, 1, -42 },
  { 9343, 14, 42, 14, 1, -42 },
  { 9417, 43, 30, 48, 2, -30 },
  { 9579, 28, 30, 32, 1, -30 },
  { 9684, 25, 30, 31, 3, -30 },
  { 9778, 30, 43, 32, -1, -30 },
  { 9940, 27, 43, 32, 3, -30 },
  { 10086, 22, 30, 22, 2, -30 },
  { 10169, 23, 31, 24, 0, -30 },
  { 10259, 18, 37, 18, 2, -36 },
  { 10343, 27, 30, 32, 3, -29 },
  { 10445, 25, 29, 26, 3, -29 },
  { 10536, 39, 29, 40, 3, -29 },
  { 10678, 30, 29, 27, -2, -29 },
  { 10787, 33, 42, 26, -5, -29 },
  { 10961, 25, 29, 24, -1, -29 },
  { 11052, 21, 48, 19, 1, -39 },
  { 11178, 4, 55, 30, 14, -42 },
  { 11206, 21, 48, 19, -2, -39 },
  { 11332, 26, 7, 31, 4, -23 },
};

const GFXfont NotoSans_Italic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic55pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_ITALIC55PT7B_H_
