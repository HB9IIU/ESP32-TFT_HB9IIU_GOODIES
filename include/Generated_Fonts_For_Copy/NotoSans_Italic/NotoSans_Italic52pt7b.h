#ifndef _NOTOSANS_ITALIC52PT7B_H_
#define _NOTOSANS_ITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x18, 0x00, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xE3, 0x87,
  0x03, 0xE1, 0xC0, 0x81, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xCE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x39, 0xF8, 0x00,
  0x3C, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE2, 0x01, 0xE3, 0xE1, 0x80, 0xE3, 0xF0,
  0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xF0, 0x1F, 0xF8, 0x00, 0x3C, 0x07, 0xFF, 0x00,
  0x0F, 0x81, 0xF0, 0xF0, 0x01, 0xE0, 0x7C, 0x1E, 0x00, 0x78, 0x0F, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x38, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x1C, 0x1E, 0x00, 0x3C, 0x07, 0x87,
  0x80, 0x07, 0x80, 0xF0, 0xF0, 0xF0, 0xF0, 0x1C, 0x3C, 0x7F, 0x9E, 0x07,
  0x8F, 0x1F, 0xFB, 0xC1, 0xF3, 0xC7, 0xFF, 0xBC, 0x3C, 0x79, 0xF0, 0xF7,
  0xFF, 0x1E, 0x7C, 0x1E, 0x7F, 0xC7, 0x8F, 0x03, 0xC7, 0xF1, 0xE1, 0xE0,
  0x78, 0x30, 0x3C, 0x78, 0x0F, 0x00, 0x0F, 0x0F, 0x01, 0xE0, 0x03, 0xC1,
  0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0xF0, 0x07,
  0x81, 0xE0, 0x1C, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0xF0, 0x03, 0xC1,
  0xF0, 0x3E, 0x00, 0x3C, 0x7C, 0x07, 0x80, 0x07, 0xFF, 0x01, 0xE0, 0x00,
  0x7F, 0xC0, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0x80, 0x1F, 0x1F,
  0x8F, 0x80, 0x3E, 0x3F, 0x07, 0xC0, 0x3E, 0x7E, 0x03, 0xE0, 0x7C, 0x7C,
  0x03, 0xF0, 0x7C, 0xF8, 0x01, 0xF0, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0xF0,
  0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x3F, 0xC0, 0xF0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x80, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0x0F, 0xF3, 0xE0, 0x3F, 0xFF, 0xE3, 0xF0, 0x1F,
  0xFF, 0x81, 0xF0, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x7D,
  0xF7, 0xDE, 0x79, 0xE7, 0xBC, 0xF3, 0xCE, 0x38, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x20, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x7E, 0x1C, 0x00,
  0xFF, 0x9C, 0x00, 0x1F, 0xFC, 0x07, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7D, 0xFF, 0x00, 0xEE, 0x01, 0x03, 0xEE, 0x00, 0x07, 0xCF, 0x00,
  0x0F, 0x8F, 0x00, 0x1F, 0x07, 0x80, 0x3F, 0x07, 0x80, 0x1E, 0x07, 0xC0,
  0x0C, 0x03, 0xC0, 0x04, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE,
  0x7C, 0xFB, 0xFF, 0xEF, 0xDF, 0x9C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x00,
  0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x0F, 0xE7, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xBE, 0xFF, 0x3C, 0x7C, 0x3C, 0x30,
  0x7C, 0x20, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE1, 0xFC,
  0x01, 0xE0, 0x0F, 0xC0, 0x18, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x78, 0x03, 0xF0,
  0x08, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x80, 0x00, 0x7C, 0x38, 0x00, 0x7E, 0x0F, 0xF0, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x7C,
  0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x60, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC2, 0x00, 0x03, 0xE0, 0xE0, 0x03, 0xF8, 0x3F, 0x07, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xFC, 0x18, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x7F, 0xC0, 0x3C, 0x7F, 0xF0, 0x1E, 0xFF, 0xFC, 0x1F, 0xFC, 0xFF,
  0x0F, 0xF0, 0x0F, 0x87, 0xF0, 0x07, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00,
  0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE1, 0xE0,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x0F,
  0xE3, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFC, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F,
  0x00, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x07, 0xE1, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFB, 0xF0, 0x03, 0xF8, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x80,
  0x3F, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x7C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xE3, 0xF0, 0x1F, 0xE0, 0xFF, 0x7E, 0xF0,
  0x3F, 0xFE, 0xF8, 0x0F, 0xFE, 0x7C, 0x03, 0xFC, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x40, 0x07, 0xE0, 0x3F, 0x7F, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x1F,
  0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC0,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0x1F, 0xE3, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0xC0,
  0x1E, 0x1E, 0x00, 0x7F, 0xFC, 0x1E, 0x1E, 0x01, 0xFF, 0xF8, 0x0F, 0x3C,
  0x03, 0xF0, 0xF8, 0x0F, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x78, 0x0F, 0x80,
  0x78, 0x0F, 0x78, 0x1F, 0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x00, 0xF0, 0x0F,
  0xF0, 0x3E, 0x00, 0xF0, 0x0F, 0xF0, 0x3C, 0x00, 0xF0, 0x0E, 0xF0, 0x3C,
  0x01, 0xE0, 0x1E, 0xF0, 0x3C, 0x01, 0xE0, 0x1E, 0xF0, 0x78, 0x01, 0xE0,
  0x1E, 0xF0, 0x78, 0x03, 0xE0, 0x3C, 0xF0, 0x78, 0x03, 0xC0, 0x3C, 0xF0,
  0x7C, 0x07, 0xC0, 0x78, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0xF0, 0x3E, 0x1F,
  0xE1, 0xF0, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x78, 0x0F, 0xF0, 0x7F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x10, 0x00, 0x07,
  0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0x00,
  0x7F, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xF0, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xF0, 0x7C, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFE, 0x7F, 0x00, 0xFF, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x60, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x0F,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E,
  0x07, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0xC0,
  0x7C, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x10, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0x00, 0xFE, 0x00, 0x02, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xE7, 0xC0, 0x07, 0xFF, 0x8F,
  0x80, 0x0F, 0xFF, 0x1F, 0x00, 0x1F, 0xFE, 0x3E, 0x00, 0x3F, 0xFC, 0x7C,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x80,
  0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x07, 0xC0, 0x7F, 0x80, 0x0F, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x02, 0x0F, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x1E, 0xF8,
  0x0F, 0x78, 0x00, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x00, 0xF7, 0xC0, 0x3C, 0xF0, 0x00, 0x79, 0xF0, 0x1F, 0x3C, 0x00,
  0x3E, 0x78, 0x07, 0xCF, 0x00, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x07, 0xC7,
  0x80, 0x78, 0xF0, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x00, 0xF8, 0xF8, 0x0F,
  0x87, 0x00, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78,
  0x07, 0x87, 0xC0, 0x3C, 0x1E, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0xF0,
  0x7C, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x01, 0xF0, 0x78, 0x3E, 0x07, 0x80,
  0x78, 0x1E, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x87, 0xC0, 0xF8, 0x07, 0x80,
  0xF1, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xDE, 0x01, 0xF0, 0x0F, 0x00, 0xF7, 0x80, 0x7C,
  0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xF0, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0x00, 0x3C,
  0x03, 0xFC, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x01, 0xF0, 0x1E, 0xF8, 0x00,
  0x3C, 0x03, 0xCF, 0x00, 0x07, 0x80, 0x79, 0xE0, 0x00, 0xF0, 0x0F, 0x3E,
  0x00, 0x3E, 0x03, 0xE3, 0xC0, 0x07, 0xC0, 0x7C, 0x7C, 0x00, 0xF0, 0x0F,
  0x0F, 0x80, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF8,
  0x0F, 0x81, 0xE0, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x1F, 0x00, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x01,
  0xF0, 0x78, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x03, 0xE1, 0xE0, 0x1E,
  0x00, 0x3C, 0x7C, 0x03, 0xC0, 0x07, 0x8F, 0x80, 0xF8, 0x00, 0xF9, 0xE0,
  0x1E, 0x00, 0x0F, 0x3C, 0x03, 0xC0, 0x01, 0xF7, 0x80, 0x78, 0x00, 0x3E,
  0xF0, 0x1F, 0x00, 0x03, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x78, 0x00,
  0x07, 0xF0, 0x0F, 0x00, 0x00, 0xFE, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xC0, 0x0F, 0xC0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x07, 0xF0, 0x3E, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xF8, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01,
  0xF0, 0x0F, 0xE0, 0x1E, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xE0, 0x78, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xF0,
  0x01, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x80,
  0xFC, 0x00, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x80, 0x01, 0xF8, 0x38, 0x00, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0x78, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xC0,
  0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x78, 0x00, 0x3F, 0x80, 0x03, 0xCF, 0x00, 0x07, 0xF0, 0x00, 0xF9,
  0xE0, 0x01, 0xFE, 0x00, 0x1E, 0x3C, 0x00, 0x3F, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0x1E, 0x00, 0x7D,
  0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x3C, 0x01, 0xF0, 0x7C, 0x03, 0xE7, 0x80,
  0x3E, 0x0F, 0x80, 0x78, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x1E, 0x01, 0xF0,
  0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x78, 0x0F, 0x80, 0xF8,
  0x1E, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0xE0, 0x7C, 0x03, 0xE0, 0xF0,
  0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x03, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x78,
  0x7C, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x01, 0xE3, 0xE0,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x00, 0x79, 0xF0, 0x07, 0x9F, 0x00, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0x3D, 0xE0,
  0x03, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x1F,
  0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x3C,
  0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7C,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xF8, 0xF8, 0x78,
  0x7C, 0x3C, 0x1E, 0x0E, 0x0F, 0x00, 0x3F, 0xC1, 0xE0, 0x1F, 0xFC, 0x38,
  0x07, 0xFF, 0xCF, 0x01, 0xFE, 0xFD, 0xE0, 0x7E, 0x03, 0xFC, 0x1F, 0x80,
  0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E,
  0x07, 0x80, 0x0F, 0xC0, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0xFF, 0x03, 0xE0,
  0x3D, 0xE0, 0x3F, 0x1F, 0x78, 0x07, 0xFF, 0xCF, 0x00, 0x7F, 0xF1, 0xE0,
  0x07, 0xF8, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x1F, 0xC0, 0x07, 0xC7, 0xFE, 0x00, 0xF3, 0xFF, 0xE0, 0x1E, 0xFD,
  0xFC, 0x07, 0xFC, 0x0F, 0xC0, 0xFF, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0x03,
  0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0xC0, 0x7E, 0x07, 0xBE, 0x3F, 0xC0,
  0xF3, 0xFF, 0xF0, 0x1E, 0x3F, 0xF8, 0x07, 0x83, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xE0, 0x08, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x10, 0x3F, 0x87, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x3E, 0x00, 0x7F, 0xF1,
  0xE0, 0x07, 0xFF, 0xCF, 0x00, 0x7F, 0xBF, 0x78, 0x07, 0xE0, 0x3F, 0xC0,
  0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0xFC, 0x03, 0xC0, 0x0F,
  0xE0, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x0F, 0xF8, 0x03, 0xF1, 0xF7, 0x80,
  0x1F, 0xFF, 0x3C, 0x00, 0x7F, 0xF1, 0xE0, 0x01, 0xFE, 0x0F, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0x7F, 0x07, 0xE0, 0x7C, 0x3F, 0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0,
  0x0F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x01, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x18, 0x3F, 0xC3, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xC1, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xCF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xF0,
  0x07, 0xFF, 0x0E, 0x00, 0xFF, 0xF9, 0xE0, 0x1F, 0xEF, 0xDE, 0x03, 0xF0,
  0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x3C, 0x00, 0x7E, 0x03, 0xC0, 0x0F,
  0xE0, 0x3E, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0x8F, 0xBC, 0x01,
  0xFF, 0xF3, 0xC0, 0x0F, 0xFE, 0x3C, 0x00, 0x7F, 0x87, 0xC0, 0x00, 0xC0,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x03, 0xF0, 0x0C, 0x00,
  0x7E, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE1, 0xFE, 0x00, 0xF8,
  0xFF, 0xC0, 0x3C, 0xFF, 0xF8, 0x0F, 0x7F, 0xFF, 0x07, 0xFC, 0x07, 0xC1,
  0xFE, 0x01, 0xF0, 0x7F, 0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x07, 0xC0, 0x07,
  0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x03, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x87, 0xC0,
  0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x7C, 0x00, 0x1F,
  0x8F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xC1, 0xFC, 0x01, 0xFE,
  0x00, 0xF1, 0xFF, 0x81, 0xFF, 0xC0, 0x3C, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F,
  0x7E, 0xFE, 0x7E, 0xFE, 0x07, 0xFC, 0x0F, 0xBC, 0x0F, 0x81, 0xFE, 0x01,
  0xFE, 0x01, 0xF0, 0x7F, 0x00, 0x7F, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x83, 0xF0, 0x03, 0xF0, 0x01, 0xE0,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F,
  0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0xF0, 0x7F, 0x80, 0x3C, 0x7F, 0xF8, 0x0F, 0x3F, 0xFE, 0x07,
  0xDF, 0xFF, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0x80, 0x7C, 0x1F, 0xC0, 0x1F,
  0x07, 0xE0, 0x07, 0xC3, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7E, 0x03,
  0xE0, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7,
  0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xF0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xF0, 0x7F, 0x80, 0x07, 0x87, 0xFE, 0x00, 0x3C, 0xFF, 0xF8,
  0x01, 0xEF, 0xDF, 0xC0, 0x1F, 0xF0, 0x3F, 0x00, 0xFF, 0x00, 0xF8, 0x07,
  0xF0, 0x03, 0xC0, 0x3F, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0x80, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0xFF, 0x00, 0xF3, 0xFF, 0xF0, 0x07,
  0x8F, 0xFE, 0x00, 0x3C, 0x3F, 0xE0, 0x03, 0xE0, 0x30, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC1, 0xE0, 0x1F, 0xFC, 0x38, 0x07, 0xFF, 0xCF,
  0x01, 0xFE, 0xFD, 0xE0, 0x7E, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0,
  0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F,
  0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x0F,
  0xC0, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x3F,
  0x1F, 0x78, 0x07, 0xFF, 0xCF, 0x00, 0x7F, 0xF1, 0xE0, 0x07, 0xF8, 0x7C,
  0x00, 0x18, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC1, 0xF8, 0x1E, 0x3F, 0xC0, 0xF3,
  0xFE, 0x07, 0xBF, 0xE0, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xF7, 0xF0, 0xF8, 0x03, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x98, 0x00, 0xF8, 0xF8, 0x3F,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x40, 0x00, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3C,
  0x00, 0xFE, 0x0F, 0x80, 0x7F, 0x83, 0xE0, 0x3F, 0xE0, 0xFE, 0x7E, 0xF0,
  0x1F, 0xFF, 0x3C, 0x07, 0xFF, 0x8F, 0x00, 0x7F, 0x83, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF,
  0x00, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F,
  0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x7B,
  0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0xFE, 0x00, 0x79, 0xF0, 0x07, 0xF0, 0x07,
  0xCF, 0x80, 0x3F, 0x80, 0x3E, 0x7C, 0x03, 0xFC, 0x03, 0xE3, 0xE0, 0x1D,
  0xE0, 0x1F, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0xF8, 0x0F, 0x78, 0x0F, 0x87,
  0xC0, 0xF3, 0xC0, 0x78, 0x3E, 0x07, 0x9E, 0x07, 0xC1, 0xF0, 0x78, 0xF0,
  0x3C, 0x0F, 0x83, 0xC7, 0x83, 0xE0, 0x3C, 0x3C, 0x3C, 0x1E, 0x01, 0xE1,
  0xE1, 0xE1, 0xF0, 0x0F, 0x1E, 0x07, 0x0F, 0x00, 0x78, 0xF0, 0x38, 0xF8,
  0x03, 0xCF, 0x01, 0xC7, 0xC0, 0x1E, 0x78, 0x0E, 0x3C, 0x00, 0xF3, 0x80,
  0x73, 0xE0, 0x07, 0xBC, 0x03, 0x9E, 0x00, 0x3D, 0xE0, 0x1E, 0xF0, 0x01,
  0xFE, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x07, 0x78, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3C,
  0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x01, 0xE0, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x87, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x7F,
  0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 38, 14, 1, -37 },
  { 63, 15, 13, 20, 6, -37 },
  { 88, 32, 37, 34, 2, -37 },
  { 236, 25, 42, 29, 2, -39 },
  { 368, 35, 39, 42, 4, -38 },
  { 539, 32, 39, 35, 2, -38 },
  { 695, 6, 13, 11, 6, -37 },
  { 705, 17, 45, 15, 2, -37 },
  { 801, 17, 45, 15, -4, -37 },
  { 897, 24, 24, 29, 5, -40 },
  { 969, 24, 25, 30, 4, -31 },
  { 1044, 10, 13, 13, -2, -6 },
  { 1061, 14, 4, 16, 1, -16 },
  { 1068, 7, 7, 13, 1, -6 },
  { 1075, 25, 37, 19, -2, -37 },
  { 1191, 25, 39, 29, 3, -38 },
  { 1313, 16, 37, 29, 7, -37 },
  { 1387, 27, 38, 29, 0, -38 },
  { 1516, 26, 39, 29, 1, -38 },
  { 1643, 28, 37, 29, 0, -37 },
  { 1773, 26, 38, 29, 2, -37 },
  { 1897, 25, 39, 29, 3, -38 },
  { 2019, 25, 37, 29, 4, -37 },
  { 2135, 26, 39, 29, 2, -38 },
  { 2262, 25, 39, 29, 2, -38 },
  { 2384, 11, 30, 13, 1, -29 },
  { 2426, 15, 36, 13, -3, -29 },
  { 2494, 24, 26, 30, 4, -32 },
  { 2572, 24, 14, 30, 4, -25 },
  { 2614, 24, 26, 30, 4, -32 },
  { 2692, 20, 39, 22, 4, -38 },
  { 2790, 40, 42, 44, 3, -37 },
  { 3000, 30, 37, 29, -3, -37 },
  { 3139, 29, 37, 31, 2, -37 },
  { 3274, 29, 39, 31, 4, -38 },
  { 3416, 31, 37, 35, 2, -37 },
  { 3560, 27, 37, 27, 2, -37 },
  { 3685, 27, 37, 25, 2, -37 },
  { 3810, 31, 39, 35, 4, -38 },
  { 3962, 34, 37, 35, 2, -37 },
  { 4120, 21, 37, 17, -1, -37 },
  { 4218, 23, 47, 14, -8, -37 },
  { 4354, 32, 37, 29, 2, -37 },
  { 4502, 20, 37, 25, 2, -37 },
  { 4595, 42, 37, 44, 2, -37 },
  { 4790, 35, 37, 37, 2, -37 },
  { 4952, 32, 39, 37, 4, -38 },
  { 5108, 27, 37, 29, 2, -37 },
  { 5233, 32, 47, 37, 4, -38 },
  { 5421, 28, 37, 30, 2, -37 },
  { 5551, 26, 39, 26, 1, -38 },
  { 5678, 26, 37, 26, 5, -37 },
  { 5799, 32, 38, 35, 4, -37 },
  { 5951, 28, 37, 29, 5, -37 },
  { 6081, 43, 37, 45, 6, -37 },
  { 6280, 35, 37, 27, -3, -37 },
  { 6442, 26, 37, 26, 5, -37 },
  { 6563, 31, 37, 28, -1, -37 },
  { 6707, 19, 45, 15, 0, -37 },
  { 6814, 9, 37, 19, 6, -37 },
  { 6856, 20, 45, 15, -4, -37 },
  { 6969, 26, 23, 30, 2, -37 },
  { 7044, 22, 3, 21, -5, 5 },
  { 7053, 8, 8, 14, 8, -40 },
  { 7061, 27, 29, 30, 2, -28 },
  { 7159, 27, 41, 30, 1, -40 },
  { 7298, 22, 29, 24, 2, -28 },
  { 7378, 29, 41, 30, 2, -40 },
  { 7527, 22, 29, 26, 2, -28 },
  { 7607, 29, 52, 17, -6, -40 },
  { 7796, 28, 40, 30, 1, -28 },
  { 7936, 26, 40, 30, 1, -40 },
  { 8066, 13, 38, 13, 1, -38 },
  { 8128, 21, 50, 13, -7, -38 },
  { 8260, 26, 40, 26, 1, -40 },
  { 8390, 13, 40, 13, 1, -40 },
  { 8455, 42, 28, 46, 1, -28 },
  { 8602, 26, 29, 30, 1, -29 },
  { 8697, 25, 28, 29, 2, -28 },
  { 8785, 29, 40, 30, -1, -28 },
  { 8930, 27, 40, 30, 2, -28 },
  { 9065, 21, 28, 21, 1, -28 },
  { 9139, 21, 29, 22, 0, -28 },
  { 9216, 17, 35, 17, 2, -34 },
  { 9291, 26, 29, 30, 3, -28 },
  { 9386, 25, 28, 24, 2, -28 },
  { 9474, 37, 28, 38, 3, -28 },
  { 9604, 29, 28, 25, -2, -28 },
  { 9706, 32, 40, 24, -5, -28 },
  { 9866, 24, 28, 23, -1, -28 },
  { 9950, 20, 45, 18, 1, -37 },
  { 10063, 3, 53, 29, 14, -40 },
  { 10083, 20, 45, 18, -2, -37 },
  { 10196, 24, 7, 30, 4, -22 },
};

const GFXfont NotoSans_Italic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic52pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_ITALIC52PT7B_H_
