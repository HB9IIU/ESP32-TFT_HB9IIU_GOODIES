#ifndef _NOTOSANS_ITALIC59PT7B_H_
#define _NOTOSANS_ITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0x07,
  0xCF, 0xC3, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0,
  0x78, 0x70, 0x1E, 0x1C, 0x07, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFE, 0x3C, 0x3C, 0x07, 0xE1, 0xE0, 0x40, 0x3E, 0x1E, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xC0,
  0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x07, 0xE7, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1E, 0x7F, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x38, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0xF0, 0x7C, 0x00, 0x07, 0x87, 0xE1, 0x00, 0x38, 0x3E, 0x0E, 0x03, 0xC7,
  0xF0, 0x7F, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x04, 0x03, 0xFE,
  0x00, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0x80, 0x01,
  0xF0, 0x1F, 0x8F, 0x80, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00,
  0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x07, 0x83, 0xE0,
  0x00, 0xF0, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x0F, 0x07, 0x83, 0xE0, 0xF0,
  0x0F, 0x0F, 0x0F, 0xF8, 0xF0, 0x1F, 0x1F, 0x1F, 0xFC, 0xF0, 0x1E, 0x3E,
  0x3F, 0xFE, 0xF8, 0x3E, 0x3C, 0x7C, 0x3E, 0xFC, 0xFC, 0x78, 0xF8, 0x1E,
  0x7F, 0xF8, 0xF8, 0xF0, 0x1E, 0x7F, 0xF1, 0xF1, 0xF0, 0x1F, 0x3F, 0xE1,
  0xE1, 0xE0, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x1E, 0x00, 0x07, 0xC3, 0xE0,
  0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00,
  0x1F, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xC0,
  0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x0F, 0x80, 0x03, 0xF3,
  0xE0, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x3E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x1F, 0x0F, 0xC3, 0xF0,
  0x03, 0xE1, 0xF8, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x07, 0xC7, 0xE0,
  0x07, 0xC0, 0x7C, 0x7C, 0x00, 0x7E, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0xF8, 0x00, 0x1F, 0xBF, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0xF8, 0x00, 0x0F,
  0xFC, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xC0,
  0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xF8,
  0x3F, 0x00, 0xFF, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x08, 0x01, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0x7E, 0x07, 0x00, 0x0F, 0xF0, 0xE0, 0x03, 0xFF, 0xBC, 0x00, 0x0F,
  0xFF, 0x00, 0x30, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x0F,
  0x8E, 0x00, 0x03, 0xE1, 0xE0, 0x01, 0xF8, 0x3C, 0x00, 0x7F, 0x07, 0xC0,
  0x0F, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x80, 0x0C, 0x01, 0xF0, 0x00, 0x80,
  0x3F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0x80, 0x3E, 0x7E, 0x7F, 0xFF, 0xFE, 0xFE, 0x7C,
  0x38, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xFC, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xE1, 0xFE, 0xF8, 0xFF, 0x7E, 0xFF, 0x9F, 0x1F, 0x87,
  0xC3, 0xC1, 0xF0, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x1E, 0x00, 0x3F, 0x80, 0x18, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0x00, 0x1F, 0xC0, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x80, 0x00, 0x1F, 0x83, 0x80, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x20, 0x00, 0x0F, 0xE0,
  0xC0, 0x00, 0x7F, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE1, 0xFF, 0x80, 0x7E, 0x7F, 0xFC, 0x07, 0xCF, 0xFF,
  0xE0, 0x7D, 0xFF, 0xFF, 0x07, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0x1F, 0x8F,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xBF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xE0, 0x7E, 0x01, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xE1, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF7, 0xC0,
  0x3F, 0xFE, 0x7C, 0x00, 0xFF, 0x87, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0xF8, 0x0F, 0xE3, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0xFF, 0x00, 0xF8, 0x3C, 0x00, 0xFF, 0xFF, 0x01, 0xE1, 0xF0, 0x07,
  0xFF, 0xFC, 0x07, 0x87, 0x80, 0x3F, 0x83, 0xF0, 0x1E, 0x3E, 0x01, 0xF8,
  0x07, 0x80, 0x78, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF3, 0xC0, 0x3C, 0x00,
  0xF8, 0x07, 0x9F, 0x01, 0xF0, 0x03, 0xC0, 0x1E, 0x78, 0x0F, 0x80, 0x0F,
  0x00, 0x79, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xE7, 0x80, 0xF0, 0x01, 0xF0,
  0x07, 0xBE, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0xF8, 0x1F, 0x00, 0x1E, 0x00,
  0xFB, 0xE0, 0x7C, 0x00, 0xF8, 0x03, 0xCF, 0x81, 0xF0, 0x03, 0xE0, 0x0F,
  0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xE3,
  0xE0, 0x7C, 0x03, 0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0x1F, 0xE0, 0x7C, 0x3E,
  0x03, 0xE0, 0xF7, 0x87, 0xE0, 0x78, 0x0F, 0xFF, 0x9F, 0xFF, 0x01, 0xE0,
  0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xF0, 0x07,
  0xC0, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x7F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0xFF, 0x03, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xF8, 0x03, 0xFC, 0x00,
  0x08, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x3F, 0xE0, 0x3F,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x0F,
  0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x03, 0xF8, 0x03,
  0xE0, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xC0, 0x00, 0x70, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x07,
  0xFF, 0xE7, 0xE0, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0xFF, 0x1F, 0x80,
  0x04, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x0F, 0x81, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x01, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xF7, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x7D, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x01, 0xE3,
  0xC0, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xC0, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xC0, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF8, 0x03, 0xE3,
  0xE0, 0x01, 0xE1, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x03, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC1,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x81,
  0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x0F, 0x81,
  0xF0, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x78, 0x07, 0xC0, 0x1F, 0x00,
  0xF0, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0xF1, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0xFF, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x7F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xF7, 0xC0,
  0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x7C,
  0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0x01, 0xE3,
  0xF0, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x1F,
  0x00, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x03,
  0xEF, 0x80, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0x03, 0xEF, 0x80,
  0x3E, 0x00, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF, 0xC0,
  0x1F, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0xC0, 0x7C, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0B, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFC, 0x3F,
  0xFC, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0xFC, 0x03, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xC0, 0x0F,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x03, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x03,
  0x00, 0x03, 0xFC, 0x0F, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x3C,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF3,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x07,
  0xC3, 0xC0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x3C, 0x03, 0xF0, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x07, 0x9F,
  0x00, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x7B,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x00, 0x7B, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0xFC,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0x01,
  0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x78, 0x03, 0xFF, 0xC3,
  0xC0, 0x3F, 0xFF, 0x1E, 0x03, 0xFF, 0xF9, 0xF0, 0x3F, 0xC3, 0xEF, 0x83,
  0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0xC0, 0xFC, 0x0F, 0xBE, 0x07, 0xFF,
  0xF9, 0xE0, 0x1F, 0xFF, 0x8F, 0x00, 0x7F, 0xF8, 0x78, 0x01, 0xFF, 0x03,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x0F, 0x87, 0xFF, 0x00,
  0x7C, 0x7F, 0xFC, 0x03, 0xE7, 0xFF, 0xF0, 0x3E, 0x7C, 0x3F, 0x81, 0xF7,
  0x80, 0xFE, 0x0F, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0x83, 0xF8, 0x00,
  0x7C, 0x3F, 0x80, 0x03, 0xE1, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x3E, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE1, 0xFC,
  0x00, 0x7E, 0x0F, 0xF0, 0x07, 0xF0, 0x7B, 0xC0, 0x7F, 0x07, 0xDF, 0xFF,
  0xF0, 0x3E, 0x7F, 0xFF, 0x01, 0xE1, 0xFF, 0xF0, 0x0F, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x1E, 0x07, 0xF0, 0x02, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x10, 0x7F, 0x80, 0x70, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xE0, 0xF8, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0xFF, 0xFC, 0xF8, 0x03,
  0xFF, 0xFC, 0xF8, 0x07, 0xFC, 0x3E, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x80, 0xF8,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x7E,
  0x07, 0xDF, 0x00, 0x7F, 0xFF, 0x9E, 0x00, 0x3F, 0xFF, 0x1E, 0x00, 0x1F,
  0xFE, 0x1E, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE3, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x06, 0x0F,
  0xF0, 0x0F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x02, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x0F, 0x00, 0x1F, 0xFE, 0x1E, 0x00, 0x3F, 0xFF, 0x1E, 0x00,
  0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0x0F, 0xBE, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F,
  0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0xE0, 0x3E,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0xC0, 0x1F,
  0x81, 0xF7, 0xC0, 0x1F, 0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0xCF, 0x80, 0x07,
  0xFF, 0x8F, 0x80, 0x03, 0xFE, 0x0F, 0x80, 0x00, 0x20, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x80,
  0x00, 0xFC, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x3F, 0xC0, 0x0F, 0x87, 0xFF, 0x00, 0x7C, 0x7F,
  0xFC, 0x03, 0xE7, 0xFF, 0xF0, 0x3E, 0x7C, 0x3F, 0x81, 0xF7, 0x80, 0x7E,
  0x0F, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0x83, 0xF8, 0x00, 0x7C, 0x3F,
  0x80, 0x03, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x08, 0x7E, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xCF, 0xC0,
  0x00, 0x3E, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xBE, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x3F, 0x87, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0x87, 0xFE, 0x01,
  0xFF, 0xC0, 0x3C, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFF, 0x07, 0xCF, 0x87, 0xE3, 0xE1, 0xFC, 0x1F, 0x78, 0x0F, 0x9E, 0x03,
  0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xC1, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0xC0, 0x07, 0xC3,
  0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0x80, 0xF9, 0xFF, 0xFE, 0x03, 0xEF, 0xE3,
  0xFC, 0x0F, 0xBE, 0x03, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0x3F,
  0x07, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x7C,
  0x3F, 0xF8, 0x00, 0x78, 0x7F, 0xFC, 0x00, 0x78, 0xFF, 0xFE, 0x00, 0xF9,
  0xF0, 0xFE, 0x00, 0xFB, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0xFE, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFC,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0,
  0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0x3F,
  0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0x80, 0x1F, 0x1F, 0xFF, 0x00, 0x1F, 0x07,
  0xFC, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x38, 0x03, 0xFF, 0xC3, 0xC0, 0x3F, 0xFF, 0x1E, 0x07, 0xFF, 0xF9,
  0xF0, 0x7F, 0xC3, 0xEF, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x0F,
  0xF0, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0xC0,
  0xFC, 0x0F, 0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x9F, 0x00, 0x7F,
  0xF8, 0xF8, 0x01, 0xFF, 0x07, 0xC0, 0x00, 0x80, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0xFE,
  0x07, 0xC3, 0xFC, 0x0F, 0x1F, 0xF8, 0x1E, 0x3F, 0xF0, 0x7C, 0xFF, 0xC0,
  0xFB, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x3E, 0x07, 0xE0, 0x06, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xC0,
  0x01, 0xF8, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x06, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xFE, 0x1F, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF8,
  0x3F, 0x00, 0x7F, 0xC0, 0xFC, 0x0F, 0xBE, 0x07, 0xFF, 0xF9, 0xE0, 0x3F,
  0xFF, 0x8F, 0x00, 0xFF, 0xF8, 0x78, 0x01, 0xFF, 0x07, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1E,
  0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x03,
  0xEF, 0x80, 0x07, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x7C,
  0x00, 0xFF, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0xC0, 0x0F, 0xC7, 0xC0, 0x1E,
  0xF0, 0x03, 0xE1, 0xF0, 0x07, 0xBC, 0x01, 0xF8, 0x7C, 0x03, 0xEF, 0x00,
  0x7C, 0x1F, 0x00, 0xF3, 0xC0, 0x3F, 0x07, 0xC0, 0x7C, 0xF0, 0x0F, 0x81,
  0xF0, 0x1E, 0x3C, 0x07, 0xE0, 0x7C, 0x0F, 0x8F, 0x01, 0xF0, 0x1F, 0x03,
  0xC3, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x3E,
  0x0F, 0x80, 0x7C, 0x1E, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x07, 0xC3, 0xC0, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x3E, 0x3E, 0x00, 0x7C,
  0x78, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x00,
  0x79, 0xF0, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x00, 0x7D, 0xE0, 0x07, 0xBE,
  0x00, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x08, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x11, 0xFF, 0x80, 0x01, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0xC0,
  0x03, 0xFF, 0xC8, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 43, 15, 1, -42 },
  { 82, 18, 15, 23, 6, -42 },
  { 116, 37, 42, 38, 2, -42 },
  { 311, 29, 48, 33, 2, -45 },
  { 485, 40, 44, 47, 5, -43 },
  { 705, 36, 44, 40, 2, -43 },
  { 903, 8, 15, 13, 6, -42 },
  { 918, 20, 51, 17, 2, -42 },
  { 1046, 20, 51, 17, -5, -42 },
  { 1174, 27, 27, 33, 6, -45 },
  { 1266, 28, 28, 34, 4, -35 },
  { 1364, 12, 15, 15, -3, -7 },
  { 1387, 15, 5, 18, 2, -18 },
  { 1397, 8, 8, 15, 1, -7 },
  { 1405, 29, 42, 21, -3, -42 },
  { 1558, 29, 44, 33, 3, -43 },
  { 1718, 18, 42, 33, 8, -42 },
  { 1813, 31, 43, 33, 0, -43 },
  { 1980, 30, 44, 33, 1, -43 },
  { 2145, 32, 42, 33, 0, -42 },
  { 2313, 30, 43, 33, 2, -42 },
  { 2475, 28, 44, 33, 4, -43 },
  { 2629, 28, 42, 33, 5, -42 },
  { 2776, 29, 44, 33, 3, -43 },
  { 2936, 28, 44, 33, 3, -43 },
  { 3090, 12, 33, 15, 1, -32 },
  { 3140, 16, 40, 15, -3, -32 },
  { 3220, 28, 29, 34, 4, -36 },
  { 3322, 28, 16, 34, 4, -29 },
  { 3378, 28, 29, 34, 4, -36 },
  { 3480, 22, 44, 25, 5, -43 },
  { 3601, 46, 47, 50, 3, -42 },
  { 3872, 33, 42, 33, -3, -42 },
  { 4046, 33, 42, 35, 2, -42 },
  { 4220, 33, 44, 35, 4, -43 },
  { 4402, 36, 42, 39, 2, -42 },
  { 4591, 31, 42, 30, 2, -42 },
  { 4754, 31, 42, 28, 2, -42 },
  { 4917, 35, 44, 40, 4, -43 },
  { 5110, 38, 42, 40, 2, -42 },
  { 5310, 23, 42, 19, -1, -42 },
  { 5431, 26, 53, 16, -9, -42 },
  { 5604, 36, 42, 33, 2, -42 },
  { 5793, 23, 42, 28, 2, -42 },
  { 5914, 48, 42, 50, 2, -42 },
  { 6166, 40, 42, 42, 2, -42 },
  { 6376, 37, 44, 43, 4, -43 },
  { 6580, 31, 42, 33, 2, -42 },
  { 6743, 37, 53, 43, 4, -43 },
  { 6989, 32, 42, 34, 2, -42 },
  { 7157, 30, 44, 30, 1, -43 },
  { 7322, 30, 42, 30, 5, -42 },
  { 7480, 36, 43, 40, 5, -42 },
  { 7674, 33, 42, 33, 5, -42 },
  { 7848, 50, 42, 51, 6, -42 },
  { 8111, 39, 42, 31, -3, -42 },
  { 8316, 30, 42, 30, 5, -42 },
  { 8474, 35, 42, 31, -1, -42 },
  { 8658, 23, 51, 17, -1, -42 },
  { 8805, 11, 42, 21, 6, -42 },
  { 8863, 22, 51, 17, -4, -42 },
  { 9004, 30, 26, 34, 2, -42 },
  { 9102, 24, 4, 23, -5, 5 },
  { 9114, 9, 9, 16, 9, -45 },
  { 9125, 29, 33, 34, 3, -32 },
  { 9245, 29, 46, 34, 2, -45 },
  { 9412, 24, 33, 27, 3, -32 },
  { 9511, 32, 46, 34, 3, -45 },
  { 9695, 25, 33, 29, 3, -32 },
  { 9799, 33, 59, 19, -7, -45 },
  { 10043, 32, 46, 34, 1, -32 },
  { 10227, 29, 45, 34, 2, -45 },
  { 10391, 14, 43, 15, 2, -43 },
  { 10467, 23, 57, 15, -7, -43 },
  { 10631, 29, 45, 29, 2, -45 },
  { 10795, 14, 45, 15, 2, -45 },
  { 10874, 46, 32, 52, 2, -32 },
  { 11058, 30, 32, 34, 1, -32 },
  { 11178, 27, 32, 33, 3, -32 },
  { 11286, 32, 46, 34, -1, -32 },
  { 11470, 29, 46, 34, 3, -32 },
  { 11637, 23, 32, 23, 2, -32 },
  { 11729, 24, 33, 25, 0, -32 },
  { 11828, 18, 40, 20, 3, -39 },
  { 11918, 29, 33, 34, 3, -32 },
  { 12038, 27, 32, 28, 3, -32 },
  { 12146, 42, 32, 43, 3, -32 },
  { 12314, 32, 32, 29, -2, -32 },
  { 12442, 36, 46, 28, -6, -32 },
  { 12649, 27, 32, 26, -1, -32 },
  { 12757, 23, 51, 21, 1, -42 },
  { 12904, 5, 59, 33, 15, -45 },
  { 12941, 22, 51, 21, -2, -42 },
  { 13082, 28, 8, 34, 4, -25 },
};

const GFXfont NotoSans_Italic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic59pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_ITALIC59PT7B_H_
