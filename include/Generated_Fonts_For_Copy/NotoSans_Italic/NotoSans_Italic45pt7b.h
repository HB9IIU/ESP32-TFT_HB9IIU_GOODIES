#ifndef _NOTOSANS_ITALIC45PT7B_H_
#define _NOTOSANS_ITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0x60, 0x00, 0x7C,
  0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x70, 0x71, 0xC3, 0xC7, 0x0F, 0x3C,
  0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0C, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x38, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xF3, 0x9E, 0x0F, 0x1C, 0x08,
  0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x38,
  0xE0, 0x00, 0xF3, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x77, 0xC0, 0x01, 0xCF, 0x80,
  0x0E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0E,
  0x3C, 0x30, 0x71, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xC1, 0xFF, 0x00, 0x0E, 0x0F, 0x9E, 0x00, 0x70, 0x3C, 0x38, 0x03, 0xC1,
  0xE0, 0xE0, 0x1E, 0x07, 0x03, 0x80, 0x70, 0x1C, 0x0E, 0x03, 0xC0, 0xF0,
  0x38, 0x1E, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x0E,
  0x1E, 0x00, 0xE0, 0x78, 0xF0, 0x03, 0x81, 0xC3, 0x87, 0x0E, 0x07, 0x1C,
  0x7F, 0x38, 0x38, 0xF3, 0xFE, 0xE1, 0xE7, 0x9E, 0x7F, 0xEF, 0x1C, 0xF0,
  0xF7, 0xF8, 0xE3, 0x81, 0xCF, 0xC7, 0x9E, 0x07, 0x08, 0x3C, 0x70, 0x1C,
  0x00, 0xE1, 0xC0, 0x70, 0x07, 0x07, 0x03, 0xC0, 0x3C, 0x3C, 0x0F, 0x01,
  0xE0, 0xF0, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x38, 0x1C, 0x0F, 0x00, 0xF0, 0x70, 0x38, 0x03, 0xC3, 0x81, 0xC0, 0x07,
  0xFE, 0x0F, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0xF1, 0xF0, 0xF0, 0x1E, 0x3C, 0x07, 0x81, 0xE7, 0x80,
  0x7C, 0x3C, 0x78, 0x03, 0xE7, 0xC7, 0x80, 0x1E, 0x78, 0xF0, 0x01, 0xFF,
  0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0xC0, 0x7C,
  0x01, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xCF, 0x01, 0xFF, 0xF0,
  0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7D, 0xE7, 0x9E, 0x71, 0xC7, 0x3C, 0xE3,
  0x8E, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x40,
  0x78, 0x0E, 0x07, 0x00, 0xF8, 0x70, 0x0F, 0xE7, 0x00, 0x3F, 0xE0, 0x70,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x0F, 0x07, 0xB0, 0x00, 0xF3, 0x80,
  0x1E, 0x38, 0x03, 0xE3, 0xC0, 0x7C, 0x1C, 0x03, 0x81, 0xE0, 0x10, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x38, 0x38, 0x00, 0x7F, 0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0x7B,
  0xFF, 0xFE, 0xF9, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0x78,
  0x7C, 0x03, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0,
  0x03, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x80, 0xF8,
  0x3E, 0x1F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00,
  0x3C, 0x03, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xF8, 0xFD, 0xEF, 0xE7, 0x9E,
  0x3C, 0x20, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xC0,
  0x1E, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3C, 0x07,
  0xC0, 0x60, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x08, 0x00, 0x3E, 0x1E, 0x01, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xDC, 0x00, 0x07, 0x9C, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78,
  0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x20,
  0x01, 0xF0, 0xE0, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE1, 0xFC, 0x07, 0x9F, 0xF8, 0x1E, 0xFF, 0xF0, 0x7F, 0x07, 0xE3,
  0xF8, 0x07, 0x8F, 0xC0, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x7E, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xE0, 0x7C, 0x1F, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0,
  0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x8F, 0xC0, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xF8, 0x7C,
  0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3E, 0x00,
  0x78, 0x78, 0x03, 0xE1, 0xF8, 0x1F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0x7C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F,
  0x3C, 0x00, 0x79, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x3E, 0x01, 0xF8,
  0xF8, 0x3F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFD, 0xE0, 0x3F, 0x8F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x60, 0x3F, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x07, 0xC3, 0xE3, 0xF1, 0xF8,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xE3, 0xF1, 0xF0, 0xF8, 0x30, 0x00,
  0x00, 0x60, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x07, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xC0, 0xF9, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x78,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x1F, 0xF0, 0x3C,
  0x78, 0x0F, 0xFF, 0x07, 0x9E, 0x03, 0xFF, 0xE0, 0x73, 0xC0, 0xF0, 0x3C,
  0x0E, 0x70, 0x3C, 0x07, 0x01, 0xDE, 0x0F, 0x00, 0xE0, 0x3B, 0x81, 0xC0,
  0x3C, 0x07, 0x70, 0x78, 0x07, 0x81, 0xEE, 0x0F, 0x00, 0xE0, 0x3F, 0xC1,
  0xC0, 0x1C, 0x07, 0x78, 0x38, 0x07, 0x80, 0xEF, 0x07, 0x00, 0xF0, 0x3D,
  0xE0, 0xE0, 0x3C, 0x07, 0x3C, 0x1C, 0x07, 0x81, 0xE3, 0x83, 0xC1, 0xB8,
  0x78, 0x70, 0x7F, 0xF7, 0xFE, 0x0E, 0x07, 0xFC, 0xFF, 0x81, 0xE0, 0x7E,
  0x0F, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x00,
  0x07, 0xE0, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E,
  0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x78, 0x1F, 0xE0, 0x3C, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x1F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0x00, 0xFC, 0x07, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x3F, 0x07, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0x70, 0x1F, 0x80,
  0x08, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x07, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xE0, 0x7F, 0x80, 0x3C, 0x01, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0xC1, 0xE0, 0x03, 0xF0, 0x3C, 0x01, 0xFC,
  0x07, 0x8F, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x3C, 0x07,
  0xE0, 0x00, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x01, 0xFF, 0x9F, 0x00, 0x3F, 0xF3, 0xE0, 0x0F, 0xFE, 0x7C, 0x01,
  0xFF, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x78, 0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x3E,
  0x00, 0x3C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xDE,
  0x07, 0xB8, 0x00, 0x3D, 0xE0, 0x7B, 0x80, 0x03, 0x9C, 0x07, 0x38, 0x00,
  0x7B, 0xC0, 0x73, 0x80, 0x07, 0x3C, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0xF3,
  0xC0, 0x1E, 0x3C, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x3C, 0x78,
  0x1E, 0x1C, 0x03, 0xC7, 0x81, 0xE1, 0xC0, 0x78, 0x78, 0x1E, 0x1C, 0x07,
  0x07, 0x81, 0xE1, 0xC0, 0xF0, 0xF0, 0x1C, 0x1C, 0x0E, 0x0F, 0x03, 0xC1,
  0xE1, 0xE0, 0xF0, 0x3C, 0x1E, 0x1C, 0x0F, 0x03, 0xC1, 0xE3, 0xC1, 0xF0,
  0x3C, 0x0E, 0x78, 0x1E, 0x03, 0x80, 0xE7, 0x81, 0xE0, 0x78, 0x0E, 0xF0,
  0x1E, 0x07, 0x80, 0xEE, 0x01, 0xE0, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0x80,
  0xFC, 0x03, 0xC0, 0x70, 0x0F, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x03, 0xC0,
  0xF0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3F, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x1E,
  0x03, 0xF8, 0x00, 0x78, 0x1F, 0xE0, 0x01, 0xE0, 0x7F, 0x80, 0x07, 0x81,
  0xEF, 0x00, 0x1C, 0x07, 0x3C, 0x00, 0xF0, 0x1C, 0x70, 0x03, 0xC0, 0xF1,
  0xE0, 0x0F, 0x03, 0xC7, 0x80, 0x3C, 0x0F, 0x0F, 0x00, 0xE0, 0x38, 0x3C,
  0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x0E, 0x0F, 0x01, 0xC0, 0x3C, 0x3C, 0x0F, 0x00, 0xF0, 0xF0,
  0x3C, 0x01, 0xE3, 0xC0, 0xF0, 0x07, 0x8E, 0x03, 0xC0, 0x1E, 0x78, 0x0E,
  0x00, 0x3D, 0xE0, 0x78, 0x00, 0xF7, 0x81, 0xE0, 0x01, 0xDE, 0x07, 0x80,
  0x07, 0xF0, 0x1E, 0x00, 0x1F, 0xC0, 0x70, 0x00, 0x3F, 0x03, 0xC0, 0x00,
  0xFC, 0x0F, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xC1, 0xFC, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x7C, 0x1E, 0x03, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x7E,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xC1, 0xFC, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x7C, 0x0F,
  0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xE0, 0x38, 0x1F, 0x00, 0x20, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x80, 0x07,
  0xC3, 0xC0, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0xCE, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xE3,
  0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3,
  0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1C,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x3D, 0xE0, 0x03, 0xF0, 0x01, 0xEF, 0x00, 0x3F, 0x80, 0x1E, 0x78,
  0x01, 0xDC, 0x00, 0xF3, 0xC0, 0x1E, 0xE0, 0x0F, 0x1E, 0x00, 0xF7, 0x00,
  0x78, 0xF0, 0x07, 0x38, 0x07, 0xC7, 0x80, 0x79, 0xC0, 0x3C, 0x3C, 0x03,
  0x8E, 0x01, 0xE1, 0xE0, 0x3C, 0x70, 0x1E, 0x0F, 0x01, 0xC3, 0x80, 0xF0,
  0x78, 0x1E, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0xE0, 0x78, 0x1E, 0x0F, 0x07,
  0x07, 0x80, 0x70, 0x70, 0x38, 0x3C, 0x03, 0x87, 0x81, 0xC1, 0xC0, 0x1C,
  0x3C, 0x0F, 0x1E, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x07, 0x1E, 0x03, 0xCF,
  0x00, 0x39, 0xE0, 0x1E, 0x78, 0x01, 0xCF, 0x00, 0xF7, 0x80, 0x0E, 0x70,
  0x07, 0xBC, 0x00, 0x77, 0x80, 0x3D, 0xC0, 0x03, 0xB8, 0x01, 0xFE, 0x00,
  0x1D, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7,
  0x80, 0x1F, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0x38, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE3,
  0xC0, 0x01, 0xC7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78,
  0x78, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00,
  0x0F, 0x78, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x07, 0x00, 0x1C,
  0x1E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x70, 0x07,
  0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xEF,
  0x00, 0x03, 0xB8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF1, 0xF1, 0xE1, 0xC1, 0xC3, 0xC3, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFE,
  0x3C, 0x0F, 0xFE, 0x70, 0x3F, 0xFC, 0xE0, 0xFC, 0x1F, 0xC3, 0xE0, 0x1F,
  0x87, 0x80, 0x3F, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0,
  0x0F, 0x87, 0x80, 0x3F, 0x07, 0x80, 0xFE, 0x0F, 0x87, 0xB8, 0x1F, 0xFE,
  0x70, 0x1F, 0xF8, 0xE0, 0x1F, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0x00,
  0x1E, 0x3F, 0xC0, 0x3C, 0xFF, 0xC0, 0x7B, 0xFF, 0xC0, 0xEF, 0x0F, 0x83,
  0xF8, 0x0F, 0x07, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x0F, 0xC0, 0x3E, 0x1F, 0xC1, 0xF8,
  0x39, 0xFF, 0xE0, 0x73, 0xFF, 0x81, 0xC1, 0xFC, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x04, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xFC,
  0x0C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x04, 0x0F, 0x00, 0x3F, 0xC7, 0x80, 0x7F, 0xF3, 0x80, 0x7F,
  0xFB, 0xC0, 0x7E, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x3C, 0x01, 0xF8, 0x3E,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x7C,
  0x0F, 0x00, 0x7E, 0x03, 0xC0, 0x7F, 0x01, 0xF0, 0xF7, 0x00, 0xFF, 0xF3,
  0x80, 0x3F, 0xF1, 0xC0, 0x0F, 0xE1, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x1F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0x80,
  0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x3F, 0x3F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x10, 0xFC, 0x0E,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x6F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x87, 0x01,
  0xFF, 0xCE, 0x03, 0xFF, 0xEE, 0x07, 0xE0, 0xFE, 0x0F, 0x80, 0x7E, 0x0F,
  0x00, 0x7E, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0x78, 0x03, 0xF0, 0x3C, 0x07, 0xF0, 0x3E, 0x1E, 0xE0, 0x3F,
  0xFD, 0xE0, 0x1F, 0xF9, 0xE0, 0x0F, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0x00, 0x1E, 0x1F,
  0xC0, 0x3C, 0xFF, 0xC0, 0x7B, 0xFF, 0xC0, 0xEF, 0x07, 0x83, 0xF8, 0x0F,
  0x07, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0xF8, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x0F, 0x80,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x04, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0xF0, 0x7C,
  0x03, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x1F, 0x00, 0x1E, 0x7C, 0x00,
  0x79, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xBF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0x9E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0xF8, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0xC0, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x80,
  0x04, 0x00, 0x78, 0xFF, 0x03, 0xFC, 0x07, 0x1F, 0xF0, 0x7F, 0xE0, 0x73,
  0xFF, 0x8F, 0xFE, 0x07, 0x70, 0x79, 0xC1, 0xF0, 0xFE, 0x03, 0xF8, 0x0F,
  0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x01, 0xE1, 0xE0,
  0x07, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x1E,
  0x3C, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x1F, 0xF0, 0x1E, 0x7F, 0xF0, 0x39,
  0xFF, 0xE0, 0xF7, 0x83, 0xC1, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF0,
  0x01, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x83,
  0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0xF0, 0xFE, 0x00,
  0x71, 0xFF, 0x80, 0x39, 0xFF, 0xE0, 0x1D, 0xE1, 0xF0, 0x1F, 0xC0, 0x78,
  0x0F, 0xC0, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x03,
  0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0x81, 0xF8, 0x07, 0xC0, 0xFE,
  0x0F, 0xC0, 0x7B, 0xFF, 0xC0, 0x39, 0xFF, 0xC0, 0x3C, 0x3F, 0x80, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xFE, 0x1C, 0x0F, 0xFE, 0x70, 0x3F, 0xFE, 0xE0, 0xFC, 0x1F,
  0xC3, 0xE0, 0x1F, 0x87, 0x80, 0x3F, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0,
  0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x3F, 0x07, 0x80, 0xFE, 0x0F, 0x87,
  0xB8, 0x1F, 0xFE, 0xF0, 0x1F, 0xF9, 0xE0, 0x1F, 0xC3, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x81, 0xE3, 0xF0, 0x71,
  0xFC, 0x1C, 0xFF, 0x07, 0x78, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF,
  0xE0, 0xF0, 0x1C, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x88, 0x00, 0xF1, 0xC0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xC0, 0x1F, 0x83, 0xC0, 0x7F, 0x07, 0x83, 0xDC, 0x0F, 0xFF, 0x38, 0x0F,
  0xFC, 0x70, 0x0F, 0xE1, 0xE0, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00,
  0x3C, 0xE0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F,
  0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x1F,
  0xC0, 0x1F, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0xF7, 0x80, 0xFE, 0x03, 0xEF,
  0x01, 0xDC, 0x07, 0x9E, 0x07, 0xB8, 0x0F, 0x3C, 0x0E, 0x70, 0x3C, 0x78,
  0x3C, 0xE0, 0x78, 0xF0, 0x71, 0xC1, 0xE1, 0xE0, 0xE3, 0x83, 0xC3, 0xC3,
  0xC7, 0x0F, 0x07, 0x87, 0x0E, 0x1E, 0x0F, 0x1E, 0x1C, 0x78, 0x1E, 0x38,
  0x38, 0xF0, 0x3C, 0xF0, 0x71, 0xC0, 0x79, 0xC0, 0xE7, 0x80, 0xF7, 0x81,
  0xCF, 0x01, 0xEE, 0x03, 0xBC, 0x03, 0xDC, 0x07, 0x78, 0x07, 0xF0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80,
  0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80,
  0x01, 0xC7, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE1,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xFC, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0x80, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x0B, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFC, 0x03, 0xFF,
  0x40, 0x07, 0xF0,
};

const GFXglyph NotoSans_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 33, 12, 1, -32 },
  { 47, 14, 11, 18, 5, -32 },
  { 67, 28, 32, 29, 1, -32 },
  { 179, 22, 37, 25, 2, -34 },
  { 281, 30, 33, 36, 4, -33 },
  { 405, 28, 33, 30, 1, -33 },
  { 521, 6, 11, 10, 5, -32 },
  { 530, 15, 39, 13, 2, -32 },
  { 604, 14, 39, 13, -3, -32 },
  { 673, 20, 21, 25, 5, -34 },
  { 726, 21, 22, 26, 3, -27 },
  { 784, 9, 11, 12, -2, -5 },
  { 797, 12, 4, 14, 1, -14 },
  { 803, 6, 6, 12, 1, -5 },
  { 808, 22, 32, 16, -2, -32 },
  { 896, 21, 33, 25, 3, -33 },
  { 983, 14, 32, 25, 6, -32 },
  { 1039, 24, 33, 25, 0, -33 },
  { 1138, 23, 33, 25, 1, -33 },
  { 1233, 24, 32, 25, 0, -32 },
  { 1329, 22, 32, 25, 2, -32 },
  { 1417, 22, 33, 25, 3, -33 },
  { 1508, 21, 32, 25, 4, -32 },
  { 1592, 22, 33, 25, 2, -33 },
  { 1683, 21, 33, 25, 2, -33 },
  { 1770, 9, 26, 12, 1, -25 },
  { 1800, 12, 31, 12, -2, -25 },
  { 1847, 21, 22, 26, 3, -27 },
  { 1905, 21, 12, 26, 3, -22 },
  { 1937, 21, 22, 26, 3, -27 },
  { 1995, 17, 34, 19, 3, -33 },
  { 2068, 35, 36, 38, 2, -32 },
  { 2226, 26, 32, 25, -3, -32 },
  { 2330, 25, 32, 27, 2, -32 },
  { 2430, 25, 33, 26, 3, -33 },
  { 2534, 27, 32, 30, 2, -32 },
  { 2642, 23, 32, 23, 2, -32 },
  { 2734, 23, 32, 21, 2, -32 },
  { 2826, 27, 33, 31, 3, -33 },
  { 2938, 29, 32, 31, 2, -32 },
  { 3054, 18, 32, 15, -1, -32 },
  { 3126, 20, 41, 12, -7, -32 },
  { 3229, 27, 32, 25, 2, -32 },
  { 3337, 17, 32, 22, 2, -32 },
  { 3405, 36, 32, 38, 2, -32 },
  { 3549, 30, 32, 32, 2, -32 },
  { 3669, 28, 33, 32, 3, -33 },
  { 3785, 24, 32, 26, 2, -32 },
  { 3881, 28, 41, 32, 3, -33 },
  { 4025, 24, 32, 26, 2, -32 },
  { 4121, 22, 33, 23, 1, -33 },
  { 4212, 23, 32, 23, 4, -32 },
  { 4304, 27, 32, 30, 4, -32 },
  { 4412, 25, 32, 25, 4, -32 },
  { 4512, 37, 32, 39, 5, -32 },
  { 4660, 29, 32, 24, -2, -32 },
  { 4776, 23, 32, 23, 4, -32 },
  { 4868, 26, 32, 24, 0, -32 },
  { 4972, 17, 39, 13, 0, -32 },
  { 5055, 8, 32, 16, 5, -32 },
  { 5087, 17, 39, 13, -3, -32 },
  { 5170, 22, 20, 26, 2, -32 },
  { 5225, 18, 3, 18, -4, 4 },
  { 5232, 7, 7, 13, 7, -34 },
  { 5239, 23, 25, 26, 2, -25 },
  { 5311, 23, 34, 26, 1, -34 },
  { 5409, 19, 25, 20, 2, -25 },
  { 5469, 25, 34, 26, 2, -34 },
  { 5576, 19, 25, 22, 2, -25 },
  { 5636, 25, 45, 14, -5, -34 },
  { 5777, 24, 36, 26, 1, -25 },
  { 5885, 23, 34, 26, 1, -34 },
  { 5983, 11, 33, 12, 1, -33 },
  { 6029, 18, 44, 12, -6, -33 },
  { 6128, 23, 34, 22, 1, -34 },
  { 6226, 11, 34, 12, 1, -34 },
  { 6273, 36, 25, 39, 1, -25 },
  { 6386, 23, 25, 26, 1, -25 },
  { 6458, 21, 24, 25, 2, -24 },
  { 6521, 25, 36, 26, -1, -25 },
  { 6634, 23, 36, 26, 2, -25 },
  { 6738, 18, 25, 18, 1, -25 },
  { 6795, 19, 25, 19, 0, -25 },
  { 6855, 14, 30, 15, 2, -30 },
  { 6908, 23, 24, 26, 2, -24 },
  { 6977, 21, 24, 21, 2, -24 },
  { 7040, 31, 24, 33, 3, -24 },
  { 7133, 25, 24, 22, -2, -24 },
  { 7208, 27, 35, 21, -4, -24 },
  { 7327, 21, 24, 20, -1, -24 },
  { 7390, 18, 39, 16, 0, -32 },
  { 7478, 3, 45, 25, 12, -34 },
  { 7495, 18, 39, 16, -2, -32 },
  { 7583, 21, 6, 26, 3, -19 },
};

const GFXfont NotoSans_Italic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_ITALIC45PT7B_H_
