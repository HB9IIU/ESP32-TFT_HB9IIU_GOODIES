#ifndef _NOTOSANS_ITALIC40PT7B_H_
#define _NOTOSANS_ITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x10, 0x00, 0x3C, 0x73, 0x8F, 0x78, 0xF7, 0x8F, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x1C, 0xE1, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0x80,
  0x01, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x0C, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE0, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x9C, 0xE0, 0xF1, 0xC0, 0x0E,
  0x18, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0F, 0x30, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x06, 0xF8,
  0x00, 0x67, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xC3,
  0x88, 0x0C, 0x78, 0xE1, 0xCF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0xC0, 0x01, 0xC1, 0xFC, 0x00, 0x70, 0x7F, 0xC0, 0x1C, 0x1E, 0x38, 0x07,
  0x83, 0x87, 0x00, 0xE0, 0xE0, 0x60, 0x38, 0x1C, 0x0C, 0x0E, 0x03, 0x83,
  0x83, 0xC0, 0x60, 0x70, 0x70, 0x1C, 0x0E, 0x1C, 0x03, 0x81, 0xC7, 0x00,
  0x70, 0x39, 0xE1, 0x0E, 0x0E, 0x39, 0xFD, 0xC1, 0xCE, 0x7F, 0xBC, 0x73,
  0x9E, 0x7B, 0xFC, 0x73, 0x87, 0x7F, 0x9C, 0xE0, 0xE3, 0xC7, 0x1C, 0x1C,
  0x01, 0xC3, 0x83, 0x80, 0x38, 0xE0, 0x70, 0x0E, 0x1C, 0x0E, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x70, 0x1C, 0x0E, 0x0E, 0x07, 0x01, 0xC1, 0xC1,
  0xC0, 0x38, 0x70, 0x78, 0x07, 0x9E, 0x0E, 0x00, 0x7F, 0x83, 0x80, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07,
  0x01, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x71, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x0F, 0x1E, 0x3C, 0x07, 0x1E, 0x0F, 0x07, 0x9E, 0x03, 0xC3,
  0x8E, 0x01, 0xE3, 0xCF, 0x00, 0x7B, 0xC7, 0x80, 0x1F, 0xC3, 0xC0, 0x0F,
  0xC1, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0xF0, 0x3C, 0x07, 0xFC, 0x1F, 0xFF,
  0xDE, 0x07, 0xFF, 0x87, 0x80, 0xFF, 0x81, 0xE0, 0x3C, 0xE7, 0x9E, 0x71,
  0xC7, 0x1C, 0x61, 0x8E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x40, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xC0,
  0xC0, 0x1E, 0x18, 0x07, 0xF3, 0x00, 0x1F, 0xCF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0x01, 0xF0, 0x00, 0xF7, 0x00, 0x3C, 0xE0, 0x0F, 0x0E, 0x03, 0xE1,
  0xC0, 0x38, 0x3C, 0x02, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x0F, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x77,
  0xFF, 0xFF, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xE1, 0xE0, 0xF8, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x3C,
  0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x0E, 0xE0,
  0x03, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0x80,
  0x78, 0x78, 0x0F, 0x0F, 0x07, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x70, 0x1F, 0x07, 0xE0, 0xFE, 0x3F, 0xE7, 0xDE, 0xF9, 0xC6,
  0x1C, 0x43, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xC3, 0xE0, 0x38, 0x07, 0x80, 0x80,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0x78, 0x1E,
  0x06, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x3F,
  0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x80, 0x07, 0x8C, 0x01, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0xDE,
  0x00, 0x3C, 0xE0, 0x03, 0xC7, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1C,
  0x1C, 0x01, 0xE0, 0xE0, 0x1E, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC1,
  0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x0E, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x80, 0x07, 0x8E, 0x01,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x10, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x7C, 0x07, 0x3F, 0xE1, 0xEF, 0xFE, 0x3F, 0x83, 0xC7, 0xC0, 0x3C, 0xF0,
  0x07, 0x9E, 0x00, 0xF3, 0x80, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x79, 0xC0,
  0x0F, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xF0, 0x0E, 0x1F, 0x07, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C,
  0x3E, 0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x0F,
  0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x03, 0xC0, 0x78, 0x78, 0x03, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3E, 0x1F, 0x07, 0xC0, 0x78,
  0x78, 0x07, 0x8F, 0x00, 0x38, 0xF0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x80, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xC3, 0xE1, 0xE0, 0x3C, 0x38, 0x03, 0xCF, 0x00, 0x79, 0xC0, 0x0F, 0x38,
  0x01, 0xE7, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF3, 0x80, 0x3E, 0x78,
  0x07, 0x8F, 0x01, 0xF0, 0xFF, 0xEE, 0x1F, 0xFB, 0xC0, 0xFE, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x10, 0x0F, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x60,
  0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7F,
  0xF1, 0xFF, 0xF3, 0xC1, 0xF2, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0E, 0x1E, 0x00, 0xF0, 0x1C, 0x38, 0x0F, 0xFC, 0x1C, 0xE0, 0x7F, 0xF8,
  0x39, 0xC1, 0xE0, 0x70, 0x77, 0x03, 0x81, 0xC0, 0xEE, 0x0E, 0x03, 0x81,
  0xDC, 0x3C, 0x07, 0x03, 0xF0, 0x70, 0x1E, 0x07, 0xE0, 0xE0, 0x38, 0x1D,
  0xC1, 0xC0, 0x70, 0x3B, 0x83, 0x81, 0xE0, 0x77, 0x07, 0x03, 0xC1, 0xCE,
  0x0E, 0x0F, 0x83, 0x9C, 0x1C, 0x3F, 0x0E, 0x3C, 0x3F, 0xEF, 0xF8, 0x38,
  0x3F, 0x8F, 0xE0, 0x70, 0x1C, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x40, 0x01, 0xF8,
  0x07, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x9C, 0x00, 0x0F,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC3,
  0x80, 0x07, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xF0, 0x03, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEF, 0x00,
  0x01, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E,
  0x07, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3C, 0x03,
  0xE0, 0xF0, 0x07, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0x70, 0x03, 0xE3, 0xC0,
  0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0x0E, 0x07, 0xC0, 0x08,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x02, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x70, 0x0F, 0xC0, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38,
  0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xE0, 0x00,
  0xF1, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3C,
  0x38, 0x00, 0xF8, 0x70, 0x07, 0xE1, 0xE0, 0x7F, 0x83, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x3E, 0x07, 0xC0, 0x04, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x07, 0xFC, 0xF0, 0x07, 0xFC, 0xF0, 0x0F, 0xFC, 0xF0,
  0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x70, 0xF8, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x3E,
  0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80,
  0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x07, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F,
  0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xEE, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xDE, 0x0E, 0xF0, 0x03, 0xDC, 0x0E, 0x70, 0x03, 0x9C, 0x0E, 0x70, 0x07,
  0xBC, 0x1E, 0x70, 0x07, 0x3C, 0x1E, 0x70, 0x0F, 0x38, 0x1C, 0x70, 0x0E,
  0x38, 0x1C, 0x70, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x78, 0x3C, 0x70, 0x38,
  0x78, 0x3C, 0x38, 0x38, 0x70, 0x38, 0x38, 0x70, 0x70, 0x38, 0x38, 0xF0,
  0xF0, 0x38, 0x38, 0xE0, 0xF0, 0x78, 0x39, 0xE0, 0xF0, 0x78, 0x39, 0xC0,
  0xE0, 0x70, 0x3B, 0xC0, 0xE0, 0x70, 0x3B, 0x81, 0xE0, 0x70, 0x1F, 0x01,
  0xE0, 0xF0, 0x1F, 0x01, 0xE0, 0xE0, 0x1E, 0x01, 0xC0, 0xE0, 0x1E, 0x01,
  0xC0, 0xE0, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC1, 0xF0, 0x00, 0x70,
  0x7C, 0x00, 0x1C, 0x1F, 0x80, 0x0F, 0x07, 0xE0, 0x03, 0xC1, 0xF8, 0x00,
  0xE0, 0xFF, 0x00, 0x38, 0x39, 0xC0, 0x0E, 0x0E, 0x70, 0x07, 0x83, 0x9E,
  0x01, 0xE1, 0xE3, 0x80, 0x70, 0x78, 0xF0, 0x1C, 0x1C, 0x3C, 0x0F, 0x07,
  0x07, 0x03, 0xC1, 0xC1, 0xE0, 0xF0, 0xF0, 0x38, 0x38, 0x3C, 0x0E, 0x0E,
  0x0E, 0x03, 0xC7, 0x83, 0x80, 0x71, 0xE0, 0xE0, 0x1E, 0x70, 0x78, 0x07,
  0x9C, 0x1E, 0x00, 0xE7, 0x07, 0x00, 0x3D, 0xC1, 0xC0, 0x07, 0xF0, 0x70,
  0x01, 0xF8, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xE0,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01,
  0xE3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x01,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x70, 0x0F,
  0x03, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70,
  0x03, 0xC3, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x01, 0xF0,
  0x70, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01,
  0xE3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x01,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF4, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x70, 0x0F, 0x03, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC3,
  0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0E, 0x03, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xE1, 0xE0, 0x0E, 0x07, 0x00, 0x70,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0E, 0x00, 0xE0,
  0x70, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x8E, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0x1E,
  0x0F, 0x80, 0x20, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x0C, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0x81,
  0xC0, 0x1E, 0x07, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x07, 0x81, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x38, 0x00, 0xE1, 0xE0,
  0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80, 0x03,
  0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFC,
  0x00, 0x78, 0x01, 0xEF, 0x00, 0x3E, 0x00, 0x7B, 0xC0, 0x0F, 0x80, 0x1C,
  0xF0, 0x07, 0xE0, 0x0F, 0x3C, 0x01, 0xF8, 0x03, 0x87, 0x00, 0xEE, 0x01,
  0xE1, 0xC0, 0x3B, 0x80, 0x78, 0x70, 0x1E, 0xE0, 0x3C, 0x1C, 0x07, 0x38,
  0x0F, 0x07, 0x03, 0xCE, 0x03, 0x81, 0xC0, 0xE3, 0x81, 0xE0, 0x70, 0x38,
  0xE0, 0x70, 0x1C, 0x1C, 0x38, 0x3C, 0x07, 0x07, 0x0E, 0x0E, 0x01, 0xC3,
  0x83, 0xC7, 0x80, 0x70, 0xE0, 0x71, 0xC0, 0x1C, 0x70, 0x1C, 0x70, 0x07,
  0x1C, 0x07, 0x3C, 0x01, 0xCF, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x77, 0x80,
  0x1D, 0xE0, 0x1D, 0xC0, 0x07, 0x70, 0x07, 0x70, 0x01, 0xDC, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0x70, 0x07, 0x87, 0x00,
  0x78, 0x78, 0x0F, 0x03, 0x81, 0xE0, 0x38, 0x1E, 0x03, 0x83, 0xC0, 0x3C,
  0x78, 0x01, 0xC7, 0x80, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x7F, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x30, 0xE0, 0x0E,
  0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1C, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0xF3, 0xC7, 0x0E, 0x38, 0x70, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0xC7, 0x07, 0xFE, 0x70, 0xF8, 0xFE, 0x1E, 0x03, 0xE3, 0xC0,
  0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x01, 0xF0, 0xF0, 0x3F, 0x07, 0xFF, 0x70,
  0x7F, 0xE7, 0x01, 0xF8, 0x70, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x0F, 0x00, 0xF3, 0xFC, 0x0F, 0x7F, 0xE0, 0xEF, 0x1E, 0x0F,
  0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0x71, 0xF0, 0x07, 0x1E, 0x00, 0x71,
  0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E,
  0x38, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x7E, 0x0F,
  0x87, 0x7F, 0xF0, 0xE7, 0xFE, 0x0E, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0x83, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x08, 0x7F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x70, 0x0F, 0xF3, 0xC0, 0x7F, 0xEF, 0x03, 0xE1,
  0xF8, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x0F,
  0x83, 0xC0, 0x7C, 0x0F, 0x03, 0x70, 0x1F, 0xFD, 0xC0, 0x7F, 0xE7, 0x00,
  0x7E, 0x1C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xF1,
  0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0E, 0x78, 0x1F, 0x38, 0x7F,
  0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x01, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xE2, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x02, 0x78, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xF1,
  0xC0, 0xFF, 0xCE, 0x0F, 0x87, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x7C, 0x1E, 0x06, 0xE0, 0x7F, 0xF7, 0x03,
  0xFF, 0x78, 0x07, 0xE3, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x81, 0x00, 0x7C, 0x0F, 0x0F, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0x80, 0x01, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x0F, 0x00, 0xF3, 0xFC, 0x0F, 0x7F, 0xE0, 0xEF,
  0x1F, 0x0F, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x70, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x03, 0xC0,
  0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x9F, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x10, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0E,
  0x0F, 0x00, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x01,
  0xDE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xC7, 0x80,
  0x38, 0x78, 0x07, 0x83, 0x80, 0x78, 0x3C, 0x07, 0x81, 0xC0, 0x70, 0x1E,
  0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0x0F,
  0x00, 0xF8, 0x0E, 0x3F, 0xC3, 0xFC, 0x0E, 0x7F, 0xC7, 0xFE, 0x0E, 0xE1,
  0xEF, 0x1F, 0x0F, 0xC0, 0xFC, 0x0F, 0x0F, 0x80, 0xF8, 0x0F, 0x1F, 0x00,
  0xF0, 0x0F, 0x1E, 0x00, 0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x0E, 0x1E, 0x01,
  0xE0, 0x0E, 0x1C, 0x01, 0xE0, 0x1E, 0x3C, 0x01, 0xC0, 0x1E, 0x3C, 0x01,
  0xC0, 0x1E, 0x38, 0x03, 0xC0, 0x1C, 0x38, 0x03, 0xC0, 0x1C, 0x78, 0x03,
  0x80, 0x3C, 0x78, 0x03, 0x80, 0x3C, 0x78, 0x03, 0x80, 0x3C, 0x70, 0x07,
  0x80, 0x38, 0x70, 0x07, 0x80, 0x38, 0xF0, 0x07, 0x00, 0x78, 0xF0, 0x07,
  0x00, 0x78, 0x07, 0x0F, 0x80, 0xF3, 0xFE, 0x0E, 0x7F, 0xE0, 0xEF, 0x1F,
  0x0F, 0xC0, 0xF1, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x38, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70,
  0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7F, 0xC0, 0x1F, 0xFE, 0x07, 0xC7, 0xC1, 0xE0, 0x3C, 0x78, 0x07, 0x8E,
  0x00, 0x73, 0xC0, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x1C, 0xF0,
  0x07, 0x9E, 0x01, 0xE1, 0xE0, 0x78, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x00, 0x43, 0xC0, 0x0E, 0x3F, 0xC0, 0x39, 0xFF, 0x80, 0xEF,
  0x1E, 0x03, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x7C, 0x01, 0xC1, 0xF0, 0x07,
  0x07, 0x80, 0x1C, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x1F, 0x00,
  0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0x7F, 0xF0, 0x3D, 0xFF, 0x80,
  0xF1, 0xFC, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC7, 0x07,
  0xFE, 0x70, 0xF8, 0x7E, 0x1E, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F,
  0x8F, 0x01, 0xF0, 0xF0, 0x37, 0x07, 0xFF, 0x70, 0x7F, 0xEF, 0x01, 0xF8,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x01, 0x0F, 0x0E, 0x3F, 0x0E, 0x7F, 0x0E, 0xF1, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x07, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0xC0, 0x3C,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xE0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x01, 0xE0, 0xFF, 0xFB, 0xFF, 0xC3, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF0, 0x7F, 0x81, 0xFC,
  0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x03, 0x70, 0x7F, 0xF7,
  0x07, 0xFC, 0x70, 0x3F, 0x87, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0,
  0x1E, 0x78, 0x03, 0x8F, 0x00, 0xF0, 0xE0, 0x1C, 0x1C, 0x07, 0x83, 0x80,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0x73, 0xC0, 0x0E, 0x78, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0x70,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0x01, 0xEF, 0x03, 0xB0, 0x1E, 0xF0, 0x3B,
  0x01, 0xC7, 0x03, 0xB0, 0x3C, 0x70, 0x73, 0x03, 0x87, 0x07, 0x38, 0x78,
  0x70, 0xE3, 0x87, 0x07, 0x0E, 0x38, 0xF0, 0x71, 0xC3, 0x8E, 0x07, 0x1C,
  0x39, 0xE0, 0x73, 0x83, 0x9C, 0x07, 0x38, 0x39, 0xC0, 0x77, 0x03, 0xBC,
  0x07, 0x70, 0x3B, 0x80, 0x76, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7C,
  0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x78, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x07, 0x80, 0x3C, 0x78, 0x00,
  0xE3, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x1E,
  0x70, 0x01, 0xE3, 0xC0, 0x1E, 0x0E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0,
  0xF0, 0x0F, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x01,
  0xC0, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x70, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07,
  0x3C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x11, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x1F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xE0,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x0F, 0xFF, 0xE7, 0xF0,
  0xFF, 0xF8, 0x07, 0xF9, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 30, 10, 1, -29 },
  { 39, 12, 11, 16, 4, -29 },
  { 56, 25, 29, 26, 1, -29 },
  { 147, 20, 32, 22, 1, -30 },
  { 227, 27, 29, 32, 3, -29 },
  { 325, 25, 29, 27, 1, -29 },
  { 416, 6, 11, 9, 4, -29 },
  { 425, 13, 35, 12, 2, -29 },
  { 482, 13, 35, 12, -3, -29 },
  { 539, 19, 19, 22, 4, -31 },
  { 585, 19, 20, 23, 3, -24 },
  { 633, 8, 10, 10, -2, -5 },
  { 643, 10, 3, 13, 1, -12 },
  { 647, 5, 6, 10, 1, -5 },
  { 651, 20, 29, 14, -2, -29 },
  { 724, 19, 29, 22, 2, -29 },
  { 793, 12, 29, 22, 6, -29 },
  { 837, 21, 29, 22, 0, -29 },
  { 914, 20, 29, 22, 1, -29 },
  { 987, 21, 29, 22, 0, -29 },
  { 1064, 20, 29, 22, 1, -29 },
  { 1137, 19, 29, 22, 3, -29 },
  { 1206, 19, 29, 22, 3, -29 },
  { 1275, 20, 29, 22, 2, -29 },
  { 1348, 19, 29, 22, 2, -29 },
  { 1417, 8, 23, 10, 1, -22 },
  { 1440, 11, 27, 10, -2, -22 },
  { 1478, 19, 19, 23, 3, -24 },
  { 1524, 18, 10, 23, 3, -19 },
  { 1547, 19, 19, 23, 3, -24 },
  { 1593, 15, 30, 17, 3, -29 },
  { 1650, 31, 33, 34, 2, -29 },
  { 1778, 23, 29, 22, -2, -29 },
  { 1862, 22, 29, 24, 2, -29 },
  { 1942, 22, 29, 23, 3, -29 },
  { 2022, 23, 29, 27, 2, -29 },
  { 2106, 20, 29, 21, 2, -29 },
  { 2179, 20, 29, 19, 2, -29 },
  { 2252, 24, 29, 27, 3, -29 },
  { 2339, 25, 29, 27, 2, -29 },
  { 2430, 16, 29, 13, -1, -29 },
  { 2488, 17, 37, 11, -6, -29 },
  { 2567, 24, 29, 22, 2, -29 },
  { 2654, 15, 29, 19, 2, -29 },
  { 2709, 32, 29, 34, 2, -29 },
  { 2825, 26, 29, 28, 2, -29 },
  { 2920, 25, 29, 29, 3, -29 },
  { 3011, 21, 29, 23, 2, -29 },
  { 3088, 25, 36, 29, 3, -29 },
  { 3201, 21, 29, 23, 2, -29 },
  { 3278, 20, 29, 20, 1, -29 },
  { 3351, 20, 29, 20, 4, -29 },
  { 3424, 25, 29, 27, 3, -29 },
  { 3515, 22, 29, 22, 4, -29 },
  { 3595, 34, 29, 34, 4, -29 },
  { 3719, 26, 29, 21, -2, -29 },
  { 3814, 20, 29, 20, 4, -29 },
  { 3887, 23, 29, 21, 0, -29 },
  { 3971, 15, 35, 12, 0, -29 },
  { 4037, 8, 29, 14, 4, -29 },
  { 4066, 15, 35, 12, -3, -29 },
  { 4132, 19, 18, 23, 2, -29 },
  { 4175, 17, 2, 16, -4, 4 },
  { 4180, 6, 7, 11, 6, -31 },
  { 4186, 20, 22, 23, 2, -22 },
  { 4241, 20, 30, 23, 1, -30 },
  { 4316, 16, 22, 18, 2, -22 },
  { 4360, 22, 30, 23, 2, -30 },
  { 4443, 17, 22, 20, 2, -22 },
  { 4490, 22, 41, 13, -4, -31 },
  { 4603, 21, 32, 23, 1, -22 },
  { 4687, 20, 30, 23, 1, -30 },
  { 4762, 10, 29, 10, 1, -29 },
  { 4799, 16, 39, 10, -5, -29 },
  { 4877, 20, 30, 20, 1, -30 },
  { 4952, 10, 30, 10, 1, -30 },
  { 4990, 32, 22, 35, 1, -22 },
  { 5078, 20, 22, 23, 1, -22 },
  { 5133, 19, 22, 23, 2, -22 },
  { 5186, 22, 32, 23, -1, -22 },
  { 5274, 20, 32, 23, 2, -22 },
  { 5354, 16, 22, 16, 1, -22 },
  { 5398, 16, 22, 17, 0, -22 },
  { 5442, 13, 26, 13, 2, -26 },
  { 5485, 20, 21, 23, 2, -21 },
  { 5538, 19, 21, 19, 2, -21 },
  { 5588, 28, 21, 29, 2, -21 },
  { 5662, 21, 21, 19, -1, -21 },
  { 5718, 25, 31, 19, -4, -21 },
  { 5815, 19, 21, 18, -1, -21 },
  { 5865, 16, 35, 14, 0, -29 },
  { 5935, 3, 40, 22, 10, -30 },
  { 5950, 15, 35, 14, -1, -29 },
  { 6016, 19, 6, 23, 3, -17 },
};

const GFXfont NotoSans_Italic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_ITALIC40PT7B_H_
