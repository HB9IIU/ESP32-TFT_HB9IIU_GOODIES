#ifndef _NOTOSANS_ITALIC36PT7B_H_
#define _NOTOSANS_ITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x10, 0x00, 0x79, 0xEE, 0x39, 0xC7,
  0x38, 0xE6, 0x1D, 0xC3, 0x38, 0x67, 0x1C, 0xC3, 0x18, 0x60, 0x00, 0x30,
  0x30, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF8, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x60, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE0, 0x18, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x07, 0xFC, 0x03, 0xFF,
  0xC3, 0xED, 0xE0, 0xE3, 0x08, 0x78, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01,
  0xE6, 0x00, 0x3D, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xCE, 0x00, 0x73, 0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x01, 0x8E,
  0x20, 0x67, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x0E, 0x1F, 0xC0,
  0x1C, 0x3D, 0xE0, 0x38, 0x70, 0xE0, 0x38, 0x70, 0xE0, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0xE1, 0xC0, 0xE0, 0xE3, 0x80, 0xE0, 0xC7,
  0x00, 0xC1, 0xC6, 0x38, 0xC1, 0xCE, 0xFE, 0xE3, 0x9D, 0xFF, 0xE7, 0xB9,
  0xC7, 0x7F, 0x33, 0x87, 0x3C, 0x73, 0x83, 0x00, 0xE3, 0x07, 0x01, 0xC7,
  0x07, 0x01, 0x87, 0x07, 0x03, 0x87, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x07,
  0x0E, 0x0C, 0x07, 0x0C, 0x1C, 0x07, 0x1C, 0x38, 0x03, 0xF8, 0x70, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xE0, 0xF0,
  0x07, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x03,
  0x87, 0x80, 0x0E, 0x7C, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xC0, 0x01, 0xE7, 0x01, 0xCE, 0x0E, 0x0E, 0x70, 0x3C, 0x39,
  0xC0, 0x79, 0xCE, 0x00, 0xEF, 0x38, 0x03, 0xF8, 0xE0, 0x07, 0xC3, 0xC0,
  0x1E, 0x07, 0x00, 0xFC, 0x1F, 0x1F, 0xF8, 0x3F, 0xF8, 0xF0, 0x7F, 0x81,
  0xE0, 0x7B, 0x9C, 0xE6, 0x73, 0x9C, 0xC6, 0x00, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x80, 0xC0, 0xE1, 0xC0, 0xF9, 0x80, 0x7F, 0x81, 0x0F, 0xFF,
  0x03, 0xFF, 0x06, 0xC0, 0x1C, 0xC0, 0x3C, 0xE0, 0x78, 0xE0, 0x70, 0x70,
  0x20, 0x70, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x40, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xE0, 0xE1, 0xE0, 0x78, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x78, 0x03,
  0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCF,
  0x01, 0xE7, 0x80, 0xE1, 0xC0, 0xE0, 0xF9, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0,
  0x00, 0x00, 0xE0, 0x7C, 0x1F, 0x8F, 0xE3, 0xFD, 0xF3, 0x9C, 0xF2, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xC1, 0xF0, 0x20,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x38, 0x0F,
  0x04, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x88, 0x01, 0xE3, 0xC3, 0xF0, 0xFF, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xF3, 0x80,
  0x3C, 0x70, 0x07, 0x0E, 0x01, 0xC3, 0xC0, 0x70, 0x70, 0x1C, 0x0E, 0x07,
  0x01, 0xC1, 0xE0, 0x38, 0x78, 0x0F, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xDF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC8, 0x01, 0xE3, 0xC3, 0xF0, 0xFF, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x9F, 0x81, 0xCF, 0xF0, 0x7F, 0x3E, 0x1F, 0x03, 0xC7, 0x80,
  0x73, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x3C,
  0xF0, 0x0E, 0x1C, 0x07, 0x87, 0x81, 0xC1, 0xF1, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x0E, 0x03, 0x87, 0x80, 0xF1,
  0xE0, 0x38, 0x78, 0x0E, 0x0E, 0x07, 0x83, 0x81, 0xC0, 0x71, 0xE0, 0x0F,
  0xF0, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xE3, 0xC1, 0xE0, 0x78, 0xF0, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x8F,
  0x01, 0xE1, 0xF1, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x3C, 0xE0, 0x0E,
  0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0xF1, 0xE1, 0xF8, 0x7F, 0xDC, 0x1F, 0xDE, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0xC7, 0xC0,
  0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x0C, 0x3C, 0x78, 0xF1, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xE3, 0xC7, 0x84, 0x00,
  0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x1F, 0xC7, 0xFF, 0x9F, 0xFE, 0xC0, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x10, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x18, 0x0E, 0x38, 0x1F, 0xF8, 0x63, 0x03, 0xFF, 0x06, 0x70,
  0x70, 0x70, 0x77, 0x0E, 0x07, 0x07, 0xE0, 0xC0, 0x70, 0x7E, 0x1C, 0x06,
  0x06, 0xE1, 0xC0, 0xE0, 0x6E, 0x18, 0x0E, 0x0E, 0xE1, 0x80, 0xE0, 0xEE,
  0x18, 0x1C, 0x1C, 0xE1, 0xC3, 0xC1, 0xCE, 0x1C, 0x7E, 0x38, 0xE1, 0xFE,
  0x7F, 0x0E, 0x07, 0xC7, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x01, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x1D, 0xC0,
  0x03, 0x9C, 0x00, 0x79, 0xC0, 0x07, 0x1C, 0x00, 0xF0, 0xE0, 0x0E, 0x0E,
  0x01, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0xC0, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0E, 0x00, 0xF1, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0xC0,
  0x07, 0x38, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x7F, 0x00, 0x07, 0x03,
  0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x70, 0x1F, 0x07, 0x00, 0xF0,
  0x70, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0E,
  0x0E, 0x03, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1C, 0x07,
  0x81, 0xC0, 0x3C, 0x3C, 0x01, 0xC3, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0x80,
  0x1C, 0x38, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x07, 0x87, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7C, 0x06, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x02, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xC0, 0xFC, 0x07, 0x00, 0xF8, 0x1C,
  0x01, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00,
  0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF1,
  0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0x80,
  0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xE0, 0x1F, 0x07, 0x01, 0xF8,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x80, 0x60,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xFF, 0x70,
  0x0F, 0xF3, 0x80, 0x7F, 0x9C, 0x00, 0x1C, 0xE0, 0x01, 0xE7, 0x00, 0x0F,
  0x38, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x3C, 0x01, 0xE1, 0xF0,
  0x0E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x07, 0x00,
  0x1E, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xF0,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x1E, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x3C, 0x0E,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x1C, 0x1E,
  0x00, 0x70, 0xF0, 0x03, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00,
  0xE7, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xF7,
  0x80, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0x81, 0xC0,
  0x0E, 0x07, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x1C,
  0x01, 0xC0, 0x70, 0x07, 0x83, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x83, 0xF0, 0x01, 0xF8, 0x1B, 0x80, 0x1D, 0xC1, 0xCC, 0x00, 0xCE, 0x0E,
  0x60, 0x0E, 0x70, 0x73, 0x80, 0xE7, 0x03, 0x9C, 0x07, 0x38, 0x3C, 0xE0,
  0x71, 0xC1, 0xC7, 0x03, 0x8E, 0x0E, 0x38, 0x38, 0xF0, 0x71, 0xC1, 0xC7,
  0x03, 0x8E, 0x1C, 0x38, 0x38, 0x30, 0xE1, 0xC1, 0xC1, 0x8E, 0x0E, 0x0E,
  0x0E, 0x60, 0xF0, 0x70, 0x77, 0x07, 0x03, 0x83, 0xF0, 0x38, 0x38, 0x1F,
  0x81, 0xC1, 0xC0, 0xF8, 0x0E, 0x0E, 0x07, 0xC0, 0xF0, 0x70, 0x1C, 0x07,
  0x07, 0x80, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x03, 0x81,
  0xF0, 0x01, 0xC0, 0xF8, 0x00, 0xE0, 0x7E, 0x00, 0x70, 0x3F, 0x00, 0x78,
  0x1B, 0xC0, 0x38, 0x1C, 0xE0, 0x1C, 0x0E, 0x70, 0x0E, 0x07, 0x1C, 0x07,
  0x03, 0x8E, 0x07, 0x03, 0xC7, 0x03, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0,
  0xE0, 0x70, 0x78, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x0E, 0x38, 0x1C, 0x03,
  0x9C, 0x0E, 0x01, 0xCE, 0x07, 0x00, 0xE7, 0x03, 0x80, 0x3F, 0x03, 0x80,
  0x1F, 0x81, 0xC0, 0x0F, 0xC0, 0xE0, 0x03, 0xE0, 0x70, 0x01, 0xF0, 0x78,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xE0, 0x7C, 0x1F, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x03, 0x9E, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x7B, 0x80, 0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0, 0x01,
  0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0x81,
  0xF0, 0x70, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x87, 0x01, 0xE1, 0xE0, 0x7C, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x03,
  0x9E, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x3C,
  0xF0, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0x81, 0xF0, 0x70, 0x1E, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x87,
  0x01, 0xE1, 0xE3, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xE1, 0xC0, 0x3C,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xF0,
  0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x9E, 0x00, 0x70, 0x00,
  0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3C, 0x06, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x88, 0x03, 0xC3, 0xEF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x1C,
  0x78, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xF0,
  0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38,
  0x70, 0x07, 0x87, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x00, 0xE0, 0x70, 0x1E,
  0x03, 0x81, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87,
  0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x39, 0xE0, 0x03, 0x9C, 0x00, 0x3B,
  0x80, 0x01, 0xB8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0xEE, 0x00, 0xF8,
  0x03, 0xB8, 0x03, 0xE0, 0x1E, 0xE0, 0x1F, 0x80, 0x73, 0x80, 0x7E, 0x03,
  0xCE, 0x03, 0xB8, 0x0E, 0x38, 0x0E, 0xE0, 0x78, 0xE0, 0x73, 0x81, 0xC3,
  0x81, 0xCE, 0x07, 0x0E, 0x0E, 0x38, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE0,
  0xC3, 0x87, 0x03, 0x87, 0x0E, 0x1C, 0x0E, 0x1C, 0x38, 0xF0, 0x1C, 0xE0,
  0x63, 0x80, 0x73, 0x81, 0x8E, 0x01, 0xDC, 0x06, 0x70, 0x07, 0x70, 0x19,
  0xC0, 0x1B, 0x80, 0x6E, 0x00, 0x6E, 0x01, 0xB8, 0x01, 0xB0, 0x06, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE0,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x87,
  0x00, 0x07, 0x83, 0x80, 0x0F, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x3C, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01,
  0xEE, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x80, 0xF0, 0x70, 0x1C,
  0x0E, 0x07, 0x01, 0xC1, 0xE0, 0x38, 0x38, 0x03, 0x8E, 0x00, 0x73, 0xC0,
  0x0E, 0x70, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xE1, 0xC3, 0x87, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0x83,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0x70, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x18, 0x70, 0x0E, 0x1C, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x1C, 0x38,
  0x07, 0x0C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF0, 0xF1, 0xC7, 0x0E, 0x18, 0x30, 0x00, 0xE0, 0x01, 0xFC, 0x70,
  0xFF, 0x98, 0x7C, 0x7E, 0x3C, 0x0F, 0x8E, 0x01, 0xE7, 0x80, 0x79, 0xC0,
  0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E,
  0x38, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0xF8, 0xF0, 0x6C, 0x3E, 0x7F, 0x07,
  0xFD, 0xC0, 0xFC, 0x70, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x30, 0x0E, 0x7F,
  0x03, 0xBF, 0xE1, 0xFC, 0x38, 0x7E, 0x0F, 0x1F, 0x01, 0xC7, 0x80, 0x71,
  0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xE0,
  0x0E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xF0, 0x78, 0x6E, 0x3E,
  0x39, 0xFF, 0x0E, 0x3F, 0x00, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xF8,
  0x23, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF8, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x06, 0x0E, 0x07, 0xF1, 0xC1, 0xFF, 0x70, 0x7C, 0x7E, 0x1E, 0x07, 0xC3,
  0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38,
  0x0F, 0x87, 0x83, 0xE0, 0xF9, 0xDC, 0x0F, 0xF3, 0x80, 0xFC, 0x70, 0x00,
  0x00, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xDC,
  0x07, 0xB8, 0x0E, 0xF0, 0x7D, 0xFF, 0xE3, 0xFF, 0x87, 0xF0, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x08, 0xF8, 0xF0, 0xFF, 0xE0,
  0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xE1,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0x1C, 0x1F, 0xF3, 0x07, 0xC7, 0xE1, 0xE0, 0x7C, 0x38,
  0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xC0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0x80,
  0xF8, 0x78, 0x3E, 0x0F, 0x9D, 0xC0, 0xFF, 0x38, 0x0F, 0xC7, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x80, 0x38, 0x18, 0x1F,
  0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x30, 0x0E, 0x7F, 0x03, 0xBF, 0xE1, 0xDC, 0x3C, 0x7E, 0x0F, 0x1F,
  0x01, 0xC7, 0x80, 0x71, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x3C, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xE0, 0x01, 0x03, 0xC1,
  0xE0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x38, 0x00, 0x00, 0x04, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x01, 0x0E, 0x07, 0x83, 0x83, 0xC1, 0xE1,
  0xE0, 0x70, 0xF0, 0x1C, 0x78, 0x07, 0x3C, 0x01, 0xDE, 0x00, 0xEF, 0x00,
  0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xE3, 0x80, 0x78, 0xF0, 0x1C,
  0x1C, 0x07, 0x07, 0x81, 0xC0, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x0E, 0x01,
  0xE0, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0xE7, 0xF0, 0xFE, 0x0E, 0xFF, 0x1F, 0xF0, 0xDC, 0x7B, 0x8F, 0x1F, 0x03,
  0xF0, 0x71, 0xF0, 0x3E, 0x07, 0x1E, 0x03, 0xC0, 0x71, 0xC0, 0x38, 0x07,
  0x3C, 0x03, 0x80, 0x73, 0xC0, 0x78, 0x07, 0x38, 0x07, 0x00, 0xF3, 0x80,
  0x70, 0x0E, 0x38, 0x07, 0x00, 0xE7, 0x80, 0x70, 0x0E, 0x70, 0x0F, 0x00,
  0xE7, 0x00, 0xE0, 0x1E, 0x70, 0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x1C, 0xF0,
  0x0E, 0x01, 0xCE, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0x9F, 0xE0, 0xEF,
  0xF8, 0x7F, 0x0F, 0x1F, 0x83, 0xC7, 0xC0, 0x71, 0xE0, 0x3C, 0x70, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xE3, 0x80, 0x38, 0x00, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0xC3, 0xC3,
  0xC0, 0xF1, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x39, 0xC0,
  0x3C, 0xF0, 0x3C, 0x3E, 0x7C, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x39, 0xFC, 0x03, 0xBF, 0xE0, 0x37, 0x0E, 0x07, 0xE0, 0xF0, 0x7C,
  0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1,
  0xE0, 0x3C, 0x1F, 0x07, 0x81, 0xF8, 0xF8, 0x39, 0xFF, 0x03, 0x8F, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xFE, 0x70, 0xFF, 0x98, 0x7C, 0x7E, 0x3C, 0x0F, 0x8E, 0x01,
  0xE7, 0x80, 0x79, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0xF3,
  0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0xF8, 0xF0,
  0x7C, 0x3E, 0x77, 0x07, 0xF9, 0xC0, 0xFC, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x39, 0xF0, 0xEF, 0xC3, 0x70,
  0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0, 0x61,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x80, 0x79,
  0xE3, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x01,
  0xC1, 0xFF, 0xFF, 0xF9, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE2,
  0x1F, 0xC1, 0xF8, 0x1C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x8E, 0x01, 0xE7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0xF3, 0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x03,
  0xE3, 0x81, 0xF0, 0xF1, 0xDC, 0x1F, 0xE7, 0x03, 0xF1, 0xC0, 0xE0, 0x07,
  0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC1, 0xC1,
  0xE0, 0xE0, 0xE0, 0x70, 0xF0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07,
  0x3C, 0x03, 0x9C, 0x01, 0xDE, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x03, 0xF0, 0x1E, 0x03, 0xF8, 0x0F, 0x01,
  0xDC, 0x0F, 0x81, 0xEE, 0x06, 0xE0, 0xE7, 0x07, 0x70, 0xF3, 0x83, 0x38,
  0x71, 0xC3, 0x9C, 0x38, 0xE1, 0x8E, 0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE3,
  0x9C, 0x0C, 0xE1, 0xCE, 0x06, 0x70, 0xEE, 0x03, 0x70, 0x77, 0x01, 0xB8,
  0x3B, 0x80, 0xD8, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0xE0, 0x78, 0x1C, 0x1E, 0x01, 0xC3,
  0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7B, 0x80, 0x1E, 0x70,
  0x07, 0x87, 0x00, 0xE0, 0xE0, 0x38, 0x1E, 0x0F, 0x01, 0xC3, 0xC0, 0x3C,
  0x00, 0x07, 0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x03,
  0x87, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0x80, 0x01, 0x9E,
  0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x00,
  0x1C, 0x01, 0xF0, 0x0F, 0xC0, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x3E,
  0x01, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x7E, 0x03, 0xE0, 0x10,
  0x00, 0x7E, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x1C,
};

const GFXglyph NotoSans_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 27, 9, 1, -26 },
  { 32, 11, 10, 14, 4, -26 },
  { 46, 23, 26, 23, 1, -26 },
  { 121, 18, 29, 20, 1, -27 },
  { 187, 24, 26, 29, 3, -26 },
  { 265, 22, 26, 24, 1, -26 },
  { 337, 5, 10, 8, 4, -26 },
  { 344, 12, 32, 10, 1, -26 },
  { 392, 12, 32, 10, -3, -26 },
  { 440, 16, 16, 20, 4, -27 },
  { 472, 16, 17, 21, 3, -21 },
  { 506, 8, 9, 9, -2, -4 },
  { 515, 9, 3, 11, 1, -11 },
  { 519, 4, 5, 9, 1, -4 },
  { 522, 18, 26, 13, -2, -26 },
  { 581, 17, 26, 20, 2, -26 },
  { 637, 11, 26, 20, 5, -26 },
  { 673, 19, 26, 20, 0, -26 },
  { 735, 18, 26, 20, 1, -26 },
  { 794, 19, 26, 20, 0, -26 },
  { 856, 18, 26, 20, 1, -26 },
  { 915, 18, 26, 20, 2, -26 },
  { 974, 17, 26, 20, 3, -26 },
  { 1030, 18, 26, 20, 2, -26 },
  { 1089, 17, 26, 20, 2, -26 },
  { 1145, 7, 21, 9, 1, -20 },
  { 1164, 10, 25, 9, -2, -20 },
  { 1196, 16, 18, 21, 3, -22 },
  { 1232, 16, 10, 21, 3, -18 },
  { 1252, 16, 18, 21, 3, -22 },
  { 1288, 13, 27, 15, 3, -26 },
  { 1332, 28, 29, 31, 2, -26 },
  { 1434, 20, 26, 20, -2, -26 },
  { 1499, 20, 26, 22, 1, -26 },
  { 1564, 20, 26, 21, 3, -26 },
  { 1629, 22, 26, 24, 1, -26 },
  { 1701, 19, 26, 19, 1, -26 },
  { 1763, 19, 26, 17, 1, -26 },
  { 1825, 21, 26, 24, 3, -26 },
  { 1894, 23, 26, 24, 2, -26 },
  { 1969, 15, 26, 12, -1, -26 },
  { 2018, 16, 33, 10, -6, -26 },
  { 2084, 22, 26, 20, 1, -26 },
  { 2156, 14, 26, 17, 1, -26 },
  { 2202, 29, 26, 30, 1, -26 },
  { 2297, 25, 26, 25, 1, -26 },
  { 2379, 22, 26, 26, 3, -26 },
  { 2451, 19, 26, 20, 1, -26 },
  { 2513, 22, 32, 26, 3, -26 },
  { 2601, 19, 26, 21, 1, -26 },
  { 2663, 18, 26, 18, 1, -26 },
  { 2722, 18, 26, 18, 3, -26 },
  { 2781, 22, 26, 24, 3, -26 },
  { 2853, 20, 26, 20, 3, -26 },
  { 2918, 30, 26, 31, 4, -26 },
  { 3016, 24, 26, 19, -2, -26 },
  { 3094, 19, 26, 18, 3, -26 },
  { 3156, 21, 26, 19, 0, -26 },
  { 3225, 13, 32, 10, 0, -26 },
  { 3277, 7, 26, 13, 4, -26 },
  { 3300, 14, 32, 10, -3, -26 },
  { 3356, 18, 16, 21, 1, -26 },
  { 3392, 15, 3, 14, -3, 3 },
  { 3398, 6, 6, 10, 5, -28 },
  { 3403, 18, 20, 20, 2, -20 },
  { 3448, 18, 27, 21, 1, -27 },
  { 3509, 15, 20, 16, 2, -20 },
  { 3547, 19, 27, 21, 2, -27 },
  { 3612, 15, 20, 18, 2, -20 },
  { 3650, 20, 37, 11, -4, -28 },
  { 3743, 19, 29, 21, 1, -20 },
  { 3812, 18, 27, 21, 1, -27 },
  { 3873, 9, 27, 9, 1, -27 },
  { 3904, 15, 36, 9, -5, -27 },
  { 3972, 18, 27, 18, 1, -27 },
  { 4033, 9, 27, 9, 1, -27 },
  { 4064, 28, 20, 32, 1, -20 },
  { 4134, 18, 20, 21, 1, -20 },
  { 4179, 17, 20, 20, 2, -20 },
  { 4222, 20, 29, 21, -1, -20 },
  { 4295, 18, 29, 21, 2, -20 },
  { 4361, 14, 20, 14, 1, -20 },
  { 4396, 15, 20, 16, 0, -20 },
  { 4434, 11, 24, 12, 2, -24 },
  { 4467, 18, 19, 21, 2, -19 },
  { 4510, 17, 19, 17, 2, -19 },
  { 4551, 25, 19, 26, 2, -19 },
  { 4611, 19, 19, 17, -1, -19 },
  { 4657, 22, 28, 17, -3, -19 },
  { 4734, 17, 19, 16, -1, -19 },
  { 4775, 14, 32, 13, 0, -26 },
  { 4831, 3, 36, 20, 9, -27 },
  { 4845, 13, 32, 13, -1, -26 },
  { 4897, 16, 5, 21, 3, -15 },
};

const GFXfont NotoSans_Italic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_ITALIC36PT7B_H_
