#ifndef _NOTOSANS_ITALIC66PT7B_H_
#define _NOTOSANS_ITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x83, 0xF3, 0xF0, 0x3F,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07,
  0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0x80,
  0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xC7, 0x81, 0xC0, 0x1F, 0x83, 0xC0, 0x20, 0x1F, 0x81, 0xE0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x07, 0xFB,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1E, 0xFF, 0x00, 0x00, 0x0F, 0x1F, 0xC0, 0x00,
  0x07, 0x87, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x01, 0xE0, 0x7E, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC1, 0x00, 0x1E, 0x0F, 0xC0,
  0xF0, 0x0F, 0x0F, 0xE0, 0x7F, 0x87, 0xBF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x01,
  0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x0F,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xC1,
  0xF0, 0x7E, 0x0F, 0x80, 0x3C, 0x1F, 0x0F, 0xFC, 0x7C, 0x03, 0xE1, 0xF0,
  0xFF, 0xF3, 0xE0, 0x1F, 0x1F, 0x8F, 0xFF, 0xCF, 0x81, 0xF0, 0xF8, 0xFE,
  0xFE, 0x7C, 0x1F, 0x0F, 0x8F, 0xC1, 0xF3, 0xFF, 0xF8, 0xF8, 0x7C, 0x07,
  0xCF, 0xFF, 0x8F, 0xC7, 0xC0, 0x3E, 0x7F, 0xF8, 0x7C, 0x3E, 0x01, 0xF1,
  0xFF, 0x87, 0xC3, 0xE0, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x07,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x41,
  0xFE, 0x3F, 0x00, 0x0F, 0xC1, 0xFE, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x07,
  0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x7E,
  0x00, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x01, 0xFD, 0xFC, 0x1F, 0x80, 0x00,
  0x7F, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xFC,
  0x03, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xFD, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x7E,
  0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xE0, 0x07,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x7C, 0x03, 0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x3F,
  0xFC, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x9F, 0xFC, 0x01, 0xFF,
  0x00, 0x70, 0x0F, 0xBC, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xF1, 0xE0,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xE0, 0x07, 0xC0, 0x01,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0x7E, 0x3F, 0xE7, 0xCF, 0xFC, 0xFC, 0x7F,
  0x0F, 0xC3, 0xE0, 0xFC, 0x38, 0x0F, 0xC1, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x0F,
  0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x80, 0x00, 0x03, 0xF8, 0x38, 0x00, 0x01, 0xFC,
  0x0F, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC1, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xF4, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFE, 0x06, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x07, 0xFE, 0x00, 0x3F,
  0x1F, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0xE0, 0x7E,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xF0, 0x7F, 0xC0, 0x03, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x87, 0xE0, 0x01, 0xFF, 0x0F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFB, 0xF0, 0x1F,
  0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0x8F, 0x80, 0x0F, 0xFC, 0x3F, 0x00, 0x00,
  0x80, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x02, 0x00, 0x0F, 0xF8,
  0x07, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0x78, 0x01,
  0xFC, 0x20, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0xF8, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xE3, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0x9F, 0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x3E, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xCF, 0x80, 0xFC,
  0x00, 0x7C, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x7C, 0x03,
  0xE0, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x7D, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE7,
  0xC0, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xBE, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xE7, 0xE0, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0xF8, 0x03, 0xF8,
  0x07, 0xE1, 0xF0, 0x1F, 0x80, 0xFF, 0x81, 0xF8, 0x3E, 0x01, 0xF8, 0x7C,
  0xF8, 0xFE, 0x07, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0xF8, 0x03, 0xFF,
  0xC3, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x7F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xDF, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0x80, 0x1F, 0xF0, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x3E,
  0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x0F,
  0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x00, 0x0C, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x07,
  0xFF, 0xF1, 0xF8, 0x00, 0x0F, 0xFF, 0xE3, 0xF0, 0x00, 0x1F, 0xFF, 0xC7,
  0xE0, 0x00, 0x7F, 0xFF, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x00, 0x3E,
  0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x00, 0x03,
  0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x00,
  0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xF9, 0xF8, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1,
  0xF0, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0,
  0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x03, 0xF0,
  0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x80, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF9, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x03, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xBE, 0x00, 0x00, 0xFC, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF1, 0xF8,
  0x00, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x1F,
  0x00, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x3F, 0x00,
  0x01, 0xF9, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x3E, 0x00, 0x00,
  0xF9, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x7E, 0x00, 0x00, 0x7D,
  0xF0, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xE0,
  0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0xE0,
  0x1F, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE3, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xFC, 0x01, 0xF8, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x9F, 0xF8,
  0x03, 0xFC, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x60, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x1F, 0xF0, 0x1F, 0xFD, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xFC, 0x0F, 0x80, 0x07, 0xE7, 0xC0,
  0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F,
  0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x00, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xE0,
  0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0x3F,
  0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE,
  0x0F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x03, 0xC0, 0x0F, 0xFF, 0xC3, 0xE0, 0x1F,
  0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0xFD, 0xF0, 0x1F, 0xF0, 0x3E, 0xF8, 0x0F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xE0, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03,
  0xFC, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0xE0, 0x03, 0xFE, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFC, 0x03, 0xEF, 0x80, 0xFF, 0x87, 0xE7, 0xC0, 0x3F, 0xFF,
  0xE3, 0xE0, 0x0F, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0xE1, 0xF0, 0x00, 0xFF,
  0xC0, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x7F,
  0xF0, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0xF8, 0xFF, 0xFF, 0x00, 0x7C, 0xFF,
  0xFF, 0x80, 0x7E, 0xFC, 0x1F, 0xE0, 0x3F, 0xF8, 0x03, 0xF0, 0x1F, 0xF8,
  0x01, 0xF8, 0x0F, 0xF8, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x3F, 0x07, 0xF8,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0xFE,
  0x03, 0xEF, 0xC1, 0xFF, 0x01, 0xF3, 0xFF, 0xFF, 0x01, 0xF0, 0xFF, 0xFF,
  0x00, 0xF8, 0x3F, 0xFE, 0x00, 0x78, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0x81, 0xFE,
  0x00, 0x10, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0x01, 0xFF,
  0x03, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x01, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0xFF, 0x1F, 0x80,
  0x0F, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0x00, 0x3F, 0xE0, 0x7D,
  0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xBE,
  0x00, 0x7F, 0x00, 0xFB, 0xE0, 0x07, 0xFC, 0x3F, 0x3E, 0x00, 0x3F, 0xFF,
  0xE7, 0xE0, 0x01, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0xFF, 0x07, 0xC0, 0x00,
  0x7F, 0xE0, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3E, 0x00,
  0x3F, 0xC7, 0xE0, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x10, 0x3F, 0x80, 0x07, 0x03, 0xFE, 0x07,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x87, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0xF0, 0x01, 0xFF, 0xF8, 0x7C, 0x01, 0xFF, 0xFF, 0x1F, 0x00, 0xFF, 0xFF,
  0xEF, 0xC0, 0x7F, 0xC0, 0xFB, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0,
  0x03, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x81, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0x7C, 0x03,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x87, 0xEF, 0xC0, 0x1F, 0xFF, 0xF3, 0xF0,
  0x03, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0x0F, 0xFC, 0x1F,
  0x80, 0x00, 0x30, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x80,
  0x00, 0x7F, 0x00, 0x30, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03,
  0xF0, 0x7F, 0xF0, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0xF8, 0xFF, 0xFF, 0x00,
  0x7C, 0xFF, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x03, 0xF0,
  0x1F, 0xF8, 0x01, 0xF8, 0x0F, 0xF8, 0x00, 0x7C, 0x0F, 0xF8, 0x00, 0x3F,
  0x07, 0xF8, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x08, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x02, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x02,
  0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF0, 0xFE,
  0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x3E, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xF3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x3F, 0x7C, 0x0F, 0xE7, 0xE0, 0xFF, 0x03, 0xEF, 0x80, 0x7E,
  0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x07, 0xEF, 0x00, 0x3F, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01,
  0xF0, 0x1F, 0xF0, 0x00, 0xF8, 0x3F, 0xFE, 0x00, 0x7C, 0x3F, 0xFF, 0x80,
  0x3E, 0x3F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xF0, 0x1F, 0xBF, 0x87, 0xF8,
  0x0F, 0xFE, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0x3F,
  0x83, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x7F,
  0xF0, 0x00, 0x3E, 0x1F, 0xFF, 0x80, 0x03, 0xE3, 0xFF, 0xFC, 0x00, 0x3E,
  0x7F, 0xFF, 0xC0, 0x07, 0xEF, 0xC1, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xE0,
  0x07, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x00,
  0xFB, 0xF0, 0x7F, 0xC0, 0x0F, 0x9F, 0xFF, 0xF8, 0x01, 0xF8, 0xFF, 0xFF,
  0x00, 0x1F, 0x87, 0xFF, 0xC0, 0x01, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0x80,
  0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x03, 0xC0, 0x0F, 0xFF, 0xC3, 0xE0, 0x1F,
  0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0xFD, 0xF0, 0x1F, 0xF0, 0x3E, 0xF8, 0x1F,
  0xE0, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x03,
  0xFC, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0xE0, 0x03, 0xFE, 0x03, 0xF0, 0x03,
  0xDF, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x87, 0xEF, 0xC0, 0x3F, 0xFF,
  0xE7, 0xE0, 0x0F, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0xC3, 0xF0, 0x00, 0xFF,
  0xC1, 0xF8, 0x00, 0x06, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x7C, 0x1F, 0xF0, 0x1F, 0x0F, 0xFC, 0x07, 0xC7, 0xFF, 0x01, 0xF3,
  0xFF, 0x80, 0xFD, 0xFC, 0x20, 0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xF0, 0x0F, 0x81, 0xFC, 0x00, 0x30, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0x00, 0x00, 0xFC, 0x38,
  0x00, 0x3F, 0x87, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x18, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC,
  0x00, 0xF7, 0xC0, 0xFC, 0x01, 0xF7, 0xC0, 0xFF, 0x0F, 0xE7, 0xC0, 0x7F,
  0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0x8F, 0x80, 0x3F, 0xFE, 0x0F, 0x80, 0x1F,
  0xFC, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x7E, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xCF, 0xC0, 0x0F,
  0xBC, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF3,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xCF, 0x00, 0x3F, 0x0F, 0xC0, 0x3E, 0x3C,
  0x01, 0xF8, 0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE3, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x3E, 0x07,
  0xE0, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x83, 0xE0, 0x7C,
  0x03, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x00, 0x1F,
  0x3E, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0x7D, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x1F,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x81, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x3F, 0xF8,
  0x00, 0x05, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x40, 0x00, 0xFF,
  0xF8, 0x80, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_Italic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 17, 48, 17, 1, -47 },
  { 103, 20, 17, 26, 7, -47 },
  { 146, 41, 47, 43, 2, -47 },
  { 387, 33, 54, 36, 2, -50 },
  { 610, 45, 49, 53, 5, -48 },
  { 886, 41, 49, 44, 2, -48 },
  { 1138, 9, 17, 15, 7, -47 },
  { 1158, 21, 57, 19, 3, -47 },
  { 1308, 21, 57, 19, -5, -47 },
  { 1458, 30, 30, 36, 7, -50 },
  { 1571, 31, 32, 38, 5, -39 },
  { 1695, 13, 17, 17, -3, -8 },
  { 1723, 16, 5, 21, 2, -20 },
  { 1733, 9, 9, 17, 1, -8 },
  { 1744, 32, 47, 24, -3, -47 },
  { 1932, 31, 49, 36, 4, -48 },
  { 2122, 20, 47, 36, 9, -47 },
  { 2240, 35, 48, 36, 0, -48 },
  { 2450, 34, 49, 36, 1, -48 },
  { 2659, 35, 47, 36, 0, -47 },
  { 2865, 33, 48, 36, 2, -47 },
  { 3063, 32, 49, 36, 4, -48 },
  { 3259, 32, 47, 36, 5, -47 },
  { 3447, 33, 49, 36, 3, -48 },
  { 3650, 31, 49, 36, 3, -48 },
  { 3840, 14, 37, 17, 1, -36 },
  { 3905, 18, 45, 17, -3, -36 },
  { 4007, 31, 32, 38, 5, -40 },
  { 4131, 30, 18, 38, 5, -32 },
  { 4199, 31, 32, 38, 5, -40 },
  { 4323, 25, 49, 28, 5, -48 },
  { 4477, 51, 53, 56, 3, -47 },
  { 4815, 38, 47, 37, -4, -47 },
  { 5039, 36, 47, 40, 3, -47 },
  { 5251, 37, 49, 39, 5, -48 },
  { 5478, 39, 47, 44, 3, -47 },
  { 5708, 34, 47, 34, 3, -47 },
  { 5908, 34, 47, 31, 3, -47 },
  { 6108, 39, 49, 45, 5, -48 },
  { 6347, 42, 47, 45, 3, -47 },
  { 6594, 26, 47, 21, -1, -47 },
  { 6747, 29, 60, 18, -10, -47 },
  { 6965, 40, 47, 37, 3, -47 },
  { 7200, 25, 47, 32, 3, -47 },
  { 7347, 53, 47, 56, 3, -47 },
  { 7659, 44, 47, 47, 3, -47 },
  { 7918, 41, 49, 48, 5, -48 },
  { 8170, 34, 47, 37, 3, -47 },
  { 8370, 41, 59, 48, 5, -48 },
  { 8673, 35, 47, 38, 3, -47 },
  { 8879, 33, 49, 33, 1, -48 },
  { 9082, 33, 47, 33, 6, -47 },
  { 9276, 40, 48, 45, 5, -47 },
  { 9516, 37, 47, 36, 6, -47 },
  { 9734, 55, 47, 57, 7, -47 },
  { 10058, 43, 47, 35, -3, -47 },
  { 10311, 34, 47, 34, 6, -47 },
  { 10511, 39, 47, 35, -1, -47 },
  { 10741, 25, 57, 19, -1, -47 },
  { 10920, 12, 47, 24, 7, -47 },
  { 10991, 25, 57, 19, -5, -47 },
  { 11170, 32, 29, 38, 3, -47 },
  { 11286, 27, 4, 26, -6, 6 },
  { 11300, 10, 11, 18, 10, -51 },
  { 11314, 33, 37, 37, 3, -36 },
  { 11467, 33, 51, 38, 2, -50 },
  { 11678, 27, 37, 30, 3, -36 },
  { 11803, 36, 51, 38, 3, -50 },
  { 12033, 28, 37, 33, 3, -36 },
  { 12163, 36, 66, 21, -7, -50 },
  { 12460, 34, 52, 38, 2, -36 },
  { 12681, 33, 50, 38, 2, -50 },
  { 12888, 16, 49, 17, 2, -49 },
  { 12986, 26, 65, 17, -8, -49 },
  { 13198, 33, 50, 33, 2, -50 },
  { 13405, 16, 50, 17, 2, -50 },
  { 13505, 52, 36, 58, 2, -36 },
  { 13739, 33, 36, 38, 2, -36 },
  { 13888, 31, 37, 37, 3, -36 },
  { 14032, 36, 52, 38, -1, -36 },
  { 14266, 33, 52, 38, 3, -36 },
  { 14481, 26, 36, 26, 2, -36 },
  { 14598, 27, 37, 29, 0, -36 },
  { 14723, 21, 44, 22, 3, -43 },
  { 14839, 32, 36, 38, 4, -35 },
  { 14983, 31, 35, 31, 3, -35 },
  { 15119, 46, 35, 48, 4, -35 },
  { 15321, 36, 35, 32, -2, -35 },
  { 15479, 40, 51, 31, -6, -35 },
  { 15734, 30, 35, 29, -1, -35 },
  { 15866, 25, 57, 23, 1, -47 },
  { 16045, 5, 66, 36, 17, -50 },
  { 16087, 25, 57, 23, -2, -47 },
  { 16266, 31, 9, 38, 5, -28 },
};

const GFXfont NotoSans_Italic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic66pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_ITALIC66PT7B_H_
