#ifndef _NOTOSANS_ITALIC71PT7B_H_
#define _NOTOSANS_ITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF0,
  0x0F, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xF7, 0xBF, 0xE0, 0x0F, 0xF1, 0xF0, 0x3C, 0x01, 0xF8, 0x3E,
  0x01, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8,
  0x1E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x78, 0x00,
  0x00, 0x7F, 0x1F, 0x00, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF3, 0xFC,
  0x00, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x00, 0xF0,
  0x3F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0xFE, 0x00,
  0x00, 0xF8, 0x1F, 0x82, 0x00, 0x1F, 0x07, 0xF0, 0x70, 0x03, 0xE1, 0xFC,
  0x0F, 0xE0, 0x78, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xC1, 0xF8, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x3F, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0xFF, 0xFC, 0xF8, 0x07, 0xC3, 0xF1,
  0xFF, 0xFC, 0xF8, 0x0F, 0xC3, 0xE3, 0xFF, 0xFE, 0xFC, 0x1F, 0x87, 0xE3,
  0xF0, 0x7E, 0x7E, 0x7F, 0x8F, 0xC7, 0xE0, 0x3E, 0x7F, 0xFF, 0x1F, 0x87,
  0xC0, 0x3E, 0x3F, 0xFE, 0x1F, 0x0F, 0xC0, 0x3F, 0x3F, 0xFC, 0x3F, 0x0F,
  0x80, 0x3F, 0x0F, 0xF0, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x00,
  0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x7F,
  0x07, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF8, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x40, 0x01, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x0F, 0xFF, 0x9E,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xDE, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x0F,
  0xE0, 0x7C, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x70, 0x03, 0xF0, 0x00, 0x18, 0x00, 0xFC, 0x00,
  0x08, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x04, 0x1F, 0xCF, 0xEF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFE, 0x7F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFB,
  0xF0, 0xFF, 0xDF, 0xCF, 0xFC, 0x7E, 0x1F, 0xE1, 0xF8, 0x7E, 0x07, 0xE0,
  0xF0, 0x3F, 0x81, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x0C,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xF8,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x40, 0x00, 0x01, 0xFE, 0x0E, 0x00, 0x00, 0x7F, 0x81, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x40, 0x00, 0x03, 0xFC, 0x0E, 0x00, 0x00, 0xFF,
  0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0x1F, 0xFF, 0xC0, 0x0F, 0xE7, 0xFF, 0xFC,
  0x01, 0xF9, 0xFF, 0xFF, 0xC0, 0x3F, 0x7E, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0x81, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x07,
  0xFF, 0xC3, 0xF0, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x38, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x01,
  0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F,
  0x80, 0xFF, 0x87, 0x80, 0x07, 0xF8, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x3E, 0x00, 0x1F,
  0xFF, 0xFC, 0x01, 0xF1, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xC7, 0xC0,
  0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7C,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xC0, 0x03, 0xE0,
  0x07, 0xDF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x7C, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7D, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x3F,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xF8,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x03,
  0xEF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xBE, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x7E, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF3, 0xE0, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xCF, 0x80, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x3E, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xF8, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE3,
  0xE0, 0x1F, 0x80, 0x7B, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xEF, 0xC3,
  0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xF8,
  0x7F, 0xFE, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x06, 0x00,
  0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x01,
  0xFE, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x81, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x8F,
  0xE0, 0x00, 0x1F, 0xFF, 0xE3, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xC7, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x0F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x0F,
  0xCF, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xE7,
  0xE0, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x00,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0xC0, 0x0F, 0xC1,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3E,
  0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xF8,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xC0, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x00,
  0x7F, 0x80, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xBE, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFC, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x80,
  0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F,
  0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x9F, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x7C, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0x00, 0x1F, 0xFF, 0xC1,
  0xF0, 0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF,
  0xFF, 0x3E, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00,
  0x7F, 0xC0, 0x7E, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0x00, 0x3E, 0xF8, 0x03, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0xFF, 0xF8, 0xF8,
  0x01, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0xE1, 0xF0, 0x00, 0xFF, 0xFC,
  0x1F, 0x00, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00,
  0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xF0, 0x01, 0xFC, 0x7F, 0xFF,
  0x80, 0x1F, 0x8F, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xFF, 0xC0, 0x1F, 0xBF,
  0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8, 0x00, 0xFE, 0x03,
  0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x7E,
  0xF0, 0x07, 0xF8, 0x07, 0xEF, 0xF7, 0xFF, 0x00, 0x7C, 0x7F, 0xFF, 0xE0,
  0x07, 0xC3, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0x80, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x00, 0xFF,
  0x80, 0x1C, 0x01, 0xFF, 0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xF0,
  0x00, 0x3F, 0xFF, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x9F, 0x80, 0x03, 0xFF,
  0xFF, 0x3F, 0x00, 0x0F, 0xFE, 0xFF, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x07,
  0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x7C, 0x00, 0x3F, 0x80, 0xFD, 0xF8, 0x00,
  0x7F, 0xFF, 0xF3, 0xF0, 0x00, 0x7F, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0xFF,
  0x0F, 0xC0, 0x00, 0xFF, 0xFC, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F,
  0x07, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x7F, 0xF1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0xFF, 0x80,
  0x1F, 0x01, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0x87, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xC0, 0x03, 0xFF, 0xF8,
  0x3E, 0x00, 0x3F, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xFF, 0x1F, 0x00, 0x3F,
  0xFB, 0xFC, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xF0,
  0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0xFE, 0x03, 0xF7, 0xE0,
  0x07, 0xFF, 0xFF, 0x3F, 0x00, 0x1F, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xFF,
  0x1F, 0x80, 0x03, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0x00, 0x00, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0x87, 0xFF,
  0xE0, 0x07, 0xF1, 0xFF, 0xFE, 0x00, 0xFC, 0x7F, 0xFF, 0xE0, 0x1F, 0x9F,
  0xFF, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xC0, 0x7D, 0xF0, 0x03, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x7F, 0xC0, 0x00, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0C, 0x3F,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0x80, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x7E, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x7E, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x01, 0xFB, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xF3, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0x9F, 0x80, 0xFF, 0x01, 0xF7, 0xC0, 0x1F,
  0x9F, 0x00, 0x7F, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x01, 0xFF,
  0xC0, 0x07, 0xE0, 0xFF, 0xFE, 0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0x1F, 0x8F,
  0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xF8, 0x1F,
  0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0xE0, 0x00, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0x83, 0xFF, 0xF0,
  0x00, 0x0F, 0x87, 0xFF, 0xF8, 0x00, 0x1F, 0x8F, 0xFF, 0xF8, 0x00, 0x1F,
  0x9F, 0xFF, 0xFC, 0x00, 0x1F, 0xBF, 0x01, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xEF, 0x00, 0x7F, 0x80, 0x07,
  0xEF, 0xF7, 0xFF, 0x00, 0x07, 0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xE3, 0xFF,
  0xFC, 0x00, 0x0F, 0xC1, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0x00, 0x1F,
  0xFF, 0xC1, 0xF0, 0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0xE3, 0xE0,
  0x0F, 0xFE, 0xFF, 0x3E, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x07,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xE0, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x0F, 0xDF, 0x80, 0x3F, 0xFF,
  0xF9, 0xF8, 0x01, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0xE3, 0xF0, 0x00,
  0xFF, 0xFC, 0x3F, 0x00, 0x03, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x81, 0xFF, 0x00, 0xF8, 0x3F, 0xF0,
  0x0F, 0x87, 0xFF, 0x01, 0xF8, 0xFF, 0xF0, 0x1F, 0x9F, 0xFE, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xC0, 0xFE, 0x00, 0x04, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0xC0, 0x00, 0x3F, 0x87, 0xC0, 0x07, 0xFC, 0x3F, 0xF3, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x3C, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0x00, 0x0F, 0xFE, 0x07, 0xF0, 0x03, 0xEF, 0x80, 0xFF, 0x01, 0xFB,
  0xF0, 0x0F, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF,
  0xE1, 0xF0, 0x01, 0xFF, 0xF8, 0x3E, 0x00, 0x1F, 0xFC, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3E,
  0x3F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE3, 0xE0, 0x0F,
  0xE0, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x3E, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC3, 0xE0,
  0x3F, 0x80, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x3E,
  0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x03,
  0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0xF8, 0x3F, 0x80, 0x1F, 0x87, 0xE0,
  0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xF0, 0x01, 0xF8, 0xFC,
  0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x3E, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0, 0x01, 0xF9,
  0xF0, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x1F,
  0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x08, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x8F, 0xFF, 0x00, 0x00, 0x4F, 0xFF,
  0xF0, 0x00, 0x6F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x80,
  0x00, 0x3F, 0xFC, 0x40, 0x00, 0x00, 0x60, 0x00,
};

const GFXglyph NotoSans_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 19, 52, 19, 1, -51 },
  { 125, 21, 19, 28, 8, -51 },
  { 175, 44, 51, 46, 2, -51 },
  { 456, 35, 58, 39, 2, -54 },
  { 710, 48, 52, 57, 6, -51 },
  { 1022, 44, 52, 48, 2, -51 },
  { 1308, 9, 19, 16, 8, -51 },
  { 1330, 23, 62, 21, 3, -51 },
  { 1509, 23, 62, 21, -5, -51 },
  { 1688, 33, 33, 39, 7, -54 },
  { 1825, 33, 34, 41, 5, -42 },
  { 1966, 14, 17, 18, -3, -8 },
  { 1996, 18, 6, 22, 2, -22 },
  { 2010, 9, 10, 18, 1, -9 },
  { 2022, 34, 51, 25, -3, -51 },
  { 2239, 34, 52, 39, 4, -51 },
  { 2460, 22, 51, 39, 10, -51 },
  { 2601, 37, 51, 39, 0, -51 },
  { 2837, 35, 52, 39, 2, -51 },
  { 3065, 38, 51, 39, 0, -51 },
  { 3308, 35, 52, 39, 3, -51 },
  { 3536, 35, 52, 39, 4, -51 },
  { 3764, 34, 51, 39, 6, -51 },
  { 3981, 36, 52, 39, 3, -51 },
  { 4215, 34, 52, 39, 3, -51 },
  { 4436, 15, 40, 18, 1, -39 },
  { 4511, 19, 48, 18, -3, -39 },
  { 4625, 33, 35, 41, 5, -43 },
  { 4770, 33, 20, 41, 5, -35 },
  { 4853, 33, 35, 41, 5, -43 },
  { 4998, 27, 52, 31, 5, -51 },
  { 5174, 54, 57, 60, 4, -51 },
  { 5559, 40, 51, 40, -4, -51 },
  { 5814, 39, 51, 43, 3, -51 },
  { 6063, 40, 52, 42, 5, -51 },
  { 6323, 42, 51, 47, 3, -51 },
  { 6591, 36, 51, 37, 3, -51 },
  { 6821, 36, 51, 34, 3, -51 },
  { 7051, 42, 52, 48, 5, -51 },
  { 7324, 46, 51, 48, 3, -51 },
  { 7618, 28, 51, 23, -1, -51 },
  { 7797, 31, 64, 19, -11, -51 },
  { 8045, 43, 51, 40, 3, -51 },
  { 8320, 27, 51, 34, 3, -51 },
  { 8493, 57, 51, 60, 3, -51 },
  { 8857, 48, 51, 50, 3, -51 },
  { 9163, 44, 52, 51, 5, -51 },
  { 9449, 37, 51, 40, 3, -51 },
  { 9685, 44, 63, 51, 5, -51 },
  { 10032, 37, 51, 41, 3, -51 },
  { 10268, 36, 52, 36, 1, -51 },
  { 10502, 36, 51, 36, 6, -51 },
  { 10732, 43, 52, 48, 6, -51 },
  { 11012, 39, 51, 39, 7, -51 },
  { 11261, 59, 51, 61, 8, -51 },
  { 11638, 47, 51, 37, -4, -51 },
  { 11938, 36, 51, 36, 7, -51 },
  { 12168, 42, 51, 38, -1, -51 },
  { 12436, 27, 62, 21, -1, -51 },
  { 12646, 13, 51, 25, 8, -51 },
  { 12729, 27, 62, 21, -5, -51 },
  { 12939, 35, 32, 41, 3, -51 },
  { 13079, 30, 5, 28, -7, 6 },
  { 13098, 12, 11, 20, 10, -54 },
  { 13115, 36, 40, 40, 3, -39 },
  { 13295, 36, 55, 41, 2, -54 },
  { 13543, 30, 40, 32, 3, -39 },
  { 13693, 39, 55, 41, 3, -54 },
  { 13962, 30, 40, 35, 3, -39 },
  { 14112, 39, 71, 23, -8, -54 },
  { 14459, 37, 56, 41, 2, -39 },
  { 14718, 35, 54, 41, 2, -54 },
  { 14955, 17, 52, 18, 2, -52 },
  { 15066, 28, 69, 18, -9, -52 },
  { 15308, 35, 54, 35, 2, -54 },
  { 15545, 18, 54, 18, 2, -54 },
  { 15667, 56, 39, 62, 2, -39 },
  { 15940, 35, 39, 41, 2, -39 },
  { 16111, 34, 40, 40, 3, -39 },
  { 16281, 40, 56, 41, -2, -39 },
  { 16561, 36, 56, 41, 3, -39 },
  { 16813, 28, 39, 28, 2, -39 },
  { 16950, 29, 40, 31, 0, -39 },
  { 17095, 23, 48, 24, 3, -47 },
  { 17233, 35, 39, 41, 4, -38 },
  { 17404, 34, 38, 33, 3, -38 },
  { 17566, 50, 38, 51, 4, -38 },
  { 17804, 39, 38, 34, -3, -38 },
  { 17990, 44, 55, 33, -7, -38 },
  { 18293, 32, 38, 32, -1, -38 },
  { 18445, 27, 62, 25, 1, -51 },
  { 18655, 6, 71, 39, 18, -54 },
  { 18709, 28, 62, 25, -3, -51 },
  { 18926, 33, 10, 41, 5, -30 },
};

const GFXfont NotoSans_Italic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic71pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_ITALIC71PT7B_H_
