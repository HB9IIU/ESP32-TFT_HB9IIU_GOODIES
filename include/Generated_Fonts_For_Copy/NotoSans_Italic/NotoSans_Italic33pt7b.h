#ifndef _NOTOSANS_ITALIC33PT7B_H_
#define _NOTOSANS_ITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0,
  0xE0, 0x73, 0xDC, 0xEE, 0x3B, 0x8E, 0xE3, 0x30, 0xCC, 0x33, 0x1C, 0xC6,
  0x00, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x70, 0x01, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x0E, 0x07, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x80, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x60, 0x03,
  0x87, 0x00, 0x18, 0x30, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x38, 0x30, 0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x07, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x01, 0xFE,
  0x07, 0xFF, 0x0F, 0x67, 0x1C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xC0,
  0x1C, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0x9C,
  0x01, 0x9C, 0x03, 0x8C, 0x03, 0x1C, 0x03, 0x1C, 0xE3, 0x78, 0xFF, 0xF0,
  0x7F, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x38, 0xFE, 0x01, 0xC3, 0x98, 0x06, 0x1C, 0x70, 0x38, 0x61, 0xC1, 0xC3,
  0x87, 0x0E, 0x0C, 0x1C, 0x30, 0x30, 0x61, 0xC0, 0xC1, 0x8E, 0x03, 0x06,
  0x70, 0x0C, 0x39, 0x9F, 0xB0, 0xCE, 0xFE, 0xE7, 0x77, 0x1D, 0xF9, 0x98,
  0x73, 0x8C, 0x61, 0xC0, 0x73, 0x87, 0x03, 0x8E, 0x1C, 0x0C, 0x30, 0x60,
  0x60, 0xC1, 0x83, 0x83, 0x0E, 0x1C, 0x0C, 0x30, 0x60, 0x39, 0xC3, 0x00,
  0xFE, 0x1C, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0xF0,
  0x07, 0x1E, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x03, 0xCE, 0x07, 0x78, 0x70, 0x77, 0x07, 0x8E, 0xE0, 0x39, 0xCE, 0x01,
  0xFC, 0xE0, 0x0F, 0x8E, 0x00, 0xF0, 0xF0, 0x1F, 0x07, 0x87, 0xF8, 0x7F,
  0xF3, 0xC1, 0xFC, 0x1E, 0x77, 0xEE, 0xEC, 0xCC, 0xC0, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x60, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x40,
  0xC0, 0x71, 0x80, 0xFD, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0x07, 0x8E, 0x0E,
  0xC0, 0x1C, 0xC0, 0x38, 0xE0, 0x78, 0x60, 0x10, 0x70, 0x00, 0x60, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1C, 0xF3, 0x8E, 0x71, 0xCE,
  0x30, 0xFF, 0xFF, 0xFF, 0x6F, 0xFE, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x07,
  0xFC, 0x0F, 0xFC, 0x1E, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x38, 0xF0, 0x70, 0x78, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x01, 0xC1, 0xE0,
  0xF8, 0xFE, 0x7B, 0xBC, 0xE4, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xE0, 0xE0, 0xF0,
  0x40, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xFE, 0x1F, 0xFF,
  0x0C, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x80, 0x3C,
  0xE0, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x07, 0x70, 0x03, 0x9C,
  0x01, 0xC7, 0x00, 0xE1, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x07,
  0x03, 0x83, 0x80, 0xC1, 0xC0, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x88, 0x03, 0xC7, 0x07, 0xC3, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x71, 0xE0, 0x77,
  0xF8, 0x7F, 0xFC, 0x78, 0x1C, 0xF0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0,
  0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x38, 0x78, 0xF0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xE0, 0xF0,
  0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x03, 0x8F,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0xF1, 0xE0, 0xE0, 0x70, 0xE0,
  0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3,
  0xC1, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xE0, 0xF3, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x1D, 0xC0, 0x7B, 0x80, 0xF3, 0x87, 0xE7, 0xFD, 0x87, 0xF7, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x10, 0x7C, 0x3F,
  0xE0, 0x7F, 0x80, 0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x3C, 0xF3, 0x80, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x1C,
  0x1C, 0x0E, 0x06, 0x07, 0x07, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xF0,
  0x00, 0xC0, 0x00, 0x0F, 0x87, 0xFE, 0xFF, 0xE4, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x70, 0x3F, 0x87, 0x30, 0x7F, 0xE1, 0xB8, 0x78, 0x60, 0xD8, 0x70,
  0x30, 0x7C, 0x38, 0x38, 0x3E, 0x38, 0x1C, 0x1E, 0x1C, 0x0C, 0x1F, 0x0C,
  0x0E, 0x0F, 0x86, 0x07, 0x06, 0xC3, 0x07, 0x87, 0x61, 0xC3, 0xC7, 0x38,
  0xFF, 0x7F, 0x1C, 0x3F, 0x3F, 0x0E, 0x04, 0x02, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x80, 0x1F, 0x03, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03, 0x9C, 0x00,
  0x73, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xC0, 0x38, 0x1C, 0x07,
  0x03, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xC0, 0x38, 0x70,
  0x07, 0x0E, 0x00, 0xE3, 0x80, 0x0C, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0x80,
  0x07, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1C, 0x0F, 0x0E, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0x03, 0xC3, 0x80, 0x70, 0xE0,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x79, 0xC0, 0x1C, 0x70, 0x0F,
  0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xE0, 0x20, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x3C, 0x07,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x70, 0x7C, 0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0, 0x07,
  0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80,
  0x1C, 0x30, 0x03, 0xC7, 0x00, 0x78, 0x70, 0x1F, 0x07, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x06, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x1F, 0xEF, 0x01, 0xFC, 0xF0, 0x01, 0xCF,
  0x00, 0x1C, 0xF0, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x87, 0x80, 0x38,
  0x3C, 0x03, 0x83, 0xF0, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x06, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x70, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x27, 0xC0, 0xFE,
  0x03, 0xF0, 0x00, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE3, 0xC0, 0x0E,
  0x78, 0x01, 0xCF, 0x00, 0x1D, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xEE, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x38, 0x03, 0x83, 0x80,
  0x30, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1D,
  0x80, 0x1B, 0x83, 0xB0, 0x07, 0x70, 0x76, 0x01, 0xCC, 0x0C, 0xC0, 0x3B,
  0x83, 0x9C, 0x0E, 0x70, 0x73, 0x81, 0xCE, 0x0E, 0x70, 0x71, 0xC1, 0xCE,
  0x0C, 0x70, 0x30, 0xC3, 0x8E, 0x0E, 0x18, 0x61, 0xC1, 0xC3, 0x1C, 0x38,
  0x38, 0x63, 0x07, 0x06, 0x0C, 0xE1, 0xC1, 0xC1, 0xF8, 0x38, 0x38, 0x3F,
  0x07, 0x07, 0x07, 0xC0, 0xE0, 0xE0, 0xF8, 0x1C, 0x18, 0x0E, 0x07, 0x07,
  0x01, 0x80, 0xE0, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x70,
  0x3E, 0x00, 0xE0, 0xFC, 0x01, 0xC1, 0xF8, 0x03, 0x03, 0xB8, 0x0E, 0x07,
  0x70, 0x1C, 0x0C, 0x60, 0x38, 0x38, 0xE0, 0x70, 0x71, 0xC0, 0xC0, 0xE1,
  0xC3, 0x81, 0xC3, 0x87, 0x03, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x1C, 0x0E,
  0x70, 0x38, 0x0C, 0xE0, 0x60, 0x1D, 0xC1, 0xC0, 0x3B, 0x83, 0x80, 0x3E,
  0x07, 0x00, 0x7C, 0x0E, 0x00, 0xF8, 0x18, 0x00, 0xF0, 0x70, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x03, 0xC0, 0xE0,
  0x0F, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0F, 0x78, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xF8, 0x00,
  0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0xF3, 0x80, 0x07, 0x1C,
  0x00, 0x78, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x1F, 0x9F, 0x80, 0x7F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1C, 0x1E,
  0x0E, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC7,
  0x00, 0xE1, 0xC0, 0x78, 0x70, 0x3C, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFE,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x03, 0xC0, 0xE0, 0x0F, 0x0E, 0x00,
  0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xF8, 0x00, 0x3B, 0xC0, 0x01,
  0xDE, 0x00, 0x0E, 0xF0, 0x00, 0xF3, 0x80, 0x07, 0x1C, 0x00, 0x78, 0xF0,
  0x07, 0x83, 0xC0, 0x78, 0x1F, 0x9F, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1C,
  0x1E, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03,
  0xC7, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0xFC, 0x1F, 0xFE, 0x07, 0xFC, 0x03,
  0x87, 0x00, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x01, 0xC1, 0xC0,
  0x70, 0x70, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x3C, 0x01, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0x1E, 0x02, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x80, 0x78, 0xE1, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x71, 0xC0, 0x06, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0,
  0xF0, 0x1E, 0x0F, 0x87, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x18, 0x03, 0xC7,
  0x00, 0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xC0, 0x70, 0x70, 0x1C, 0x38, 0x03, 0x0E, 0x00, 0xC7, 0x00, 0x39, 0xC0,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x80,
  0x78, 0x07, 0x70, 0x1F, 0x00, 0xEE, 0x03, 0x60, 0x39, 0xC0, 0xEC, 0x07,
  0x38, 0x1D, 0x81, 0xC7, 0x03, 0x30, 0x38, 0xE0, 0xE6, 0x0E, 0x1C, 0x18,
  0xC1, 0xC3, 0x87, 0x18, 0x38, 0x70, 0xC3, 0x0E, 0x0E, 0x38, 0x61, 0xC1,
  0xC6, 0x0C, 0x70, 0x39, 0xC1, 0x8E, 0x07, 0x30, 0x3B, 0x80, 0xEE, 0x07,
  0x70, 0x1D, 0xC0, 0xEC, 0x03, 0xB0, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x70, 0x3C,
  0x01, 0xC0, 0xE0, 0x03, 0x07, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00,
  0x77, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0xE0,
  0x0E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xF0, 0xE0, 0x07, 0xF0, 0x03, 0x98,
  0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0xE0,
  0x38, 0xE0, 0x1C, 0x70, 0x06, 0x70, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0F,
  0xE0, 0xFC, 0x00, 0xC3, 0x0E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC7, 0x1C,
  0x71, 0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0x87, 0x03, 0xF0, 0x7F,
  0x07, 0xF0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x76, 0x00, 0x33, 0x80, 0x38, 0xC0, 0x18, 0x70, 0x1C, 0x18,
  0x0C, 0x0E, 0x0E, 0x03, 0x06, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x3B, 0x80,
  0x0E, 0xFF, 0xFF, 0xFF, 0xE0, 0xE3, 0x9C, 0x71, 0x80, 0x03, 0xC3, 0x0F,
  0xF7, 0x1F, 0x77, 0x3C, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0,
  0x78, 0xE0, 0xF8, 0xF1, 0xF8, 0x7F, 0xB8, 0x3E, 0x38, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x7C, 0x1C, 0xFE, 0x1D, 0xDF, 0x1F, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x3C,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70,
  0x0E, 0x70, 0x1E, 0x78, 0x1C, 0xFC, 0x7C, 0xEF, 0xF8, 0xC7, 0xE0, 0x03,
  0xF0, 0x7F, 0xC7, 0xDE, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0x0C, 0x7F, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0x1C, 0x0F,
  0xF7, 0x07, 0xDD, 0xC3, 0xC1, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC3,
  0x80, 0xF0, 0xE0, 0x78, 0x38, 0x3E, 0x0F, 0x1F, 0x81, 0xFE, 0xE0, 0x3E,
  0x38, 0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xDE, 0x78, 0x77, 0x81, 0xB8, 0x1D,
  0xC0, 0xFC, 0x3E, 0xFF, 0xE7, 0xFC, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1F, 0x0C, 0x7F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x71, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE1, 0x83, 0xFD, 0xC3, 0xEE, 0xE3, 0xC1, 0xF3,
  0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xE3, 0x81, 0xE1, 0xC1, 0xF0, 0xF1,
  0xF8, 0x3F, 0xDC, 0x0F, 0x8C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x82, 0x03, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x7C, 0x1C, 0xFE, 0x1D, 0xEF, 0x1F, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0x07, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0,
  0xE0, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x7E, 0x03, 0xF0, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x07, 0x1C, 0x0E, 0x1C,
  0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x18, 0xE0, 0x39, 0xC0, 0x3B, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7D, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x70,
  0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0x07, 0x07, 0x07, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x0C, 0x7C, 0x1F, 0x07,
  0x3F, 0x8F, 0xE1, 0xDD, 0xE7, 0xFC, 0x7C, 0x1B, 0x07, 0x1E, 0x07, 0x81,
  0xC7, 0x01, 0xC0, 0x73, 0xC0, 0x70, 0x1C, 0xE0, 0x3C, 0x07, 0x38, 0x0E,
  0x03, 0x8E, 0x03, 0x80, 0xE3, 0x00, 0xE0, 0x39, 0xC0, 0x30, 0x0E, 0x70,
  0x1C, 0x03, 0x9C, 0x07, 0x01, 0xC7, 0x01, 0xC0, 0x73, 0x80, 0x70, 0x1C,
  0xE0, 0x38, 0x07, 0x38, 0x0E, 0x03, 0xC0, 0x0C, 0x7C, 0x1C, 0xFF, 0x1D,
  0xFF, 0x1F, 0x07, 0x1E, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xE0, 0xE7, 0x80, 0xEE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x1E, 0x3C,
  0x78, 0x7F, 0xE0, 0x3F, 0x80, 0x03, 0x1F, 0x01, 0xCF, 0xE0, 0x77, 0x7C,
  0x1F, 0x07, 0x07, 0x81, 0xC1, 0xC0, 0x70, 0xF0, 0x1C, 0x38, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x01,
  0xE1, 0xE0, 0x70, 0xFC, 0x7C, 0x3B, 0xFE, 0x0E, 0x7E, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xE3, 0x0F, 0xF7, 0x1F, 0x77, 0x3C, 0x1E,
  0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0xF8, 0xF1, 0xF8,
  0x7F, 0xB8, 0x3E, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x78, 0xE7, 0xC7,
  0x7E, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF1, 0xF7, 0x8F, 0x02, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x30, 0x78, 0xFF, 0xE1, 0xFE, 0x00, 0x02, 0x00,
  0xC0, 0x38, 0x07, 0x03, 0xFE, 0xFF, 0xFF, 0xF8, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0xF0, 0x7E, 0x00, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x06, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0xF8, 0xF1,
  0xF8, 0xFF, 0xB8, 0x7E, 0x38, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x77, 0x01,
  0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0x61, 0xE0, 0xC3, 0x81,
  0xCF, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0xF0, 0x1F, 0x81, 0xE0, 0x77,
  0x07, 0xC0, 0xEE, 0x0D, 0x83, 0x9C, 0x3B, 0x07, 0x38, 0x66, 0x1C, 0x71,
  0xCC, 0x38, 0xE3, 0x18, 0xE1, 0xCE, 0x31, 0xC3, 0x9C, 0x73, 0x07, 0x30,
  0xEE, 0x0E, 0xE1, 0xD8, 0x1D, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x3C, 0x0F,
  0x80, 0x78, 0x1F, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0xC3, 0x80, 0xE0,
  0x60, 0x70, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1D, 0xC0, 0x0F, 0x70,
  0x03, 0x8E, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x1C, 0x3C, 0x07, 0x80,
  0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x07, 0x03, 0x80, 0x30, 0x70, 0x03, 0x87, 0x00, 0x38,
  0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x1B, 0x80, 0x01,
  0xB0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0B, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x20, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x00, 0x18, 0x07, 0xC0, 0x3E, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x3F, 0x01, 0xE0, 0x1F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x04, 0x00, 0x78, 0x07, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xF0, 0x1F,
  0x03, 0xC0, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0x7F, 0x83,
  0xFF, 0xFF, 0xC0, 0xFE, 0x80, 0x18,
};

const GFXglyph NotoSans_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 24, 9, 1, -24 },
  { 25, 10, 9, 13, 4, -24 },
  { 37, 21, 24, 21, 1, -24 },
  { 100, 16, 27, 18, 1, -25 },
  { 154, 22, 24, 26, 3, -24 },
  { 220, 20, 24, 22, 1, -24 },
  { 280, 4, 9, 7, 4, -24 },
  { 285, 11, 29, 10, 1, -24 },
  { 325, 11, 29, 10, -3, -24 },
  { 365, 16, 15, 18, 3, -25 },
  { 395, 16, 16, 19, 2, -20 },
  { 427, 6, 8, 8, -1, -4 },
  { 433, 8, 3, 10, 1, -10 },
  { 436, 4, 4, 8, 1, -4 },
  { 438, 17, 24, 12, -2, -24 },
  { 489, 16, 24, 18, 2, -24 },
  { 537, 10, 24, 18, 5, -24 },
  { 567, 17, 24, 18, 0, -24 },
  { 618, 16, 24, 18, 1, -24 },
  { 666, 18, 24, 18, 0, -24 },
  { 720, 17, 24, 18, 1, -24 },
  { 771, 16, 24, 18, 2, -24 },
  { 819, 16, 24, 18, 3, -24 },
  { 867, 17, 24, 18, 1, -24 },
  { 918, 15, 24, 18, 2, -24 },
  { 963, 6, 18, 8, 1, -18 },
  { 977, 9, 22, 8, -2, -18 },
  { 1002, 16, 16, 19, 2, -20 },
  { 1034, 15, 9, 19, 3, -16 },
  { 1051, 16, 16, 19, 2, -20 },
  { 1083, 12, 24, 14, 3, -24 },
  { 1119, 25, 27, 28, 2, -24 },
  { 1204, 19, 24, 19, -2, -24 },
  { 1261, 18, 24, 20, 1, -24 },
  { 1315, 19, 24, 19, 2, -24 },
  { 1372, 20, 24, 22, 1, -24 },
  { 1432, 17, 24, 17, 1, -24 },
  { 1483, 17, 24, 16, 1, -24 },
  { 1534, 20, 24, 22, 2, -24 },
  { 1594, 22, 24, 22, 1, -24 },
  { 1660, 14, 24, 11, -1, -24 },
  { 1702, 14, 30, 9, -5, -24 },
  { 1755, 20, 24, 19, 1, -24 },
  { 1815, 13, 24, 16, 1, -24 },
  { 1854, 27, 24, 28, 1, -24 },
  { 1935, 23, 24, 23, 1, -24 },
  { 2004, 21, 24, 24, 2, -24 },
  { 2067, 18, 24, 19, 1, -24 },
  { 2121, 21, 30, 24, 2, -24 },
  { 2200, 18, 24, 19, 1, -24 },
  { 2254, 16, 24, 17, 1, -24 },
  { 2302, 16, 24, 17, 3, -24 },
  { 2350, 20, 24, 22, 3, -24 },
  { 2410, 18, 24, 18, 3, -24 },
  { 2464, 27, 24, 28, 4, -24 },
  { 2545, 22, 24, 17, -2, -24 },
  { 2611, 17, 24, 17, 3, -24 },
  { 2662, 19, 24, 18, 0, -24 },
  { 2719, 12, 29, 10, 0, -24 },
  { 2763, 6, 24, 12, 4, -24 },
  { 2781, 12, 29, 10, -2, -24 },
  { 2825, 17, 15, 19, 1, -24 },
  { 2857, 14, 2, 13, -3, 3 },
  { 2861, 5, 5, 9, 5, -25 },
  { 2865, 16, 18, 19, 2, -18 },
  { 2901, 16, 25, 19, 1, -25 },
  { 2951, 13, 18, 15, 2, -18 },
  { 2981, 18, 25, 19, 2, -25 },
  { 3038, 13, 18, 16, 2, -18 },
  { 3068, 19, 33, 11, -4, -25 },
  { 3147, 17, 26, 19, 1, -18 },
  { 3203, 16, 25, 19, 1, -25 },
  { 3253, 8, 24, 9, 1, -24 },
  { 3277, 13, 32, 9, -4, -24 },
  { 3329, 16, 25, 16, 1, -25 },
  { 3379, 8, 25, 9, 1, -25 },
  { 3404, 26, 18, 29, 1, -18 },
  { 3463, 16, 18, 19, 1, -18 },
  { 3499, 15, 18, 19, 2, -18 },
  { 3533, 18, 26, 19, -1, -18 },
  { 3592, 16, 26, 19, 2, -18 },
  { 3644, 13, 18, 13, 1, -18 },
  { 3674, 14, 18, 14, 0, -18 },
  { 3706, 11, 22, 11, 1, -22 },
  { 3737, 16, 18, 19, 2, -18 },
  { 3773, 15, 18, 15, 2, -18 },
  { 3807, 23, 18, 24, 2, -18 },
  { 3859, 18, 18, 16, -1, -18 },
  { 3900, 20, 26, 15, -3, -18 },
  { 3965, 15, 18, 15, -1, -18 },
  { 3999, 13, 29, 12, 0, -24 },
  { 4047, 2, 33, 18, 9, -25 },
  { 4056, 12, 29, 12, -1, -24 },
  { 4100, 16, 5, 19, 2, -14 },
};

const GFXfont NotoSans_Italic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_ITALIC33PT7B_H_
