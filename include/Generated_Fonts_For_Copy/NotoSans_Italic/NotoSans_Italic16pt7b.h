#ifndef _NOTOSANS_ITALIC16PT7B_H_
#define _NOTOSANS_ITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x32, 0x22, 0x64, 0x04, 0xC0, 0xDC, 0xA5, 0x40, 0x04, 0x82,
  0x20, 0x99, 0xFF, 0x19, 0x04, 0x41, 0x27, 0xFE, 0x22, 0x09, 0x82, 0x40,
  0x08, 0x3D, 0xAA, 0x45, 0x8E, 0x07, 0x0A, 0x15, 0x4B, 0xE1, 0x02, 0x00,
  0x10, 0x2F, 0x09, 0x22, 0x64, 0x88, 0xB1, 0x35, 0xFD, 0x49, 0x49, 0x1A,
  0x22, 0x44, 0x89, 0x20, 0xE0, 0x0C, 0x1F, 0x08, 0x84, 0x42, 0x61, 0xC1,
  0xE1, 0x93, 0x85, 0x43, 0x23, 0xDF, 0x30, 0xEA, 0x19, 0x18, 0x8C, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x20, 0x10, 0xC2, 0x10, 0x84, 0x63, 0x11, 0x88,
  0xC4, 0x40, 0x19, 0x23, 0x41, 0xF7, 0x1B, 0x12, 0x00, 0x10, 0x10, 0x10,
  0x10, 0xFF, 0x10, 0x10, 0x10, 0x36, 0x4C, 0xF0, 0x70, 0x03, 0x02, 0x04,
  0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x0C, 0x3E, 0x62, 0x43,
  0xC3, 0xC2, 0x82, 0x82, 0x86, 0x84, 0xCC, 0x78, 0x3F, 0xD4, 0x21, 0x18,
  0xC4, 0x21, 0x18, 0x04, 0x3F, 0x21, 0x01, 0x01, 0x03, 0x06, 0x0C, 0x18,
  0x20, 0x40, 0xFE, 0x0C, 0x3F, 0x21, 0x01, 0x03, 0x0E, 0x1C, 0x02, 0x03,
  0x02, 0x86, 0xFC, 0x03, 0x03, 0x83, 0xC3, 0x61, 0x21, 0x11, 0x09, 0xFF,
  0x06, 0x02, 0x01, 0x00, 0x3F, 0x20, 0x60, 0x40, 0x7C, 0x04, 0x06, 0x06,
  0x06, 0x8C, 0xF8, 0x06, 0x1F, 0x30, 0x60, 0x40, 0xFC, 0xC6, 0xC2, 0x82,
  0x86, 0xC4, 0x78, 0x7F, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20,
  0x60, 0xC0, 0x0C, 0x3E, 0x23, 0x63, 0x22, 0x3C, 0x7C, 0xC6, 0x86, 0x86,
  0xC4, 0x78, 0x08, 0x7D, 0x0A, 0x1C, 0x38, 0x5B, 0x9B, 0x04, 0x08, 0x67,
  0x80, 0x23, 0x00, 0x00, 0x04, 0xC0, 0x10, 0xC0, 0x00, 0x00, 0x04, 0x62,
  0x30, 0x01, 0x07, 0x1C, 0x60, 0xC0, 0x30, 0x0E, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x1C, 0x70, 0xC0, 0x11, 0xF0,
  0x41, 0x0C, 0x63, 0x18, 0x40, 0x04, 0x30, 0x0F, 0xC3, 0x02, 0x60, 0x14,
  0xF9, 0x89, 0x99, 0x11, 0x91, 0x19, 0x32, 0x9F, 0xEC, 0x00, 0x40, 0x03,
  0xF8, 0x03, 0x03, 0x81, 0x41, 0xA0, 0x90, 0xCC, 0x7E, 0x43, 0x61, 0xA0,
  0x70, 0x20, 0x3F, 0x21, 0x61, 0x61, 0x7E, 0x7E, 0x43, 0xC3, 0xC3, 0x86,
  0xFC, 0x06, 0x0F, 0xCC, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x87, 0xC0, 0x3F, 0x10, 0xD8, 0x6C, 0x14, 0x0A, 0x05, 0x07, 0x82,
  0xC3, 0x47, 0x3E, 0x00, 0x3F, 0x20, 0x60, 0x60, 0x7E, 0x7C, 0x40, 0xC0,
  0xC0, 0x80, 0xFC, 0x3F, 0x20, 0x60, 0x60, 0x40, 0x7C, 0x40, 0xC0, 0xC0,
  0x80, 0x80, 0x07, 0x07, 0xF3, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x7B, 0x06,
  0xC1, 0x30, 0x46, 0x10, 0xFC, 0x30, 0xC8, 0x36, 0x09, 0x82, 0x7F, 0x9F,
  0xE4, 0x13, 0x04, 0xC1, 0x20, 0xC8, 0x30, 0x3C, 0x41, 0x04, 0x30, 0xC2,
  0x08, 0x61, 0x8F, 0x00, 0x03, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0xF0, 0x31, 0x91, 0x99, 0x8D, 0x85, 0x83,
  0xC1, 0x21, 0x98, 0xC4, 0x43, 0x21, 0x80, 0x30, 0x86, 0x18, 0x41, 0x04,
  0x30, 0xC2, 0x0F, 0xC0, 0x30, 0x39, 0x83, 0x9C, 0x14, 0xF1, 0x65, 0x8A,
  0x24, 0x91, 0x24, 0x99, 0x4C, 0xCE, 0x64, 0x62, 0x23, 0x10, 0x30, 0x4C,
  0x17, 0x8D, 0xA3, 0x48, 0x93, 0x24, 0x4B, 0x1E, 0xC3, 0x20, 0xC8, 0x30,
  0x06, 0x07, 0xE3, 0x0D, 0x83, 0x40, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xB0,
  0x66, 0x30, 0xF8, 0x3E, 0x23, 0x61, 0x63, 0x43, 0x7E, 0x70, 0xC0, 0xC0,
  0x80, 0x80, 0x06, 0x07, 0xE3, 0x0D, 0x83, 0x40, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xB0, 0x66, 0x30, 0xF8, 0x06, 0x00, 0x80, 0x30, 0x3E, 0x23, 0x61,
  0x63, 0x43, 0x7C, 0x48, 0xCC, 0xC4, 0x86, 0x86, 0x06, 0x1F, 0x30, 0x20,
  0x20, 0x38, 0x0C, 0x06, 0x02, 0x02, 0x86, 0xFC, 0xFF, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x20, 0xC8, 0x36, 0x09, 0x82,
  0x40, 0x90, 0x6C, 0x1B, 0x04, 0xC3, 0x10, 0x87, 0xC0, 0xC1, 0xA0, 0x90,
  0xC8, 0x44, 0x62, 0x21, 0xB0, 0xD0, 0x78, 0x18, 0x08, 0x00, 0x86, 0x1C,
  0x30, 0xA3, 0x8D, 0x14, 0x49, 0xA6, 0x49, 0x22, 0xC9, 0x14, 0x50, 0xA3,
  0x86, 0x1C, 0x30, 0xC0, 0x18, 0xE1, 0x10, 0x24, 0x07, 0x80, 0x60, 0x1C,
  0x02, 0x80, 0x90, 0x33, 0x0C, 0x23, 0x06, 0x00, 0xC3, 0xA1, 0x19, 0x8D,
  0x82, 0x81, 0xC0, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x00, 0x3F, 0x80, 0x80,
  0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x3F, 0x80, 0x1C, 0xC3,
  0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0xE3, 0x80, 0x92, 0x6C, 0x92,
  0x49, 0x80, 0x1C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0xC3, 0x08, 0xE3,
  0x80, 0x10, 0x10, 0x28, 0x28, 0x44, 0x44, 0x82, 0x83, 0xFF, 0xF0, 0xCC,
  0x19, 0x77, 0x42, 0xC2, 0x82, 0x86, 0x86, 0xCC, 0xF4, 0x10, 0x10, 0x30,
  0x36, 0x2B, 0x31, 0x21, 0x61, 0x61, 0x63, 0x66, 0xDC, 0x1D, 0xD4, 0x30,
  0x82, 0x08, 0x31, 0x78, 0x01, 0x80, 0x80, 0x43, 0x67, 0x72, 0x13, 0x09,
  0x04, 0x86, 0x42, 0x33, 0x1E, 0x80, 0x18, 0xF9, 0x1E, 0x2F, 0x90, 0x20,
  0x62, 0x78, 0x03, 0x82, 0x01, 0x01, 0xE1, 0xF0, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x01, 0x82, 0x81, 0xC0, 0x0C, 0x9D, 0xC8, 0x4C,
  0x24, 0x12, 0x19, 0x0C, 0xCC, 0x7A, 0x03, 0x01, 0x99, 0x87, 0x80, 0x10,
  0x10, 0x30, 0x36, 0x2B, 0x31, 0x21, 0x61, 0x63, 0x43, 0x42, 0xC2, 0x11,
  0x03, 0x22, 0x26, 0x64, 0x4C, 0x04, 0x10, 0x03, 0x08, 0x20, 0x86, 0x18,
  0x41, 0x04, 0x30, 0xCE, 0x30, 0x10, 0x10, 0x30, 0x31, 0x22, 0x24, 0x28,
  0x78, 0x68, 0x4C, 0x44, 0xC6, 0x11, 0x33, 0x22, 0x26, 0x64, 0x4C, 0x26,
  0x31, 0x5A, 0xCC, 0x62, 0x42, 0x16, 0x31, 0xB1, 0x8D, 0x08, 0x48, 0x42,
  0xC6, 0x30, 0x26, 0x2F, 0x31, 0x21, 0x61, 0x63, 0x43, 0x42, 0xC2, 0x18,
  0xFD, 0x0E, 0x18, 0x30, 0x61, 0xE6, 0x78, 0x26, 0x2B, 0x31, 0x21, 0x61,
  0x61, 0x63, 0x66, 0x5C, 0xC0, 0xC0, 0x80, 0x80, 0x19, 0x77, 0x42, 0xC2,
  0x82, 0x86, 0x86, 0xCC, 0xF4, 0x0C, 0x0C, 0x08, 0x08, 0x26, 0x5C, 0xC1,
  0x06, 0x0C, 0x10, 0x20, 0xC0, 0x1E, 0xE9, 0x83, 0x03, 0x81, 0x83, 0x46,
  0xF8, 0x21, 0x1F, 0xF4, 0x23, 0x18, 0x84, 0x38, 0x63, 0x43, 0x42, 0x42,
  0xC2, 0xC6, 0x86, 0x8C, 0xF4, 0x83, 0x0E, 0x14, 0x6C, 0x9A, 0x34, 0x30,
  0x60, 0x84, 0x31, 0x8E, 0x31, 0x4A, 0x69, 0x49, 0x6F, 0x29, 0xC5, 0x38,
  0xC6, 0x00, 0x31, 0x88, 0x86, 0x81, 0xC0, 0xC0, 0xE0, 0x50, 0x4C, 0xC3,
  0x00, 0x10, 0x44, 0x31, 0x08, 0x66, 0x19, 0x02, 0x80, 0xA0, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0xE0, 0x00, 0x3E, 0x0C, 0x30, 0x41, 0x06, 0x18,
  0x60, 0xFC, 0x0C, 0x61, 0x04, 0x10, 0xCC, 0x08, 0x20, 0x86, 0x10, 0x70,
  0x40, 0xFF, 0xFF, 0x18, 0x18, 0x20, 0x40, 0x81, 0x01, 0x8C, 0x10, 0x20,
  0xC1, 0x0E, 0x10, 0x00, 0x61, 0xFF,
};

const GFXglyph NotoSans_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 5, 4, 6, 2, -11 },
  { 10, 10, 11, 10, 0, -11 },
  { 24, 7, 13, 9, 1, -12 },
  { 36, 11, 12, 13, 1, -12 },
  { 53, 9, 12, 11, 1, -12 },
  { 67, 2, 4, 4, 2, -11 },
  { 68, 5, 14, 5, 1, -11 },
  { 77, 5, 14, 5, -1, -11 },
  { 86, 7, 7, 9, 2, -12 },
  { 93, 8, 8, 9, 1, -10 },
  { 101, 4, 4, 4, -1, -2 },
  { 103, 4, 1, 5, 0, -5 },
  { 104, 2, 2, 4, 0, -2 },
  { 105, 8, 11, 6, -1, -11 },
  { 116, 8, 12, 9, 1, -12 },
  { 128, 5, 11, 9, 2, -11 },
  { 135, 8, 12, 9, 0, -12 },
  { 147, 8, 12, 9, 0, -12 },
  { 159, 9, 11, 9, 0, -11 },
  { 172, 8, 11, 9, 1, -11 },
  { 183, 8, 12, 9, 1, -12 },
  { 195, 8, 11, 9, 1, -11 },
  { 206, 8, 12, 9, 1, -12 },
  { 218, 7, 12, 9, 1, -12 },
  { 229, 4, 9, 4, 0, -9 },
  { 234, 5, 11, 4, -1, -9 },
  { 241, 8, 8, 9, 1, -10 },
  { 249, 8, 5, 9, 1, -8 },
  { 254, 8, 8, 9, 1, -10 },
  { 262, 6, 12, 7, 1, -12 },
  { 271, 12, 12, 14, 1, -11 },
  { 289, 9, 11, 9, -1, -11 },
  { 302, 8, 11, 10, 1, -11 },
  { 313, 9, 12, 9, 1, -12 },
  { 327, 9, 11, 11, 1, -11 },
  { 340, 8, 11, 8, 1, -11 },
  { 351, 8, 11, 8, 1, -11 },
  { 362, 10, 12, 11, 1, -12 },
  { 377, 10, 11, 11, 1, -11 },
  { 391, 6, 11, 5, 0, -11 },
  { 400, 8, 14, 4, -3, -11 },
  { 414, 9, 11, 9, 1, -11 },
  { 427, 6, 11, 8, 1, -11 },
  { 436, 13, 11, 13, 1, -11 },
  { 454, 10, 11, 11, 1, -11 },
  { 468, 10, 12, 12, 1, -12 },
  { 483, 8, 11, 9, 1, -11 },
  { 494, 10, 15, 12, 1, -12 },
  { 513, 8, 11, 9, 1, -11 },
  { 524, 8, 12, 8, 0, -12 },
  { 536, 8, 11, 8, 1, -11 },
  { 547, 10, 11, 11, 1, -11 },
  { 561, 9, 11, 9, 1, -11 },
  { 574, 13, 11, 14, 2, -11 },
  { 592, 11, 11, 8, -1, -11 },
  { 608, 9, 11, 8, 1, -11 },
  { 621, 9, 11, 9, 0, -11 },
  { 634, 6, 14, 5, 0, -11 },
  { 645, 3, 11, 6, 2, -11 },
  { 650, 6, 14, 5, -1, -11 },
  { 661, 8, 8, 9, 1, -12 },
  { 669, 6, 2, 6, -1, 1 },
  { 671, 3, 2, 4, 2, -12 },
  { 672, 8, 9, 9, 1, -9 },
  { 681, 8, 12, 9, 0, -12 },
  { 693, 6, 9, 7, 1, -9 },
  { 700, 9, 12, 9, 1, -12 },
  { 714, 7, 9, 8, 1, -9 },
  { 722, 9, 16, 5, -2, -12 },
  { 740, 9, 13, 9, 0, -9 },
  { 755, 8, 12, 9, 0, -12 },
  { 767, 4, 12, 4, 0, -12 },
  { 773, 6, 16, 4, -2, -12 },
  { 785, 8, 12, 8, 0, -12 },
  { 797, 4, 12, 4, 0, -12 },
  { 803, 13, 9, 14, 0, -9 },
  { 818, 8, 9, 9, 0, -9 },
  { 827, 7, 9, 9, 1, -9 },
  { 835, 8, 13, 9, 0, -9 },
  { 848, 8, 13, 9, 1, -9 },
  { 861, 7, 9, 6, 0, -9 },
  { 869, 7, 9, 7, 0, -9 },
  { 877, 5, 11, 5, 1, -11 },
  { 884, 8, 9, 9, 1, -9 },
  { 893, 7, 9, 7, 1, -9 },
  { 901, 11, 9, 12, 1, -9 },
  { 914, 9, 9, 8, -1, -9 },
  { 925, 10, 13, 7, -2, -9 },
  { 942, 7, 9, 7, 0, -9 },
  { 950, 6, 14, 6, 0, -11 },
  { 961, 1, 16, 9, 4, -12 },
  { 963, 7, 14, 6, -1, -11 },
  { 976, 8, 2, 9, 1, -7 },
};

const GFXfont NotoSans_Italic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_ITALIC16PT7B_H_
