#ifndef _NOTOSANS_ITALIC39PT7B_H_
#define _NOTOSANS_ITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0,
  0x40, 0x00, 0x38, 0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71,
  0xC6, 0x1C, 0xE1, 0xCE, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0C, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC0, 0x18, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E,
  0x00, 0x06, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x70, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x78, 0xC2, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x18, 0x00, 0xE3, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x38, 0x01,
  0x87, 0x00, 0x31, 0xE0, 0x0E, 0x3C, 0xE1, 0xCF, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x03, 0x87, 0xF8, 0x01, 0xC1, 0xCF, 0x00, 0xE0, 0xE1,
  0xC0, 0x38, 0x70, 0x70, 0x1C, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x07, 0x01,
  0x81, 0xC1, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0x1C, 0x70, 0x0E, 0x0E, 0x38,
  0x03, 0x83, 0x8E, 0x7C, 0xE0, 0xE7, 0x3F, 0xB8, 0x73, 0x9E, 0xF7, 0x39,
  0xCF, 0x1D, 0xFE, 0x73, 0x83, 0x3E, 0x39, 0xC0, 0xC0, 0x1C, 0x70, 0x30,
  0x0F, 0x1C, 0x1C, 0x03, 0x87, 0x07, 0x01, 0xC1, 0x81, 0xC0, 0xE0, 0xE0,
  0x70, 0x78, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x0E, 0x01, 0xC7, 0x07, 0x00,
  0x73, 0xC1, 0xC0, 0x1F, 0xE1, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03,
  0xC7, 0xC0, 0x01, 0xCF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x38, 0x0F, 0x3C, 0x3C, 0x0E, 0x78,
  0x1E, 0x1E, 0x70, 0x0F, 0x1C, 0xF0, 0x0F, 0x3C, 0xF0, 0x07, 0xF8, 0xF0,
  0x03, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0x78, 0x0F, 0xF0, 0x7F,
  0xFF, 0x78, 0x3F, 0xFC, 0x78, 0x1F, 0xF0, 0x3E, 0x3B, 0xDE, 0xE7, 0x39,
  0xCC, 0xE7, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x40,
  0xE0, 0x1C, 0x38, 0x0F, 0xCE, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3E, 0x3C, 0x1D, 0x80, 0x0E, 0x70, 0x07, 0x1C, 0x07, 0xC7, 0x00,
  0xE0, 0xE0, 0x10, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x37, 0xFF, 0xFF, 0x30, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xC1,
  0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03,
  0xDC, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0E,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0,
  0x78, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xE0,
  0x7C, 0x1F, 0x8F, 0xF7, 0xFD, 0xFB, 0xBC, 0x72, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0x01, 0xE0,
  0x30, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x83, 0x80,
  0xF0, 0x40, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0xC0, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x7B, 0x80, 0x07, 0x9C, 0x00, 0x79, 0xE0, 0x03, 0x8F,
  0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x03, 0xC1, 0xE0, 0x3C,
  0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x3C, 0x1C, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0xC0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x40,
  0x1C, 0xFF, 0x07, 0xBF, 0xF0, 0xFE, 0x3F, 0x1F, 0x01, 0xE3, 0xC0, 0x1C,
  0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x38,
  0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x1E, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xC0, 0xF0, 0xF0, 0x1E,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xE0, 0x78,
  0x1E, 0x1E, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x00,
  0xF8, 0xF0, 0x3C, 0x0F, 0x0F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCE,
  0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x80, 0x38, 0xF8, 0x0F, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x78, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x1D, 0xE0, 0x0F, 0x38, 0x03,
  0xCF, 0x01, 0xF3, 0xE1, 0xFC, 0x7F, 0xEE, 0x0F, 0xF3, 0x80, 0xE1, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0x1F,
  0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0xF8, 0xF8, 0xF8, 0xF0, 0x60, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xF1, 0x81, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x04, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E,
  0x1C, 0x03, 0xFA, 0x1C, 0xE0, 0x3F, 0xF0, 0x73, 0x83, 0xE1, 0xC1, 0xDC,
  0x0E, 0x07, 0x07, 0x70, 0x70, 0x1C, 0x1D, 0xC3, 0x80, 0xE0, 0x7E, 0x0E,
  0x03, 0x81, 0xF8, 0x38, 0x0E, 0x07, 0xE1, 0xC0, 0x78, 0x1B, 0x87, 0x01,
  0xC0, 0xEE, 0x1C, 0x07, 0x03, 0xB8, 0x70, 0x3C, 0x1C, 0xE0, 0xE1, 0xB0,
  0xF3, 0x83, 0xFE, 0xFF, 0x87, 0x07, 0xF3, 0xFC, 0x1C, 0x0F, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x01, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x01,
  0xEE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x87,
  0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x00,
  0x70, 0x1C, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xC0,
  0x0E, 0x0F, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0E,
  0x38, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0E, 0x03, 0xE0, 0x70, 0x0F,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0xF0,
  0x03, 0x87, 0x80, 0x3C, 0x3C, 0x07, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x8E,
  0x00, 0x78, 0xF0, 0x0F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xF8, 0x06,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x38, 0x1F, 0xC0, 0x70, 0x0F, 0x81, 0xE0, 0x0F, 0x83,
  0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0xCF, 0x00,
  0x07, 0x9E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x78, 0xE0, 0x00,
  0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8E, 0x00, 0x3E, 0x1C, 0x00, 0xF8,
  0x38, 0x03, 0xE0, 0xF0, 0x3F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x00, 0xE0, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x01, 0xFF, 0x3C, 0x03, 0xFE, 0x78, 0x07, 0xFC, 0xF0, 0x00, 0x79,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x3E, 0x00, 0xE0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E,
  0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x70, 0x3C, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x38, 0x07, 0x80, 0x70,
  0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x0E, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xDE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xE0, 0x0E,
  0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x07, 0x01, 0xE0,
  0x0F, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x1D, 0xC1, 0xDC, 0x00, 0x3F, 0x83, 0xB8, 0x00, 0xEF,
  0x07, 0x70, 0x01, 0xDC, 0x0E, 0xE0, 0x07, 0x38, 0x3D, 0xC0, 0x1E, 0x70,
  0x79, 0xC0, 0x39, 0xE0, 0xE3, 0x80, 0xF3, 0xC1, 0xC7, 0x01, 0xC7, 0x03,
  0x8E, 0x07, 0x0E, 0x0F, 0x1C, 0x0E, 0x3C, 0x1E, 0x38, 0x38, 0x78, 0x38,
  0x70, 0x70, 0xF0, 0x70, 0xE1, 0xC1, 0xC0, 0xE0, 0xE3, 0x83, 0x83, 0xC1,
  0xCE, 0x0F, 0x07, 0x03, 0xBC, 0x1E, 0x0E, 0x07, 0x70, 0x38, 0x1C, 0x0F,
  0xE0, 0x70, 0x38, 0x1F, 0x80, 0xE0, 0xF0, 0x3E, 0x03, 0xC1, 0xC0, 0x7C,
  0x07, 0x83, 0x80, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80,
  0x03, 0xC1, 0xF0, 0x00, 0xE0, 0x7C, 0x00, 0x38, 0x1F, 0x00, 0x0E, 0x07,
  0xE0, 0x03, 0x83, 0xB8, 0x01, 0xE0, 0xEF, 0x00, 0x70, 0x39, 0xC0, 0x1C,
  0x0E, 0x70, 0x07, 0x07, 0x9E, 0x03, 0xC1, 0xE3, 0x80, 0xF0, 0x70, 0xE0,
  0x38, 0x1C, 0x3C, 0x0E, 0x07, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE0, 0xF0,
  0x38, 0x78, 0x38, 0x0E, 0x1C, 0x0E, 0x03, 0xC7, 0x03, 0x80, 0x71, 0xC1,
  0xE0, 0x1C, 0xF0, 0x70, 0x07, 0xB8, 0x1C, 0x00, 0xEE, 0x07, 0x00, 0x3B,
  0x81, 0xC0, 0x0F, 0xE0, 0xF0, 0x01, 0xF8, 0x38, 0x00, 0x7C, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x70, 0x3E, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xE0,
  0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1C,
  0x03, 0xE1, 0xC0, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xF8, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0x78, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x70, 0x3E, 0x07, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1C, 0x03, 0xE1, 0xC7, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0x83, 0xC0, 0x38, 0x1C, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0xF0,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x3C, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xC0, 0x60, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0xC0, 0x3E, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E,
  0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38,
  0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78,
  0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE, 0x00,
  0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x83,
  0x80, 0x78, 0x1C, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x1E,
  0x01, 0xC0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x0E,
  0x38, 0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0xF8, 0x01, 0xE0, 0x07, 0xBC, 0x00,
  0xF0, 0x03, 0xDE, 0x00, 0xF8, 0x01, 0xCF, 0x00, 0x7C, 0x01, 0xE7, 0x80,
  0x76, 0x00, 0xE3, 0xC0, 0x3B, 0x80, 0xF1, 0xE0, 0x39, 0xC0, 0x70, 0x70,
  0x1C, 0xE0, 0x78, 0x38, 0x1C, 0x70, 0x3C, 0x1C, 0x0E, 0x38, 0x1C, 0x0E,
  0x0F, 0x1C, 0x1E, 0x07, 0x07, 0x0E, 0x0E, 0x03, 0x87, 0x87, 0x0F, 0x01,
  0xC3, 0x83, 0x87, 0x00, 0xE3, 0xC1, 0xC7, 0x80, 0x71, 0xC0, 0xE3, 0x80,
  0x38, 0xE0, 0x71, 0xC0, 0x1C, 0xE0, 0x39, 0xC0, 0x0E, 0x70, 0x1C, 0xE0,
  0x07, 0x70, 0x0E, 0xF0, 0x03, 0xB8, 0x07, 0x70, 0x01, 0xD8, 0x03, 0xB8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x00,
  0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC3, 0xC0,
  0x00, 0x39, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0x78, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xE0,
  0x38, 0x3C, 0x07, 0x0F, 0x00, 0xF1, 0xC0, 0x0E, 0x78, 0x01, 0xDE, 0x00,
  0x3B, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x43, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x00, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xB8, 0x00, 0x39,
  0xC0, 0x03, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x70, 0x0E,
  0x07, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x01, 0xC7,
  0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xC7, 0x0E, 0x38, 0x70, 0x01, 0xF8, 0x60, 0xFF, 0x9C, 0x3F, 0xFB, 0x8F,
  0x83, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x70,
  0x03, 0xDE, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x03, 0xCE, 0x00, 0x79, 0xC0,
  0x0F, 0x38, 0x03, 0xC7, 0x00, 0xF8, 0xF0, 0x1F, 0x1E, 0x0E, 0xE1, 0xF7,
  0x9C, 0x3F, 0xE7, 0x03, 0xF8, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF1, 0xF8, 0x0F, 0x7F, 0xC0, 0xEF, 0xFE,
  0x0F, 0xC1, 0xE0, 0xF8, 0x0E, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80,
  0x1E, 0x38, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0xC0, 0x78, 0x7C,
  0x0F, 0x87, 0x7B, 0xF0, 0xE7, 0xFE, 0x0E, 0x3F, 0x80, 0x01, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x08, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0xC7, 0x01, 0xFF, 0x38, 0x1F, 0xFD, 0xC1, 0xF0,
  0x7E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3,
  0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x70, 0x03,
  0xC3, 0x80, 0x1E, 0x1C, 0x01, 0xE0, 0xE0, 0x1F, 0x07, 0x80, 0xF8, 0x3C,
  0x1D, 0xC0, 0xFB, 0xDE, 0x07, 0xFC, 0xE0, 0x1F, 0xC7, 0x00, 0x01, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x78, 0x0F,
  0x78, 0x0F, 0x70, 0x3E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x0C, 0x7F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1E, 0x10, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x30, 0x3F, 0xE7, 0x07, 0xFF, 0x70, 0xF8, 0x3F, 0x1F, 0x01, 0xF1,
  0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1C,
  0x78, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x07,
  0x87, 0x00, 0xF8, 0x78, 0x0F, 0x87, 0x83, 0xB8, 0x3E, 0xF7, 0x83, 0xFE,
  0x70, 0x1F, 0xC7, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x80, 0x3C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE3, 0xF0, 0x3D, 0xFF, 0x07, 0x7F, 0xF0, 0xFC, 0x1E, 0x1F, 0x01, 0xC7,
  0xC0, 0x38, 0xF0, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x0E, 0x00, 0x01, 0x00, 0xE0, 0x7C, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0xF0, 0x1C, 0x3C,
  0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1C, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0F, 0x0F, 0x00, 0xE1,
  0xE0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x0E, 0x1F, 0x81, 0xF8, 0x1C, 0xFF, 0x8F,
  0xF8, 0x3B, 0xFF, 0x3F, 0xF8, 0x7E, 0x0E, 0xE0, 0xF0, 0xF8, 0x1F, 0x81,
  0xE3, 0xE0, 0x3E, 0x03, 0xC7, 0x80, 0x7C, 0x07, 0x8F, 0x00, 0xF0, 0x0F,
  0x1C, 0x01, 0xE0, 0x1C, 0x38, 0x03, 0x80, 0x38, 0xF0, 0x0F, 0x00, 0x71,
  0xE0, 0x1E, 0x01, 0xE3, 0x80, 0x38, 0x03, 0xC7, 0x00, 0x70, 0x07, 0x1E,
  0x00, 0xE0, 0x0E, 0x3C, 0x03, 0xC0, 0x1C, 0x70, 0x07, 0x80, 0x78, 0xE0,
  0x0E, 0x00, 0xF1, 0xC0, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0x03, 0x8F, 0x00,
  0xF0, 0x0F, 0x00, 0x0E, 0x1F, 0x80, 0xE7, 0xFE, 0x0E, 0xFF, 0xE0, 0xFE,
  0x1E, 0x1F, 0x80, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xE1, 0xE0, 0x0E, 0x1E,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x38, 0x03, 0xC3,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7C, 0x1E, 0x3C, 0x03, 0xCE, 0x00, 0xF7, 0x80, 0x1D,
  0xC0, 0x07, 0x70, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x7B, 0xC0, 0x1C, 0xF0, 0x0F, 0x1E, 0x07,
  0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0x87, 0xE0, 0x0E,
  0x7F, 0xC0, 0x3B, 0xFF, 0x80, 0xFC, 0x1E, 0x03, 0xE0, 0x38, 0x1F, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0,
  0xF0, 0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xDE, 0xFC,
  0x0F, 0x7F, 0xE0, 0x3C, 0xFE, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x60, 0xFF, 0x9C,
  0x3F, 0xFB, 0x8F, 0x83, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x1E, 0x70, 0x03, 0xDE, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x03, 0xCE,
  0x00, 0x79, 0xC0, 0x0F, 0x38, 0x03, 0xC7, 0x00, 0xF8, 0xF0, 0x1F, 0x1E,
  0x0E, 0xE1, 0xF7, 0xBC, 0x3F, 0xE7, 0x03, 0xF8, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x1F, 0x0E, 0x7E, 0x0E,
  0xFE, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x1E, 0x02, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x80,
  0x3C, 0xFB, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x03, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x90, 0x7F, 0x03, 0xF0, 0x1E, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x0E,
  0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF8,
  0xF0, 0x1F, 0x1E, 0x0E, 0xE1, 0xF7, 0xBC, 0x3F, 0xE7, 0x03, 0xF8, 0xE0,
  0xE0, 0x03, 0xF8, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C,
  0x03, 0x87, 0x01, 0xE1, 0xC0, 0xF0, 0x70, 0x3C, 0x1C, 0x1E, 0x07, 0x07,
  0x01, 0xC3, 0xC0, 0x78, 0xE0, 0x1E, 0x78, 0x03, 0x9C, 0x00, 0xEF, 0x00,
  0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x01, 0xEF, 0x03,
  0xF0, 0x1C, 0xF0, 0x3F, 0x03, 0xCF, 0x07, 0x70, 0x38, 0xF0, 0x77, 0x07,
  0x87, 0x0E, 0x70, 0x70, 0x70, 0xE7, 0x0F, 0x07, 0x0E, 0x70, 0xE0, 0x71,
  0xC7, 0x1E, 0x07, 0x1C, 0x71, 0xC0, 0x73, 0x87, 0x1C, 0x07, 0x38, 0x73,
  0x80, 0x77, 0x03, 0x38, 0x07, 0x70, 0x37, 0x80, 0x7E, 0x03, 0x70, 0x07,
  0xE0, 0x37, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x78, 0x38, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x07,
  0x80, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x07, 0x38, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xDE, 0x00, 0x1E, 0x70, 0x01, 0xE3, 0xC0, 0x1E, 0x0E, 0x01, 0xE0,
  0x70, 0x0F, 0x03, 0xC0, 0xF0, 0x0E, 0x0F, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x0F, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x3C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0xF0, 0x01, 0xC0,
  0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0xE3,
  0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xDF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xE1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xBE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x1F,
  0xC0, 0xF8, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFE,
  0x80, 0x1E, 0x00,
};

const GFXglyph NotoSans_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 29, 10, 1, -28 },
  { 38, 12, 10, 15, 4, -28 },
  { 53, 25, 28, 25, 1, -28 },
  { 141, 19, 32, 21, 1, -30 },
  { 217, 26, 28, 31, 3, -28 },
  { 308, 24, 28, 26, 1, -28 },
  { 392, 5, 10, 9, 4, -28 },
  { 399, 12, 34, 11, 2, -28 },
  { 450, 13, 34, 11, -3, -28 },
  { 506, 18, 18, 21, 4, -30 },
  { 547, 18, 19, 22, 3, -23 },
  { 590, 8, 10, 10, -2, -5 },
  { 600, 10, 3, 12, 1, -12 },
  { 604, 5, 6, 10, 1, -5 },
  { 608, 19, 28, 14, -2, -28 },
  { 675, 19, 28, 21, 2, -28 },
  { 742, 11, 28, 21, 6, -28 },
  { 781, 21, 28, 21, 0, -28 },
  { 855, 19, 28, 21, 1, -28 },
  { 922, 21, 28, 21, 0, -28 },
  { 996, 20, 28, 21, 1, -28 },
  { 1066, 19, 28, 21, 2, -28 },
  { 1133, 19, 28, 21, 3, -28 },
  { 1200, 19, 28, 21, 2, -28 },
  { 1267, 18, 28, 21, 2, -28 },
  { 1330, 8, 22, 10, 1, -21 },
  { 1352, 11, 26, 10, -2, -21 },
  { 1388, 18, 19, 22, 3, -24 },
  { 1431, 18, 11, 22, 3, -19 },
  { 1456, 18, 19, 22, 3, -24 },
  { 1499, 15, 29, 17, 3, -28 },
  { 1554, 30, 32, 33, 2, -28 },
  { 1674, 22, 28, 22, -2, -28 },
  { 1751, 21, 28, 23, 2, -28 },
  { 1825, 22, 28, 23, 3, -28 },
  { 1902, 23, 28, 26, 2, -28 },
  { 1983, 20, 28, 20, 2, -28 },
  { 2053, 20, 28, 19, 2, -28 },
  { 2123, 23, 28, 26, 3, -28 },
  { 2204, 25, 28, 27, 2, -28 },
  { 2292, 16, 28, 13, -1, -28 },
  { 2348, 17, 35, 11, -6, -28 },
  { 2423, 23, 28, 22, 2, -28 },
  { 2504, 14, 28, 19, 2, -28 },
  { 2553, 31, 28, 33, 2, -28 },
  { 2662, 26, 28, 28, 2, -28 },
  { 2753, 24, 28, 28, 3, -28 },
  { 2837, 20, 28, 22, 2, -28 },
  { 2907, 24, 35, 28, 3, -28 },
  { 3012, 20, 28, 22, 2, -28 },
  { 3082, 19, 28, 20, 1, -28 },
  { 3149, 19, 28, 20, 4, -28 },
  { 3216, 24, 28, 26, 3, -28 },
  { 3300, 21, 28, 22, 4, -28 },
  { 3374, 33, 28, 33, 4, -28 },
  { 3490, 26, 28, 21, -2, -28 },
  { 3581, 19, 28, 20, 4, -28 },
  { 3648, 22, 28, 21, 0, -28 },
  { 3725, 14, 34, 11, 0, -28 },
  { 3785, 7, 28, 14, 4, -28 },
  { 3810, 15, 34, 11, -3, -28 },
  { 3874, 20, 18, 22, 1, -28 },
  { 3919, 16, 2, 15, -4, 4 },
  { 3923, 6, 6, 11, 6, -30 },
  { 3928, 19, 21, 22, 2, -21 },
  { 3978, 20, 30, 23, 1, -30 },
  { 4053, 16, 21, 18, 2, -21 },
  { 4095, 21, 30, 23, 2, -30 },
  { 4174, 16, 21, 19, 2, -21 },
  { 4216, 21, 39, 12, -4, -30 },
  { 4319, 20, 30, 23, 1, -21 },
  { 4394, 19, 30, 23, 1, -30 },
  { 4466, 10, 29, 10, 1, -29 },
  { 4503, 15, 38, 10, -5, -29 },
  { 4575, 19, 30, 19, 1, -30 },
  { 4647, 10, 30, 10, 1, -30 },
  { 4685, 31, 21, 34, 1, -21 },
  { 4767, 20, 21, 23, 1, -21 },
  { 4820, 18, 21, 22, 2, -21 },
  { 4868, 22, 30, 23, -1, -21 },
  { 4951, 19, 30, 23, 2, -21 },
  { 5023, 16, 21, 16, 1, -21 },
  { 5065, 16, 21, 17, 0, -21 },
  { 5107, 12, 26, 13, 2, -26 },
  { 5146, 19, 21, 23, 2, -21 },
  { 5196, 18, 21, 18, 2, -21 },
  { 5244, 28, 21, 28, 2, -21 },
  { 5318, 21, 21, 19, -1, -21 },
  { 5374, 24, 30, 18, -4, -21 },
  { 5464, 18, 21, 17, -1, -21 },
  { 5512, 16, 34, 14, 0, -28 },
  { 5580, 3, 39, 21, 10, -30 },
  { 5595, 14, 34, 14, -1, -28 },
  { 5655, 18, 5, 22, 3, -16 },
};

const GFXfont NotoSans_Italic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_ITALIC39PT7B_H_
