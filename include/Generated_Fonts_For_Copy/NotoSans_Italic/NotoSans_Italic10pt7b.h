#ifndef _NOTOSANS_ITALIC10PT7B_H_
#define _NOTOSANS_ITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x20, 0xB4, 0x14, 0x49, 0xF9, 0x4F, 0xCA, 0x14, 0x00,
  0x11, 0xD4, 0xA3, 0x16, 0xCC, 0x40, 0xE5, 0x52, 0xD6, 0xD3, 0x2A, 0xA3,
  0x00, 0x38, 0xA3, 0x98, 0x96, 0x27, 0x40, 0xC0, 0x34, 0x44, 0x88, 0x84,
  0x40, 0x24, 0x92, 0x4A, 0x80, 0x25, 0x1E, 0xC9, 0x00, 0x22, 0xF2, 0x20,
  0xE0, 0xE0, 0x80, 0x11, 0x24, 0x48, 0x80, 0x79, 0x99, 0x99, 0xE0, 0x3C,
  0x94, 0x90, 0x78, 0x42, 0x22, 0x23, 0xE0, 0x78, 0x42, 0x60, 0x87, 0xC0,
  0x08, 0xCA, 0x9F, 0x88, 0x40, 0x3A, 0x18, 0xB0, 0x87, 0xC0, 0x78, 0xAD,
  0x99, 0xE0, 0xF8, 0x88, 0x44, 0x22, 0x00, 0x3A, 0x4A, 0x64, 0xC5, 0xC0,
  0x3A, 0x52, 0xF0, 0x8B, 0xC0, 0x50, 0x20, 0x50, 0x68, 0x16, 0x86, 0x10,
  0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE1, 0x24, 0x80, 0x80, 0x3C, 0x86, 0xEE,
  0x5C, 0xB7, 0xA0, 0x3C, 0x08, 0x51, 0x49, 0x3D, 0x1C, 0x40, 0x3C, 0x94,
  0x5E, 0x49, 0x2F, 0x80, 0x7A, 0x21, 0x08, 0x41, 0xC0, 0x3C, 0x94, 0x51,
  0x45, 0x3F, 0x00, 0x3C, 0x84, 0x1E, 0x41, 0x0F, 0x00, 0x3C, 0x84, 0x1E,
  0x41, 0x08, 0x00, 0x7D, 0x08, 0x26, 0x8A, 0x27, 0x80, 0x22, 0x45, 0x13,
  0xE4, 0x48, 0xA2, 0x00, 0x72, 0x44, 0x44, 0xC0, 0x08, 0x44, 0x21, 0x08,
  0x84, 0xC0, 0x26, 0x51, 0x43, 0x85, 0x0A, 0x22, 0x00, 0x22, 0x44, 0x44,
  0xF0, 0x21, 0x63, 0x53, 0x55, 0x59, 0x5A, 0x92, 0x22, 0xA5, 0x4A, 0xA4,
  0xC9, 0xA3, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x27, 0x00, 0x38, 0x94, 0x5E,
  0x41, 0x08, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x27, 0x04, 0x18, 0x38, 0x94,
  0x5E, 0x51, 0x28, 0x80, 0x3A, 0x10, 0x61, 0x0B, 0xC0, 0xF9, 0x10, 0x84,
  0x21, 0x00, 0x46, 0x18, 0xA2, 0x8A, 0x2F, 0x00, 0x8C, 0x65, 0x2A, 0x51,
  0x00, 0x99, 0x99, 0xAA, 0xAA, 0xAC, 0xCC, 0xC8, 0x22, 0x28, 0x60, 0x82,
  0x85, 0x31, 0x00, 0x8C, 0x98, 0xC4, 0x23, 0x00, 0x7C, 0x21, 0x08, 0x41,
  0x0F, 0x80, 0x34, 0x44, 0x48, 0x88, 0xC0, 0xA9, 0x54, 0x31, 0x12, 0x22,
  0x22, 0xC0, 0x21, 0x93, 0x90, 0xF0, 0x90, 0x7D, 0x28, 0xA6, 0x68, 0x21,
  0x14, 0xD4, 0xA5, 0x36, 0x7A, 0x21, 0x07, 0x00, 0x04, 0x11, 0x5A, 0x4A,
  0x29, 0x9A, 0x7A, 0xD9, 0x07, 0x00, 0x08, 0x86, 0xC2, 0x10, 0x88, 0x46,
  0x00, 0x7D, 0x28, 0xA6, 0x68, 0x4F, 0x00, 0x21, 0x14, 0xD4, 0xA5, 0x31,
  0x21, 0x24, 0xA0, 0x10, 0x22, 0x22, 0x44, 0xC0, 0x21, 0x10, 0xB6, 0x31,
  0x52, 0x25, 0x24, 0x94, 0x7F, 0x49, 0x49, 0x49, 0x93, 0x7A, 0x52, 0x99,
  0x80, 0x7A, 0x63, 0x17, 0x00, 0x7A, 0x52, 0x9B, 0x42, 0x00, 0x7D, 0x28,
  0xA6, 0x68, 0x41, 0x00, 0x74, 0x44, 0x80, 0x74, 0x21, 0xE0, 0x27, 0xC4,
  0x44, 0x60, 0x9C, 0xA5, 0x6D, 0x00, 0xCA, 0x94, 0xC6, 0x00, 0xB7, 0x6B,
  0x66, 0xC9, 0x00, 0x59, 0x88, 0xC9, 0x00, 0x64, 0xA2, 0x8C, 0x30, 0x8C,
  0x00, 0x72, 0x44, 0xF0, 0x32, 0x24, 0xC4, 0x44, 0x40, 0xFF, 0xC0, 0x64,
  0x92, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 7, 7, 6, 0, -7 },
  { 12, 5, 9, 6, 0, -8 },
  { 18, 7, 7, 8, 1, -7 },
  { 25, 6, 7, 7, 0, -7 },
  { 31, 1, 2, 2, 1, -7 },
  { 32, 4, 9, 3, 0, -7 },
  { 37, 3, 9, 3, -1, -7 },
  { 41, 5, 5, 6, 1, -8 },
  { 45, 4, 5, 6, 1, -6 },
  { 48, 2, 2, 3, 0, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 1, 1, 3, 0, -1 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 6, 1, -7 },
  { 59, 3, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 0, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 5, 7, 6, 1, -7 },
  { 91, 5, 7, 6, 0, -7 },
  { 96, 5, 7, 6, 0, -7 },
  { 101, 2, 6, 3, 0, -6 },
  { 103, 2, 7, 3, 0, -6 },
  { 105, 4, 5, 6, 1, -6 },
  { 108, 4, 3, 6, 1, -5 },
  { 110, 4, 5, 6, 1, -6 },
  { 113, 4, 7, 4, 1, -7 },
  { 117, 7, 8, 8, 1, -7 },
  { 124, 6, 7, 6, -1, -7 },
  { 130, 6, 7, 6, 0, -7 },
  { 136, 5, 7, 6, 1, -7 },
  { 141, 6, 7, 7, 0, -7 },
  { 147, 6, 7, 5, 0, -7 },
  { 153, 6, 7, 5, 0, -7 },
  { 159, 6, 7, 7, 1, -7 },
  { 165, 7, 7, 7, 0, -7 },
  { 172, 4, 7, 3, 0, -7 },
  { 176, 5, 9, 3, -2, -7 },
  { 182, 7, 7, 6, 0, -7 },
  { 189, 4, 7, 5, 0, -7 },
  { 193, 8, 7, 8, 0, -7 },
  { 200, 7, 7, 7, 0, -7 },
  { 207, 6, 7, 7, 1, -7 },
  { 213, 6, 7, 6, 0, -7 },
  { 219, 6, 9, 7, 1, -7 },
  { 226, 6, 7, 6, 0, -7 },
  { 232, 5, 7, 5, 0, -7 },
  { 237, 5, 7, 5, 1, -7 },
  { 242, 6, 7, 7, 1, -7 },
  { 248, 5, 7, 6, 1, -7 },
  { 253, 8, 7, 9, 1, -7 },
  { 260, 7, 7, 5, -1, -7 },
  { 267, 5, 7, 5, 1, -7 },
  { 272, 6, 7, 5, 0, -7 },
  { 278, 4, 9, 3, 0, -7 },
  { 283, 2, 7, 4, 1, -7 },
  { 285, 4, 9, 3, -1, -7 },
  { 290, 5, 4, 6, 0, -7 },
  { 293, 4, 1, 4, -1, 1 },
  { 294, 2, 2, 3, 1, -8 },
  { 295, 6, 5, 6, 0, -5 },
  { 299, 5, 8, 6, 0, -8 },
  { 304, 5, 5, 5, 0, -5 },
  { 308, 6, 8, 6, 0, -8 },
  { 314, 5, 5, 5, 0, -5 },
  { 318, 5, 10, 3, -1, -8 },
  { 325, 6, 7, 6, 0, -5 },
  { 331, 5, 8, 6, 0, -8 },
  { 336, 3, 7, 3, 0, -7 },
  { 339, 4, 9, 3, -1, -7 },
  { 344, 5, 8, 5, 0, -8 },
  { 349, 3, 8, 3, 0, -8 },
  { 352, 8, 5, 9, 0, -5 },
  { 357, 5, 5, 6, 0, -5 },
  { 361, 5, 5, 6, 0, -5 },
  { 365, 5, 7, 6, 0, -5 },
  { 370, 6, 7, 6, 0, -5 },
  { 376, 4, 5, 4, 0, -5 },
  { 379, 4, 5, 4, 0, -5 },
  { 382, 4, 7, 3, 0, -7 },
  { 386, 5, 5, 6, 1, -5 },
  { 390, 5, 5, 5, 0, -5 },
  { 394, 7, 5, 7, 1, -5 },
  { 399, 5, 5, 5, 0, -5 },
  { 403, 6, 7, 5, -1, -5 },
  { 409, 4, 5, 4, 0, -5 },
  { 412, 4, 9, 4, 0, -7 },
  { 417, 1, 10, 6, 2, -8 },
  { 419, 3, 9, 4, 0, -7 },
  { 423, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_Italic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_ITALIC10PT7B_H_
