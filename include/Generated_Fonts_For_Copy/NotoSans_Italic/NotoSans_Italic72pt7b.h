#ifndef _NOTOSANS_ITALIC72PT7B_H_
#define _NOTOSANS_ITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF0,
  0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x1F,
  0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x01,
  0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x8F, 0x87, 0xC0, 0x0F, 0xE0, 0xF0, 0x0C, 0x01, 0xFC, 0x1F,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF8, 0x3C,
  0x00, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x00, 0xFF, 0x7C, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF7, 0xFC, 0x00, 0x00,
  0x1F, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x3C, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFE, 0x08, 0x00, 0x7C, 0x1F, 0xC0,
  0xF0, 0x07, 0xC3, 0xFC, 0x0F, 0xE0, 0x7C, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x04, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x3E,
  0x01, 0x00, 0xF8, 0x03, 0xF0, 0x7C, 0x1F, 0xF0, 0xF8, 0x03, 0xE0, 0xFC,
  0x3F, 0xFC, 0xF8, 0x03, 0xE1, 0xF8, 0xFF, 0xFE, 0xF8, 0x07, 0xC1, 0xF1,
  0xFF, 0xFE, 0xFC, 0x0F, 0xC3, 0xE1, 0xFC, 0x7F, 0xFC, 0x1F, 0x87, 0xE3,
  0xF0, 0x3F, 0x7F, 0xFF, 0x8F, 0xC7, 0xE0, 0x1F, 0x7F, 0xFF, 0x0F, 0x87,
  0xE0, 0x1F, 0x3F, 0xFE, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0xFC, 0x3F, 0x0F,
  0xC0, 0x1F, 0x07, 0xF0, 0x7E, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x00,
  0x01, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x0F,
  0xF0, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x7E, 0x00, 0x01, 0xFC,
  0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x9F, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF0, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x0F, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x00, 0x7F,
  0xF0, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x0F, 0xE1,
  0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x01, 0xFE,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01,
  0xC0, 0x07, 0xE0, 0x00, 0x30, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x06, 0x0F, 0xE7, 0xF9, 0xFE, 0x7F,
  0xFF, 0xEF, 0xF9, 0xFE, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFB, 0xF3, 0xFF, 0x8F, 0xC7, 0xFC, 0x7F, 0x1F, 0xC1, 0xF8, 0x3E, 0x07,
  0xE0, 0x60, 0x1F, 0x81, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xFE,
  0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x20, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x80,
  0x00, 0x03, 0xFC, 0x0E, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00,
  0x7F, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x05, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x08, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x0F, 0xF8, 0x0F,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0x00,
  0x0F, 0xC3, 0xFF, 0xF0, 0x03, 0xF1, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF,
  0xC0, 0x7E, 0xFF, 0xFF, 0xF8, 0x1F, 0xBE, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xC3, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0x7E, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xEF, 0xC0, 0x3F, 0xFF, 0xFD, 0xF8,
  0x03, 0xFF, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0xE1,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F,
  0xE3, 0xFF, 0x8F, 0x80, 0x0F, 0xF0, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x7E, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7C, 0x7E, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0xF8, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x01, 0xF3, 0xF0,
  0x07, 0xF0, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xDF, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xBF, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x1F, 0x7C, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0xF8, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0xE0,
  0x1F, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x07,
  0xDF, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xBE, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x3F, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xF9, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF3, 0xE0,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xC7, 0xC0, 0x3F, 0x00, 0x3F, 0xC0, 0x1F,
  0x8F, 0x80, 0x3E, 0x00, 0xFF, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x03, 0xFF,
  0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x9F, 0x8F, 0xF0, 0x7E, 0x00, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0x01,
  0xF8, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x3F,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x81, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xE1, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x1F,
  0xFF, 0xE1, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0x87, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x02, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x0F, 0xCF, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x03, 0xF3,
  0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x00,
  0x0F, 0xCF, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00,
  0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0x80,
  0x3E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xC7, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xC3, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x0C, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE8, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0x0F,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x1F, 0xC1, 0xF8,
  0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0x80, 0x07, 0xFF,
  0xF0, 0x7C, 0x00, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0xFF, 0xFF, 0x3F, 0x00,
  0xFF, 0xC0, 0xFD, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0x00, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xE0, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFE, 0x03, 0xF7,
  0xE0, 0x0F, 0xFF, 0xFF, 0x3E, 0x00, 0x3F, 0xFF, 0xF1, 0xF0, 0x01, 0xFF,
  0xFE, 0x0F, 0x80, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xC1,
  0xFF, 0xF0, 0x00, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xFC, 0x01,
  0xF8, 0xFF, 0xFF, 0xC0, 0x1F, 0x9F, 0x83, 0xFE, 0x01, 0xFB, 0xE0, 0x0F,
  0xE0, 0x1F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x3F, 0xF0,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xEF, 0x80,
  0x7F, 0xC0, 0x7E, 0xFF, 0xFF, 0xF8, 0x07, 0xC7, 0xFF, 0xFF, 0x00, 0x7C,
  0x3F, 0xFF, 0xE0, 0x0F, 0x81, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0x01, 0xE0, 0x1F, 0xE0, 0x00, 0x80, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0xFF, 0x80, 0x1E,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0xFF, 0xC3, 0xF0, 0x00, 0x7F,
  0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0x81, 0xFB,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xC0, 0x7C, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0xFF, 0xE1, 0xF8, 0x00,
  0x0F, 0xFF, 0xC1, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFE, 0x1F, 0x80, 0x07, 0xF8, 0x3F, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x7F,
  0xC0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x0C, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x83, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xFF, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0xFF, 0xFC, 0x3E, 0x00, 0x7F, 0xFF,
  0xF9, 0xF8, 0x03, 0xFF, 0x03, 0xF7, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xF8,
  0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0x7E, 0x00, 0x7F, 0x80, 0xF9, 0xF8, 0x01, 0xFF, 0xFF, 0xCF, 0xC0,
  0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x0F, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xFF,
  0x83, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xC1, 0xFF,
  0xF0, 0x00, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xFC, 0x01, 0xF8,
  0xFF, 0xFF, 0xE0, 0x1F, 0x9F, 0x81, 0xFE, 0x01, 0xFB, 0xE0, 0x0F, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x3F, 0xF0, 0x00,
  0x7F, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x83, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xDF, 0x80,
  0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x3E, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x0F, 0xCF,
  0xC1, 0xFE, 0x7F, 0x07, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0x3E, 0x00, 0xFE,
  0x03, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0x00, 0xF8, 0x1F,
  0xFF, 0x80, 0x0F, 0x87, 0xFF, 0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0xC0, 0x1F,
  0x9F, 0xFF, 0xFE, 0x01, 0xFB, 0xFE, 0x3F, 0xE0, 0x1F, 0xBF, 0x00, 0xFF,
  0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0x03, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0x81, 0xFF, 0xF0,
  0x00, 0x0F, 0x83, 0xFF, 0xF8, 0x00, 0x0F, 0x87, 0xFF, 0xFC, 0x00, 0x1F,
  0x8F, 0xFF, 0xFC, 0x00, 0x1F, 0x9F, 0x83, 0xFE, 0x00, 0x1F, 0xBE, 0x00,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xEF, 0x80, 0x7F, 0xC0, 0x07, 0xEF, 0xFF, 0xFF, 0x80, 0x07, 0xE7, 0xFF,
  0xFF, 0x00, 0x07, 0xE3, 0xFF, 0xFE, 0x00, 0x0F, 0xE1, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xF8, 0x00,
  0x7F, 0xFC, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x7C, 0x00, 0xFF, 0xFF, 0xC3,
  0xE0, 0x0F, 0xFF, 0xFF, 0x3F, 0x00, 0xFF, 0xC0, 0xFD, 0xF8, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0x80, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x03, 0xFE,
  0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0x00,
  0x3E, 0xFC, 0x01, 0xFE, 0x03, 0xE7, 0xE0, 0x0F, 0xFF, 0xFE, 0x7E, 0x00,
  0x3F, 0xFF, 0xE3, 0xF0, 0x01, 0xFF, 0xFE, 0x1F, 0x80, 0x07, 0xFF, 0xE1,
  0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x07, 0xF8, 0x07, 0xC0, 0xFF, 0xC0, 0x3E, 0x1F, 0xFC,
  0x01, 0xF1, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0x00, 0xFC, 0xFF, 0xB8, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xC0, 0x3F, 0x80,
  0x07, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x07, 0xF0, 0xC0,
  0x00, 0x3F, 0x83, 0xE0, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xBC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0xFE,
  0x00, 0x7D, 0xF8, 0x0F, 0xF0, 0x1F, 0x9F, 0x80, 0x7F, 0xFF, 0xF1, 0xF0,
  0x07, 0xFF, 0xFE, 0x1F, 0x00, 0x3F, 0xFF, 0xC3, 0xF0, 0x01, 0xFF, 0xF8,
  0x3F, 0x00, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xDF, 0x00, 0x1F,
  0xC1, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x7C, 0x00,
  0xFE, 0x07, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF1, 0xF0,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x87,
  0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7C,
  0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x3F, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x00, 0xFC,
  0x1F, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x7F, 0x00,
  0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x07, 0xCF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x1F,
  0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x80, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x47, 0xFF, 0xC0, 0x00, 0x37, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFB, 0x00, 0x01, 0xFF, 0xFC, 0x80, 0x00, 0x0F, 0xFC, 0x00,
};

const GFXglyph NotoSans_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 19, 52, 19, 1, -51 },
  { 125, 22, 18, 28, 8, -51 },
  { 175, 45, 51, 47, 2, -51 },
  { 462, 36, 59, 40, 2, -55 },
  { 728, 48, 53, 58, 6, -52 },
  { 1046, 44, 53, 48, 2, -52 },
  { 1338, 9, 18, 16, 8, -51 },
  { 1359, 23, 62, 21, 3, -51 },
  { 1538, 24, 62, 21, -6, -51 },
  { 1724, 34, 33, 40, 7, -55 },
  { 1865, 34, 35, 41, 5, -43 },
  { 2014, 14, 17, 18, -3, -8 },
  { 2044, 18, 6, 23, 2, -22 },
  { 2058, 10, 10, 18, 1, -9 },
  { 2071, 35, 51, 26, -3, -51 },
  { 2295, 34, 53, 40, 4, -52 },
  { 2521, 22, 51, 40, 10, -51 },
  { 2662, 38, 52, 40, 0, -52 },
  { 2909, 36, 53, 40, 2, -52 },
  { 3148, 39, 51, 40, 0, -51 },
  { 3397, 36, 52, 40, 3, -51 },
  { 3631, 34, 53, 40, 5, -52 },
  { 3857, 34, 51, 40, 6, -51 },
  { 4074, 36, 53, 40, 3, -52 },
  { 4313, 35, 53, 40, 3, -52 },
  { 4545, 15, 41, 18, 1, -40 },
  { 4622, 20, 49, 18, -4, -40 },
  { 4745, 34, 36, 41, 5, -44 },
  { 4898, 33, 19, 41, 5, -35 },
  { 4977, 34, 36, 41, 5, -44 },
  { 5130, 27, 53, 31, 6, -52 },
  { 5309, 55, 58, 61, 4, -51 },
  { 5708, 41, 51, 40, -4, -51 },
  { 5970, 39, 51, 43, 3, -51 },
  { 6219, 41, 53, 42, 5, -52 },
  { 6491, 43, 51, 48, 3, -51 },
  { 6766, 37, 51, 37, 3, -51 },
  { 7002, 37, 51, 34, 3, -51 },
  { 7238, 43, 53, 49, 5, -52 },
  { 7523, 46, 51, 49, 3, -51 },
  { 7817, 28, 51, 23, -1, -51 },
  { 7996, 31, 65, 20, -11, -51 },
  { 8248, 44, 51, 40, 3, -51 },
  { 8529, 27, 51, 34, 3, -51 },
  { 8702, 58, 51, 61, 3, -51 },
  { 9072, 48, 51, 51, 3, -51 },
  { 9378, 45, 53, 52, 5, -52 },
  { 9677, 38, 51, 41, 3, -51 },
  { 9920, 45, 64, 52, 5, -52 },
  { 10280, 38, 51, 41, 3, -51 },
  { 10523, 36, 53, 36, 1, -52 },
  { 10762, 36, 51, 36, 6, -51 },
  { 10992, 44, 52, 49, 6, -51 },
  { 11278, 39, 51, 40, 7, -51 },
  { 11527, 60, 51, 62, 8, -51 },
  { 11910, 48, 51, 38, -4, -51 },
  { 12216, 36, 51, 37, 7, -51 },
  { 12446, 42, 51, 38, -1, -51 },
  { 12714, 28, 62, 21, -1, -51 },
  { 12931, 13, 51, 26, 8, -51 },
  { 13014, 27, 62, 21, -5, -51 },
  { 13224, 35, 33, 41, 3, -52 },
  { 13369, 30, 5, 28, -7, 6 },
  { 13388, 11, 11, 20, 11, -55 },
  { 13404, 37, 40, 41, 3, -39 },
  { 13589, 36, 56, 42, 2, -55 },
  { 13841, 30, 40, 33, 3, -39 },
  { 13991, 40, 56, 42, 3, -55 },
  { 14271, 31, 40, 36, 3, -39 },
  { 14426, 40, 72, 23, -8, -55 },
  { 14786, 38, 56, 42, 2, -39 },
  { 15052, 36, 55, 42, 2, -55 },
  { 15300, 17, 53, 19, 2, -53 },
  { 15413, 28, 70, 19, -9, -53 },
  { 15658, 36, 55, 36, 2, -55 },
  { 15906, 18, 55, 19, 2, -55 },
  { 16030, 57, 39, 63, 2, -39 },
  { 16308, 36, 40, 42, 2, -40 },
  { 16488, 34, 40, 41, 3, -39 },
  { 16658, 40, 56, 42, -2, -39 },
  { 16938, 37, 56, 42, 3, -39 },
  { 17197, 29, 39, 29, 2, -39 },
  { 17339, 30, 40, 31, 0, -39 },
  { 17489, 23, 48, 24, 3, -47 },
  { 17627, 36, 40, 42, 4, -39 },
  { 17807, 34, 39, 34, 3, -39 },
  { 17973, 51, 39, 52, 4, -39 },
  { 18222, 40, 39, 35, -3, -39 },
  { 18417, 44, 56, 34, -7, -39 },
  { 18725, 33, 39, 32, -1, -39 },
  { 18886, 28, 62, 25, 1, -51 },
  { 19103, 5, 72, 40, 19, -55 },
  { 19148, 28, 62, 25, -3, -51 },
  { 19365, 34, 9, 41, 5, -30 },
};

const GFXfont NotoSans_Italic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic72pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_ITALIC72PT7B_H_
