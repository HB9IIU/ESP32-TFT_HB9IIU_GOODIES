#ifndef _NOTOSANS_ITALIC58PT7B_H_
#define _NOTOSANS_ITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x3F, 0x0F, 0xCF, 0x83,
  0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x03, 0xC7, 0xC1, 0xF1,
  0xF0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x70, 0x70,
  0x1C, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xCF, 0x3E, 0x03, 0xF1,
  0xE0, 0x60, 0x3E, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00,
  0x07, 0xC1, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C,
  0x3C, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x3F, 0x38, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0xF1,
  0xF8, 0x00, 0x0E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xC1, 0xF0, 0x80, 0x3C,
  0x3F, 0x0E, 0x03, 0xC7, 0xE0, 0xFC, 0x3D, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x08, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x7F,
  0xFC, 0x00, 0x1F, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0xF0, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x1F, 0x00, 0x1E,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x07, 0x83,
  0xE0, 0x00, 0xF0, 0x0F, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x1E, 0x1F, 0xE3,
  0xC0, 0x78, 0x7C, 0x7F, 0xE7, 0x80, 0xF1, 0xF3, 0xFF, 0xEF, 0x03, 0xC3,
  0xC7, 0xEF, 0xDF, 0x0F, 0x8F, 0x1F, 0x07, 0x9F, 0xFE, 0x3E, 0x7C, 0x0F,
  0xBF, 0xF8, 0xF8, 0xF0, 0x1F, 0x3F, 0xE1, 0xE1, 0xE0, 0x1E, 0x1F, 0x07,
  0x87, 0xC0, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x1E, 0x01,
  0xF0, 0x00, 0xF0, 0x7C, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x07, 0x80, 0x0F,
  0x81, 0xE0, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x1F,
  0x00, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0xF8,
  0x3C, 0x03, 0xE0, 0x00, 0xF9, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x1E,
  0x00, 0x01, 0xFF, 0x80, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x03, 0xE1, 0xFC, 0x00,
  0x00, 0x3E, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0xF8, 0x7F, 0x1F, 0x80, 0x1F, 0x1F,
  0x81, 0xF0, 0x07, 0xC7, 0xE0, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xF0, 0x3E,
  0x3E, 0x00, 0x3E, 0x07, 0xCF, 0xC0, 0x07, 0xE1, 0xF1, 0xF0, 0x00, 0x7E,
  0x7C, 0x3E, 0x00, 0x07, 0xFF, 0x87, 0xC0, 0x00, 0x7F, 0xE0, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x07, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x9F, 0x81, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x70, 0x70,
  0xF0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x18, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x7E, 0x0F, 0x00,
  0x1F, 0xF1, 0xC0, 0x01, 0xFF, 0xB8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xBF, 0xF0, 0x07, 0xF8, 0x02,
  0x01, 0xF7, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC1,
  0xE0, 0x01, 0xF8, 0x3C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00,
  0x60, 0x0F, 0x80, 0x04, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFD,
  0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x1F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0,
  0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3, 0xFE, 0x7C, 0x7F,
  0x1F, 0x1F, 0x07, 0xC3, 0x83, 0xE0, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0x80,
  0x3F, 0x80, 0x1C, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0xFF, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0x80, 0x07, 0xE0, 0x08,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE1, 0x00, 0x00, 0x3F, 0x0E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x7F, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x30, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x20, 0x00, 0x0F, 0xC1, 0x80, 0x00, 0xFE, 0x0F, 0x80,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x03, 0xE3, 0xFF, 0x80,
  0x7C, 0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0x07, 0xF8,
  0x03, 0xF0, 0xFF, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3E, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0x1F,
  0x81, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF1,
  0xF0, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xBE, 0x07, 0xFF, 0xE7, 0xC0, 0x3F, 0xF1, 0xF0, 0x00, 0x70, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0x80, 0x3F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xEF, 0xF8, 0x70, 0x07, 0xF1, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xF8, 0x03, 0xE0, 0xF8, 0x01,
  0xFF, 0xF8, 0x0F, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x78, 0x78, 0x03, 0xFF,
  0xFE, 0x03, 0xE7, 0xC0, 0x3F, 0x01, 0xF0, 0x1F, 0x3C, 0x03, 0xF0, 0x0F,
  0x00, 0xF9, 0xE0, 0x3E, 0x00, 0x78, 0x07, 0xDF, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF7, 0x80, 0xF0, 0x01, 0xE0, 0x0F,
  0x3C, 0x07, 0x80, 0x0F, 0x00, 0x7B, 0xE0, 0x7C, 0x00, 0xF8, 0x03, 0xDF,
  0x03, 0xE0, 0x07, 0xC0, 0x1E, 0xF8, 0x1E, 0x00, 0x3C, 0x01, 0xF7, 0x80,
  0xF0, 0x03, 0xE0, 0x0F, 0x3C, 0x07, 0x80, 0x1F, 0x00, 0xF9, 0xE0, 0x3C,
  0x01, 0xF8, 0x07, 0x8F, 0x01, 0xE0, 0x0F, 0xC0, 0x7C, 0x7C, 0x0F, 0x80,
  0xFE, 0x07, 0xC3, 0xE0, 0x7E, 0x0E, 0xF8, 0x7E, 0x1F, 0x01, 0xFF, 0xF3,
  0xFF, 0xE0, 0x78, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F,
  0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x7E,
  0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x70, 0x07, 0xF8, 0x00, 0x08,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x3F, 0xE0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xF0, 0x3E, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0x00, 0x3F, 0xF0, 0x07, 0xC1, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0xF8, 0x00, 0x3F,
  0xFE, 0x3F, 0x00, 0x07, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xF8, 0xFC, 0x00,
  0x3F, 0xFE, 0x1F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xC0,
  0x00, 0x7C, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xBE, 0x00, 0x00, 0x0F, 0xF3, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x1E, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x3D, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0xFB, 0xC0,
  0x00, 0x0F, 0x7C, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x00, 0x79, 0xF0, 0x07, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x0F, 0x3E, 0x00,
  0x03, 0xCF, 0xC0, 0x3E, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x7C, 0x78, 0x00,
  0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7E, 0x01, 0xF0, 0x3C, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xE0, 0x7C, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x80, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x01, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x79, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF7, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xFE, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x07,
  0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0x01,
  0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0x80, 0x3F,
  0xE0, 0x00, 0x1F, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x01, 0xF7, 0xC0, 0x00,
  0xF8, 0x03, 0xEF, 0x80, 0x01, 0xF0, 0x07, 0x8F, 0x80, 0x03, 0xE0, 0x0F,
  0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x00,
  0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x00,
  0xF8, 0xF8, 0x03, 0xE0, 0x00, 0xF9, 0xF0, 0x07, 0x80, 0x01, 0xF3, 0xE0,
  0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x03, 0xEF, 0x00, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0x00,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xC0, 0x1F,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xC0, 0x1F, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x00,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x78, 0x0F, 0xE0, 0x00, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x0C, 0x00, 0x0F, 0xE0, 0x7C, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3D,
  0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E,
  0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0x1F, 0x01,
  0xF0, 0x3C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xF0, 0x01, 0xF0,
  0x7C, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0x1F,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x07, 0x9F, 0x00, 0x00,
  0xF3, 0xC0, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xE0, 0x01, 0xE7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x01, 0xFD, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x1F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0xC0,
  0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x3F,
  0xFE, 0x3E, 0x03, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xCF, 0x03, 0xF8, 0x0F,
  0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xF8, 0x01, 0xFE, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0xC3, 0xE0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0xFF, 0x07, 0xE0, 0x07,
  0xF8, 0x3F, 0x00, 0xFF, 0x80, 0xFC, 0x0F, 0xBC, 0x07, 0xFF, 0xF9, 0xE0,
  0x1F, 0xFF, 0x8F, 0x00, 0x7F, 0xF0, 0xF8, 0x01, 0xFF, 0x07, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x01, 0x80, 0x01, 0xF0, 0x7F, 0xC0, 0x0F, 0x8F, 0xFF, 0x00, 0x7C, 0xFF,
  0xFC, 0x07, 0xCF, 0xFF, 0xE0, 0x3E, 0xF8, 0x1F, 0x81, 0xFF, 0x00, 0xFC,
  0x0F, 0xF0, 0x03, 0xE0, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xFE, 0x00, 0xFC,
  0x0F, 0x78, 0x1F, 0xE0, 0xFB, 0xFF, 0xFE, 0x07, 0x8F, 0xFF, 0xE0, 0x3C,
  0x3F, 0xFC, 0x01, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xF0, 0x06, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x7F, 0x00, 0x60, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x58, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0xFF,
  0xF8, 0xF8, 0x01, 0xFF, 0xFD, 0xF0, 0x03, 0xFF, 0xFD, 0xF0, 0x07, 0xF0,
  0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0xFC, 0x03,
  0xDE, 0x00, 0x7E, 0x07, 0xDE, 0x00, 0x7F, 0xFF, 0xBE, 0x00, 0x3F, 0xFF,
  0x3E, 0x00, 0x1F, 0xFC, 0x3E, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0xFE, 0x7C, 0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFE, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x7F,
  0x00, 0x70, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xF8, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x3C, 0x00, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xF9, 0xE0, 0x0F, 0xFF, 0xF3,
  0xC0, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00,
  0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x80, 0xFC, 0x03,
  0xDE, 0x00, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xFE, 0xF8, 0x01, 0xFF, 0xF9,
  0xF0, 0x01, 0xFF, 0xC3, 0xE0, 0x01, 0xFF, 0x0F, 0x80, 0x00, 0x20, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x40, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xFE, 0x3F, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x1C, 0x00, 0x3E, 0x0F, 0xF8, 0x03, 0xE3, 0xFF, 0xC0, 0x3E, 0x7F, 0xFE,
  0x07, 0xCF, 0xFF, 0xF0, 0x7D, 0xF0, 0x3F, 0x07, 0xFC, 0x01, 0xF0, 0x7F,
  0x80, 0x1F, 0x07, 0xF0, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xE0, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x30, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x08,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0,
  0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x7E, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xCF, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00,
  0xFC, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0F,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3C, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xF1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xCF, 0xFF, 0xC7, 0xFF, 0xF8, 0x1F, 0x78,
  0x1F, 0x9E, 0x07, 0xE0, 0x7F, 0xC0, 0x3E, 0xF0, 0x0F, 0x81, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xC3, 0xFF, 0x00, 0x1E, 0x1F, 0xFF, 0x00, 0xF8, 0xFF, 0xFC,
  0x03, 0xE7, 0xFF, 0xF8, 0x0F, 0xBE, 0x07, 0xE0, 0x3F, 0xE0, 0x0F, 0x80,
  0xFF, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xE0, 0x7F,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xBF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xC1, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x78, 0x1F, 0xF0, 0x00, 0x78, 0x7F, 0xF8, 0x00, 0x78, 0xFF,
  0xFC, 0x00, 0xF9, 0xFF, 0xFC, 0x00, 0xFB, 0xE0, 0x7E, 0x00, 0xFF, 0x80,
  0x7E, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x01,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0x78, 0x1F,
  0xE0, 0x1F, 0x7F, 0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0x80, 0x1F, 0x1F, 0xFE,
  0x00, 0x1F, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x3F, 0xFE, 0x3E,
  0x03, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xCF, 0x03, 0xF8, 0x0F, 0xF8, 0x3F,
  0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xFC,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0xFF, 0x07, 0xE0, 0x0F, 0xF8, 0x3F,
  0x00, 0xF7, 0x80, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF,
  0x9F, 0x00, 0x7F, 0xF0, 0xF8, 0x01, 0xFF, 0x0F, 0x80, 0x00, 0x80, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0x83, 0xFC, 0x0F, 0x0F, 0xF0, 0x1E, 0x3F, 0xE0,
  0x7C, 0xFF, 0xC0, 0xFB, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xE0, 0x0E, 0x0F, 0xC0, 0x02, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x80, 0x01, 0xF0, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x10, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xE0,
  0x01, 0xFC, 0x1F, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0xFF, 0x07, 0xE0, 0x1E,
  0xF0, 0x3F, 0x81, 0xE7, 0x80, 0xFF, 0xFE, 0x7C, 0x07, 0xFF, 0xE3, 0xE0,
  0x1F, 0xFE, 0x1F, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x80, 0x07, 0xDF,
  0x00, 0x1F, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0xE0, 0x03, 0xE3, 0xC0, 0x0F,
  0x78, 0x03, 0xF1, 0xE0, 0x07, 0xBC, 0x01, 0xF0, 0xF8, 0x07, 0x9E, 0x01,
  0xF8, 0x7C, 0x03, 0xCF, 0x00, 0xF8, 0x3E, 0x03, 0xE7, 0x80, 0xFC, 0x1F,
  0x01, 0xE3, 0xC0, 0x7C, 0x0F, 0x81, 0xF1, 0xE0, 0x3E, 0x07, 0xC0, 0xF0,
  0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x78, 0x1F, 0x01, 0xF0, 0x78, 0x3C, 0x1F,
  0x00, 0xF8, 0x7C, 0x1E, 0x0F, 0x80, 0x7C, 0x3C, 0x0F, 0x0F, 0x80, 0x3E,
  0x1E, 0x07, 0x87, 0xC0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0, 0x0F, 0x8F, 0x01,
  0xE3, 0xE0, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x79, 0xF0,
  0x01, 0xF7, 0xC0, 0x3C, 0xF8, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x00, 0x7D,
  0xE0, 0x0F, 0x7C, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x87, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x27, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xA0, 0x00, 0x7F, 0xC0,
};

const GFXglyph NotoSans_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 42, 15, 1, -41 },
  { 80, 18, 15, 23, 6, -41 },
  { 114, 36, 41, 37, 2, -41 },
  { 299, 28, 47, 32, 2, -44 },
  { 464, 39, 43, 46, 5, -42 },
  { 674, 35, 43, 39, 2, -42 },
  { 863, 8, 15, 13, 6, -41 },
  { 878, 19, 50, 17, 2, -41 },
  { 997, 18, 50, 17, -4, -41 },
  { 1110, 27, 27, 32, 6, -44 },
  { 1202, 27, 29, 33, 4, -35 },
  { 1300, 12, 14, 15, -3, -7 },
  { 1321, 14, 5, 18, 2, -18 },
  { 1330, 7, 8, 15, 1, -7 },
  { 1337, 29, 41, 21, -3, -41 },
  { 1486, 28, 43, 32, 3, -42 },
  { 1637, 18, 41, 32, 8, -41 },
  { 1730, 31, 42, 32, 0, -42 },
  { 1893, 29, 43, 32, 1, -42 },
  { 2049, 31, 41, 32, 0, -41 },
  { 2208, 29, 42, 32, 2, -41 },
  { 2361, 28, 43, 32, 4, -42 },
  { 2512, 28, 41, 32, 5, -41 },
  { 2656, 29, 43, 32, 3, -42 },
  { 2812, 27, 43, 32, 3, -42 },
  { 2958, 12, 33, 15, 1, -32 },
  { 3008, 16, 39, 15, -3, -32 },
  { 3086, 27, 28, 33, 4, -35 },
  { 3181, 27, 15, 33, 4, -28 },
  { 3232, 27, 28, 33, 4, -35 },
  { 3327, 22, 43, 25, 4, -42 },
  { 3446, 45, 46, 49, 3, -41 },
  { 3705, 33, 41, 33, -3, -41 },
  { 3875, 32, 41, 35, 2, -41 },
  { 4039, 33, 43, 34, 4, -42 },
  { 4217, 35, 41, 39, 2, -41 },
  { 4397, 30, 41, 30, 2, -41 },
  { 4551, 30, 41, 28, 2, -41 },
  { 4705, 35, 43, 39, 4, -42 },
  { 4894, 38, 41, 39, 2, -41 },
  { 5089, 23, 41, 19, -1, -41 },
  { 5207, 25, 52, 16, -9, -41 },
  { 5370, 36, 41, 33, 2, -41 },
  { 5555, 22, 41, 28, 2, -41 },
  { 5668, 47, 41, 49, 2, -41 },
  { 5909, 39, 41, 41, 2, -41 },
  { 6109, 36, 43, 42, 4, -42 },
  { 6303, 31, 41, 33, 2, -41 },
  { 6462, 36, 52, 42, 4, -42 },
  { 6696, 31, 41, 33, 2, -41 },
  { 6855, 29, 43, 29, 1, -42 },
  { 7011, 29, 41, 29, 5, -41 },
  { 7160, 35, 42, 39, 5, -41 },
  { 7344, 32, 41, 32, 5, -41 },
  { 7508, 49, 41, 50, 6, -41 },
  { 7760, 38, 41, 31, -3, -41 },
  { 7955, 30, 41, 30, 5, -41 },
  { 8109, 34, 41, 31, -1, -41 },
  { 8284, 22, 50, 17, -1, -41 },
  { 8422, 11, 41, 21, 6, -41 },
  { 8479, 22, 50, 17, -4, -41 },
  { 8617, 29, 27, 33, 2, -42 },
  { 8715, 24, 4, 23, -5, 5 },
  { 8727, 10, 9, 16, 8, -44 },
  { 8739, 29, 33, 33, 3, -32 },
  { 8859, 29, 45, 34, 2, -44 },
  { 9023, 24, 33, 26, 3, -32 },
  { 9122, 32, 45, 34, 3, -44 },
  { 9302, 24, 33, 29, 3, -32 },
  { 9401, 33, 58, 18, -7, -44 },
  { 9641, 31, 46, 34, 1, -32 },
  { 9820, 28, 44, 34, 2, -44 },
  { 9974, 14, 43, 15, 2, -43 },
  { 10050, 23, 57, 15, -7, -43 },
  { 10214, 28, 44, 29, 2, -44 },
  { 10368, 14, 44, 15, 2, -44 },
  { 10445, 46, 32, 51, 2, -32 },
  { 10629, 30, 32, 34, 1, -32 },
  { 10749, 27, 32, 33, 3, -32 },
  { 10857, 32, 46, 34, -1, -32 },
  { 11041, 29, 46, 34, 3, -32 },
  { 11208, 23, 32, 23, 2, -32 },
  { 11300, 24, 33, 25, 0, -32 },
  { 11399, 18, 39, 19, 3, -38 },
  { 11487, 29, 32, 34, 3, -31 },
  { 11603, 27, 31, 27, 3, -31 },
  { 11708, 41, 31, 42, 3, -31 },
  { 11867, 32, 31, 28, -2, -31 },
  { 11991, 35, 45, 27, -5, -31 },
  { 12188, 26, 31, 26, -1, -31 },
  { 12289, 22, 50, 20, 1, -41 },
  { 12427, 4, 58, 32, 15, -44 },
  { 12456, 22, 50, 20, -2, -41 },
  { 12594, 27, 7, 33, 4, -24 },
};

const GFXfont NotoSans_Italic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic58pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_ITALIC58PT7B_H_
