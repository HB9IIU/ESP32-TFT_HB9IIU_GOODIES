#ifndef _NOTOSANS_ITALIC34PT7B_H_
#define _NOTOSANS_ITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0,
  0xE0, 0x71, 0xDC, 0xFE, 0x3B, 0x8E, 0xE3, 0xB0, 0xCC, 0x33, 0x0C, 0xC2,
  0x00, 0x00, 0x70, 0xE0, 0x03, 0x06, 0x00, 0x38, 0x30, 0x01, 0xC3, 0x80,
  0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x07, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x60, 0x03,
  0x83, 0x00, 0x18, 0x38, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x70, 0xE0,
  0x03, 0x07, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x1C, 0x00, 0x60,
  0xC0, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1F,
  0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0x39, 0x84, 0x38, 0xC0, 0x1C, 0x60, 0x0E,
  0x30, 0x07, 0x38, 0x03, 0xD8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0x9E, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x71, 0xC8, 0x31,
  0xC7, 0x9B, 0xE3, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x04, 0x3F, 0x00, 0x70, 0xFF, 0x00,
  0xC3, 0x8E, 0x03, 0x07, 0x0C, 0x0E, 0x0C, 0x18, 0x38, 0x38, 0x30, 0x60,
  0x70, 0xE1, 0xC0, 0xC1, 0xC7, 0x01, 0x83, 0x9C, 0x03, 0x06, 0x31, 0xE6,
  0x1C, 0xEF, 0xEC, 0x33, 0xBD, 0xDF, 0xEE, 0x61, 0xDF, 0x99, 0xC3, 0x88,
  0x73, 0x07, 0x01, 0xC6, 0x0E, 0x07, 0x1C, 0x18, 0x0C, 0x38, 0x30, 0x38,
  0x70, 0xE0, 0xE0, 0xE1, 0xC3, 0x81, 0xC3, 0x06, 0x03, 0x8E, 0x1C, 0x03,
  0xF8, 0x70, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0x0F, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0,
  0xE0, 0x07, 0x0F, 0x00, 0x1D, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xF1, 0xC1, 0xCF, 0x0F, 0x0E, 0x70, 0x38,
  0xE7, 0x00, 0xE7, 0x38, 0x07, 0xF1, 0xC0, 0x1F, 0x0E, 0x00, 0x70, 0x78,
  0x0F, 0xC1, 0xE1, 0xFF, 0x07, 0xFF, 0x38, 0x1F, 0xE0, 0xF0, 0x77, 0xEE,
  0xEC, 0xCC, 0xC0, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x60, 0xC0, 0x78, 0xC0, 0xFE,
  0x80, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x38,
  0x60, 0x38, 0x70, 0x10, 0x78, 0x00, 0x20, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0xF3, 0x8E, 0x71, 0xCE, 0x30, 0xFF, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0x0E, 0x1E, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70,
  0x78, 0x78, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xC1, 0xF1, 0xFC, 0xFE,
  0xFB, 0xB8, 0xE4, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1E, 0x1E, 0x02, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x70,
  0x01, 0xFF, 0x07, 0xFF, 0xC1, 0xC1, 0xE0, 0x40, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0xFF, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE4, 0x01, 0xE3, 0xC3, 0xE1, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x30, 0x03, 0x9C, 0x01, 0xC7,
  0x00, 0xE1, 0xC0, 0x70, 0x70, 0x3C, 0x38, 0x1E, 0x0E, 0x07, 0x03, 0x83,
  0x80, 0xE1, 0xC0, 0x38, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC8, 0x03, 0xC7, 0x87, 0xC3, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0x0E, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0xF8, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0xFC,
  0x0E, 0xFF, 0x87, 0xE3, 0xC3, 0xC0, 0xF3, 0xC0, 0x39, 0xE0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC3, 0x81, 0xC1,
  0xE3, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x0E, 0x0E, 0x0F, 0x3C, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x3C,
  0x38, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0,
  0x1C, 0xE0, 0x3C, 0xF8, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x00, 0xC0, 0x07,
  0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3E,
  0xFE, 0x1F, 0xEE, 0x0F, 0x8E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x83, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0C,
  0x3C, 0xF9, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0xF1, 0xE3, 0x80, 0x01, 0x80, 0xF0, 0x7C, 0x1E, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x02, 0x07, 0xFE, 0xFF, 0xF6, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x01, 0xE0,
  0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80, 0x30,
  0x18, 0xE0, 0x7F, 0x87, 0x70, 0x7F, 0xE1, 0xDC, 0x38, 0x38, 0x76, 0x1C,
  0x0E, 0x1F, 0x87, 0x03, 0x07, 0xE1, 0x81, 0xC1, 0xF0, 0xE0, 0x70, 0x7C,
  0x38, 0x1C, 0x1B, 0x0E, 0x0E, 0x0E, 0xC3, 0x83, 0x83, 0x30, 0xE1, 0xE1,
  0xCE, 0x1F, 0xDF, 0xE3, 0x83, 0xE3, 0xF0, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x80, 0x1F, 0x83, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03,
  0x8C, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00,
  0x3F, 0x80, 0x07, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1C, 0x1F, 0x03, 0x80,
  0xF0, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0F, 0x0E, 0x01,
  0xC3, 0xC0, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x38, 0x0F,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E,
  0x38, 0x03, 0xC7, 0x00, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xF0, 0x70, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0xE7, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xC3, 0xF8, 0x0E, 0x03, 0xC0, 0x70,
  0x0F, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E,
  0x00, 0xF0, 0xE0, 0x0F, 0x07, 0x01, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xC0, 0xE0, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x01,
  0xFE, 0x38, 0x0F, 0xF3, 0xC0, 0x7F, 0x9E, 0x00, 0x1C, 0xF0, 0x01, 0xC7,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x80, 0x3C, 0x1E, 0x01,
  0xC0, 0xFE, 0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0x80, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x78, 0x01,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x70, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x38,
  0x3C, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x04,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x78, 0x38, 0x07, 0x01,
  0xC0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x07, 0x78, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x6C,
  0x00, 0x7E, 0x0E, 0xC0, 0x0E, 0xE0, 0xEC, 0x00, 0xEE, 0x0E, 0xE0, 0x1D,
  0xC0, 0xEE, 0x01, 0xDC, 0x0C, 0xE0, 0x39, 0xC1, 0xCE, 0x03, 0x9C, 0x1C,
  0xE0, 0x73, 0x81, 0xC6, 0x06, 0x38, 0x1C, 0x60, 0xE3, 0x81, 0x86, 0x0C,
  0x38, 0x38, 0x71, 0xC3, 0x83, 0x87, 0x38, 0x70, 0x38, 0x73, 0x87, 0x03,
  0x87, 0x70, 0x70, 0x30, 0x77, 0x07, 0x07, 0x03, 0xE0, 0x70, 0x70, 0x3C,
  0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0xE0,
  0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1F, 0x00, 0x38, 0x3E, 0x00, 0xE0,
  0xEE, 0x01, 0xC1, 0xDC, 0x03, 0x83, 0xB8, 0x07, 0x07, 0x38, 0x0E, 0x0C,
  0x70, 0x38, 0x38, 0xE0, 0x70, 0x70, 0xE0, 0xE0, 0xE1, 0xC1, 0xC1, 0xC1,
  0x83, 0x83, 0x03, 0x8E, 0x0E, 0x07, 0x1C, 0x1C, 0x07, 0x38, 0x38, 0x0E,
  0x70, 0x70, 0x1C, 0xC0, 0xC0, 0x1F, 0x83, 0x80, 0x3F, 0x07, 0x00, 0x3E,
  0x0E, 0x00, 0x7C, 0x1C, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0x3C, 0x70, 0x00, 0xE7, 0x80, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0,
  0x03, 0xC7, 0x80, 0x1E, 0x1E, 0x03, 0xE0, 0xFC, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x70, 0xF8, 0x1C, 0x0F,
  0x07, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC7,
  0x80, 0xF1, 0xC0, 0x78, 0x70, 0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xF8,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0x3C, 0x70, 0x00, 0xE7, 0x80, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0,
  0x03, 0xC7, 0x80, 0x1C, 0x1E, 0x03, 0xE0, 0xFC, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x70, 0xFC, 0x1C, 0x0F, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x78, 0x7F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFC, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x3C, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xC0, 0x78, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xF3, 0xC0,
  0x1C, 0x00, 0x38, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0, 0xE1, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC4, 0x03, 0xC3,
  0xC7, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0,
  0xF0, 0x1E, 0x07, 0xC7, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0xE0, 0x01,
  0xFC, 0x00, 0x3B, 0x80, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x38, 0x3C, 0x03, 0x07, 0x00, 0x61, 0xE0, 0x0E, 0x38, 0x01, 0xCF, 0x00,
  0x39, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0xFE, 0x01,
  0xE0, 0x0E, 0xE0, 0x1F, 0x00, 0xEE, 0x01, 0xF0, 0x1C, 0xE0, 0x3F, 0x01,
  0xCE, 0x03, 0x70, 0x38, 0xE0, 0x77, 0x03, 0x8E, 0x06, 0x70, 0x78, 0xE0,
  0xE7, 0x07, 0x0E, 0x0C, 0x70, 0x70, 0xE1, 0xC7, 0x0E, 0x0E, 0x1C, 0x70,
  0xE0, 0xE3, 0x87, 0x1C, 0x0E, 0x38, 0x71, 0xC0, 0xE7, 0x07, 0x38, 0x0E,
  0x70, 0x33, 0x80, 0xEE, 0x03, 0x30, 0x0E, 0xE0, 0x37, 0x00, 0xEC, 0x03,
  0x70, 0x0F, 0xC0, 0x36, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0x70, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x07, 0x80,
  0x70, 0x07, 0x01, 0xE0, 0x0E, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3B, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x1E, 0x00,
  0xF0, 0x78, 0x00, 0xE0, 0xE0, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0xCE, 0x01,
  0xC7, 0x01, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x0C,
  0x70, 0x07, 0x70, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0x81, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0xE3, 0x8E, 0x38, 0xE1, 0x86, 0x1C, 0x71, 0xC7,
  0x1C, 0x30, 0xC3, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x71, 0xC7, 0x03, 0xF0,
  0x7F, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x6C, 0x00, 0x77, 0x00, 0x31, 0x80, 0x38, 0xE0, 0x18, 0x30, 0x1C,
  0x1C, 0x0C, 0x06, 0x0E, 0x03, 0x86, 0x00, 0xC7, 0x00, 0x73, 0x80, 0x1B,
  0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC7, 0x0E, 0x1C, 0x00, 0x80,
  0x03, 0xF9, 0xC3, 0xFE, 0xC3, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xC0,
  0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E,
  0x01, 0xC7, 0x01, 0xE3, 0x81, 0xF1, 0xC0, 0xF8, 0xF1, 0xD8, 0x3F, 0xCC,
  0x0F, 0xCE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x20, 0x0E, 0x7E, 0x0E, 0x7F,
  0x87, 0x61, 0xC3, 0xE0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70,
  0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3,
  0xC0, 0x71, 0xE0, 0x79, 0xD8, 0xF8, 0xEF, 0xF8, 0x63, 0xF8, 0x00, 0x00,
  0xC0, 0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x61, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x02, 0x0E, 0x07, 0xF3, 0x83, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0, 0x3C,
  0x78, 0x0F, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38,
  0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x1F, 0x0E, 0x07,
  0xC3, 0xC7, 0x60, 0x7F, 0x98, 0x0F, 0xCE, 0x00, 0x00, 0x80, 0x1F, 0xE0,
  0xFF, 0x87, 0x8F, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xFC, 0x1E, 0xE3, 0xF3,
  0xFF, 0x8F, 0xF8, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x04,
  0x78, 0x71, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x04, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFE, 0x70, 0x7F, 0xD8, 0x3C, 0x3E,
  0x1E, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x03,
  0xE1, 0xC1, 0xF8, 0x78, 0xFC, 0x0F, 0xF7, 0x01, 0xF9, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x82, 0x01, 0xC0, 0xF1, 0xF0, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x10, 0x0E, 0x7E, 0x0E,
  0x7F, 0x87, 0x61, 0xE3, 0xE0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x1C,
  0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x00,
  0x07, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x02, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x01,
  0x0E, 0x07, 0x0E, 0x07, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC7, 0x00, 0xE7,
  0x00, 0xE7, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1E, 0x70, 0x0E,
  0x1C, 0x07, 0x0E, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xF0, 0xE0, 0x38,
  0x70, 0x1E, 0x00, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x00, 0x10, 0x02, 0x01, 0x8F, 0xC3, 0xF8,
  0x77, 0xF8, 0xFF, 0x0E, 0xC3, 0xB8, 0xF1, 0xF0, 0x7C, 0x0E, 0x3C, 0x0F,
  0x01, 0xC7, 0x01, 0xE0, 0x39, 0xE0, 0x38, 0x07, 0x38, 0x07, 0x01, 0xC7,
  0x00, 0xE0, 0x38, 0xE0, 0x38, 0x07, 0x1C, 0x07, 0x00, 0xE7, 0x00, 0xE0,
  0x3C, 0xE0, 0x1C, 0x07, 0x1C, 0x07, 0x00, 0xE3, 0x80, 0xE0, 0x1C, 0xE0,
  0x1C, 0x03, 0x9C, 0x03, 0x80, 0xE3, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x1C,
  0x06, 0x3F, 0x87, 0x7F, 0xC3, 0xF8, 0xF1, 0xF0, 0x38, 0xF0, 0x1C, 0xF0,
  0x0E, 0x78, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x01, 0xE7,
  0x00, 0xF3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0x1E, 0x70, 0x0E,
  0x38, 0x07, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x38, 0x0E, 0x78,
  0x0E, 0x70, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x78, 0xF0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x00, 0x02, 0x00, 0x63, 0xF0, 0x1C, 0xFF, 0x03, 0xB0,
  0xE0, 0x7C, 0x0E, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07,
  0x87, 0x80, 0xE0, 0xF0, 0x3C, 0x3B, 0x1F, 0x07, 0x7F, 0xC0, 0xE7, 0xF0,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x03, 0xF9,
  0xC3, 0xFE, 0xC3, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xC0, 0x39, 0xE0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xE3, 0x81, 0xF1, 0xC1, 0xF8, 0xF1, 0xD8, 0x3F, 0xDC, 0x0F, 0xCE,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x31, 0xE1, 0xDF, 0x87,
  0x60, 0x1F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xF1, 0xFF, 0xC7, 0x02, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x20, 0x1C, 0xE1, 0xF3, 0xFF, 0x87,
  0xF8, 0x00, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x07, 0xFE, 0xFF, 0xE7, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x47, 0xF0, 0x7E, 0x00, 0x3C, 0x03, 0x9C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x31, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03,
  0xC7, 0x03, 0xE3, 0x81, 0xF1, 0xE3, 0xB0, 0x7F, 0x98, 0x3F, 0x9C, 0x00,
  0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x70,
  0xE0, 0x70, 0x60, 0xE0, 0x70, 0xE0, 0x71, 0xC0, 0x71, 0xC0, 0x73, 0x80,
  0x73, 0x80, 0x77, 0x00, 0x77, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0xE0, 0x38, 0x0F, 0xE0, 0x78, 0x0E, 0xE0, 0x7C, 0x1E, 0xE0, 0xFC, 0x1C,
  0xE0, 0xDC, 0x1C, 0xE1, 0xDC, 0x38, 0xE1, 0xDC, 0x38, 0xE1, 0x9C, 0x70,
  0xE3, 0x9C, 0x70, 0xE3, 0x1C, 0xE0, 0xE7, 0x1C, 0xE0, 0xE6, 0x1C, 0xC0,
  0xEE, 0x0D, 0xC0, 0x6C, 0x0D, 0xC0, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x03, 0xC3, 0x81, 0xE0, 0x70,
  0x70, 0x1C, 0x38, 0x03, 0x9C, 0x00, 0xEF, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1D, 0xC0, 0x0F, 0x30, 0x03,
  0x8E, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x70, 0x1C, 0x3C, 0x03, 0x80, 0x07,
  0x00, 0x78, 0x38, 0x07, 0x81, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C,
  0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x38, 0x00, 0x19, 0xC0, 0x00, 0xDC, 0x00,
  0x06, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x13,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x01, 0xF0, 0x07, 0x00, 0x3F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xF8, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xE3,
  0xE3, 0xFF, 0x80, 0x7E,
};

const GFXglyph NotoSans_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 24, 9, 1, -24 },
  { 25, 10, 9, 13, 4, -24 },
  { 37, 21, 24, 22, 1, -24 },
  { 100, 17, 28, 19, 1, -26 },
  { 160, 23, 25, 27, 3, -25 },
  { 232, 21, 25, 23, 1, -25 },
  { 298, 4, 9, 7, 4, -24 },
  { 303, 11, 29, 10, 1, -24 },
  { 343, 11, 29, 10, -3, -24 },
  { 383, 16, 16, 19, 3, -26 },
  { 415, 16, 16, 19, 2, -20 },
  { 447, 6, 8, 9, -1, -4 },
  { 453, 9, 2, 11, 1, -10 },
  { 456, 4, 4, 9, 1, -4 },
  { 458, 17, 24, 12, -2, -24 },
  { 509, 16, 25, 19, 2, -25 },
  { 559, 10, 24, 19, 5, -24 },
  { 589, 18, 25, 19, 0, -25 },
  { 646, 17, 25, 19, 1, -25 },
  { 700, 18, 24, 19, 0, -24 },
  { 754, 17, 24, 19, 1, -24 },
  { 805, 17, 25, 19, 2, -25 },
  { 859, 16, 24, 19, 3, -24 },
  { 907, 16, 25, 19, 2, -25 },
  { 957, 16, 25, 19, 2, -25 },
  { 1007, 7, 19, 9, 1, -19 },
  { 1024, 10, 23, 9, -2, -19 },
  { 1053, 16, 17, 19, 2, -21 },
  { 1087, 15, 10, 19, 3, -17 },
  { 1106, 16, 17, 19, 2, -21 },
  { 1140, 12, 25, 15, 3, -25 },
  { 1178, 26, 27, 29, 2, -24 },
  { 1266, 19, 24, 19, -2, -24 },
  { 1323, 19, 24, 20, 1, -24 },
  { 1380, 19, 25, 20, 2, -25 },
  { 1440, 21, 24, 23, 1, -24 },
  { 1503, 18, 24, 17, 1, -24 },
  { 1557, 18, 24, 16, 1, -24 },
  { 1611, 21, 25, 23, 2, -25 },
  { 1677, 22, 24, 23, 1, -24 },
  { 1743, 14, 24, 11, -1, -24 },
  { 1785, 15, 30, 9, -5, -24 },
  { 1842, 21, 24, 19, 1, -24 },
  { 1905, 13, 24, 16, 1, -24 },
  { 1944, 28, 24, 29, 1, -24 },
  { 2028, 23, 24, 24, 1, -24 },
  { 2097, 21, 25, 25, 2, -25 },
  { 2163, 18, 24, 19, 1, -24 },
  { 2217, 21, 31, 25, 2, -25 },
  { 2299, 18, 24, 19, 1, -24 },
  { 2353, 17, 25, 17, 1, -25 },
  { 2407, 17, 24, 17, 3, -24 },
  { 2458, 20, 24, 23, 3, -24 },
  { 2518, 19, 24, 19, 3, -24 },
  { 2575, 28, 24, 29, 4, -24 },
  { 2659, 23, 24, 18, -2, -24 },
  { 2728, 17, 24, 17, 3, -24 },
  { 2779, 19, 24, 18, 0, -24 },
  { 2836, 13, 29, 10, 0, -24 },
  { 2884, 6, 24, 12, 4, -24 },
  { 2902, 12, 29, 10, -2, -24 },
  { 2946, 17, 15, 19, 1, -24 },
  { 2978, 14, 2, 13, -3, 3 },
  { 2982, 6, 5, 9, 5, -26 },
  { 2986, 17, 19, 19, 2, -19 },
  { 3027, 17, 26, 20, 1, -26 },
  { 3083, 14, 19, 15, 2, -19 },
  { 3117, 18, 26, 20, 2, -26 },
  { 3176, 14, 19, 17, 2, -19 },
  { 3210, 19, 34, 11, -4, -26 },
  { 3291, 18, 27, 20, 1, -19 },
  { 3352, 17, 26, 20, 1, -26 },
  { 3408, 8, 25, 9, 1, -25 },
  { 3433, 13, 33, 9, -4, -25 },
  { 3487, 17, 26, 17, 1, -26 },
  { 3543, 8, 26, 9, 1, -26 },
  { 3569, 27, 19, 30, 1, -19 },
  { 3634, 17, 19, 20, 1, -19 },
  { 3675, 16, 18, 19, 2, -18 },
  { 3711, 19, 27, 20, -1, -19 },
  { 3776, 17, 27, 20, 2, -19 },
  { 3834, 14, 19, 14, 1, -19 },
  { 3868, 14, 19, 15, 0, -19 },
  { 3902, 11, 22, 11, 1, -22 },
  { 3933, 17, 18, 20, 2, -18 },
  { 3972, 16, 18, 16, 2, -18 },
  { 4008, 24, 18, 25, 2, -18 },
  { 4062, 18, 18, 16, -1, -18 },
  { 4103, 21, 26, 16, -3, -18 },
  { 4172, 16, 18, 15, -1, -18 },
  { 4208, 14, 29, 12, 0, -24 },
  { 4259, 2, 34, 19, 9, -26 },
  { 4268, 13, 29, 12, -1, -24 },
  { 4316, 16, 4, 19, 2, -14 },
};

const GFXfont NotoSans_Italic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_ITALIC34PT7B_H_
