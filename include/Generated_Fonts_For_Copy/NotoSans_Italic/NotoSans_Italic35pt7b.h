#ifndef _NOTOSANS_ITALIC35PT7B_H_
#define _NOTOSANS_ITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x00, 0x00, 0x00,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x71, 0xDC, 0x77, 0x1D, 0x86, 0xE3,
  0xB8, 0xEE, 0x3B, 0x0C, 0xC3, 0x00, 0x00, 0x70, 0x70, 0x01, 0xC1, 0x80,
  0x06, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x1C, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x18, 0x30,
  0x00, 0xE0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x60, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xE0, 0xC0, 0x03, 0x07,
  0x00, 0x0C, 0x1C, 0x00, 0x70, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x0E, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0xCE, 0x1C, 0xE0, 0x1C, 0x60, 0x0E, 0x30,
  0x07, 0x18, 0x03, 0xCC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x01, 0xDE, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x18, 0xE4,
  0x1C, 0xF3, 0xED, 0xF1, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x1C, 0x7F, 0x80, 0x70, 0xE7,
  0x00, 0xC3, 0x86, 0x03, 0x86, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30,
  0x60, 0x70, 0x61, 0xC0, 0xC1, 0xC7, 0x01, 0x83, 0x9C, 0x03, 0x06, 0x33,
  0xF6, 0x1C, 0xEF, 0xFE, 0x73, 0x9C, 0xFF, 0xEE, 0x70, 0xDF, 0x98, 0xC1,
  0x80, 0x73, 0x83, 0x01, 0xC7, 0x06, 0x03, 0x0C, 0x0C, 0x0E, 0x18, 0x38,
  0x38, 0x30, 0x70, 0xE0, 0x60, 0xC1, 0x80, 0xC3, 0x87, 0x01, 0xCE, 0x1C,
  0x03, 0xFC, 0x70, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3C,
  0x78, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC1, 0xE0, 0x07, 0x8F, 0x00, 0x0E, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7B, 0xC0, 0xF3, 0xC7, 0x83, 0x9E, 0x0E,
  0x1C, 0x70, 0x3C, 0x73, 0x80, 0x7B, 0x8E, 0x00, 0xFC, 0x38, 0x01, 0xF0,
  0xE0, 0x07, 0x83, 0xC0, 0x7F, 0x07, 0xC7, 0xDC, 0x0F, 0xFE, 0x78, 0x1F,
  0xE0, 0xF0, 0x77, 0x76, 0xEE, 0xEC, 0xC0, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0xC1, 0xC0, 0xF1, 0x80, 0xFD, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0x07,
  0x8F, 0x0F, 0xC0, 0x1C, 0xC0, 0x38, 0xE0, 0x70, 0xE0, 0x30, 0xE0, 0x00,
  0x70, 0x00, 0x40, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xE7, 0xC1, 0xC0, 0xE1, 0xC0, 0x71, 0xE0,
  0x3C, 0xE0, 0x1E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xFE,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x07, 0x9C, 0x03, 0x8F, 0x03, 0xC3, 0x83, 0xC1, 0xF3,
  0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0xF8, 0x3F, 0x1F, 0xE7,
  0xDD, 0xE7, 0x18, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7C, 0x7C,
  0x0C, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE3, 0xE0, 0x80, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE4, 0x00,
  0xE3, 0xC3, 0xF1, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x77, 0x00, 0x1E,
  0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x1C, 0x03, 0x83,
  0x80, 0xE0, 0x70, 0x3C, 0x0E, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x08,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x20, 0x07, 0x8F, 0x0F, 0xC3,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFC, 0x20,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x78, 0x1C, 0xFF, 0x0E, 0xFF, 0x87, 0xC1, 0xE3, 0xC0, 0x73, 0xC0,
  0x39, 0xE0, 0x1E, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCF,
  0x01, 0xC3, 0x81, 0xE1, 0xF1, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xE3, 0xC1,
  0xC0, 0xF1, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x0E, 0x07,
  0x07, 0x8F, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xF3, 0xC1, 0xE0,
  0xF0, 0xE0, 0x3C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x01, 0xE7, 0x80, 0xE3, 0xE1, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x0F, 0xFC, 0x1F, 0x1E, 0x1C, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x38,
  0x3F, 0x3F, 0xFF, 0x1F, 0xEE, 0x07, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0xC3, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0x1E, 0x3C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0xF1, 0xE3, 0xC0, 0x03, 0xC0, 0xF0, 0x7C, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x01, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC7, 0xFF, 0x9E,
  0x3C, 0x80, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF1, 0xFC, 0x01,
  0xE0, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x71, 0xC0, 0x7F, 0x06, 0x38, 0x3F, 0xF0, 0xEE, 0x0F, 0x0E, 0x1D, 0xC3,
  0x81, 0x83, 0xB0, 0x60, 0x70, 0x7E, 0x1C, 0x0E, 0x0F, 0xC3, 0x01, 0xC1,
  0xB8, 0xE0, 0x30, 0x37, 0x1C, 0x0E, 0x0E, 0xC3, 0x81, 0xC1, 0xDC, 0x70,
  0x78, 0x73, 0x87, 0x1B, 0x1C, 0x70, 0xFF, 0x7F, 0x8E, 0x0F, 0x87, 0xC0,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x20, 0x03, 0xF0, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1D,
  0x80, 0x01, 0xDC, 0x00, 0x39, 0xC0, 0x07, 0x9C, 0x00, 0x71, 0xC0, 0x0F,
  0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x0E, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1,
  0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0F, 0x78, 0x00, 0x77, 0x00, 0x07,
  0xF0, 0x00, 0x70, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x70,
  0x1E, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0x1C, 0x1E, 0x0F, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xC0, 0xF0, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x00, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xCF, 0x07, 0xC0, 0x21, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xEF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF8, 0x0E, 0x03, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x3C, 0x38, 0x01,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xE7, 0x80, 0x0E,
  0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x70, 0x07, 0x87, 0x80,
  0x7C, 0x38, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x10, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07,
  0xF3, 0xF0, 0xF8, 0x02, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x1F, 0xEE, 0x01, 0xFE, 0xE0, 0x3F, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x03, 0x87, 0x80,
  0x38, 0x3F, 0xBF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x0E,
  0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x01,
  0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC0, 0x07, 0xFC, 0x1F,
  0xF0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x1F,
  0xE0, 0x3F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x3C, 0x1E, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xEE, 0x00, 0x07,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x80,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0xF0,
  0x07, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xDF, 0xFE, 0xFF, 0xF8, 0x03, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x6E, 0x00, 0x77, 0x03, 0x70, 0x03, 0xF0, 0x3B, 0x80, 0x3B, 0x81,
  0xDC, 0x01, 0xDC, 0x0E, 0xE0, 0x1C, 0xE0, 0x73, 0x00, 0xCF, 0x07, 0x18,
  0x0E, 0x70, 0x38, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x1C, 0x0E, 0x38, 0x70,
  0xE0, 0x71, 0xC3, 0x8F, 0x07, 0x0E, 0x38, 0x70, 0x38, 0x71, 0xC3, 0x81,
  0xC1, 0x9C, 0x1C, 0x0E, 0x0C, 0xE0, 0xE0, 0x70, 0x6E, 0x0F, 0x07, 0x03,
  0xE0, 0x70, 0x38, 0x1F, 0x03, 0x81, 0xC0, 0xF0, 0x1C, 0x0E, 0x07, 0x80,
  0xE0, 0xE0, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x07, 0xC0, 0x07, 0x07,
  0xC0, 0x0E, 0x07, 0xC0, 0x0E, 0x06, 0xE0, 0x0E, 0x06, 0xE0, 0x0E, 0x0E,
  0xE0, 0x0E, 0x0E, 0x70, 0x1C, 0x0E, 0x70, 0x1C, 0x0E, 0x38, 0x1C, 0x1C,
  0x38, 0x1C, 0x1C, 0x38, 0x3C, 0x1C, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C,
  0x1C, 0x38, 0x38, 0x0E, 0x38, 0x38, 0x0E, 0x70, 0x38, 0x07, 0x70, 0x38,
  0x07, 0x70, 0x38, 0x07, 0x70, 0x70, 0x03, 0xF0, 0x70, 0x03, 0xE0, 0x70,
  0x03, 0xE0, 0x70, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xFE, 0x01, 0xF9, 0xF8, 0x1E, 0x03, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x3C,
  0xE0, 0x01, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x39, 0xE0, 0x03,
  0xCF, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0xFD, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x81, 0xE0,
  0x70, 0x1E, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1,
  0xC0, 0x38, 0x78, 0x0F, 0x0E, 0x03, 0xC1, 0xC3, 0xF8, 0x3F, 0xFC, 0x07,
  0xFE, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xF9, 0xF8, 0x1E, 0x03,
  0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x3C, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0x70,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0xB8, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x3C, 0x03, 0xC0,
  0xFD, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x81, 0xE0, 0x70, 0x1E,
  0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38,
  0x78, 0x0F, 0x0E, 0x07, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x01,
  0xE1, 0xC0, 0x38, 0x3C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x07,
  0x80, 0xE0, 0xE0, 0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x80,
  0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xF7, 0xE3, 0xC0, 0x21, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC4, 0x01, 0xE3, 0xE7,
  0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38,
  0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C,
  0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00,
  0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC7,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x78, 0x07,
  0x81, 0xF9, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0xFE,
  0x00, 0x1E, 0xF0, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x78,
  0x70, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x0E, 0x07, 0x01, 0xE0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0x38, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x3B,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x7F, 0x00, 0x78, 0x03, 0xB8, 0x03, 0xC0, 0x1D, 0xC0,
  0x3E, 0x01, 0xCE, 0x01, 0xB0, 0x0E, 0x70, 0x1D, 0x80, 0xF3, 0x80, 0xEC,
  0x07, 0x1C, 0x0E, 0x60, 0x78, 0xE0, 0x73, 0x03, 0x87, 0x07, 0x18, 0x1C,
  0x38, 0x38, 0xC1, 0xC1, 0xC3, 0x86, 0x0E, 0x0E, 0x1C, 0x38, 0xE0, 0x71,
  0xC1, 0xC7, 0x03, 0x8E, 0x0E, 0x70, 0x1C, 0x60, 0x73, 0x80, 0xE7, 0x03,
  0x9C, 0x07, 0x30, 0x1D, 0xC0, 0x1B, 0x80, 0xEE, 0x00, 0xDC, 0x07, 0xE0,
  0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x0F,
  0x00, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1E, 0x07, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x80, 0x00, 0x6E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xCF, 0x00, 0x07, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x3C, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x03, 0xDC, 0x00, 0xE7,
  0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0xE0,
  0xE0, 0x38, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0xE3, 0x8E,
  0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xE3, 0x8E, 0x38, 0xE1,
  0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x03, 0x70, 0x01,
  0xCC, 0x00, 0x63, 0x80, 0x38, 0x60, 0x0C, 0x1C, 0x07, 0x03, 0x01, 0x80,
  0xE0, 0xE0, 0x1C, 0x30, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC7, 0x0E, 0x18, 0x30, 0x03,
  0xE1, 0x87, 0xFD, 0xC7, 0xFE, 0xE7, 0xC1, 0xF3, 0x80, 0xF3, 0xC0, 0x39,
  0xC0, 0x1D, 0xE0, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03,
  0xCE, 0x01, 0xE7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0xF8, 0xF1, 0xDC, 0x3F,
  0xCE, 0x0F, 0xC6, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x3E,
  0x03, 0xBF, 0xC1, 0xDF, 0xF8, 0x7E, 0x0E, 0x1F, 0x03, 0x87, 0x80, 0xF1,
  0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x0E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x6E, 0x3C,
  0x3B, 0xFE, 0x0E, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFB, 0xCF, 0x80,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x61, 0xFF,
  0x81, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xE3,
  0x81, 0xFF, 0x70, 0x7F, 0xEE, 0x1E, 0x07, 0xC3, 0x80, 0xF0, 0xF0, 0x0E,
  0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x78, 0x38, 0x0F, 0x07, 0x03, 0xE0,
  0xF1, 0xDC, 0x0F, 0xF3, 0x80, 0xFC, 0x60, 0x00, 0x03, 0xF0, 0x3F, 0xE1,
  0xF7, 0xCF, 0x07, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xFC, 0x1E, 0xFF, 0xF3,
  0xFF, 0x8F, 0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x04,
  0x78, 0x71, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0xD0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x9E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0xC1, 0xFF, 0x70, 0xFF, 0xDC, 0x78, 0x1F, 0x1C, 0x07, 0x8F, 0x00, 0xE3,
  0x80, 0x39, 0xE0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x3C, 0x70, 0x0F, 0x1C, 0x07, 0x87, 0x01, 0xE1, 0xC0, 0xF8, 0x78, 0xEE,
  0x0F, 0xF3, 0x81, 0xF9, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x82, 0x01, 0xE0, 0xE0, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x3E, 0x07, 0x7F, 0x87, 0x7F, 0xE3, 0xF0,
  0x71, 0xF0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C,
  0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x80, 0x03, 0x07, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x13, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x07, 0x87, 0x07, 0x87, 0x83, 0x83, 0x83, 0x81, 0xC3, 0x80, 0xE3,
  0x80, 0x73, 0x80, 0x73, 0x80, 0x3B, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0x1C, 0x07, 0x0E, 0x03, 0x87, 0x81, 0xC1, 0xC0, 0xE0, 0xF0, 0xF0, 0x38,
  0x70, 0x1E, 0x38, 0x07, 0x00, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x00,
  0x0C, 0x3E, 0x0F, 0xC0, 0xCF, 0xF1, 0xFE, 0x1D, 0xFF, 0x3F, 0xE1, 0xF8,
  0x77, 0x0F, 0x1F, 0x03, 0xC0, 0x71, 0xE0, 0x3C, 0x07, 0x1C, 0x07, 0x80,
  0xF3, 0xC0, 0x78, 0x0E, 0x38, 0x07, 0x00, 0xE3, 0x80, 0x70, 0x0E, 0x38,
  0x07, 0x00, 0xE3, 0x80, 0xF0, 0x1C, 0x70, 0x0E, 0x01, 0xC7, 0x00, 0xE0,
  0x1C, 0x70, 0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x3C, 0x70, 0x1C, 0x03, 0x8E,
  0x01, 0xC0, 0x38, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x3E, 0x06, 0x7F, 0xC7,
  0x7F, 0xE3, 0xF0, 0x71, 0xF0, 0x38, 0xF0, 0x1C, 0xF0, 0x0E, 0x78, 0x07,
  0x3C, 0x07, 0x9C, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0x73, 0x80,
  0x79, 0xC0, 0x3C, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x80,
  0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C, 0x0E, 0x38, 0x0F, 0x70, 0x07,
  0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xF0, 0x3C, 0x7C, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x03, 0x0F, 0x80, 0x33, 0xFC, 0x07, 0x7F, 0xE0, 0x7E, 0x0E,
  0x07, 0xC0, 0xE0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1C, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x1B, 0x8F, 0x03, 0xBF, 0xE0, 0x38,
  0xFC, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE1,
  0x87, 0xFD, 0xC7, 0xFE, 0xE7, 0x81, 0xF3, 0x80, 0xF3, 0xC0, 0x79, 0xC0,
  0x1D, 0xE0, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE,
  0x01, 0xE7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0xF8, 0xF1, 0xDC, 0x3F, 0xCE,
  0x0F, 0xCE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0C, 0x3C, 0x33, 0xF1,
  0xDF, 0x87, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7,
  0x01, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0xA0, 0x1C, 0xE1, 0xF3,
  0xFF, 0x87, 0xFC, 0x00, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x07, 0xFF, 0xFF,
  0xBF, 0xF1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x11, 0xFC, 0x1F, 0x80,
  0x1C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0,
  0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x9C,
  0x01, 0xCE, 0x01, 0xE7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0xF8, 0xF1, 0xDC,
  0x3F, 0xCE, 0x0F, 0xC6, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0x60, 0x70, 0x70, 0xF0, 0x70,
  0xE0, 0x71, 0xC0, 0x71, 0xC0, 0x73, 0x80, 0x73, 0x80, 0x77, 0x00, 0x77,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xE0, 0x3C, 0x07, 0xF0, 0x1E,
  0x03, 0xB8, 0x1F, 0x03, 0xDC, 0x0D, 0x81, 0xCE, 0x0E, 0xC1, 0xE7, 0x07,
  0x60, 0xE3, 0x83, 0x30, 0x71, 0xC3, 0x98, 0x70, 0xE1, 0x8C, 0x38, 0x71,
  0xC6, 0x38, 0x38, 0xC3, 0x1C, 0x1C, 0xE1, 0x9C, 0x06, 0x60, 0xCE, 0x03,
  0x70, 0x67, 0x01, 0xB8, 0x37, 0x00, 0xD8, 0x1B, 0x80, 0x7C, 0x0F, 0x80,
  0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xE1, 0xC0, 0x78,
  0x1C, 0x1E, 0x03, 0x83, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0x6F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0x77, 0x00, 0x1E, 0x70, 0x07, 0x8E, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x0E,
  0x01, 0xC3, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x38, 0x38, 0x03, 0x81, 0xC0,
  0x1C, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x0E, 0x0F, 0x00,
  0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0xBC, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0x80, 0x3E, 0x01, 0xF8, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x0F, 0x80, 0x78, 0x02, 0x00, 0x00, 0x1C, 0x00, 0xBF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xF8, 0x03, 0xE0,
};

const GFXglyph NotoSans_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 25, 9, 1, -25 },
  { 30, 10, 9, 14, 4, -25 },
  { 42, 22, 25, 23, 1, -25 },
  { 111, 17, 29, 19, 1, -27 },
  { 173, 23, 25, 28, 3, -25 },
  { 245, 22, 25, 24, 1, -25 },
  { 314, 4, 9, 8, 4, -25 },
  { 319, 12, 31, 10, 1, -25 },
  { 366, 12, 31, 10, -3, -25 },
  { 413, 16, 17, 19, 4, -27 },
  { 447, 17, 17, 20, 2, -21 },
  { 484, 7, 9, 9, -2, -4 },
  { 492, 9, 3, 11, 1, -11 },
  { 496, 4, 4, 9, 1, -4 },
  { 498, 17, 25, 12, -2, -25 },
  { 552, 17, 25, 19, 2, -25 },
  { 606, 11, 25, 19, 5, -25 },
  { 641, 18, 25, 19, 0, -25 },
  { 698, 17, 25, 19, 1, -25 },
  { 752, 19, 25, 19, 0, -25 },
  { 812, 18, 25, 19, 1, -25 },
  { 869, 17, 25, 19, 2, -25 },
  { 923, 17, 25, 19, 3, -25 },
  { 977, 17, 25, 19, 2, -25 },
  { 1031, 16, 25, 19, 2, -25 },
  { 1081, 7, 19, 9, 1, -19 },
  { 1098, 10, 24, 9, -2, -19 },
  { 1128, 17, 17, 20, 2, -21 },
  { 1165, 16, 9, 20, 3, -17 },
  { 1183, 17, 17, 20, 2, -21 },
  { 1220, 13, 25, 15, 3, -25 },
  { 1261, 27, 28, 30, 2, -25 },
  { 1356, 20, 25, 20, -2, -25 },
  { 1419, 20, 25, 21, 1, -25 },
  { 1482, 19, 25, 21, 3, -25 },
  { 1542, 21, 25, 23, 1, -25 },
  { 1608, 18, 25, 18, 1, -25 },
  { 1665, 18, 25, 17, 1, -25 },
  { 1722, 20, 25, 24, 3, -25 },
  { 1785, 23, 25, 24, 1, -25 },
  { 1857, 14, 25, 11, -1, -25 },
  { 1901, 15, 32, 10, -5, -25 },
  { 1961, 22, 25, 20, 1, -25 },
  { 2030, 14, 25, 17, 1, -25 },
  { 2074, 29, 25, 29, 1, -25 },
  { 2165, 24, 25, 25, 1, -25 },
  { 2240, 21, 25, 25, 3, -25 },
  { 2306, 19, 25, 20, 1, -25 },
  { 2366, 21, 31, 25, 3, -25 },
  { 2448, 19, 25, 20, 1, -25 },
  { 2508, 17, 25, 18, 1, -25 },
  { 2562, 18, 25, 18, 3, -25 },
  { 2619, 21, 25, 24, 3, -25 },
  { 2685, 20, 25, 19, 3, -25 },
  { 2748, 29, 25, 30, 4, -25 },
  { 2839, 23, 25, 18, -2, -25 },
  { 2911, 18, 25, 18, 3, -25 },
  { 2968, 20, 25, 19, 0, -25 },
  { 3031, 13, 31, 10, 0, -25 },
  { 3082, 6, 25, 12, 4, -25 },
  { 3101, 14, 31, 10, -3, -25 },
  { 3156, 18, 16, 20, 1, -25 },
  { 3192, 14, 3, 14, -3, 3 },
  { 3198, 6, 6, 10, 5, -27 },
  { 3203, 17, 19, 20, 2, -19 },
  { 3244, 18, 27, 20, 1, -27 },
  { 3305, 14, 19, 16, 2, -19 },
  { 3339, 19, 27, 20, 2, -27 },
  { 3404, 14, 19, 17, 2, -19 },
  { 3438, 20, 35, 11, -4, -27 },
  { 3526, 18, 27, 20, 1, -19 },
  { 3587, 17, 27, 20, 1, -27 },
  { 3645, 8, 26, 9, 1, -26 },
  { 3671, 13, 34, 9, -4, -26 },
  { 3727, 17, 27, 17, 1, -27 },
  { 3785, 9, 27, 9, 1, -27 },
  { 3816, 28, 19, 31, 1, -19 },
  { 3883, 17, 19, 20, 1, -19 },
  { 3924, 16, 19, 20, 2, -19 },
  { 3962, 20, 27, 20, -1, -19 },
  { 4030, 17, 27, 20, 2, -19 },
  { 4088, 14, 19, 14, 1, -19 },
  { 4122, 14, 19, 15, 0, -19 },
  { 4156, 11, 23, 12, 2, -23 },
  { 4188, 17, 19, 20, 2, -19 },
  { 4229, 16, 19, 16, 2, -19 },
  { 4267, 25, 19, 25, 2, -19 },
  { 4327, 19, 19, 17, -1, -19 },
  { 4373, 21, 27, 16, -3, -19 },
  { 4444, 16, 19, 16, -1, -19 },
  { 4482, 14, 31, 12, 0, -25 },
  { 4537, 3, 35, 19, 9, -27 },
  { 4551, 13, 31, 12, -1, -25 },
  { 4602, 17, 5, 20, 2, -15 },
};

const GFXfont NotoSans_Italic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_ITALIC35PT7B_H_
