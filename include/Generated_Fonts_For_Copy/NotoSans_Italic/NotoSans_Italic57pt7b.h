#ifndef _NOTOSANS_ITALIC57PT7B_H_
#define _NOTOSANS_ITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x3F, 0x0F, 0x9F, 0x07,
  0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x07, 0x87, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0x9E, 0x1E, 0x03, 0xE1, 0xE0, 0x40, 0x7C, 0x1E, 0x00, 0x07, 0xC1,
  0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x38, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF7, 0xF0, 0x00,
  0x0E, 0x3F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x3C, 0x1F, 0x00,
  0x03, 0xC3, 0xF0, 0xC0, 0x3C, 0x7E, 0x0F, 0xC3, 0x9F, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0x80, 0xFF, 0xF0, 0x00, 0x3C, 0x07,
  0xFF, 0xC0, 0x01, 0xF0, 0x1E, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0x81, 0xE0, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0x1F, 0x0F, 0x0F, 0xC3, 0xC0, 0x78, 0x78, 0xFF, 0xCF, 0x03,
  0xE3, 0xE7, 0xFF, 0xBC, 0x0F, 0x1F, 0x3F, 0xFE, 0xF0, 0x7C, 0x78, 0xF8,
  0x7F, 0xFF, 0xE3, 0xC7, 0xC1, 0xF7, 0xFF, 0x1F, 0x1E, 0x03, 0xCF, 0xF8,
  0xF8, 0xF8, 0x0F, 0x1F, 0xC3, 0xC3, 0xC0, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0xF0, 0x00, 0xF8, 0x7C, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x7C, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x3E, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x78,
  0x07, 0x80, 0x07, 0x83, 0xE0, 0x3C, 0x00, 0x1F, 0x1F, 0x01, 0xF0, 0x00,
  0x3F, 0xF8, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x03,
  0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x1F,
  0x80, 0x3E, 0x3F, 0x01, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x01, 0xF1, 0xF0,
  0x03, 0xF0, 0x7C, 0x7E, 0x00, 0x3F, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE1,
  0xF0, 0x00, 0x7E, 0xF8, 0x3E, 0x00, 0x07, 0xFF, 0x07, 0xC0, 0x00, 0x7F,
  0xC0, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0xC0, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0x03, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x10, 0x03, 0xC0, 0x07,
  0x00, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xFF, 0x0E, 0x00, 0x3F, 0xF3, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xE7, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x03, 0xC0,
  0x0F, 0x80, 0xF8, 0x01, 0xC0, 0x3E, 0x00, 0x30, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xC0, 0x3C, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00,
  0x07, 0xC7, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xBE, 0xFF, 0x1F, 0x3F, 0x1F,
  0x1E, 0x0F, 0x86, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0x03, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x0F, 0xC0, 0x08, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x00,
  0x78, 0x01, 0xF8, 0x03, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x20, 0x00, 0x07, 0xE1,
  0x80, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x38, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x20, 0x00, 0x0F, 0xC1,
  0x80, 0x00, 0xFC, 0x0F, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0A, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xF8, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x18, 0x00, 0x3E, 0x3F, 0xF0, 0x0F,
  0x8F, 0xFF, 0x01, 0xF7, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0x07, 0xFC, 0x07,
  0xF1, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xF1, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x03, 0xFC, 0x3F, 0xC3, 0xEF,
  0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x7C, 0x03, 0xFF, 0x8F, 0x80, 0x1F,
  0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x08,
  0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0x40, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0x03, 0xF8, 0x60, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x04, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0xFE, 0x01, 0xE1, 0xF0, 0x03,
  0xFF, 0xF8, 0x1F, 0x1E, 0x00, 0xFF, 0xFF, 0x81, 0xF3, 0xE0, 0x1F, 0xC1,
  0xF0, 0x0F, 0x3C, 0x03, 0xF0, 0x0F, 0x00, 0xF3, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0xF7, 0x80, 0xF8, 0x01, 0xE0, 0x0F,
  0x78, 0x0F, 0x00, 0x1E, 0x01, 0xF7, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0xF8,
  0x1F, 0x00, 0x3C, 0x01, 0xEF, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0xF0, 0x1E,
  0x00, 0x7C, 0x01, 0xEF, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0xF0, 0x1E, 0x00,
  0x78, 0x03, 0xCF, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0xF0, 0x1E, 0x01, 0xF8,
  0x07, 0x8F, 0x01, 0xE0, 0x1F, 0x80, 0xF8, 0xF8, 0x1F, 0x07, 0xBC, 0x1F,
  0x0F, 0x80, 0xFF, 0xF3, 0xFF, 0xE0, 0x78, 0x0F, 0xFE, 0x1F, 0xFC, 0x07,
  0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x78, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x03,
  0xE0, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x0F, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7E, 0x00,
  0xFF, 0x00, 0x0C, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x80, 0x1F, 0xF0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3E, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF8, 0x0F,
  0x80, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x7C, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xC0, 0x1F, 0xC0, 0x00, 0x10,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x3F,
  0x00, 0x0F, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xF8,
  0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xC0, 0x00, 0x03, 0xFC, 0xF8, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x00, 0x0F, 0xBE, 0x01,
  0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x1E,
  0x78, 0x00, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x00, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x00, 0x1E, 0x3E, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xC0,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xC0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0xFC, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x80, 0x3C, 0x07, 0x81, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x78, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xE1, 0xF0, 0x1F, 0x00,
  0x7C, 0x07, 0xCF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x7D, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF7, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x3F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xE0,
  0x00, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x00, 0x7C,
  0x01, 0xFF, 0x80, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x01, 0xF0, 0x07, 0x9F,
  0x00, 0x03, 0xC0, 0x0F, 0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x1F,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x01, 0xE0,
  0xF8, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x1E,
  0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x00, 0x78,
  0x7C, 0x01, 0xF0, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x01, 0xF1, 0xE0, 0x0F,
  0x80, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0x07,
  0xDF, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00,
  0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xFC,
  0x07, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xE0, 0x7C,
  0x00, 0x7F, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0x00, 0xFC, 0x00, 0x70, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0x80, 0x01, 0xFC, 0x0F,
  0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3D,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x79,
  0xE0, 0x03, 0xF0, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF9,
  0xE0, 0x07, 0xE0, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF1,
  0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE1,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC1, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC1,
  0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x81, 0xE0, 0x3F, 0x00, 0x7C, 0x0F, 0x81,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x00, 0x7C, 0x1F, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x01,
  0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00,
  0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0xF7, 0xC0, 0x00, 0x7D, 0xE0, 0x00,
  0xF7, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x3E, 0x3C, 0x00,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF0, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0x80, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3C, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x03, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F,
  0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x1F,
  0xC0, 0x70, 0x07, 0xFF, 0x0F, 0x01, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0x9F,
  0x07, 0xF8, 0x7D, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x00, 0xFE, 0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x01,
  0xFE, 0x0F, 0xC0, 0x3D, 0xE0, 0x7E, 0x07, 0xBE, 0x07, 0xFF, 0xF3, 0xE0,
  0x3F, 0xFE, 0x3C, 0x01, 0xFF, 0xC3, 0xC0, 0x0F, 0xF8, 0x3C, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x1F, 0xF8, 0x03, 0xE7, 0xFF, 0xC0, 0x7C, 0xFF, 0xFE, 0x07, 0xDF,
  0x0F, 0xE0, 0x7F, 0xC0, 0x3E, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0x0F, 0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87,
  0xF0, 0x03, 0xF0, 0x7B, 0x80, 0xFE, 0x0F, 0xBF, 0xFF, 0xC0, 0xF1, 0xFF,
  0xF8, 0x0F, 0x0F, 0xFF, 0x00, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0x81, 0xC1, 0xFC, 0x00, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x03, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x1F, 0x00, 0x0F,
  0xFE, 0x3E, 0x00, 0x7F, 0xFE, 0x7C, 0x01, 0xFF, 0xFC, 0xF8, 0x07, 0xF8,
  0x7D, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xFC, 0x07,
  0xC0, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0xC0, 0x1F,
  0x81, 0xEF, 0x80, 0x3F, 0xFF, 0x9F, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x3F,
  0xF8, 0x78, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C,
  0x01, 0xFC, 0x7C, 0x3F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x10, 0x7F, 0x00, 0x70, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1C,
  0x00, 0x7F, 0xF0, 0xF0, 0x07, 0xFF, 0xE3, 0xC0, 0x3F, 0xFF, 0xDF, 0x01,
  0xFE, 0x0F, 0x7C, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0x80,
  0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0x80, 0xFC, 0x03, 0xFE, 0x01, 0xF8, 0x1E,
  0xF8, 0x07, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0x8F, 0x00, 0x1F, 0xFC, 0x7C,
  0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x08, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x08, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x1F, 0xF8, 0x03, 0xC7,
  0xFF, 0xC0, 0x7C, 0xFF, 0xFE, 0x07, 0xDF, 0x87, 0xE0, 0x7F, 0xC0, 0x3F,
  0x07, 0xF8, 0x01, 0xF0, 0x7F, 0x00, 0x1F, 0x0F, 0xE0, 0x01, 0xF0, 0xFE,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7C,
  0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F,
  0x3F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0x8F, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0xFE, 0x00, 0x3F, 0x80, 0x1E, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xF1, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0x9F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7D, 0xF0, 0xFC,
  0xFC, 0x3F, 0x03, 0xFE, 0x03, 0xE7, 0x80, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xF8, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0x0F, 0x0F, 0xFF,
  0x00, 0xF8, 0xFF, 0xFC, 0x07, 0xCF, 0xFF, 0xE0, 0x3E, 0xFC, 0x7F, 0x81,
  0xFF, 0x80, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0x1F, 0x07, 0xF8,
  0x00, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xF8, 0x7F, 0x03, 0xF8, 0x07, 0xE1, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xF0,
  0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0xF0, 0x7F, 0xE0, 0x01,
  0xE3, 0xFF, 0xE0, 0x07, 0xCF, 0xFF, 0xE0, 0x0F, 0xBE, 0x1F, 0xC0, 0x1F,
  0xF0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x01, 0xFC,
  0x00, 0x3E, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3D, 0xC0, 0x7F, 0x00,
  0xFB, 0xFF, 0xFC, 0x01, 0xF3, 0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xC0, 0x07,
  0xC3, 0xFE, 0x00, 0x0F, 0x80, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x70, 0x07, 0xFF, 0x0F, 0x01, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0xDF,
  0x07, 0xF8, 0x7D, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xF0, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x01,
  0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0x7E, 0x07, 0xBE, 0x07, 0xFF, 0xF3, 0xE0,
  0x3F, 0xFE, 0x3C, 0x01, 0xFF, 0xC7, 0xC0, 0x0F, 0xF0, 0x7C, 0x00, 0x08,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0xFC, 0x0F, 0x0F, 0xF0, 0x3C, 0x7F, 0xC1, 0xF3, 0xFF, 0x07,
  0xDF, 0xD8, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0x03, 0xC1, 0xF8, 0x00, 0x83, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF1, 0x00, 0x07, 0xE3, 0x80, 0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x10, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0x0F, 0x80,
  0x0F, 0xE0, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x07, 0xBE,
  0x07, 0xFF, 0xF3, 0xE0, 0x7F, 0xFE, 0x3C, 0x03, 0xFF, 0xC3, 0xC0, 0x1F,
  0xF0, 0x3C, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xCF, 0x80, 0x03, 0xE1, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x0F,
  0xC0, 0x0F, 0x03, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0xFE,
  0x00, 0x3E, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xFE, 0x00, 0x7E,
  0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x78, 0x01, 0xFE, 0x00, 0xFC, 0x78, 0x03,
  0xDE, 0x00, 0xF8, 0x78, 0x03, 0xDE, 0x01, 0xF8, 0x78, 0x07, 0x9E, 0x01,
  0xF0, 0x78, 0x07, 0x9E, 0x01, 0xF0, 0x78, 0x0F, 0x9E, 0x03, 0xE0, 0x78,
  0x0F, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x1F,
  0x07, 0xC0, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x1F, 0x0F, 0x80,
  0x7C, 0x7C, 0x1F, 0x1F, 0x80, 0x7C, 0x78, 0x0F, 0x1F, 0x00, 0x7C, 0xF8,
  0x0F, 0x1F, 0x00, 0x7C, 0xF0, 0x0F, 0x3E, 0x00, 0x7C, 0xF0, 0x0F, 0x3E,
  0x00, 0x7D, 0xE0, 0x0F, 0x7C, 0x00, 0x7D, 0xE0, 0x0F, 0x7C, 0x00, 0x7F,
  0xC0, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF0,
  0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x27, 0xFF, 0x00, 0x0D, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xA0, 0x00, 0xFF, 0xC4, 0x00, 0x00, 0xC0,
};

const GFXglyph NotoSans_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 42, 15, 1, -41 },
  { 80, 17, 15, 22, 6, -41 },
  { 112, 35, 41, 37, 2, -41 },
  { 292, 28, 46, 31, 2, -43 },
  { 453, 38, 42, 46, 5, -41 },
  { 653, 35, 42, 38, 2, -41 },
  { 837, 8, 15, 13, 6, -41 },
  { 852, 19, 50, 17, 2, -41 },
  { 971, 18, 50, 17, -4, -41 },
  { 1084, 26, 26, 31, 6, -43 },
  { 1169, 27, 28, 33, 4, -34 },
  { 1264, 11, 14, 15, -2, -7 },
  { 1284, 15, 5, 18, 1, -18 },
  { 1294, 7, 8, 15, 1, -7 },
  { 1301, 28, 41, 20, -3, -41 },
  { 1445, 27, 42, 31, 3, -41 },
  { 1587, 17, 41, 31, 8, -41 },
  { 1675, 30, 41, 31, 0, -41 },
  { 1829, 29, 42, 31, 1, -41 },
  { 1982, 31, 41, 31, 0, -41 },
  { 2141, 29, 42, 31, 2, -41 },
  { 2294, 27, 42, 31, 4, -41 },
  { 2436, 27, 41, 31, 5, -41 },
  { 2575, 28, 42, 31, 3, -41 },
  { 2722, 27, 42, 31, 3, -41 },
  { 2864, 12, 32, 15, 1, -31 },
  { 2912, 16, 38, 15, -3, -31 },
  { 2988, 27, 28, 33, 4, -35 },
  { 3083, 26, 16, 33, 4, -28 },
  { 3135, 27, 28, 33, 4, -35 },
  { 3230, 22, 42, 25, 4, -41 },
  { 3346, 44, 46, 48, 3, -41 },
  { 3599, 32, 41, 32, -3, -41 },
  { 3763, 32, 41, 34, 2, -41 },
  { 3927, 32, 42, 33, 4, -41 },
  { 4095, 34, 41, 38, 2, -41 },
  { 4270, 30, 41, 29, 2, -41 },
  { 4424, 30, 41, 27, 2, -41 },
  { 4578, 34, 42, 39, 4, -41 },
  { 4757, 37, 41, 39, 2, -41 },
  { 4947, 23, 41, 18, -1, -41 },
  { 5065, 25, 52, 16, -9, -41 },
  { 5228, 35, 41, 32, 2, -41 },
  { 5408, 22, 41, 27, 2, -41 },
  { 5521, 46, 41, 48, 2, -41 },
  { 5757, 39, 41, 40, 2, -41 },
  { 5957, 35, 42, 41, 4, -41 },
  { 6141, 30, 41, 32, 2, -41 },
  { 6295, 35, 51, 41, 4, -41 },
  { 6519, 30, 41, 33, 2, -41 },
  { 6673, 29, 42, 29, 1, -41 },
  { 6826, 29, 41, 29, 5, -41 },
  { 6975, 35, 42, 39, 4, -41 },
  { 7159, 32, 41, 31, 5, -41 },
  { 7323, 48, 41, 49, 6, -41 },
  { 7569, 38, 41, 30, -3, -41 },
  { 7764, 29, 41, 29, 5, -41 },
  { 7913, 34, 41, 30, -1, -41 },
  { 8088, 22, 50, 17, -1, -41 },
  { 8226, 11, 41, 20, 6, -41 },
  { 8283, 21, 50, 17, -4, -41 },
  { 8415, 28, 26, 33, 2, -41 },
  { 8506, 23, 4, 23, -5, 5 },
  { 8518, 10, 9, 16, 8, -44 },
  { 8530, 28, 32, 32, 3, -31 },
  { 8642, 28, 44, 33, 2, -43 },
  { 8796, 23, 32, 26, 3, -31 },
  { 8888, 31, 44, 33, 3, -43 },
  { 9059, 24, 32, 28, 3, -31 },
  { 9155, 31, 58, 18, -6, -44 },
  { 9380, 30, 45, 33, 1, -31 },
  { 9549, 28, 43, 33, 2, -43 },
  { 9700, 13, 42, 15, 2, -42 },
  { 9769, 22, 56, 15, -7, -42 },
  { 9923, 28, 43, 28, 2, -43 },
  { 10074, 14, 43, 15, 2, -43 },
  { 10150, 45, 31, 50, 2, -31 },
  { 10325, 29, 31, 33, 1, -31 },
  { 10438, 26, 31, 32, 3, -31 },
  { 10539, 31, 45, 33, -1, -31 },
  { 10714, 28, 45, 33, 3, -31 },
  { 10872, 22, 31, 23, 2, -31 },
  { 10958, 23, 32, 25, 0, -31 },
  { 11050, 18, 39, 19, 3, -38 },
  { 11138, 28, 32, 33, 3, -31 },
  { 11250, 26, 31, 27, 3, -31 },
  { 11351, 40, 31, 41, 3, -31 },
  { 11506, 31, 31, 28, -2, -31 },
  { 11627, 34, 45, 27, -5, -31 },
  { 11819, 26, 31, 25, -1, -31 },
  { 11920, 22, 50, 20, 1, -41 },
  { 12058, 4, 57, 31, 15, -43 },
  { 12087, 22, 50, 20, -2, -41 },
  { 12225, 27, 8, 33, 4, -24 },
};

const GFXfont NotoSans_Italic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_ITALIC57PT7B_H_
