#ifndef _NOTOSANS_ITALIC19PT7B_H_
#define _NOTOSANS_ITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x21, 0x10, 0x06, 0x70, 0x6D, 0x3C,
  0xB2, 0x98, 0x04, 0x41, 0x88, 0x23, 0x04, 0x47, 0xFE, 0xFF, 0xC4, 0x40,
  0x88, 0x33, 0x1F, 0xF8, 0x88, 0x11, 0x06, 0x60, 0x88, 0x00, 0x06, 0x07,
  0x8F, 0xEC, 0x86, 0xC3, 0x40, 0xE0, 0x1C, 0x0B, 0x0D, 0x84, 0xDA, 0xCF,
  0xC0, 0x80, 0xC0, 0x30, 0x37, 0x86, 0xC8, 0x48, 0x88, 0x89, 0x88, 0xB0,
  0x9A, 0xFF, 0x59, 0x6D, 0x11, 0x91, 0x11, 0x12, 0x33, 0x61, 0x2C, 0x1C,
  0x0E, 0x03, 0xF0, 0xC6, 0x18, 0xC3, 0x18, 0x2E, 0x07, 0x03, 0xE0, 0xC4,
  0x78, 0xCA, 0x0F, 0x40, 0xCC, 0x78, 0xF9, 0xC0, 0x6B, 0x68, 0x0C, 0x61,
  0x0C, 0x61, 0x84, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x0C, 0x30, 0x40, 0x10,
  0x60, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x10, 0xC6, 0x10, 0xC0,
  0x08, 0x06, 0x22, 0x1D, 0x03, 0xF8, 0xCC, 0xB0, 0xC8, 0x46, 0x00, 0x08,
  0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x36, 0x6C,
  0x7F, 0xC0, 0x7C, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x00, 0x0E, 0x0F, 0x8C, 0x6C, 0x36,
  0x1A, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xB0, 0xD8, 0x66, 0x63, 0xE0, 0x09,
  0xDF, 0xB1, 0x88, 0xC6, 0x31, 0x08, 0xC6, 0x30, 0x07, 0x07, 0xE1, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xFF,
  0xBF, 0xE0, 0x07, 0x07, 0xE1, 0x0C, 0x03, 0x00, 0xC0, 0x61, 0xF0, 0x7C,
  0x01, 0x80, 0x60, 0x18, 0x06, 0xC3, 0x1F, 0x80, 0x00, 0xC0, 0x70, 0x3C,
  0x1A, 0x04, 0x82, 0x61, 0x98, 0xC4, 0x61, 0x3F, 0xFF, 0xFC, 0x0C, 0x02,
  0x01, 0x80, 0x1F, 0x8F, 0xCC, 0x06, 0x02, 0x03, 0x01, 0xF8, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x68, 0x67, 0xE0, 0x03, 0x87, 0xC6, 0x06, 0x06, 0x03,
  0x21, 0x7D, 0xC6, 0xC1, 0xE0, 0xB0, 0x58, 0x66, 0x61, 0xE0, 0xFF, 0xFF,
  0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C,
  0x06, 0x00, 0x0F, 0x0F, 0xCC, 0x64, 0x13, 0x19, 0x98, 0x78, 0x7C, 0x63,
  0x61, 0xB0, 0x58, 0x6E, 0x73, 0xF0, 0x0E, 0x1F, 0x98, 0x6C, 0x34, 0x1A,
  0x0D, 0x86, 0xEF, 0x3D, 0x01, 0x80, 0xC0, 0xC8, 0xC7, 0xC0, 0x33, 0x00,
  0x00, 0x00, 0x6E, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x19, 0x80, 0x00,
  0x80, 0xC1, 0xC3, 0x87, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x40, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x1C, 0x78, 0xE0, 0x40, 0x00, 0x1C, 0x7E, 0x03, 0x03, 0x02, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x00, 0x00, 0x60, 0xE0, 0x00, 0xC0, 0x0F, 0xF0, 0x60,
  0x31, 0x80, 0x26, 0x1C, 0x48, 0xCC, 0xF3, 0x11, 0xE4, 0x23, 0x88, 0xC5,
  0x11, 0x9B, 0x25, 0x26, 0x73, 0x84, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x07,
  0x80, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x40, 0x6C, 0x09, 0x83, 0x30, 0xC6,
  0x1F, 0xC7, 0xF8, 0xC1, 0x30, 0x26, 0x07, 0x80, 0xC0, 0x1E, 0x0F, 0xE3,
  0x0C, 0xC3, 0x20, 0xC8, 0x37, 0xF1, 0xFC, 0x61, 0x90, 0x24, 0x1B, 0x06,
  0xC7, 0x3F, 0x80, 0x03, 0xC1, 0xFC, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x07, 0x18, 0x3F, 0x00, 0x1E,
  0x07, 0xF0, 0xC3, 0x18, 0x32, 0x06, 0x40, 0xD8, 0x1B, 0x03, 0x60, 0x68,
  0x19, 0x03, 0x60, 0xCC, 0xF1, 0xF8, 0x00, 0x1F, 0xCF, 0xE3, 0x00, 0xC0,
  0x20, 0x08, 0x07, 0xF1, 0xFC, 0x60, 0x10, 0x04, 0x03, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0xCF, 0xE3, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0xFC, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0xFF, 0x18, 0x23,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x3E, 0xC0, 0x6C, 0x04, 0x40, 0xC6,
  0x0C, 0x71, 0xC1, 0xF8, 0x10, 0x33, 0x03, 0x30, 0x33, 0x02, 0x20, 0x62,
  0x06, 0x7F, 0xE7, 0xFE, 0x60, 0x44, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0x8C,
  0x18, 0x3E, 0x3C, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x06,
  0x1F, 0x00, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0xF0, 0xE0, 0x10, 0x66, 0x18, 0xC6,
  0x19, 0x82, 0x60, 0x58, 0x1F, 0x03, 0xE0, 0x64, 0x08, 0xC1, 0x18, 0x61,
  0x8C, 0x31, 0x83, 0x00, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60,
  0x81, 0x06, 0x0F, 0xFF, 0xC0, 0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0,
  0xA2, 0x83, 0x45, 0x85, 0x9B, 0x1B, 0x36, 0x26, 0x64, 0xC8, 0x89, 0x31,
  0x14, 0x66, 0x38, 0xCC, 0x61, 0x90, 0xC2, 0x00, 0x10, 0x19, 0xC0, 0x8E,
  0x0C, 0x58, 0x62, 0xC3, 0x12, 0x11, 0x98, 0x8C, 0xCC, 0x62, 0x62, 0x1B,
  0x10, 0x51, 0x83, 0x8C, 0x1C, 0x40, 0x60, 0x07, 0x81, 0xFE, 0x38, 0x63,
  0x03, 0x60, 0x36, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0x40, 0x66,
  0x0C, 0x71, 0xC1, 0xF0, 0x1E, 0x0F, 0xE3, 0x0C, 0xC3, 0x20, 0xC8, 0x36,
  0x19, 0xFC, 0x7C, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x81,
  0xFE, 0x38, 0x63, 0x03, 0x60, 0x36, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C,
  0x02, 0x40, 0x66, 0x0C, 0x71, 0xC1, 0xF0, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x1E, 0x0F, 0xE3, 0x0C, 0xC3, 0x20, 0xC8, 0x36, 0x19, 0xFC, 0x66, 0x11,
  0x84, 0x23, 0x0C, 0xC3, 0x30, 0x60, 0x07, 0x87, 0xF3, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x40, 0x18, 0x0C, 0xC7, 0x3F, 0x80,
  0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x03, 0x00, 0x30, 0x33, 0x03, 0x30, 0x33, 0x02, 0x20, 0x26,
  0x06, 0x60, 0x66, 0x06, 0x40, 0x44, 0x0C, 0xC0, 0xC4, 0x08, 0x73, 0x83,
  0xF0, 0x80, 0xF0, 0x3C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x61, 0x10, 0x4C,
  0x12, 0x05, 0x81, 0x40, 0x70, 0x18, 0x00, 0xC1, 0x83, 0xC1, 0x82, 0xC3,
  0x86, 0xC2, 0x86, 0xC6, 0x8C, 0xC4, 0x8C, 0xCC, 0x98, 0xC8, 0x98, 0xD8,
  0x90, 0xD0, 0xB0, 0xF0, 0xA0, 0x60, 0xE0, 0x60, 0xC0, 0x60, 0xC0, 0x18,
  0x18, 0x41, 0x83, 0x18, 0x19, 0x80, 0x48, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0xC8, 0x06, 0x60, 0x63, 0x06, 0x08, 0x60, 0x60, 0x81, 0xE0,
  0xF0, 0xC8, 0xC4, 0x63, 0x61, 0xA0, 0x70, 0x30, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x00, 0x1F, 0xE3, 0xFC, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xF9, 0xFE, 0x00, 0x1E, 0x3C,
  0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60,
  0xF0, 0xCC, 0xC4, 0x44, 0x46, 0x66, 0x22, 0x23, 0x1E, 0x3C, 0x10, 0x20,
  0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0xE0, 0x08,
  0x0C, 0x07, 0x06, 0x82, 0x63, 0x11, 0x0D, 0x82, 0x81, 0x80, 0xFF, 0xD9,
  0x80, 0x3E, 0xB9, 0xD8, 0x78, 0x3C, 0x16, 0x1B, 0x0D, 0x8E, 0xCF, 0x3D,
  0x00, 0x30, 0x18, 0x0C, 0x04, 0x02, 0xF3, 0x8D, 0x86, 0xC3, 0x41, 0xE0,
  0xF0, 0x78, 0x6A, 0x65, 0xE0, 0x3F, 0x71, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE4, 0x7C, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x3E, 0x9C, 0xE6, 0x1B,
  0x06, 0xC1, 0x30, 0x4C, 0x33, 0x1C, 0xCF, 0x1E, 0x80, 0x3E, 0x73, 0x63,
  0xC3, 0xFE, 0xF0, 0xC0, 0xC0, 0xE2, 0x7E, 0x00, 0x80, 0xF0, 0x20, 0x18,
  0x06, 0x07, 0xE0, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x0E, 0x03, 0x00, 0x1F, 0x4E, 0x73, 0x0D,
  0x83, 0x60, 0x98, 0x66, 0x19, 0x8E, 0x67, 0x8F, 0x40, 0x10, 0x0C, 0x82,
  0x3F, 0x81, 0x00, 0x30, 0x18, 0x0C, 0x04, 0x02, 0xF3, 0x8D, 0x86, 0xC3,
  0x41, 0xE0, 0xB0, 0xD8, 0x6C, 0x34, 0x10, 0x33, 0x00, 0x26, 0x66, 0x4C,
  0xCC, 0xC8, 0x06, 0x0C, 0x00, 0x00, 0x41, 0x83, 0x06, 0x08, 0x30, 0x60,
  0xC1, 0x82, 0x0C, 0x18, 0x31, 0xC2, 0x00, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x3B, 0x31, 0xB0, 0xF0, 0x78, 0x7C, 0x33, 0x19, 0x8C, 0x64, 0x30, 0x33,
  0x32, 0x26, 0x66, 0x4C, 0xCC, 0xC8, 0x2F, 0x3C, 0xE2, 0x8D, 0x86, 0x1B,
  0x0C, 0x24, 0x10, 0x58, 0x61, 0xB0, 0xC3, 0x61, 0x86, 0xC2, 0x09, 0x0C,
  0x30, 0x37, 0xCF, 0x33, 0x8C, 0xC3, 0x20, 0xD8, 0x26, 0x19, 0x86, 0x61,
  0xB0, 0x60, 0x3F, 0x39, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x05, 0x86, 0xE6,
  0x3E, 0x00, 0x17, 0x8E, 0x33, 0x0C, 0xC3, 0x20, 0xD8, 0x36, 0x0D, 0x86,
  0x53, 0x17, 0x8C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x00, 0x3E, 0xB9, 0xD8,
  0x78, 0x3C, 0x16, 0x1B, 0x0D, 0x8E, 0xCF, 0x3D, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x2E, 0xF1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x00, 0x3F,
  0x61, 0x60, 0x70, 0x38, 0x0C, 0x06, 0x06, 0x8E, 0xFC, 0x10, 0xC2, 0x3F,
  0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0x70, 0x60, 0xB0, 0xD8, 0x68, 0x34,
  0x16, 0x0B, 0x0D, 0x8E, 0xCF, 0x3D, 0x00, 0xC1, 0xE1, 0xB0, 0x98, 0xCC,
  0xC2, 0x61, 0x60, 0xB0, 0x50, 0x38, 0x00, 0xC7, 0x1E, 0x38, 0xF1, 0xCD,
  0x9E, 0x6C, 0xB2, 0x6C, 0xB3, 0x45, 0x1E, 0x38, 0xE1, 0x87, 0x0C, 0x00,
  0x30, 0xE3, 0x30, 0x24, 0x07, 0x80, 0x60, 0x1C, 0x06, 0x81, 0x98, 0x23,
  0x1C, 0x30, 0x18, 0x31, 0x86, 0x18, 0x41, 0x8C, 0x08, 0x80, 0x98, 0x0B,
  0x00, 0xB0, 0x0A, 0x00, 0xE0, 0x0C, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x40,
  0x00, 0x3F, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0xFE, 0x03,
  0x0E, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x30, 0xE0, 0x60, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x70, 0x30, 0xFF, 0xFF, 0xE0, 0x08, 0x1C, 0x04, 0x04, 0x04,
  0x0C, 0x0C, 0x0C, 0x07, 0x0E, 0x18, 0x18, 0x10, 0x10, 0x30, 0x70, 0xE0,
  0x78, 0xEF, 0xE0, 0xC0,
};

const GFXglyph NotoSans_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 11, 14, 12, 1, -14 },
  { 34, 9, 15, 10, 1, -14 },
  { 51, 12, 14, 15, 2, -14 },
  { 72, 11, 14, 13, 1, -14 },
  { 92, 3, 5, 4, 2, -14 },
  { 94, 6, 17, 6, 1, -14 },
  { 107, 6, 17, 6, -1, -14 },
  { 120, 9, 9, 10, 2, -15 },
  { 131, 9, 9, 11, 1, -11 },
  { 142, 4, 4, 5, -1, -2 },
  { 144, 5, 2, 6, 0, -6 },
  { 146, 3, 2, 5, 0, -2 },
  { 147, 9, 14, 7, -1, -14 },
  { 163, 9, 14, 10, 1, -14 },
  { 179, 5, 14, 10, 3, -14 },
  { 188, 10, 14, 10, 0, -14 },
  { 206, 10, 14, 10, 0, -14 },
  { 224, 10, 14, 10, 0, -14 },
  { 242, 9, 14, 10, 1, -14 },
  { 258, 9, 14, 10, 1, -14 },
  { 274, 9, 14, 10, 2, -14 },
  { 290, 9, 14, 10, 1, -14 },
  { 306, 9, 14, 10, 1, -14 },
  { 322, 4, 10, 5, 0, -10 },
  { 327, 5, 12, 5, -1, -10 },
  { 335, 9, 10, 11, 1, -12 },
  { 347, 9, 5, 11, 1, -9 },
  { 353, 9, 10, 11, 1, -12 },
  { 365, 8, 14, 8, 1, -14 },
  { 379, 15, 16, 16, 1, -14 },
  { 409, 11, 14, 11, -1, -14 },
  { 429, 10, 14, 11, 1, -14 },
  { 447, 11, 14, 11, 1, -14 },
  { 467, 11, 14, 13, 1, -14 },
  { 487, 10, 14, 10, 1, -14 },
  { 505, 10, 14, 9, 1, -14 },
  { 523, 12, 14, 13, 1, -14 },
  { 544, 12, 14, 13, 1, -14 },
  { 565, 7, 14, 6, 0, -14 },
  { 578, 8, 18, 5, -3, -14 },
  { 596, 11, 14, 11, 1, -14 },
  { 616, 7, 14, 9, 1, -14 },
  { 629, 15, 14, 16, 1, -14 },
  { 656, 13, 14, 13, 1, -14 },
  { 679, 12, 14, 14, 1, -14 },
  { 700, 10, 14, 11, 1, -14 },
  { 718, 12, 17, 14, 1, -14 },
  { 744, 10, 14, 11, 1, -14 },
  { 762, 10, 14, 10, 0, -14 },
  { 780, 9, 14, 10, 2, -14 },
  { 796, 12, 14, 13, 1, -14 },
  { 817, 10, 14, 10, 2, -14 },
  { 835, 16, 14, 16, 2, -14 },
  { 863, 13, 14, 10, -1, -14 },
  { 886, 9, 14, 10, 2, -14 },
  { 902, 11, 14, 10, 0, -14 },
  { 922, 7, 17, 6, 0, -14 },
  { 937, 4, 14, 7, 2, -14 },
  { 944, 7, 17, 6, -1, -14 },
  { 959, 9, 9, 11, 1, -14 },
  { 970, 8, 1, 8, -2, 2 },
  { 971, 3, 3, 5, 3, -15 },
  { 973, 9, 10, 11, 1, -10 },
  { 985, 9, 14, 11, 1, -14 },
  { 1001, 8, 10, 9, 1, -10 },
  { 1011, 10, 14, 11, 1, -14 },
  { 1029, 8, 10, 9, 1, -10 },
  { 1039, 10, 20, 6, -2, -15 },
  { 1064, 10, 15, 11, 0, -10 },
  { 1083, 9, 14, 11, 1, -14 },
  { 1099, 4, 14, 5, 1, -14 },
  { 1106, 7, 19, 5, -2, -14 },
  { 1123, 9, 14, 9, 1, -14 },
  { 1139, 4, 14, 5, 1, -14 },
  { 1146, 15, 10, 17, 1, -10 },
  { 1165, 10, 10, 11, 0, -10 },
  { 1178, 9, 10, 11, 1, -10 },
  { 1190, 10, 15, 11, 0, -10 },
  { 1209, 9, 15, 11, 1, -10 },
  { 1226, 7, 10, 8, 1, -10 },
  { 1235, 8, 10, 8, 0, -10 },
  { 1245, 6, 13, 6, 1, -13 },
  { 1255, 9, 10, 11, 1, -10 },
  { 1267, 9, 10, 9, 1, -10 },
  { 1279, 13, 10, 14, 1, -10 },
  { 1296, 11, 10, 9, -1, -10 },
  { 1310, 12, 15, 9, -2, -10 },
  { 1333, 8, 10, 8, 0, -10 },
  { 1343, 8, 17, 7, 0, -14 },
  { 1360, 1, 19, 10, 5, -14 },
  { 1363, 8, 17, 7, -1, -14 },
  { 1380, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_Italic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_ITALIC19PT7B_H_
