#ifndef _NOTOSANS_ITALIC68PT7B_H_
#define _NOTOSANS_ITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFE, 0x78, 0xFC, 0x00, 0xFE, 0x1E, 0x07, 0x00, 0x7E, 0x0F, 0x80, 0x40,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x03, 0xF0, 0x3C, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xF0, 0x78, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x00, 0x1F, 0xCF,
  0x80, 0x00, 0x07, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0x9F, 0xE0, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x80, 0x00, 0x1E,
  0x07, 0xE0, 0x00, 0x07, 0x83, 0xF8, 0x30, 0x03, 0xE1, 0xFC, 0x0F, 0x80,
  0xF8, 0xFF, 0x03, 0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x3F, 0xFF,
  0x00, 0x00, 0x7E, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE3, 0xF8,
  0x00, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0x80,
  0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x7F, 0xE3, 0xE0,
  0x0F, 0x87, 0xC3, 0xFF, 0xC7, 0xC0, 0x7C, 0x3F, 0x1F, 0xFF, 0x9F, 0x01,
  0xF0, 0xF8, 0xFF, 0xFE, 0x7C, 0x0F, 0x87, 0xC7, 0xE0, 0xFD, 0xFC, 0xFE,
  0x3E, 0x1F, 0x01, 0xF3, 0xFF, 0xF1, 0xF8, 0xFC, 0x07, 0xCF, 0xFF, 0x87,
  0xC3, 0xE0, 0x1F, 0x1F, 0xFC, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0xC1, 0xF0,
  0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0xF8,
  0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x03,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFC, 0x1F, 0xE1, 0xF8, 0x00,
  0x7E, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x0F, 0xE0, 0x0F, 0xC3,
  0xF8, 0x01, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xE0, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00,
  0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xCF,
  0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xFC,
  0x03, 0xC0, 0x01, 0xFE, 0x0F, 0x80, 0x07, 0xFF, 0x1E, 0x00, 0x0F, 0xFF,
  0xBC, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x9F, 0xFC, 0x00, 0xFF,
  0x80, 0x38, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x01, 0xFC, 0x3E, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xF0,
  0x00, 0x60, 0x07, 0xE0, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0x1F, 0xDF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xF7, 0xC7,
  0xFC, 0xFC, 0xFF, 0x8F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xC3, 0x01, 0xF8,
  0x20, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x01, 0xC0, 0x00, 0xFE, 0x00, 0x08, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x20, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x83, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x00, 0x7F,
  0x03, 0x80, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x40, 0x00, 0x07, 0xF8, 0x30, 0x00,
  0x07, 0xF8, 0x1E, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x08, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x08, 0x00, 0x03, 0xF0, 0x7F, 0xE0, 0x03, 0xF0, 0xFF, 0xFC, 0x01, 0xF9,
  0xFF, 0xFF, 0x00, 0xFD, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xE0, 0x7F,
  0xF0, 0x07, 0xF8, 0x3F, 0xF0, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x1F,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x1F,
  0x80, 0x03, 0xFE, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0xCF, 0xC0, 0x1F, 0xFF, 0xC7, 0xE0,
  0x07, 0xFF, 0xC7, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x18, 0x00, 0x7F,
  0xC0, 0x0F, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0xE1,
  0xC0, 0x03, 0xF8, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x03,
  0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x1F, 0x00, 0x1F, 0xFF, 0xFC,
  0x01, 0xF1, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0x3E, 0x00, 0x7F, 0x00,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x7E, 0x01, 0xF8,
  0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x7C, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x07, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x3E,
  0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xEF, 0x80, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xEF, 0x80, 0xF8, 0x00, 0x7E,
  0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xCF, 0x80, 0xF8, 0x00,
  0xFE, 0x00, 0xFC, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x8F, 0x80, 0xFC,
  0x01, 0xFE, 0x01, 0xF8, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x3F, 0x0F, 0x80,
  0x7E, 0x07, 0xFE, 0x07, 0xE0, 0xF8, 0x07, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F,
  0x80, 0x3F, 0xFF, 0x1F, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x07, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x83, 0xF0,
  0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x3F, 0xE0,
  0x00, 0x04, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x80,
  0x07, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x7E,
  0x00, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3C,
  0x00, 0xFF, 0x80, 0x00, 0x04, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7D,
  0xF8, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF0,
  0x00, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF8,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xC3, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x7E, 0x01,
  0xFC, 0x01, 0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF9, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xE0, 0x0F,
  0x80, 0x0F, 0xBE, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x1F,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xDF,
  0x80, 0x00, 0x1F, 0x80, 0x3E, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x01,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x00,
  0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x7E,
  0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x1F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x07, 0xC0,
  0x00, 0x0F, 0xDF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF8, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x04, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x0C,
  0x00, 0x01, 0xFF, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF1, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0xFE, 0x0F, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0x83, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x3E,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x01, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC1, 0xF0, 0x03, 0xFF, 0xF8, 0x7C, 0x01, 0xFF,
  0xFF, 0x1F, 0x00, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xC0, 0xFB, 0xE0, 0x3F,
  0xC0, 0x1F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x83,
  0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0x80, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xDF, 0x01, 0xFC, 0x03, 0xE7,
  0xC0, 0x3F, 0xE7, 0xFB, 0xF0, 0x0F, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xFC,
  0x3E, 0x00, 0x3F, 0xFE, 0x0F, 0x80, 0x07, 0xFE, 0x03, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01,
  0xF8, 0x3F, 0xFC, 0x00, 0x7E, 0x1F, 0xFF, 0x80, 0x1F, 0x8F, 0xFF, 0xF0,
  0x07, 0xE7, 0xFF, 0xFC, 0x01, 0xF3, 0xE0, 0x7F, 0x80, 0xFD, 0xF0, 0x0F,
  0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x0F, 0xC0, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xC0,
  0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x01, 0xF3,
  0xF1, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xC0, 0x3E, 0x1F, 0xFF, 0xE0, 0x0F,
  0x83, 0xFF, 0xF0, 0x03, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x0E, 0x03, 0xFC,
  0x00, 0x20, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0x03, 0xFC, 0x00, 0x60, 0x3F, 0xF0, 0x7E, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xC0, 0x00,
  0xFF, 0xFE, 0x3F, 0x00, 0x07, 0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0xFF, 0xF3,
  0xF0, 0x01, 0xFF, 0x03, 0xEF, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xBF, 0x00, 0x0F, 0xF8, 0xFC,
  0xFC, 0x00, 0x3F, 0xFF, 0xE3, 0xE0, 0x00, 0x7F, 0xFF, 0x0F, 0x80, 0x00,
  0xFF, 0xF8, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x04, 0x07, 0xF8, 0x00, 0xE0, 0x3F, 0xF0,
  0x7F, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x20, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x3C, 0x00, 0x7F, 0xFF, 0x0F, 0x80, 0x1F, 0xFF, 0xF1,
  0xF0, 0x07, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0x03, 0xEF, 0x80, 0x7F, 0x80,
  0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFC,
  0x03, 0xEF, 0xC0, 0x1F, 0xF1, 0xF9, 0xF8, 0x03, 0xFF, 0xFE, 0x3E, 0x00,
  0x3F, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0x00, 0x00, 0x70, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0x00, 0x00, 0x7F, 0x00, 0x30, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0xFC, 0x00,
  0x7E, 0x1F, 0xFF, 0x80, 0x1F, 0x8F, 0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xFE,
  0x01, 0xF3, 0xF0, 0x7F, 0x80, 0xFD, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0x01,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xBF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xC0, 0x00,
  0x1F, 0xF3, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x08, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7C, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x01, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x07, 0xCF, 0x81,
  0xFC, 0xFC, 0x0F, 0xE0, 0x3F, 0x78, 0x03, 0xF7, 0xC0, 0x1F, 0x80, 0xFF,
  0xC0, 0x0F, 0xDE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0xF8, 0x00, 0x7E, 0x0F, 0xFF, 0x80, 0x1F, 0x8F, 0xFF, 0xF0, 0x07, 0xC7,
  0xFF, 0xFC, 0x01, 0xF3, 0xFF, 0xFF, 0x80, 0xFD, 0xFC, 0x1F, 0xE0, 0x3F,
  0x7C, 0x03, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x1F, 0xC1,
  0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF9, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x7F, 0x00,
  0x00, 0x7C, 0x0F, 0xFF, 0x00, 0x01, 0xF0, 0x7F, 0xFE, 0x00, 0x07, 0xC3,
  0xFF, 0xFC, 0x00, 0x1F, 0x1F, 0xFF, 0xF0, 0x00, 0x7C, 0xF8, 0x1F, 0xE0,
  0x03, 0xF7, 0xC0, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xC0, 0x07, 0xEF, 0xC7, 0xFE, 0x00, 0x1F, 0x3F, 0xFF, 0xF0,
  0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x03, 0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0xC1,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0xF0, 0x03, 0xFF, 0xF8, 0x7C, 0x01, 0xFF, 0xFF, 0x1F,
  0x00, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xC0, 0xFB, 0xE0, 0x3F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xF8, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0x80,
  0x07, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x01, 0xFC, 0x03, 0xEF, 0xC0, 0x3F,
  0xE3, 0xF3, 0xF0, 0x0F, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xFC, 0x7E, 0x00,
  0x3F, 0xFE, 0x1F, 0x80, 0x07, 0xFE, 0x07, 0xE0, 0x00, 0x1C, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x08, 0x0F, 0xE0, 0x3E, 0x07, 0xFC,
  0x07, 0xC3, 0xFF, 0x80, 0xF8, 0xFF, 0xE0, 0x1F, 0x3F, 0xFC, 0x03, 0xE7,
  0xF0, 0x80, 0xFD, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x3E, 0x07, 0xF0, 0x00, 0x40, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x80, 0x00, 0x7F, 0x0F, 0x00,
  0x0F, 0xF0, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x86, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x07, 0xFC, 0x1F, 0x80, 0x03,
  0xFC, 0x0F, 0xC0, 0x03, 0xFE, 0x07, 0xE0, 0x07, 0xFF, 0x03, 0xF8, 0x07,
  0xDF, 0x81, 0xFF, 0x1F, 0xCF, 0xC0, 0x7F, 0xFF, 0xC7, 0xC0, 0x3F, 0xFF,
  0xC3, 0xE0, 0x0F, 0xFF, 0xC1, 0xF0, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F,
  0x03, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3D,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7D, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7D,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xF9, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xF9,
  0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF1, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF1,
  0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE1,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC1,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x81,
  0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x81, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x01,
  0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xE0, 0x01,
  0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0xF9, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0xC0, 0x01, 0xFF, 0xFC, 0x80, 0x00,
  0x3F, 0xF0,
};

const GFXglyph NotoSans_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 18, 50, 18, 1, -49 },
  { 114, 21, 18, 27, 7, -49 },
  { 162, 42, 49, 44, 2, -49 },
  { 420, 34, 56, 37, 2, -52 },
  { 658, 46, 50, 54, 5, -49 },
  { 946, 42, 50, 46, 2, -49 },
  { 1209, 9, 18, 15, 7, -49 },
  { 1230, 22, 60, 20, 3, -49 },
  { 1395, 22, 60, 20, -5, -49 },
  { 1560, 31, 32, 37, 7, -52 },
  { 1684, 32, 32, 39, 5, -40 },
  { 1812, 14, 17, 17, -3, -8 },
  { 1842, 17, 6, 21, 2, -21 },
  { 1855, 9, 9, 17, 1, -8 },
  { 1866, 33, 49, 24, -3, -49 },
  { 2069, 32, 50, 37, 4, -49 },
  { 2269, 20, 49, 37, 10, -49 },
  { 2392, 36, 49, 37, 0, -49 },
  { 2613, 35, 50, 37, 1, -49 },
  { 2832, 36, 49, 37, 0, -49 },
  { 3053, 33, 50, 37, 3, -49 },
  { 3260, 33, 50, 37, 4, -49 },
  { 3467, 32, 49, 37, 6, -49 },
  { 3663, 34, 50, 37, 3, -49 },
  { 3876, 33, 50, 37, 3, -49 },
  { 4083, 14, 38, 17, 1, -37 },
  { 4150, 18, 46, 17, -3, -37 },
  { 4254, 32, 33, 39, 5, -41 },
  { 4386, 31, 18, 39, 5, -33 },
  { 4456, 32, 33, 39, 5, -41 },
  { 4588, 26, 50, 29, 5, -49 },
  { 4751, 52, 54, 58, 4, -48 },
  { 5102, 39, 49, 38, -4, -49 },
  { 5341, 37, 49, 41, 3, -49 },
  { 5568, 38, 50, 40, 5, -49 },
  { 5806, 40, 49, 45, 3, -49 },
  { 6051, 35, 49, 35, 3, -49 },
  { 6266, 35, 49, 32, 3, -49 },
  { 6481, 40, 50, 46, 5, -49 },
  { 6731, 44, 49, 46, 3, -49 },
  { 7001, 27, 49, 22, -1, -49 },
  { 7167, 30, 62, 19, -11, -49 },
  { 7400, 41, 49, 38, 3, -49 },
  { 7652, 26, 49, 33, 3, -49 },
  { 7812, 54, 49, 57, 3, -49 },
  { 8143, 45, 49, 48, 3, -49 },
  { 8419, 42, 50, 49, 5, -49 },
  { 8682, 36, 49, 39, 3, -49 },
  { 8903, 42, 61, 49, 5, -49 },
  { 9224, 36, 49, 39, 3, -49 },
  { 9445, 34, 50, 34, 1, -49 },
  { 9658, 34, 49, 34, 6, -49 },
  { 9867, 42, 50, 46, 5, -49 },
  { 10130, 38, 49, 38, 6, -49 },
  { 10363, 57, 49, 58, 7, -49 },
  { 10713, 45, 49, 36, -4, -49 },
  { 10989, 35, 49, 35, 6, -49 },
  { 11204, 40, 49, 36, -1, -49 },
  { 11449, 26, 60, 20, -1, -49 },
  { 11644, 13, 49, 24, 7, -49 },
  { 11724, 26, 60, 20, -5, -49 },
  { 11919, 33, 31, 39, 3, -49 },
  { 12047, 28, 5, 27, -6, 6 },
  { 12065, 11, 11, 19, 10, -52 },
  { 12081, 34, 38, 39, 3, -37 },
  { 12243, 34, 53, 39, 2, -52 },
  { 12469, 28, 38, 31, 3, -37 },
  { 12602, 38, 53, 39, 3, -52 },
  { 12854, 29, 38, 34, 3, -37 },
  { 12992, 38, 68, 22, -8, -52 },
  { 13315, 35, 53, 39, 2, -37 },
  { 13547, 34, 52, 39, 2, -52 },
  { 13768, 16, 50, 18, 2, -50 },
  { 13868, 27, 66, 18, -9, -50 },
  { 14091, 34, 52, 34, 2, -52 },
  { 14312, 17, 52, 18, 2, -52 },
  { 14423, 54, 37, 60, 2, -37 },
  { 14673, 34, 37, 39, 2, -37 },
  { 14831, 32, 38, 38, 3, -37 },
  { 14983, 38, 53, 39, -2, -37 },
  { 15235, 34, 53, 39, 3, -37 },
  { 15461, 27, 37, 27, 2, -37 },
  { 15586, 28, 38, 29, 0, -37 },
  { 15719, 22, 46, 23, 3, -45 },
  { 15846, 33, 37, 39, 4, -36 },
  { 15999, 32, 36, 32, 3, -36 },
  { 16143, 48, 36, 49, 4, -36 },
  { 16359, 38, 36, 33, -3, -36 },
  { 16530, 41, 52, 32, -6, -36 },
  { 16797, 31, 36, 30, -1, -36 },
  { 16937, 26, 60, 24, 1, -49 },
  { 17132, 5, 68, 37, 18, -52 },
  { 17175, 26, 60, 24, -3, -49 },
  { 17370, 32, 8, 39, 5, -28 },
};

const GFXfont NotoSans_Italic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic68pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_ITALIC68PT7B_H_
