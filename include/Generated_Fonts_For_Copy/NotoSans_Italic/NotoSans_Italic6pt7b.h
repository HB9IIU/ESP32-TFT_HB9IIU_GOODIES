#ifndef _NOTOSANS_ITALIC6PT7B_H_
#define _NOTOSANS_ITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x80, 0x56, 0xFA, 0x2D, 0x3C, 0xF6, 0x8A, 0xE0, 0x64, 0xBF,
  0x80, 0x6A, 0x80, 0x56, 0x80, 0x6C, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A,
  0x40, 0x76, 0xF0, 0xDA, 0x65, 0x70, 0x6C, 0xF0, 0x2F, 0x90, 0x68, 0xF0,
  0x6E, 0xF0, 0x65, 0x60, 0x6E, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0x69, 0x40, 0x7D, 0xF7, 0x47, 0x00, 0x2F, 0xD0, 0x76,
  0xAE, 0x78, 0x86, 0x75, 0x9E, 0x6E, 0x70, 0x6E, 0x40, 0x7A, 0x97, 0x57,
  0x99, 0x5A, 0x25, 0x2C, 0x74, 0xAA, 0x4A, 0x70, 0x4A, 0xFB, 0x50, 0x55,
  0xB9, 0x79, 0x96, 0x6E, 0x40, 0x79, 0x96, 0x20, 0x6E, 0xD0, 0xE8, 0xF0,
  0xF2, 0x40, 0x59, 0x9E, 0xBA, 0x40, 0xCF, 0xA9, 0x40, 0x74, 0x4A, 0xF2,
  0x40, 0x69, 0x70, 0x6A, 0x80, 0xF0, 0x5A, 0x80, 0x54, 0xE0, 0x80, 0xF7,
  0x80, 0x49, 0xDE, 0xF3, 0x80, 0x11, 0xEA, 0xE0, 0xFB, 0x80, 0x12, 0x64,
  0x4C, 0xF6, 0xF0, 0x49, 0xDA, 0x6A, 0x29, 0x2C, 0x4A, 0xEA, 0x5A, 0x80,
  0x7D, 0x6A, 0x76, 0x80, 0xF7, 0x80, 0x77, 0xC0, 0xF7, 0x90, 0x72, 0x00,
  0xDC, 0x6B, 0xB7, 0x80, 0xB9, 0x00, 0xBF, 0xA8, 0xEB, 0x00, 0x56, 0x2C,
  0x6B, 0x00, 0x5A, 0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_Italic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 1, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 2, 3, 3, 1, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 2, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 3, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 1, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 2, 0, -3 },
  { 45, 1, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 5, 5, 5, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 4, 4, 4, 0, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 2, 4, 2, 0, -4 },
  { 74, 3, 5, 2, -1, -4 },
  { 76, 4, 4, 3, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 5, 4, 5, 0, -4 },
  { 83, 4, 4, 4, 0, -4 },
  { 85, 4, 4, 4, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 4, 5, 4, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 3, 4, 3, 1, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 3, 4, 3, 1, -4 },
  { 102, 5, 4, 5, 1, -4 },
  { 105, 4, 4, 3, 0, -4 },
  { 107, 3, 4, 3, 1, -4 },
  { 109, 3, 4, 3, 0, -4 },
  { 111, 2, 5, 2, 0, -4 },
  { 113, 1, 4, 2, 1, -4 },
  { 114, 2, 5, 2, 0, -4 },
  { 116, 3, 2, 3, 0, -4 },
  { 117, 3, 1, 2, -1, 0 },
  { 118, 1, 1, 2, 1, -5 },
  { 119, 3, 3, 3, 0, -3 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 3, 3, 3, 0, -3 },
  { 125, 4, 5, 3, 0, -5 },
  { 128, 3, 3, 3, 0, -3 },
  { 130, 4, 6, 2, -1, -5 },
  { 133, 3, 4, 3, 0, -3 },
  { 135, 3, 5, 3, 0, -5 },
  { 137, 2, 4, 2, 0, -4 },
  { 138, 3, 5, 2, -1, -4 },
  { 140, 3, 5, 3, 0, -5 },
  { 142, 2, 5, 2, 0, -5 },
  { 144, 5, 3, 5, 0, -3 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 3, 4, 3, 0, -3 },
  { 152, 3, 4, 3, 0, -3 },
  { 154, 3, 3, 2, 0, -3 },
  { 156, 2, 3, 3, 0, -3 },
  { 157, 2, 4, 2, 0, -4 },
  { 158, 3, 3, 3, 0, -3 },
  { 160, 3, 3, 3, 0, -3 },
  { 162, 5, 3, 4, 0, -3 },
  { 164, 3, 3, 3, 0, -3 },
  { 166, 4, 4, 3, -1, -3 },
  { 168, 3, 3, 3, 0, -3 },
  { 170, 2, 5, 2, 0, -4 },
  { 172, 1, 6, 3, 1, -5 },
  { 173, 2, 5, 2, 0, -4 },
  { 175, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Italic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic6pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_ITALIC6PT7B_H_
