#ifndef _NOTOSANS_ITALIC53PT7B_H_
#define _NOTOSANS_ITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x3E, 0x1F,
  0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xE0, 0x78, 0xE0, 0x70,
  0xE0, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x78,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFB, 0xCF, 0x81, 0xF8, 0xE0, 0x40,
  0x7C, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0,
  0x00, 0xF8, 0x70, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xFB,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x77, 0xF0, 0x00, 0x1C, 0x7C,
  0x00, 0x07, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x38,
  0x3E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x87, 0xC2, 0x01, 0xE1, 0xF0, 0xE0,
  0x79, 0xF8, 0x3F, 0xDF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xC0, 0x7F, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0x00, 0x0F,
  0x01, 0xF1, 0xF0, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x70,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x7C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x03, 0xE0,
  0x07, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x1E, 0x1F, 0x00, 0x0F, 0x01, 0xE1, 0xE3, 0xF8, 0xF0,
  0x1E, 0x3C, 0x7F, 0xCF, 0x03, 0xC7, 0x8F, 0xFE, 0xF8, 0x7C, 0xF9, 0xF1,
  0xE7, 0x8F, 0x8F, 0x3E, 0x0F, 0x7F, 0xF1, 0xE3, 0xC0, 0xF3, 0xFE, 0x3C,
  0x78, 0x0F, 0x1F, 0xC7, 0xC7, 0x80, 0xF0, 0x00, 0x78, 0x78, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x0F, 0x8F,
  0x80, 0xF0, 0x00, 0x7F, 0xF0, 0x1E, 0x00, 0x07, 0xFE, 0x03, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF0, 0x3F, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xEF, 0x80, 0x1F, 0x1F, 0x87, 0xC0, 0x1F, 0x3E,
  0x03, 0xE0, 0x3E, 0x7C, 0x03, 0xE0, 0x3E, 0x7C, 0x01, 0xF0, 0x7C, 0xF8,
  0x00, 0xF8, 0x78, 0xF8, 0x00, 0xFC, 0xF8, 0xF0, 0x00, 0x7D, 0xF0, 0xF0,
  0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0xC0, 0x7E, 0x01, 0xFF, 0xE0, 0x7F,
  0x8F, 0xFB, 0xE0, 0x3F, 0xFF, 0xE1, 0xF0, 0x1F, 0xFF, 0xC0, 0xF8, 0x0F,
  0xFF, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x3E, 0xF9, 0xF3, 0xE7, 0x8F,
  0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x01, 0x00, 0x78, 0x01, 0xE0, 0x38, 0x00, 0xFC, 0x1C,
  0x00, 0x7F, 0x8E, 0x00, 0x7F, 0xF6, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xF0, 0xFC, 0x07, 0xB8, 0x00, 0x07,
  0xDE, 0x00, 0x07, 0xC7, 0x00, 0x07, 0xC3, 0xC0, 0x07, 0xC1, 0xE0, 0x07,
  0xE0, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x60, 0x1F, 0x00, 0x10, 0x0F, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF,
  0xFE, 0x7C, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x3F,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x7F, 0xBC, 0xFF,
  0x7C, 0xFC, 0x7C, 0x70, 0x7C, 0x60, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x0E, 0x00, 0x3F, 0x00, 0x40,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0x80, 0x0F, 0x80, 0x20,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x3F, 0x83, 0xFE, 0x3F, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E,
  0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x10, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x80,
  0x00, 0xFC, 0x38, 0x00, 0xFE, 0x0F, 0xE3, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0xFF, 0xC0, 0x3E, 0xFF, 0xF8, 0x0F, 0x7F, 0xFF, 0x07, 0xFE, 0x0F, 0xC1,
  0xFE, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0x87, 0xC0, 0x01,
  0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x80,
  0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87,
  0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7E,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE7, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x07,
  0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E,
  0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF0,
  0x1F, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x3F,
  0x03, 0xFE, 0x0F, 0xFF, 0xEF, 0x81, 0xFF, 0xF3, 0xC0, 0x3F, 0xF9, 0xF0,
  0x03, 0xF8, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x20, 0x03, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC0, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3C, 0x07, 0xF2,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x07,
  0xFF, 0x01, 0xE1, 0xE0, 0x0F, 0xFF, 0xC0, 0xF1, 0xF0, 0x0F, 0xFF, 0xE0,
  0x78, 0xF0, 0x0F, 0x80, 0xF0, 0x1C, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x78,
  0x0F, 0x80, 0x78, 0x07, 0xBC, 0x0F, 0x80, 0x3C, 0x03, 0xDE, 0x07, 0x80,
  0x1E, 0x01, 0xDE, 0x03, 0xC0, 0x1E, 0x01, 0xEF, 0x03, 0xC0, 0x0F, 0x00,
  0xF7, 0x81, 0xE0, 0x07, 0x80, 0x7B, 0xC0, 0xF0, 0x07, 0xC0, 0x3D, 0xE0,
  0x78, 0x03, 0xC0, 0x3C, 0xF0, 0x3C, 0x01, 0xE0, 0x1E, 0x78, 0x1E, 0x01,
  0xF0, 0x1F, 0x3C, 0x0F, 0x01, 0xF8, 0x0F, 0x1E, 0x07, 0x80, 0xFC, 0x0F,
  0x8F, 0x03, 0xE1, 0xEF, 0x0F, 0x87, 0x80, 0xFF, 0xE7, 0xFF, 0x83, 0xE0,
  0x7F, 0xE1, 0xFF, 0x80, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x40, 0x00, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x7C, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0x87, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0xFF, 0x00,
  0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x07, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x70, 0x07, 0xF0, 0x00, 0x40, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x1F, 0xF0, 0x01, 0xF0,
  0x03, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x07, 0xF0, 0x3C, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x1F, 0xC0, 0x7C, 0x00,
  0x7F, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xC0,
  0x3F, 0x80, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xFF, 0xE7, 0xC0, 0x03, 0xFF, 0xCF, 0x80, 0x07,
  0xFF, 0x9F, 0x00, 0x1F, 0xFF, 0x3E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x07, 0xC0,
  0x7F, 0x80, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x04, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E,
  0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x00, 0x0F, 0xBC, 0x03,
  0xEF, 0x00, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x00, 0x7D, 0xF0, 0x0F, 0x3C,
  0x00, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x00,
  0x78, 0xF0, 0x0F, 0x9E, 0x00, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x03, 0xC7,
  0xC0, 0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x01,
  0xF0, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xE0, 0x1E, 0x0F, 0x01,
  0xE0, 0x78, 0x07, 0xC1, 0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0x1E, 0x0F, 0x03,
  0xE0, 0x1E, 0x03, 0xC3, 0xE0, 0x7C, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x00,
  0x78, 0x0F, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xE3, 0xC0, 0x7C, 0x03, 0xE0,
  0x3C, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x9E, 0x01, 0xF0, 0x0F, 0x00, 0xF7,
  0x80, 0x3C, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xFC, 0x01,
  0xF0, 0x0F, 0x80, 0x3F, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x1E, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0x00, 0x1E, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x03,
  0xC0, 0x1F, 0xF0, 0x00, 0x3C, 0x03, 0xEF, 0x00, 0x07, 0xC0, 0x3C, 0xF8,
  0x00, 0x7C, 0x03, 0xCF, 0x80, 0x07, 0xC0, 0x3C, 0x78, 0x00, 0x78, 0x03,
  0xC7, 0xC0, 0x07, 0x80, 0x7C, 0x3C, 0x00, 0xF8, 0x07, 0xC3, 0xC0, 0x0F,
  0x80, 0x78, 0x3E, 0x00, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF8, 0x1F,
  0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x00, 0x78, 0x3E,
  0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x1E, 0x00, 0x3C, 0x3E, 0x01, 0xE0, 0x03,
  0xE3, 0xC0, 0x1E, 0x00, 0x3E, 0x3C, 0x03, 0xE0, 0x01, 0xE3, 0xC0, 0x3E,
  0x00, 0x1F, 0x7C, 0x03, 0xC0, 0x00, 0xF7, 0xC0, 0x3C, 0x00, 0x0F, 0x78,
  0x07, 0xC0, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x00,
  0x7F, 0x80, 0x78, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xF0, 0x3F, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0,
  0x03, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x2F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xF0, 0x3F, 0xE0, 0x1F, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E,
  0x07, 0x80, 0x0F, 0xC0, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x78, 0x07, 0xE0,
  0x01, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x80, 0x01, 0xF8, 0x1C, 0x00, 0x7F, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3C,
  0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x78, 0x00, 0xF8, 0xF8,
  0x01, 0xF7, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x78, 0x01, 0xF0, 0xF8, 0x01,
  0xE7, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xC7,
  0x80, 0x3C, 0x0F, 0x80, 0x78, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0x87, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x07, 0x80, 0xF8,
  0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x00, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x0F,
  0x83, 0xE0, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x07, 0x83, 0xE0, 0x07, 0x87,
  0xC0, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x07, 0x87, 0xC0, 0x07, 0x8F, 0x80,
  0x78, 0x78, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x80, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x79, 0xF0,
  0x00, 0x7B, 0xE0, 0x03, 0x9E, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3B, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x20, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x8F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03,
  0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xF0, 0xF0, 0x1F, 0xFE, 0x3C, 0x1F, 0xFF, 0xDF, 0x07,
  0xF0, 0xF7, 0x83, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xC3,
  0xC0, 0x03, 0xF0, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x7F, 0x0F, 0x80, 0x3F,
  0xC3, 0xE0, 0x1F, 0xE0, 0xFC, 0x0F, 0x78, 0x1F, 0xCF, 0x9E, 0x07, 0xFF,
  0xC7, 0x80, 0xFF, 0xE1, 0xC0, 0x1F, 0xE0, 0xF0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0xF0, 0x07, 0xCF, 0xFF, 0x00,
  0xF3, 0xFF, 0xF0, 0x1E, 0xF8, 0x7E, 0x07, 0xFC, 0x07, 0xE0, 0xFF, 0x00,
  0x7C, 0x1F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F,
  0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0xC0,
  0x7F, 0x07, 0xBF, 0x3F, 0xC0, 0xF3, 0xFF, 0xF0, 0x1E, 0x3F, 0xFC, 0x07,
  0x83, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x03, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x83, 0xFC, 0x7C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0xFC,
  0x7C, 0x00, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0xDF, 0x01, 0xFC, 0x1E, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xE0, 0x78,
  0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x80, 0xF0, 0x01,
  0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x3E, 0x01, 0xFE, 0x01, 0xF8, 0x1E, 0xF0,
  0x07, 0xF3, 0xE7, 0x80, 0x3F, 0xFE, 0x3C, 0x00, 0xFF, 0xE3, 0xC0, 0x03,
  0xFC, 0x1E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3E, 0x01, 0xF1,
  0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x1F, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x08, 0x7E, 0x00, 0xC1, 0xFF, 0x1F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE1,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x04, 0x3E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x7F, 0xF8, 0xF0, 0x1F, 0xFF, 0xDF,
  0x03, 0xF8, 0x3D, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFC,
  0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x01,
  0xF8, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xF0, 0x3C, 0x00, 0x3F, 0x03,
  0xC0, 0x07, 0xF0, 0x3E, 0x00, 0xFF, 0x03, 0xE0, 0x1F, 0xE0, 0x3F, 0x03,
  0xDE, 0x01, 0xFC, 0xFB, 0xE0, 0x1F, 0xFF, 0x3E, 0x00, 0xFF, 0xE3, 0xC0,
  0x07, 0xF8, 0x3C, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0xC0, 0x03, 0xF0, 0x0F, 0xC1, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0xF0, 0x07, 0xCF, 0xFF,
  0x00, 0xF3, 0xFF, 0xF0, 0x1E, 0xF8, 0x3E, 0x07, 0xFC, 0x07, 0xE0, 0xFF,
  0x00, 0x7C, 0x1F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x1F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00,
  0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x10,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x10, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x0F, 0xC0, 0x1E, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0xF8,
  0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x7E,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xEF, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF0, 0xFF, 0x80, 0x7F,
  0xC0, 0x3C, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0x3F, 0xFE, 0x3F, 0xFF, 0x03,
  0xDE, 0x0F, 0x9F, 0x0F, 0xC1, 0xFF, 0x01, 0xEF, 0x01, 0xF0, 0x7F, 0x80,
  0x7F, 0x80, 0x3C, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC1, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x03,
  0xE1, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x03, 0xE1,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0xFE, 0x00, 0x78, 0x7F, 0xF0, 0x0F, 0x1F, 0xFF, 0x01, 0xE7, 0xFF,
  0xE0, 0x7D, 0xF0, 0xFE, 0x0F, 0xF8, 0x0F, 0xC1, 0xFE, 0x00, 0xF8, 0x3F,
  0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE1, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x3F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0x83, 0xFE, 0x00,
  0x3C, 0x7F, 0xF8, 0x01, 0xE7, 0xFF, 0xE0, 0x0F, 0x7C, 0x3F, 0x00, 0xFF,
  0x80, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x3F, 0x80, 0x1F, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0xE7, 0xF8, 0x07, 0xDF, 0xFF, 0x80, 0x3C, 0x7F, 0xF8, 0x01, 0xE1, 0xFF,
  0x00, 0x1F, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0xF0, 0x1F, 0xFE, 0x3C, 0x1F,
  0xFF, 0xDF, 0x0F, 0xE0, 0xF7, 0x83, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8,
  0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x8F,
  0x00, 0x07, 0xC3, 0xC0, 0x03, 0xF0, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x7F,
  0x0F, 0x80, 0x3F, 0xC3, 0xE0, 0x1F, 0xE0, 0xFC, 0x0F, 0x78, 0x1F, 0xCF,
  0xBE, 0x07, 0xFF, 0xCF, 0x80, 0xFF, 0xE3, 0xC0, 0x1F, 0xE0, 0xF0, 0x00,
  0x40, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0x0F, 0xE0,
  0x3C, 0x7F, 0x80, 0xF3, 0xFE, 0x03, 0xDF, 0x08, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xE0, 0x78, 0x3E, 0x00, 0x20, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x20, 0x00, 0xF8, 0xC0, 0x07, 0xC3, 0xF0,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x60, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8,
  0x01, 0xFC, 0x3E, 0x00, 0xFF, 0x0F, 0x80, 0x7F, 0x83, 0xE0, 0x3D, 0xE0,
  0xFE, 0x7E, 0x78, 0x1F, 0xFF, 0x1E, 0x03, 0xFF, 0x8F, 0x00, 0x7F, 0x83,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78,
  0x07, 0xC0, 0x78, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3C,
  0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xC0, 0x07, 0xBE, 0x00, 0x7E, 0x00, 0x7D, 0xF0, 0x07, 0xF0, 0x03, 0xEF,
  0x80, 0x3B, 0x80, 0x3E, 0x7C, 0x03, 0xDC, 0x01, 0xF3, 0xE0, 0x1E, 0xE0,
  0x1F, 0x1F, 0x01, 0xE7, 0x00, 0xF8, 0xF8, 0x0F, 0x38, 0x0F, 0x87, 0xC0,
  0xF1, 0xE0, 0x7C, 0x3E, 0x07, 0x8F, 0x03, 0xC0, 0xF0, 0x78, 0x78, 0x3E,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x3C, 0x3C, 0x1E, 0x1F, 0x01, 0xE1, 0xE0,
  0xF0, 0xF0, 0x0F, 0x0F, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x3C, 0x7C, 0x03,
  0xC7, 0x81, 0xE7, 0xC0, 0x1E, 0x78, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x79,
  0xE0, 0x07, 0xBC, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x1E, 0xF0, 0x01, 0xEE,
  0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3C, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x01,
  0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x83, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xF4, 0x00, 0x7F, 0xF2, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 39, 14, 1, -38 },
  { 70, 16, 14, 21, 6, -38 },
  { 98, 33, 38, 34, 2, -38 },
  { 255, 26, 43, 29, 2, -40 },
  { 395, 36, 39, 42, 4, -38 },
  { 571, 32, 39, 36, 2, -38 },
  { 727, 7, 14, 12, 6, -38 },
  { 740, 17, 46, 15, 2, -38 },
  { 838, 17, 46, 15, -4, -38 },
  { 936, 25, 24, 29, 5, -40 },
  { 1011, 25, 26, 30, 4, -32 },
  { 1093, 10, 13, 14, -2, -6 },
  { 1110, 14, 4, 17, 1, -16 },
  { 1117, 7, 7, 14, 1, -6 },
  { 1124, 25, 38, 19, -2, -38 },
  { 1243, 25, 39, 29, 3, -38 },
  { 1365, 16, 38, 29, 8, -38 },
  { 1441, 28, 38, 29, 0, -38 },
  { 1574, 27, 39, 29, 1, -38 },
  { 1706, 28, 38, 29, 0, -38 },
  { 1839, 26, 39, 29, 2, -38 },
  { 1966, 26, 39, 29, 3, -38 },
  { 2093, 26, 38, 29, 4, -38 },
  { 2217, 27, 39, 29, 2, -38 },
  { 2349, 26, 39, 29, 2, -38 },
  { 2476, 11, 30, 14, 1, -29 },
  { 2518, 15, 36, 14, -3, -29 },
  { 2586, 25, 26, 30, 4, -32 },
  { 2668, 24, 15, 30, 4, -26 },
  { 2713, 25, 26, 30, 4, -32 },
  { 2795, 20, 39, 23, 4, -38 },
  { 2893, 41, 43, 45, 3, -38 },
  { 3114, 30, 38, 30, -3, -38 },
  { 3257, 29, 38, 32, 2, -38 },
  { 3395, 30, 39, 31, 4, -38 },
  { 3542, 32, 38, 35, 2, -38 },
  { 3694, 27, 38, 27, 2, -38 },
  { 3823, 27, 38, 25, 2, -38 },
  { 3952, 31, 39, 36, 4, -38 },
  { 4104, 34, 38, 36, 2, -38 },
  { 4266, 21, 38, 17, -1, -38 },
  { 4366, 23, 48, 14, -8, -38 },
  { 4504, 33, 38, 30, 2, -38 },
  { 4661, 20, 38, 25, 2, -38 },
  { 4756, 43, 38, 45, 2, -38 },
  { 4961, 36, 38, 37, 2, -38 },
  { 5132, 33, 39, 38, 4, -38 },
  { 5293, 28, 38, 30, 2, -38 },
  { 5426, 33, 47, 38, 4, -38 },
  { 5620, 28, 38, 30, 2, -38 },
  { 5753, 27, 39, 27, 1, -38 },
  { 5885, 26, 38, 27, 5, -38 },
  { 6009, 32, 39, 36, 4, -38 },
  { 6165, 29, 38, 29, 5, -38 },
  { 6303, 44, 38, 45, 6, -38 },
  { 6512, 35, 38, 28, -3, -38 },
  { 6679, 27, 38, 27, 5, -38 },
  { 6808, 31, 38, 28, -1, -38 },
  { 6956, 20, 46, 15, 0, -38 },
  { 7071, 10, 38, 19, 6, -38 },
  { 7119, 20, 46, 15, -4, -38 },
  { 7234, 26, 24, 30, 2, -38 },
  { 7312, 22, 3, 21, -5, 5 },
  { 7321, 8, 9, 15, 8, -41 },
  { 7330, 26, 30, 30, 3, -29 },
  { 7428, 27, 41, 31, 1, -40 },
  { 7567, 21, 30, 24, 3, -29 },
  { 7646, 29, 41, 31, 3, -40 },
  { 7795, 22, 30, 26, 3, -29 },
  { 7878, 29, 54, 17, -6, -41 },
  { 8074, 28, 42, 31, 1, -29 },
  { 8221, 27, 40, 31, 1, -40 },
  { 8356, 13, 39, 14, 1, -39 },
  { 8420, 21, 52, 14, -7, -39 },
  { 8557, 27, 40, 26, 1, -40 },
  { 8692, 14, 40, 14, 1, -40 },
  { 8762, 42, 29, 46, 1, -29 },
  { 8915, 27, 29, 31, 1, -29 },
  { 9013, 24, 29, 30, 3, -29 },
  { 9100, 29, 42, 31, -1, -29 },
  { 9253, 26, 42, 31, 3, -29 },
  { 9390, 22, 29, 21, 1, -29 },
  { 9470, 22, 30, 23, 0, -29 },
  { 9553, 17, 36, 18, 2, -35 },
  { 9630, 26, 29, 31, 3, -28 },
  { 9725, 24, 28, 25, 3, -28 },
  { 9809, 37, 28, 38, 3, -28 },
  { 9939, 29, 28, 26, -2, -28 },
  { 10041, 32, 41, 25, -5, -28 },
  { 10205, 24, 28, 24, -1, -28 },
  { 10289, 20, 46, 19, 1, -38 },
  { 10404, 4, 53, 29, 14, -40 },
  { 10431, 20, 46, 19, -2, -38 },
  { 10546, 25, 7, 30, 4, -22 },
};

const GFXfont NotoSans_Italic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic53pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_ITALIC53PT7B_H_
