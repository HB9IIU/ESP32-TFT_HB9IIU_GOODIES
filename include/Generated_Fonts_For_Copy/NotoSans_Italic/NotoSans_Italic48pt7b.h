#ifndef _NOTOSANS_ITALIC48PT7B_H_
#define _NOTOSANS_ITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0x60, 0x00, 0x3E, 0x3E, 0x78, 0x78, 0xF0, 0xF3,
  0xC1, 0xE7, 0x83, 0x8F, 0x0F, 0x1E, 0x1E, 0x38, 0x3C, 0x70, 0x70, 0xE0,
  0xE3, 0x81, 0xC7, 0x07, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x01,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xC0, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xF3, 0x9E,
  0x07, 0x8F, 0x04, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00,
  0xF0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0xEE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0x7E, 0x00, 0x1E, 0x7C, 0x00, 0x38, 0x78, 0x00, 0x70,
  0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x8F, 0x88, 0x0E, 0x1E,
  0x1E, 0x1C, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x07, 0xF8,
  0x00, 0x3C, 0x0F, 0xFC, 0x00, 0x38, 0x1F, 0x7C, 0x00, 0x78, 0x3C, 0x1C,
  0x00, 0xF0, 0x38, 0x1E, 0x01, 0xE0, 0x78, 0x1E, 0x01, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x0F, 0x00, 0xF0, 0x1C,
  0x0E, 0x00, 0xF0, 0x1C, 0x1E, 0x00, 0xE0, 0x3C, 0x3C, 0x00, 0xE0, 0x3C,
  0x78, 0x00, 0xE0, 0x38, 0x70, 0xF8, 0xE0, 0x78, 0xF3, 0xFE, 0xE0, 0x71,
  0xE7, 0xFE, 0xF0, 0xF3, 0xCF, 0x8F, 0xFB, 0xE3, 0x8F, 0x0F, 0x7F, 0xC7,
  0x9E, 0x07, 0x3F, 0x8F, 0x1C, 0x07, 0x1E, 0x1E, 0x3C, 0x07, 0x00, 0x1C,
  0x3C, 0x07, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x78, 0x38, 0x0F, 0x00, 0xF0,
  0x38, 0x0F, 0x00, 0xF0, 0x38, 0x0E, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0x78, 0x1C, 0x07, 0x80, 0x38, 0x3C, 0x0F, 0x00,
  0x3C, 0x78, 0x1E, 0x00, 0x3F, 0xF8, 0x1C, 0x00, 0x1F, 0xF0, 0x7C, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x1F,
  0x80, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0x3E, 0x01, 0xF3, 0xE0, 0xF0, 0x0F, 0x3E, 0x07, 0xC0, 0xF9, 0xE0, 0x1F,
  0x07, 0x9E, 0x00, 0x7C, 0x7C, 0xF0, 0x01, 0xE7, 0xC7, 0x80, 0x0F, 0xFC,
  0x3C, 0x00, 0x3F, 0xC1, 0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x7F, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xC1, 0xFD, 0xE0, 0x7F, 0xFF,
  0xCF, 0x81, 0xFF, 0xF8, 0x3E, 0x03, 0xFF, 0x00, 0xF8, 0x3E, 0x78, 0xF3,
  0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0x87, 0x00, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x01, 0x00, 0xF0,
  0x07, 0x03, 0x80, 0x1F, 0x0E, 0x00, 0xFF, 0x38, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0x10, 0x79,
  0xC0, 0x03, 0xE7, 0x00, 0x1F, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xC0, 0xF0,
  0x07, 0x03, 0xC0, 0x08, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x87, 0xC3,
  0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0x39, 0xFF, 0xFF, 0xFF, 0xE6, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00,
  0x07, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x00,
  0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xC1,
  0xFF, 0x1F, 0xF9, 0xFD, 0xEF, 0xE7, 0xBE, 0x3E, 0x70, 0xF1, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0x01, 0xF8, 0x06, 0x00,
  0x7C, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xE0, 0x3F, 0x01,
  0x80, 0x1F, 0x01, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0xC0, 0x01, 0xF0, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3C,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0x9F, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0xC0,
  0x07, 0xE0, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x80, 0x0F, 0x1F, 0xE0, 0x3E, 0xFF, 0xF0,
  0x7B, 0xFF, 0xF0, 0xFF, 0x03, 0xE1, 0xF8, 0x03, 0xC7, 0xE0, 0x07, 0xCF,
  0x80, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x80,
  0x1F, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x7C, 0x01, 0xF1, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xC7, 0xE0, 0x1F, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1, 0xF0, 0x07, 0x83,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF8,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00,
  0x0F, 0x9F, 0x00, 0x1F, 0x1E, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7E, 0x0F,
  0xF0, 0x7F, 0xFD, 0xE0, 0x7F, 0xF7, 0xC0, 0x7F, 0x8F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x70,
  0x3F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x06, 0x00, 0x00, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE,
  0x78, 0x0F, 0x88, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x03, 0xF0, 0x0F, 0x1E, 0x01, 0xFF,
  0xE0, 0xF3, 0xC0, 0x7F, 0xFE, 0x07, 0x38, 0x0F, 0xC3, 0xE0, 0x77, 0x81,
  0xF0, 0x1C, 0x07, 0x70, 0x1E, 0x03, 0xC0, 0x7F, 0x03, 0xC0, 0x3C, 0x07,
  0xF0, 0x38, 0x03, 0xC0, 0x7F, 0x07, 0x80, 0x38, 0x07, 0xE0, 0x78, 0x07,
  0x80, 0xFE, 0x07, 0x00, 0x78, 0x0F, 0xE0, 0x70, 0x07, 0x80, 0xFE, 0x0F,
  0x00, 0xF0, 0x0E, 0xE0, 0xF0, 0x0F, 0x01, 0xEE, 0x07, 0x01, 0xF0, 0x3C,
  0xE0, 0x78, 0x3F, 0x03, 0xCE, 0x07, 0xC7, 0x78, 0xF8, 0xF0, 0x3F, 0xF3,
  0xFF, 0x0F, 0x03, 0xFE, 0x3F, 0xE0, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x04, 0x00, 0x0F, 0xE0, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x3E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x1F, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x0F, 0x83, 0xFE, 0x03, 0xE0, 0x0F, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7E,
  0x1E, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x3C, 0x03, 0xF0,
  0x00, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x02, 0x00, 0xFF, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xC1, 0xFF, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xE0,
  0x03, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x7C, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x07, 0x80, 0x0F,
  0xE0, 0x3C, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F,
  0x00, 0xFC, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0x1E,
  0x00, 0x3F, 0xF8, 0xF0, 0x01, 0xFF, 0xCF, 0x80, 0x1F, 0xFC, 0x7C, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07,
  0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0x80, 0x7E, 0x00, 0x3C, 0x03, 0xFE,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x1F, 0x80, 0x78,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3C, 0x01, 0xF8, 0x01, 0xE0, 0x1F,
  0x80, 0x0F, 0x01, 0xF8, 0x00, 0x78, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00,
  0x3C, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF3, 0xC0, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7B,
  0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x01, 0xDE,
  0x00, 0x07, 0xBC, 0x07, 0x9C, 0x00, 0x1E, 0x78, 0x0F, 0x38, 0x00, 0x3D,
  0xF0, 0x1E, 0x70, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0xF1,
  0xE0, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x01, 0xE1, 0xE0, 0x3C,
  0x1C, 0x07, 0x83, 0xC0, 0x78, 0x38, 0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x78, 0x3C, 0x03, 0xC1, 0xE1, 0xE0, 0x78, 0x0F,
  0x03, 0xC3, 0x80, 0xF0, 0x1E, 0x07, 0x8F, 0x03, 0xE0, 0x3C, 0x07, 0x3C,
  0x07, 0x80, 0x78, 0x0E, 0x78, 0x0F, 0x01, 0xF0, 0x1D, 0xE0, 0x1E, 0x03,
  0xC0, 0x3F, 0xC0, 0x7C, 0x07, 0x80, 0x7F, 0x00, 0xF8, 0x0F, 0x00, 0xFE,
  0x01, 0xE0, 0x1E, 0x01, 0xF8, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xF8,
  0x00, 0x1E, 0x03, 0xF8, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x1E, 0x03, 0xBC,
  0x00, 0x1E, 0x03, 0xBE, 0x00, 0x3E, 0x07, 0x9E, 0x00, 0x3C, 0x07, 0x9E,
  0x00, 0x3C, 0x07, 0x8F, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x3C, 0x0F, 0x0F,
  0x00, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0x07,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x01,
  0xE0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x00,
  0xF1, 0xF0, 0x3C, 0x00, 0xF1, 0xE0, 0x3C, 0x00, 0xF9, 0xE0, 0x3C, 0x00,
  0x79, 0xE0, 0x3C, 0x00, 0x79, 0xE0, 0x7C, 0x00, 0x3D, 0xE0, 0x78, 0x00,
  0x3F, 0xC0, 0x78, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x1F, 0xC0, 0x78, 0x00,
  0x1F, 0xC0, 0xF0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78,
  0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFC,
  0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7C, 0x3F, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3E,
  0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0xFC, 0x0F, 0x01, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78, 0x7C,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFC, 0x7F,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x3F, 0xE0, 0x3E, 0x01, 0xF8, 0x1E,
  0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x3C, 0x00, 0xFC, 0x1E, 0x01, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x1E, 0x07, 0xE0, 0x04,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0xC0, 0x07, 0xE0, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x80, 0xF0,
  0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0xF0,
  0x00, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFE, 0x00, 0x3C, 0xF8, 0x01, 0xFE,
  0x00, 0x7C, 0xF8, 0x01, 0xFE, 0x00, 0x78, 0xF8, 0x03, 0xDE, 0x00, 0xF8,
  0x78, 0x03, 0xDE, 0x00, 0xF0, 0x78, 0x07, 0x9E, 0x01, 0xF0, 0x78, 0x07,
  0x9E, 0x01, 0xE0, 0x78, 0x0F, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x1E, 0x07, 0xC0, 0x78,
  0x1E, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x1E, 0x0F, 0x80, 0x78, 0x3C, 0x0E,
  0x0F, 0x00, 0x78, 0x78, 0x0E, 0x0F, 0x00, 0x78, 0x78, 0x0E, 0x1E, 0x00,
  0x78, 0xF0, 0x0E, 0x1E, 0x00, 0x78, 0xF0, 0x0E, 0x3C, 0x00, 0x79, 0xE0,
  0x0E, 0x3C, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x00, 0x79, 0xC0, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0x80, 0xFC, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0xBC, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0,
  0x03, 0xC1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF8,
  0x00, 0x0E, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xF0,
  0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xC7,
  0x00, 0x03, 0xC7, 0x80, 0x03, 0x83, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x01,
  0xC0, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x00,
  0x70, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0E,
  0x07, 0x00, 0x7F, 0x07, 0x01, 0xFF, 0x87, 0x03, 0xFF, 0xCF, 0x07, 0xF3,
  0xEF, 0x0F, 0xC0, 0xFF, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03,
  0xF0, 0x78, 0x07, 0xF0, 0x7C, 0x0F, 0xF0, 0x7E, 0x1E, 0xF0, 0x3F, 0xFC,
  0xE0, 0x3F, 0xF8, 0xE0, 0x0F, 0xE0, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC3, 0xF0, 0x03, 0xCF, 0xFC, 0x07, 0x9F, 0xFE, 0x07, 0xBE,
  0x7E, 0x07, 0xF8, 0x1F, 0x07, 0xF0, 0x0F, 0x0F, 0xE0, 0x0F, 0x0F, 0xC0,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00,
  0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0xF8, 0x7F, 0x01, 0xF8, 0x7B, 0x83, 0xF0, 0x7B, 0xFF,
  0xE0, 0x71, 0xFF, 0xC0, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0x9E, 0x0F, 0xC0, 0x21, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x08, 0x3F, 0x07, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFC,
  0x3C, 0x00, 0xFF, 0xC7, 0x80, 0x3F, 0xFC, 0xF0, 0x0F, 0xE7, 0xDE, 0x03,
  0xF0, 0x1F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF8,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x1E, 0x01, 0xFC, 0x03, 0xE0, 0x7F, 0x80,
  0x7E, 0x1E, 0xF0, 0x07, 0xFF, 0x9C, 0x00, 0xFF, 0xE3, 0x80, 0x07, 0xF0,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xE7,
  0xE0, 0xFC, 0x0F, 0x07, 0x80, 0x7C, 0x7C, 0x03, 0xC7, 0xC0, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x0F, 0x9F, 0x01, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x40,
  0xFC, 0x0E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x10, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x8F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x83, 0x80, 0x7F, 0xF1, 0xC0, 0x7F, 0xF9,
  0xE0, 0x7F, 0x3E, 0xF0, 0x7E, 0x03, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x03, 0xC0, 0x3F, 0x81, 0xF0, 0x3F, 0xC0,
  0xFC, 0x3D, 0xE0, 0x3F, 0xFD, 0xE0, 0x1F, 0xFC, 0xF0, 0x03, 0xF8, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x80, 0x07, 0xC0, 0x78, 0x0F,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC3, 0xF8, 0x03,
  0xC7, 0xFC, 0x07, 0x9F, 0xFE, 0x07, 0xBF, 0x7F, 0x07, 0xF8, 0x1F, 0x07,
  0xF0, 0x0F, 0x0F, 0xE0, 0x0F, 0x0F, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F,
  0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x02, 0x3F,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xE0, 0x0F,
  0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xBE, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x78,
  0x03, 0xC0, 0x78, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0x03, 0x83, 0xF0, 0x07, 0xE0, 0x0E, 0x3F,
  0xF0, 0x7F, 0xE0, 0x79, 0xFF, 0xC3, 0xFF, 0x81, 0xEF, 0x9F, 0x9F, 0x3F,
  0x07, 0xF8, 0x1E, 0xF0, 0x7C, 0x1F, 0x80, 0x7F, 0x00, 0xF0, 0xFC, 0x01,
  0xF8, 0x03, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xC0, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0x83, 0xF8,
  0x07, 0x8F, 0xFE, 0x07, 0x9F, 0xFE, 0x07, 0xBF, 0xFF, 0x07, 0xF8, 0x1F,
  0x07, 0xF0, 0x0F, 0x0F, 0xE0, 0x0F, 0x0F, 0xC0, 0x0F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E,
  0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C,
  0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xDF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x1F,
  0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0,
  0x01, 0xF7, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00,
  0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0x87, 0x80, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x38, 0x7F,
  0xC0, 0x1E, 0x7F, 0xF8, 0x07, 0xBE, 0x7E, 0x01, 0xFE, 0x07, 0xC0, 0x7F,
  0x00, 0xF0, 0x3F, 0x80, 0x3C, 0x0F, 0xC0, 0x0F, 0x03, 0xE0, 0x03, 0xC0,
  0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xF0, 0x1F, 0x81, 0xEE, 0x0F, 0xC0, 0x7B, 0xFF, 0xE0,
  0x1E, 0x7F, 0xF0, 0x0F, 0x8F, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0x01, 0xFF, 0xC7, 0x03, 0xFF, 0xCF, 0x07, 0xF3, 0xEF, 0x0F, 0xC0,
  0xFF, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0x78, 0x07,
  0xF0, 0x7C, 0x0F, 0xF0, 0x7E, 0x1E, 0xF0, 0x3F, 0xFD, 0xE0, 0x3F, 0xF9,
  0xE0, 0x0F, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x03, 0x83, 0xF0, 0x38, 0xFE, 0x07, 0x9F, 0xE0,
  0x7B, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x3E, 0x0F, 0x80, 0x61, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x88, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03,
  0xFF, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC2, 0x0F, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78,
  0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0xC7, 0x80, 0x3F, 0x0F,
  0x00, 0xFE, 0x1E, 0x03, 0xFC, 0x3E, 0x1F, 0x78, 0x7F, 0xFC, 0xE0, 0x7F,
  0xF1, 0xC0, 0x7F, 0x87, 0x80, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0,
  0x01, 0xF3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00,
  0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x81, 0xF0, 0x1E,
  0x01, 0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x00,
  0xE7, 0x80, 0x01, 0xCF, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xFC, 0x00, 0xF8, 0x03, 0xEF, 0x00, 0x7E, 0x00, 0xFB, 0xC0, 0x1F, 0x80,
  0x3C, 0xF0, 0x0F, 0xE0, 0x1F, 0x3C, 0x03, 0xB8, 0x07, 0x8F, 0x01, 0xEE,
  0x03, 0xE3, 0xC0, 0x73, 0x80, 0xF0, 0xF0, 0x3C, 0xE0, 0x7C, 0x3C, 0x0E,
  0x38, 0x1E, 0x0F, 0x07, 0x8E, 0x0F, 0x83, 0xC1, 0xE3, 0x83, 0xC0, 0xF0,
  0xF0, 0xE0, 0xF0, 0x3C, 0x3C, 0x38, 0x78, 0x0F, 0x0E, 0x0F, 0x1E, 0x03,
  0xC7, 0x83, 0xCF, 0x00, 0xF1, 0xC0, 0xF3, 0xC0, 0x3C, 0xF0, 0x3D, 0xF0,
  0x0F, 0x38, 0x0F, 0x78, 0x01, 0xDE, 0x03, 0xDE, 0x00, 0x77, 0x00, 0xFF,
  0x00, 0x1D, 0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x3F, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0xCF,
  0xFF, 0xFE, 0x03, 0xFF, 0xD0, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 35, 13, 1, -34 },
  { 54, 15, 12, 19, 5, -34 },
  { 77, 30, 34, 31, 1, -34 },
  { 205, 23, 39, 26, 2, -36 },
  { 318, 32, 35, 38, 4, -35 },
  { 458, 29, 35, 32, 2, -35 },
  { 585, 7, 12, 11, 5, -34 },
  { 596, 16, 42, 14, 2, -34 },
  { 680, 16, 42, 14, -4, -34 },
  { 764, 22, 23, 26, 5, -37 },
  { 828, 23, 24, 27, 3, -29 },
  { 897, 9, 12, 12, -2, -6 },
  { 911, 12, 4, 15, 1, -15 },
  { 917, 6, 7, 12, 1, -6 },
  { 923, 23, 34, 17, -2, -34 },
  { 1021, 23, 35, 26, 3, -35 },
  { 1122, 14, 34, 26, 7, -34 },
  { 1182, 25, 35, 26, 0, -35 },
  { 1292, 24, 35, 26, 1, -35 },
  { 1397, 26, 34, 26, 0, -34 },
  { 1508, 24, 34, 26, 2, -34 },
  { 1610, 23, 35, 26, 3, -35 },
  { 1711, 23, 34, 26, 4, -34 },
  { 1809, 24, 35, 26, 2, -35 },
  { 1914, 23, 35, 26, 2, -35 },
  { 2015, 10, 27, 12, 1, -26 },
  { 2049, 13, 32, 12, -2, -26 },
  { 2101, 23, 23, 27, 3, -29 },
  { 2168, 22, 13, 27, 4, -23 },
  { 2204, 23, 23, 27, 3, -29 },
  { 2271, 18, 36, 21, 4, -35 },
  { 2352, 36, 38, 41, 3, -34 },
  { 2523, 28, 34, 27, -3, -34 },
  { 2642, 26, 34, 29, 2, -34 },
  { 2753, 27, 35, 28, 3, -35 },
  { 2872, 29, 34, 32, 2, -34 },
  { 2996, 25, 34, 25, 2, -34 },
  { 3103, 25, 34, 23, 2, -34 },
  { 3210, 29, 35, 33, 3, -35 },
  { 3337, 31, 34, 33, 2, -34 },
  { 3469, 19, 34, 16, -1, -34 },
  { 3550, 21, 43, 13, -7, -34 },
  { 3663, 29, 34, 27, 2, -34 },
  { 3787, 18, 34, 23, 2, -34 },
  { 3864, 39, 34, 40, 2, -34 },
  { 4030, 32, 34, 34, 2, -34 },
  { 4166, 30, 35, 35, 3, -35 },
  { 4298, 25, 34, 27, 2, -34 },
  { 4405, 30, 43, 35, 3, -35 },
  { 4567, 25, 34, 28, 2, -34 },
  { 4674, 24, 35, 24, 1, -35 },
  { 4779, 24, 34, 24, 4, -34 },
  { 4881, 29, 34, 33, 4, -34 },
  { 5005, 27, 34, 27, 4, -34 },
  { 5120, 40, 34, 41, 5, -34 },
  { 5290, 32, 34, 25, -3, -34 },
  { 5426, 25, 34, 24, 4, -34 },
  { 5533, 28, 34, 25, 0, -34 },
  { 5652, 18, 42, 14, 0, -34 },
  { 5747, 9, 34, 17, 5, -34 },
  { 5786, 18, 42, 14, -3, -34 },
  { 5881, 24, 22, 27, 2, -35 },
  { 5947, 19, 4, 19, -4, 4 },
  { 5957, 8, 8, 13, 7, -37 },
  { 5965, 24, 26, 27, 2, -26 },
  { 6043, 24, 36, 28, 1, -36 },
  { 6151, 20, 26, 22, 2, -26 },
  { 6216, 27, 36, 28, 2, -36 },
  { 6338, 21, 26, 24, 2, -26 },
  { 6407, 26, 49, 15, -5, -37 },
  { 6567, 25, 38, 28, 1, -26 },
  { 6686, 24, 36, 28, 1, -36 },
  { 6794, 12, 35, 12, 1, -35 },
  { 6847, 19, 47, 12, -6, -35 },
  { 6959, 24, 36, 24, 1, -36 },
  { 7067, 12, 36, 12, 1, -36 },
  { 7121, 38, 26, 42, 1, -26 },
  { 7245, 24, 26, 28, 1, -26 },
  { 7323, 23, 26, 27, 2, -26 },
  { 7398, 26, 38, 28, -1, -26 },
  { 7522, 24, 38, 28, 2, -26 },
  { 7636, 20, 26, 19, 1, -26 },
  { 7701, 20, 26, 21, 0, -26 },
  { 7766, 15, 32, 16, 2, -32 },
  { 7826, 23, 26, 28, 3, -26 },
  { 7901, 23, 26, 22, 2, -26 },
  { 7976, 34, 26, 35, 3, -26 },
  { 8087, 26, 26, 23, -2, -26 },
  { 8172, 30, 38, 22, -5, -26 },
  { 8315, 22, 26, 21, -1, -26 },
  { 8387, 18, 42, 17, 1, -34 },
  { 8482, 4, 48, 26, 12, -36 },
  { 8506, 19, 42, 17, -2, -34 },
  { 8606, 23, 6, 27, 3, -20 },
};

const GFXfont NotoSans_Italic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic48pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_ITALIC48PT7B_H_
