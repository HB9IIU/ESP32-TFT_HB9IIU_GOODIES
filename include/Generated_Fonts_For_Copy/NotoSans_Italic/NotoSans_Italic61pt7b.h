#ifndef _NOTOSANS_ITALIC61PT7B_H_
#define _NOTOSANS_ITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x3F, 0x0F, 0xCF, 0x83, 0xF7,
  0xE0, 0xFD, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFD,
  0xFF, 0xE0, 0x1F, 0x8F, 0x03, 0x80, 0xFC, 0x3C, 0x04, 0x03, 0xE0, 0xF0,
  0x00, 0x1F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0xFC, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x07, 0x8F,
  0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x07, 0x83, 0xF0, 0x80, 0x1E, 0x1F, 0x83, 0xC0, 0x79, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3E, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x1E,
  0x00, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0x3C,
  0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x03, 0xE0,
  0x01, 0xE0, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x07, 0x83, 0xE0, 0x00, 0x78,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x03, 0xE1, 0xF1, 0xFF, 0x1E, 0x01, 0xE1,
  0xF1, 0xFF, 0xCF, 0x01, 0xF1, 0xF1, 0xFF, 0xF7, 0xC1, 0xF0, 0xF1, 0xF8,
  0xFB, 0xF1, 0xF8, 0xF9, 0xF8, 0x3E, 0xFF, 0xF8, 0xF8, 0xF8, 0x1F, 0x7F,
  0xF8, 0xF8, 0xF8, 0x07, 0x9F, 0xF8, 0x78, 0x7C, 0x03, 0xC3, 0xF0, 0x7C,
  0x3C, 0x01, 0xE0, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x3E, 0x00,
  0x3E, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xC0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x01,
  0xFB, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0xF8,
  0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x00, 0x3E, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x7E,
  0x00, 0x1F, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x0F, 0xC0, 0x0F, 0x8F,
  0xE0, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x07, 0xC7, 0xE0, 0x03, 0xF0,
  0x7E, 0x3E, 0x00, 0x1F, 0x83, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x1F, 0x00,
  0x01, 0xFB, 0xF0, 0xF8, 0x00, 0x0F, 0xFF, 0x07, 0xC0, 0x00, 0x3F, 0xF0,
  0x3E, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xE0,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x03,
  0x40, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x02, 0x00, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x07, 0xE0, 0x78,
  0x00, 0x7F, 0xC7, 0x80, 0x0F, 0xFF, 0x70, 0x00, 0x1F, 0xFF, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0x83, 0xF0, 0x0F, 0xB8, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x3C, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x1E, 0x00, 0x1F, 0x81, 0xF0, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x60, 0x0F, 0x80, 0x04, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xC0, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E,
  0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0x9F, 0x3F, 0xC7, 0xC7, 0xC1, 0xF1,
  0xE0, 0xFC, 0x20, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x1C, 0x00,
  0x3F, 0x80, 0x20, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x10, 0x00, 0x01,
  0xF8, 0x3C, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x03, 0xF0, 0x38, 0x00,
  0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0xC0, 0x0F, 0x8F, 0xFF, 0x80, 0xFC,
  0xFF, 0xFE, 0x07, 0xEF, 0xFF, 0xF8, 0x3E, 0xF8, 0x1F, 0xC1, 0xFF, 0x00,
  0x7F, 0x0F, 0xF0, 0x01, 0xF8, 0xFF, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x3E,
  0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C,
  0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3E, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE,
  0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF8, 0x7F,
  0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF,
  0x9F, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x1C, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x0F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7C,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x0F,
  0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xC7, 0x80, 0x3F, 0x84, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0xFF, 0xF8, 0x07,
  0xC3, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0x8F, 0x80, 0x1F, 0xFF, 0xF0, 0x1F,
  0x1F, 0x00, 0x7F, 0x07, 0xE0, 0x1E, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x3C,
  0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x79, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF7,
  0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xEF, 0x80, 0xF8, 0x00, 0xF0, 0x03, 0xDE,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xBC, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x78,
  0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xF0, 0x1F, 0x00, 0x1E, 0x00, 0x7B, 0xE0,
  0x3C, 0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x78, 0x00, 0xF8, 0x03, 0xEF, 0x80,
  0xF0, 0x03, 0xF0, 0x07, 0x9F, 0x01, 0xE0, 0x07, 0xE0, 0x1F, 0x3E, 0x03,
  0xC0, 0x1F, 0xC0, 0x3C, 0x7C, 0x07, 0xC0, 0x3F, 0x80, 0xF8, 0xF8, 0x0F,
  0x80, 0xEF, 0x03, 0xE0, 0xF0, 0x1F, 0xC7, 0xDF, 0x1F, 0x81, 0xE0, 0x1F,
  0xFF, 0x3F, 0xFF, 0x03, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xC0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x07, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x54, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0x00, 0x3F, 0xC0, 0x00, 0x20, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x18,
  0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x03,
  0xFE, 0x00, 0x01, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xE1, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x7C, 0x00,
  0x0F, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x01,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x7F, 0x00,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xC0,
  0xFE, 0x00, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x7C,
  0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x00,
  0x0F, 0xBE, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x7D, 0xE0, 0x00,
  0x07, 0xDF, 0x80, 0x3C, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF8, 0x07, 0xE7, 0xC0,
  0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xE0,
  0x78, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x01, 0xF0,
  0x1F, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3C, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x0F,
  0xF0, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x80, 0x3C,
  0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x1F, 0x00,
  0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x03, 0xF0, 0x07, 0xC7, 0xE0, 0x01, 0xF0,
  0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x01, 0xFB,
  0xE0, 0x0F, 0xC0, 0x00, 0x7D, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x80, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x1F, 0xF0, 0x03,
  0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE0,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0x00,
  0x7F, 0x00, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x10,
  0x00, 0x07, 0xF0, 0x38, 0x00, 0x1F, 0xC0, 0x7E, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xD0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x7E, 0x1F, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF3,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0x8F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x3E, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x80, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x7C, 0x07, 0xE0,
  0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x07, 0xC0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x03, 0xCF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xEF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x7F, 0xF0, 0x78, 0x03, 0xFF, 0xF0,
  0xF0, 0x0F, 0xFF, 0xF3, 0xE0, 0x3F, 0xE3, 0xF7, 0xC0, 0xFE, 0x01, 0xFF,
  0x03, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8,
  0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3E,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xF0, 0x0F,
  0x7C, 0x07, 0xF0, 0x7E, 0xF8, 0x0F, 0xFF, 0xF9, 0xE0, 0x0F, 0xFF, 0xE3,
  0xC0, 0x0F, 0xFF, 0x07, 0x80, 0x0F, 0xF8, 0x1F, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x3F, 0x0F, 0xFE, 0x00, 0xF8, 0xFF,
  0xFC, 0x03, 0xE7, 0xFF, 0xF8, 0x0F, 0xBF, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xC1, 0xFF, 0x80, 0x3F, 0x07, 0xF8, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xF0,
  0x7F, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFF,
  0x81, 0xFE, 0x0F, 0x9F, 0xFF, 0xF0, 0x3E, 0x3F, 0xFF, 0x80, 0xF0, 0x7F,
  0xF8, 0x03, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xE0, 0xF0, 0x3F, 0x80, 0x08, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x01, 0x03, 0xF8, 0x07, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x83, 0xE0, 0x01, 0xFF, 0xE1, 0xF0, 0x01,
  0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xFE, 0x7C, 0x01, 0xFE, 0x1F, 0xBE, 0x01,
  0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x01,
  0xFE, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xEF, 0x80, 0x3F, 0x83,
  0xE7, 0xC0, 0x1F, 0xFF, 0xE3, 0xC0, 0x07, 0xFF, 0xE3, 0xE0, 0x01, 0xFF,
  0xE1, 0xF0, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x03, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x87, 0xDF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x3F, 0x80, 0x7C, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x3F, 0xFC, 0x1E, 0x00, 0x7F,
  0xFE, 0x1E, 0x00, 0xFF, 0xFF, 0x3E, 0x01, 0xFE, 0x1F, 0xBE, 0x03, 0xF8,
  0x07, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0xC0, 0x7E, 0x00,
  0x7F, 0xC0, 0x3F, 0x00, 0xF7, 0xC0, 0x3F, 0x83, 0xEF, 0xC0, 0x3F, 0xFF,
  0xCF, 0x80, 0x1F, 0xFF, 0x8F, 0x80, 0x0F, 0xFF, 0x0F, 0x80, 0x07, 0xFE,
  0x1F, 0x80, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x01,
  0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x3F, 0x0F, 0xFE, 0x00, 0xF8,
  0xFF, 0xFC, 0x03, 0xE7, 0xFF, 0xF8, 0x0F, 0xBF, 0x0F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xC1, 0xFF, 0x80, 0x3F, 0x07, 0xF8, 0x00, 0xFC, 0x1F, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xF8,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F,
  0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFB,
  0xF0, 0x00, 0x3F, 0xC7, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xE1, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE3,
  0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xE7, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xEF,
  0xC7, 0xF1, 0xF8, 0xFE, 0x03, 0xFF, 0x01, 0xF3, 0xC0, 0x3F, 0x07, 0xFC,
  0x01, 0xF7, 0x80, 0x3F, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xE0, 0x03, 0xE1, 0xFF, 0xF0,
  0x07, 0xC7, 0xFF, 0xF0, 0x0F, 0x9F, 0xFF, 0xE0, 0x1F, 0x7F, 0xBF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xC0, 0x1F, 0x81, 0xFF, 0x00, 0x3F, 0x03,
  0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x07, 0xF0,
  0x00, 0x3E, 0x0F, 0xFE, 0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x0F, 0x9F, 0xFF,
  0xE0, 0x07, 0xDF, 0x8F, 0xF0, 0x03, 0xDF, 0x01, 0xFC, 0x03, 0xFF, 0x00,
  0x7E, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x7F, 0x00,
  0x07, 0xC0, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7E, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFD, 0xFF, 0xFF, 0x00,
  0x7C, 0x7F, 0xFF, 0x00, 0x3E, 0x1F, 0xFF, 0x00, 0x1F, 0x07, 0xFE, 0x00,
  0x0F, 0x80, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0xF0, 0x78, 0x03, 0xFF,
  0xF0, 0xF0, 0x0F, 0xFF, 0xF3, 0xE0, 0x3F, 0xC3, 0xF7, 0xC0, 0xFE, 0x01,
  0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03,
  0xF8, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xF0,
  0x0F, 0x7C, 0x07, 0xF0, 0x7D, 0xF8, 0x0F, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF,
  0xC7, 0xC0, 0x0F, 0xFF, 0x0F, 0x80, 0x0F, 0xFC, 0x3F, 0x00, 0x01, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x7F, 0x03,
  0xE1, 0xFF, 0x03, 0xE3, 0xFF, 0x03, 0xE7, 0xFE, 0x03, 0xEF, 0xFE, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0x83, 0xF0, 0x3F, 0x00, 0x18, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x18,
  0x00, 0x3F, 0x0F, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x02, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xE0, 0x0F, 0x7C,
  0x07, 0xE0, 0x7C, 0xF8, 0x0F, 0xFF, 0xF1, 0xE0, 0x0F, 0xFF, 0xC7, 0xC0,
  0x0F, 0xFF, 0x0F, 0x80, 0x0F, 0xF8, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xEF, 0x80, 0x07, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x3E, 0x00, 0x3F, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0x1F, 0x00, 0x3D, 0xE0, 0x07, 0xE3, 0xE0, 0x0F,
  0xBC, 0x00, 0xF8, 0x7C, 0x01, 0xE7, 0x80, 0x3F, 0x0F, 0x80, 0x7C, 0xF0,
  0x07, 0xC1, 0xF0, 0x0F, 0x9E, 0x01, 0xF8, 0x3E, 0x01, 0xE3, 0xC0, 0x3E,
  0x07, 0xC0, 0x7C, 0x78, 0x0F, 0xC0, 0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0x1F,
  0x03, 0xE1, 0xE0, 0x7E, 0x03, 0xE0, 0x78, 0x3C, 0x0F, 0x80, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x1F,
  0x0F, 0x80, 0x3E, 0x1E, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x7C, 0xF0, 0x07, 0xDF, 0x00, 0x07, 0xBE,
  0x00, 0xFB, 0xE0, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x08,
  0xFF, 0xC0, 0x00, 0x4F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xD0, 0x00, 0x1F,
  0xF8, 0x80, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 45, 16, 1, -44 },
  { 91, 18, 16, 24, 7, -44 },
  { 127, 38, 44, 39, 2, -44 },
  { 336, 30, 50, 34, 2, -46 },
  { 524, 41, 45, 49, 5, -44 },
  { 755, 37, 45, 41, 2, -44 },
  { 964, 8, 16, 13, 7, -44 },
  { 980, 20, 54, 18, 2, -44 },
  { 1115, 20, 54, 18, -5, -44 },
  { 1250, 28, 29, 34, 6, -47 },
  { 1352, 29, 29, 35, 4, -36 },
  { 1458, 13, 15, 16, -3, -7 },
  { 1483, 15, 5, 19, 2, -19 },
  { 1493, 8, 8, 16, 1, -7 },
  { 1501, 30, 44, 22, -3, -44 },
  { 1666, 30, 45, 34, 3, -44 },
  { 1835, 18, 44, 34, 9, -44 },
  { 1934, 32, 44, 34, 0, -44 },
  { 2110, 31, 45, 34, 1, -44 },
  { 2285, 33, 44, 34, 0, -44 },
  { 2467, 31, 45, 34, 2, -44 },
  { 2642, 29, 45, 34, 4, -44 },
  { 2806, 29, 44, 34, 5, -44 },
  { 2966, 30, 45, 34, 3, -44 },
  { 3135, 29, 45, 34, 3, -44 },
  { 3299, 13, 35, 16, 1, -34 },
  { 3356, 17, 42, 16, -3, -34 },
  { 3446, 29, 30, 35, 4, -37 },
  { 3555, 28, 17, 35, 5, -30 },
  { 3615, 29, 30, 35, 4, -37 },
  { 3724, 23, 45, 26, 5, -44 },
  { 3854, 47, 50, 52, 3, -44 },
  { 4148, 34, 44, 34, -3, -44 },
  { 4335, 34, 44, 37, 2, -44 },
  { 4522, 35, 45, 36, 4, -44 },
  { 4719, 37, 44, 41, 2, -44 },
  { 4923, 32, 44, 31, 2, -44 },
  { 5099, 32, 44, 29, 2, -44 },
  { 5275, 37, 45, 41, 4, -44 },
  { 5484, 39, 44, 41, 3, -44 },
  { 5699, 24, 44, 20, -1, -44 },
  { 5831, 27, 56, 17, -10, -44 },
  { 6020, 38, 44, 34, 2, -44 },
  { 6229, 24, 44, 29, 2, -44 },
  { 6361, 49, 44, 51, 2, -44 },
  { 6631, 41, 44, 43, 2, -44 },
  { 6857, 38, 45, 44, 4, -44 },
  { 7071, 33, 44, 35, 2, -44 },
  { 7253, 38, 54, 44, 4, -44 },
  { 7510, 33, 44, 35, 2, -44 },
  { 7692, 31, 45, 31, 1, -44 },
  { 7867, 31, 44, 31, 5, -44 },
  { 8038, 37, 45, 41, 5, -44 },
  { 8247, 33, 44, 34, 6, -44 },
  { 8429, 51, 44, 52, 7, -44 },
  { 8710, 40, 44, 32, -3, -44 },
  { 8930, 31, 44, 31, 6, -44 },
  { 9101, 36, 44, 32, -1, -44 },
  { 9299, 24, 54, 18, -1, -44 },
  { 9461, 11, 44, 22, 7, -44 },
  { 9522, 23, 54, 18, -4, -44 },
  { 9678, 31, 28, 35, 2, -44 },
  { 9787, 26, 5, 24, -6, 5 },
  { 9804, 10, 10, 17, 9, -47 },
  { 9817, 31, 34, 35, 3, -33 },
  { 9949, 30, 47, 35, 2, -46 },
  { 10126, 25, 34, 28, 3, -33 },
  { 10233, 33, 47, 35, 3, -46 },
  { 10427, 26, 34, 30, 3, -33 },
  { 10538, 34, 62, 19, -7, -47 },
  { 10802, 32, 48, 35, 2, -33 },
  { 10994, 30, 46, 35, 2, -46 },
  { 11167, 14, 45, 16, 2, -45 },
  { 11246, 24, 60, 16, -8, -45 },
  { 11426, 30, 46, 30, 2, -46 },
  { 11599, 15, 46, 16, 2, -46 },
  { 11686, 48, 33, 53, 2, -33 },
  { 11884, 31, 33, 35, 1, -33 },
  { 12012, 28, 33, 34, 3, -33 },
  { 12128, 33, 48, 35, -1, -33 },
  { 12326, 31, 48, 35, 3, -33 },
  { 12512, 24, 33, 24, 2, -33 },
  { 12611, 25, 34, 26, 0, -33 },
  { 12718, 19, 41, 20, 3, -40 },
  { 12816, 31, 34, 35, 3, -33 },
  { 12948, 28, 33, 28, 3, -33 },
  { 13064, 43, 33, 44, 3, -33 },
  { 13242, 33, 33, 29, -2, -33 },
  { 13379, 37, 48, 28, -6, -33 },
  { 13601, 28, 33, 27, -1, -33 },
  { 13717, 23, 54, 21, 1, -44 },
  { 13873, 4, 61, 34, 16, -46 },
  { 13904, 23, 54, 21, -2, -44 },
  { 14060, 29, 9, 35, 4, -26 },
};

const GFXfont NotoSans_Italic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic61pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_ITALIC61PT7B_H_
