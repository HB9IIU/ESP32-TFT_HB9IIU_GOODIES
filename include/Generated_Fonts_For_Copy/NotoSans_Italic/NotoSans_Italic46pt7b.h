#ifndef _NOTOSANS_ITALIC46PT7B_H_
#define _NOTOSANS_ITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x06, 0x00, 0x3C, 0x7D, 0xF1, 0xF7, 0x87, 0x9E, 0x1E, 0x78,
  0x79, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0xF3, 0x83, 0x8E, 0x0E, 0x38,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0,
  0x70, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x80, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xBE, 0x0F,
  0x8E, 0x18, 0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0xEE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xCF, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87,
  0x80, 0x0E, 0x1E, 0x20, 0x38, 0xF8, 0xC0, 0xE7, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x78, 0x1F, 0xF0, 0x00, 0xE0, 0x7F, 0xE0, 0x03, 0x81, 0xE1, 0xC0,
  0x0F, 0x03, 0x83, 0xC0, 0x3C, 0x0F, 0x07, 0x80, 0x70, 0x1C, 0x0F, 0x01,
  0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x1E, 0x01, 0xC0, 0x70, 0x38,
  0x03, 0x80, 0xE0, 0xF0, 0x07, 0x01, 0xC3, 0xC0, 0x0E, 0x07, 0x8F, 0x00,
  0x1C, 0x0E, 0x1C, 0x7E, 0x38, 0x1C, 0x79, 0xFE, 0x70, 0x79, 0xE7, 0xFE,
  0xF1, 0xE7, 0x9E, 0x1D, 0xFF, 0x8E, 0x38, 0x3D, 0xFE, 0x3C, 0xF0, 0x79,
  0xF8, 0xF1, 0xC0, 0xF0, 0x03, 0xC7, 0x81, 0xE0, 0x07, 0x0F, 0x03, 0xC0,
  0x1E, 0x1C, 0x07, 0x00, 0x78, 0x38, 0x0E, 0x01, 0xE0, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0xE0, 0x3C, 0x03, 0x81, 0xC0, 0x70,
  0x07, 0x07, 0x81, 0xC0, 0x0E, 0x1E, 0x07, 0x80, 0x1F, 0xF8, 0x1E, 0x00,
  0x1F, 0xE0, 0x78, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE3,
  0xF0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xC7,
  0xE3, 0xC0, 0x3C, 0x7C, 0x1F, 0x01, 0xE3, 0xC0, 0x7C, 0x1E, 0x3C, 0x01,
  0xE1, 0xF1, 0xE0, 0x07, 0x8F, 0x0F, 0x00, 0x3E, 0xF0, 0xF0, 0x00, 0xFF,
  0x87, 0x80, 0x03, 0xF8, 0x1E, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFC, 0x07,
  0xC0, 0x1F, 0xE0, 0x3F, 0x03, 0xF7, 0x80, 0xFF, 0xFF, 0x3E, 0x03, 0xFF,
  0xF0, 0xF8, 0x0F, 0xFC, 0x03, 0xE0, 0x3D, 0xF7, 0x9E, 0x79, 0xE7, 0x1C,
  0xF3, 0x8E, 0x38, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x30, 0x1C,
  0x03, 0xE0, 0xC0, 0x1F, 0xCE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3B, 0x00, 0x83, 0xDC, 0x00, 0x3C, 0xE0,
  0x03, 0xC3, 0x80, 0x3C, 0x1C, 0x03, 0xE0, 0xF0, 0x06, 0x07, 0x80, 0x20,
  0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x38, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFE, 0x11, 0xEF, 0xFF, 0xFB, 0xE6, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8,
  0x7C, 0x0F, 0xC0, 0xF8, 0x3E, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E,
  0x3E, 0x00, 0x78, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0x78,
  0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x0F, 0x8F, 0x00, 0x3C, 0x3E, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xF0, 0x7C,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0xBF, 0xFB, 0xFB, 0xDF, 0x1E, 0x60, 0xF2,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xF8, 0x7E, 0x01, 0xC0, 0x1F, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3F, 0x07, 0xE0, 0x38, 0x03, 0xE0, 0x20, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x8C, 0x00, 0x3E, 0x1F, 0x01, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9C, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x83,
  0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0,
  0x07, 0x81, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0E,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x08, 0x00, 0x7C,
  0x1E, 0x03, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x82, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x0C, 0x01,
  0xF3, 0xFE, 0x07, 0x9F, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x03, 0xE3, 0xF0,
  0x07, 0xCF, 0xC0, 0x0F, 0x3E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF8, 0x3E, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0x83, 0xE0, 0x3C, 0x03, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3E, 0x03,
  0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x7E, 0x1F, 0x01, 0xF0, 0x1F, 0x07,
  0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x87, 0xC0,
  0x1E, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8, 0x7E,
  0x0F, 0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3E,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x1F, 0x01, 0xF8,
  0x7F, 0x7F, 0xE0, 0xFF, 0xF7, 0x81, 0xFF, 0x9E, 0x01, 0xF0, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0x01, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07, 0x87, 0xE3, 0xF1, 0xF0, 0xF8,
  0x30, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0x3F, 0xFF,
  0xCF, 0x87, 0xE2, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0xF0, 0x03, 0xE0, 0x0E, 0x1E, 0x01, 0xFF, 0xE0, 0xE1, 0xE0, 0x3F, 0xFE,
  0x0F, 0x3C, 0x07, 0xC1, 0xC0, 0xF3, 0x80, 0xF0, 0x1C, 0x0F, 0x38, 0x1E,
  0x03, 0xC0, 0xF7, 0x83, 0xC0, 0x3C, 0x0F, 0x70, 0x3C, 0x03, 0x80, 0xF7,
  0x03, 0x80, 0x38, 0x0F, 0x70, 0x78, 0x07, 0x80, 0xE7, 0x07, 0x80, 0x78,
  0x0E, 0xF0, 0x78, 0x07, 0x01, 0xEF, 0x07, 0x00, 0xF0, 0x1C, 0xF0, 0x78,
  0x0F, 0x03, 0xC7, 0x07, 0x81, 0xF0, 0x38, 0x70, 0x78, 0x3F, 0x87, 0x87,
  0x03, 0xFF, 0x3F, 0xF0, 0x78, 0x1F, 0xE3, 0xFE, 0x07, 0x80, 0xF8, 0x1F,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x38,
  0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3C,
  0x01, 0xF8, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xF0, 0x78, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x87, 0x80, 0x1F, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFC, 0x7E, 0x03, 0xF8, 0x01, 0x80, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x10, 0x07, 0xF0, 0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3C, 0x03, 0xF8, 0x07,
  0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x8F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xE0, 0x01,
  0xF8, 0x3C, 0x00, 0x7E, 0x07, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF0, 0xFE, 0x03, 0xF8,
  0x00, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xC7, 0x80, 0x1F, 0xF8, 0xF8,
  0x01, 0xFF, 0x8F, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x3F, 0x00,
  0x1E, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xF0,
  0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x80,
  0x07, 0x81, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x7C, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x1F,
  0x9E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0xC0, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3B, 0x80,
  0x00, 0xFF, 0x01, 0xDC, 0x00, 0x07, 0x78, 0x1E, 0xE0, 0x00, 0x7B, 0xC0,
  0xF7, 0x00, 0x03, 0xBC, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x3D, 0xE0, 0x03,
  0xCF, 0x01, 0xCF, 0x00, 0x1E, 0x78, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0xF1,
  0xC0, 0x0F, 0x3C, 0x07, 0x8E, 0x00, 0xF1, 0xE0, 0x3C, 0x70, 0x07, 0x0F,
  0x01, 0xC3, 0x80, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0x87, 0x80, 0xF0, 0xF0,
  0x3C, 0x3C, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0x3C, 0x3C, 0x1E, 0x0F, 0x03,
  0xC0, 0xE1, 0xE0, 0x78, 0x1E, 0x07, 0x0F, 0x07, 0x80, 0xF0, 0x38, 0xF0,
  0x3C, 0x07, 0x81, 0xC7, 0x81, 0xE0, 0x3C, 0x0E, 0x78, 0x0F, 0x03, 0xC0,
  0x7B, 0x80, 0xF8, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xF0, 0x1F, 0xC0, 0x3C,
  0x07, 0x80, 0xFE, 0x01, 0xE0, 0x38, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x1F,
  0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0xF0,
  0x1F, 0x80, 0x01, 0xE0, 0x3F, 0x80, 0x03, 0xC0, 0x7F, 0x00, 0x07, 0x81,
  0xEF, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x3C, 0x07, 0xBC, 0x00, 0x78, 0x0F,
  0x3C, 0x00, 0xF0, 0x1C, 0x78, 0x01, 0xE0, 0x78, 0xF0, 0x07, 0x80, 0xF0,
  0xF0, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x03, 0xC1, 0xC0, 0x3C, 0x07, 0x03,
  0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0x1E, 0x3C, 0x07, 0x80, 0x3C,
  0x78, 0x0F, 0x00, 0x38, 0xF0, 0x1E, 0x00, 0x79, 0xE0, 0x3C, 0x00, 0xF3,
  0xC0, 0xF0, 0x00, 0xF7, 0x01, 0xE0, 0x01, 0xFE, 0x03, 0xC0, 0x03, 0xFC,
  0x07, 0x80, 0x03, 0xF8, 0x0E, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3E,
  0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x3E, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x3E, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x1F, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0xFC, 0x1E, 0x07, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x1F, 0x07, 0xC0,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00,
  0x7C, 0x0F, 0x01, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x78, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00,
  0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xC3, 0xE0, 0x7C, 0x00, 0xC0, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x08, 0x00, 0x7C, 0x1E, 0x03, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x0F, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0x80, 0x07, 0xBC, 0x00, 0x7E, 0x00, 0x1E, 0xF0, 0x01, 0xF8, 0x00,
  0xF3, 0xC0, 0x07, 0xE0, 0x03, 0xCF, 0x00, 0x3F, 0xC0, 0x1F, 0x3C, 0x00,
  0xEF, 0x00, 0x78, 0xF0, 0x07, 0xBC, 0x03, 0xE3, 0xC0, 0x1C, 0xF0, 0x0F,
  0x0F, 0x00, 0xF3, 0xC0, 0x3C, 0x3C, 0x03, 0x8F, 0x01, 0xE0, 0xF0, 0x1E,
  0x3C, 0x07, 0x83, 0xC0, 0x78, 0xF0, 0x3C, 0x07, 0x03, 0xC3, 0xC0, 0xF0,
  0x1C, 0x0F, 0x0F, 0x07, 0x80, 0x70, 0x78, 0x3C, 0x1E, 0x01, 0xE1, 0xE0,
  0x70, 0xF8, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0x1E, 0x3C, 0x07, 0x0F, 0x00,
  0x78, 0xE0, 0x1C, 0x78, 0x01, 0xE7, 0x80, 0x71, 0xE0, 0x07, 0x9C, 0x01,
  0xCF, 0x00, 0x1E, 0xF0, 0x07, 0x3C, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x01,
  0xFE, 0x00, 0x77, 0x80, 0x07, 0xF8, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x1F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x3C, 0x01, 0xF0,
  0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x3E, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x78,
  0x3C, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03,
  0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x80,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x21, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0xF3, 0x80, 0x01, 0xC7, 0x80,
  0x07, 0x87, 0x00, 0x0E, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1E, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x38,
  0x00, 0x70, 0xF0, 0x00, 0xF1, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xEE, 0x00,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xF1, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC3, 0x80, 0x00, 0x7E, 0x0E, 0x03, 0xFF, 0x1C, 0x0F,
  0xFF, 0x78, 0x3F, 0x1E, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x0F, 0x87,
  0xC0, 0x3F, 0x07, 0x80, 0xFE, 0x0F, 0x83, 0xBC, 0x1F, 0xFE, 0x78, 0x1F,
  0xF8, 0xE0, 0x1F, 0xE1, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x0F,
  0x80, 0x3C, 0x7F, 0xC0, 0x79, 0xFF, 0xC0, 0xF7, 0x8F, 0x81, 0xDC, 0x0F,
  0x87, 0xF0, 0x0F, 0x0F, 0xC0, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78,
  0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x03, 0xE3, 0xC0, 0x07, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x7C, 0x3F, 0x83,
  0xF0, 0x73, 0xFF, 0xC0, 0xE3, 0xFF, 0x03, 0xC3, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xF8, 0xE0, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x0E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x87, 0x80, 0x3F, 0xF3, 0xC0,
  0x3F, 0xFD, 0xE0, 0x3F, 0x1E, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x00, 0xF8,
  0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00,
  0x7E, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x3F, 0x01, 0xE0, 0x3F, 0x80, 0xF8,
  0x3B, 0xC0, 0x7F, 0xF9, 0xE0, 0x1F, 0xF8, 0xE0, 0x07, 0xF8, 0x70, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0x3E, 0x0F, 0x81,
  0xE1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0x80,
  0x7C, 0x78, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x87, 0xE0, 0x78, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7C, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x27, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x07, 0x00, 0xFF, 0xC7, 0x01, 0xFF, 0xEF,
  0x03, 0xF1, 0xEF, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78,
  0x7C, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x3C, 0x07, 0xF0, 0x3E, 0x1E, 0xF0, 0x3F, 0xFC, 0xF0,
  0x1F, 0xF9, 0xE0, 0x0F, 0xF1, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xC0, 0x0F, 0x80, 0xFC, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0xC0, 0x3C,
  0x7F, 0xC0, 0x79, 0xFF, 0xC0, 0xF7, 0x8F, 0xC1, 0xDC, 0x0F, 0x87, 0xF0,
  0x0F, 0x0F, 0xC0, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78, 0x00,
  0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x23, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xE0,
  0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x0F,
  0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x73, 0xE0, 0x01, 0xEF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xDE, 0x00, 0x3F, 0x3C,
  0x00, 0x7C, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC0,
  0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x83, 0xE0, 0x0F, 0xC0, 0x3C, 0x7F, 0xC1, 0xFF, 0x01, 0xE7, 0xFE, 0x1F,
  0xFC, 0x0F, 0x78, 0xF9, 0xE3, 0xE0, 0x77, 0x03, 0xDC, 0x0F, 0x87, 0xF0,
  0x1F, 0xC0, 0x7C, 0x3F, 0x00, 0xFC, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x0F,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x87, 0xC0, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x0F, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x0F, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x87, 0xF0, 0x0F, 0x1F,
  0xF8, 0x1E, 0x7F, 0xF0, 0x3D, 0xF7, 0xF0, 0xFF, 0x03, 0xE1, 0xFC, 0x03,
  0xC3, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xF8, 0xFC, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xE3,
  0xE0, 0x07, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x80, 0x1F, 0x1E,
  0x00, 0x78, 0x7C, 0x03, 0xC0, 0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0xF1, 0xFF, 0x00, 0x79,
  0xFF, 0xC0, 0x39, 0xE3, 0xE0, 0x1D, 0xC0, 0xF8, 0x1F, 0xC0, 0x3C, 0x0F,
  0xC0, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC1,
  0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F,
  0x83, 0xC0, 0x07, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0xFE, 0x0F,
  0xC0, 0x7B, 0xFF, 0xC0, 0x3C, 0xFF, 0xC0, 0x3C, 0x3F, 0xC0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x0E,
  0x03, 0xFF, 0x1C, 0x0F, 0xFF, 0x78, 0x3F, 0x1E, 0xF0, 0xF8, 0x0F, 0xC3,
  0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x07,
  0xE3, 0xC0, 0x0F, 0x87, 0xC0, 0x3F, 0x07, 0x80, 0xFE, 0x0F, 0x87, 0xBC,
  0x1F, 0xFE, 0x78, 0x1F, 0xF9, 0xE0, 0x1F, 0xE3, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0x87, 0xE0, 0xF1, 0xF8, 0x1E, 0x7F,
  0x03, 0xDF, 0xE0, 0x77, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x87, 0xE3, 0xE1, 0xF0, 0x04, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC8, 0x00, 0xF1, 0xC0, 0x7E, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x7C, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03,
  0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x7C, 0x3C, 0x03, 0xF0, 0xF0, 0x1F, 0xC3,
  0xE1, 0xEF, 0x0F, 0xFF, 0x3C, 0x1F, 0xF8, 0xE0, 0x3F, 0xC3, 0x80, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x9E, 0x00, 0x3C, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x81,
  0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0x38, 0x1E, 0x00, 0xF0,
  0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x0F,
  0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x0F, 0xC0, 0x1E, 0xF0, 0x0F, 0xC0, 0x3E,
  0xF0, 0x1F, 0xC0, 0x3C, 0xF0, 0x1D, 0xC0, 0x7C, 0xF0, 0x1D, 0xC0, 0x78,
  0xF0, 0x3D, 0xC0, 0x78, 0xF0, 0x39, 0xC0, 0xF0, 0xF0, 0x79, 0xC0, 0xF0,
  0xF0, 0x71, 0xC1, 0xE0, 0xF0, 0xF1, 0xC1, 0xE0, 0xF0, 0xE1, 0xE3, 0xC0,
  0xF1, 0xE1, 0xE3, 0xC0, 0xF1, 0xC1, 0xE7, 0x80, 0xF3, 0xC1, 0xE7, 0x80,
  0xF3, 0x81, 0xE7, 0x80, 0xF7, 0x81, 0xEF, 0x00, 0xF7, 0x01, 0xEF, 0x00,
  0xF7, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x07,
  0xC0, 0x1E, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x00, 0xF3,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3C,
  0x00, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x8F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0x3F, 0xC0, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFA, 0x00, 0x0F, 0x80,
};

const GFXglyph NotoSans_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 34, 12, 1, -33 },
  { 52, 14, 12, 18, 5, -33 },
  { 73, 29, 33, 30, 1, -33 },
  { 193, 22, 38, 25, 2, -35 },
  { 298, 31, 33, 37, 4, -33 },
  { 426, 29, 33, 31, 1, -33 },
  { 546, 6, 12, 10, 5, -33 },
  { 555, 15, 40, 13, 2, -33 },
  { 630, 15, 40, 13, -4, -33 },
  { 705, 21, 21, 25, 5, -35 },
  { 761, 22, 22, 26, 3, -27 },
  { 822, 9, 11, 12, -2, -5 },
  { 835, 12, 4, 14, 1, -14 },
  { 841, 6, 7, 12, 1, -6 },
  { 847, 22, 33, 16, -2, -33 },
  { 938, 22, 33, 25, 3, -33 },
  { 1029, 13, 33, 25, 7, -33 },
  { 1083, 24, 33, 25, 0, -33 },
  { 1182, 23, 33, 25, 1, -33 },
  { 1277, 25, 33, 25, 0, -33 },
  { 1381, 23, 33, 25, 2, -33 },
  { 1476, 22, 33, 25, 3, -33 },
  { 1567, 22, 33, 25, 4, -33 },
  { 1658, 23, 33, 25, 2, -33 },
  { 1753, 22, 33, 25, 2, -33 },
  { 1844, 9, 26, 12, 1, -25 },
  { 1874, 12, 31, 12, -2, -25 },
  { 1921, 22, 23, 26, 3, -28 },
  { 1985, 22, 12, 26, 3, -22 },
  { 2018, 22, 23, 26, 3, -28 },
  { 2082, 17, 34, 20, 4, -33 },
  { 2155, 36, 37, 39, 2, -33 },
  { 2322, 27, 33, 26, -3, -33 },
  { 2434, 25, 33, 28, 2, -33 },
  { 2538, 26, 33, 27, 3, -33 },
  { 2646, 27, 33, 31, 2, -33 },
  { 2758, 23, 33, 24, 2, -33 },
  { 2853, 23, 33, 22, 2, -33 },
  { 2948, 28, 33, 31, 3, -33 },
  { 3064, 29, 33, 31, 2, -33 },
  { 3184, 19, 33, 15, -1, -33 },
  { 3263, 20, 42, 13, -7, -33 },
  { 3368, 28, 33, 26, 2, -33 },
  { 3484, 17, 33, 22, 2, -33 },
  { 3555, 37, 33, 39, 2, -33 },
  { 3708, 31, 33, 33, 2, -33 },
  { 3836, 29, 33, 33, 3, -33 },
  { 3956, 24, 33, 26, 2, -33 },
  { 4055, 29, 41, 33, 3, -33 },
  { 4204, 24, 33, 26, 2, -33 },
  { 4303, 23, 33, 23, 1, -33 },
  { 4398, 23, 33, 23, 4, -33 },
  { 4493, 28, 33, 31, 4, -33 },
  { 4609, 26, 33, 25, 4, -33 },
  { 4717, 38, 33, 39, 5, -33 },
  { 4874, 30, 33, 24, -2, -33 },
  { 4998, 24, 33, 23, 4, -33 },
  { 5097, 26, 33, 24, 0, -33 },
  { 5205, 17, 40, 13, 0, -33 },
  { 5290, 9, 33, 16, 5, -33 },
  { 5328, 17, 40, 13, -3, -33 },
  { 5413, 23, 21, 26, 2, -33 },
  { 5474, 19, 3, 18, -4, 4 },
  { 5482, 7, 7, 13, 7, -35 },
  { 5489, 23, 25, 26, 2, -25 },
  { 5561, 23, 35, 27, 1, -35 },
  { 5662, 19, 25, 21, 2, -25 },
  { 5722, 25, 35, 27, 2, -35 },
  { 5832, 20, 25, 23, 2, -25 },
  { 5895, 25, 46, 15, -5, -35 },
  { 6039, 24, 36, 27, 1, -25 },
  { 6147, 23, 35, 27, 1, -35 },
  { 6248, 11, 34, 12, 1, -34 },
  { 6295, 18, 45, 12, -6, -34 },
  { 6397, 23, 35, 23, 1, -35 },
  { 6498, 12, 35, 12, 1, -35 },
  { 6551, 37, 25, 40, 1, -25 },
  { 6667, 23, 25, 27, 1, -25 },
  { 6739, 22, 25, 26, 2, -25 },
  { 6808, 25, 36, 27, -1, -25 },
  { 6921, 23, 36, 27, 2, -25 },
  { 7025, 19, 25, 18, 1, -25 },
  { 7085, 19, 25, 20, 0, -25 },
  { 7145, 15, 30, 15, 2, -30 },
  { 7202, 22, 25, 27, 3, -25 },
  { 7271, 22, 25, 21, 2, -25 },
  { 7340, 32, 25, 33, 3, -25 },
  { 7440, 25, 25, 22, -2, -25 },
  { 7519, 28, 36, 21, -4, -25 },
  { 7645, 21, 25, 20, -1, -25 },
  { 7711, 18, 40, 16, 0, -33 },
  { 7801, 3, 46, 25, 12, -35 },
  { 7819, 18, 40, 16, -2, -33 },
  { 7909, 22, 6, 26, 3, -19 },
};

const GFXfont NotoSans_Italic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_ITALIC46PT7B_H_
