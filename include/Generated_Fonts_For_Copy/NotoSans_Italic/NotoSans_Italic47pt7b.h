#ifndef _NOTOSANS_ITALIC47PT7B_H_
#define _NOTOSANS_ITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0x60, 0x00, 0x3C, 0x3C, 0xF0, 0xF7, 0xC3, 0xDE,
  0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x1C, 0x70, 0x71, 0xC1, 0xCE,
  0x0E, 0x38, 0x38, 0xE0, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x01,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xC0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xCE, 0x1C, 0x1F, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0xCE, 0x00, 0x0F,
  0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x70,
  0xF0, 0x00, 0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x0F, 0x08, 0x0E, 0x3E,
  0x1C, 0x1C, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x1F, 0xF0,
  0x00, 0xF0, 0x7F, 0xE0, 0x01, 0xC0, 0xF1, 0xE0, 0x07, 0x83, 0xC3, 0xC0,
  0x1E, 0x0F, 0x03, 0x80, 0x78, 0x1E, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0xF0, 0x1C, 0x0F, 0x01, 0xE0, 0x38, 0x3C, 0x03, 0x80, 0xF0, 0x70,
  0x07, 0x01, 0xE1, 0xE0, 0x0E, 0x03, 0x87, 0x80, 0x1C, 0x07, 0x0E, 0x08,
  0x38, 0x1E, 0x38, 0xFE, 0x70, 0x38, 0xF3, 0xFE, 0xE0, 0xF3, 0xCF, 0xBF,
  0xE3, 0xC7, 0x3C, 0x3D, 0xFF, 0x1E, 0x78, 0x3B, 0xFC, 0x79, 0xE0, 0x71,
  0xF1, 0xE3, 0xC0, 0xE0, 0x03, 0x87, 0x01, 0xC0, 0x0F, 0x0E, 0x03, 0x80,
  0x3C, 0x3C, 0x07, 0x00, 0xF0, 0x78, 0x1E, 0x01, 0xC0, 0xF0, 0x3C, 0x07,
  0x81, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x07, 0x03, 0xC0, 0xE0,
  0x0F, 0x07, 0x03, 0xC0, 0x1E, 0x1E, 0x0F, 0x00, 0x1F, 0xF8, 0x3C, 0x00,
  0x3F, 0xE0, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x78, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0,
  0xF8, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xF3, 0xC0, 0x1E, 0x3E, 0x1F, 0x00, 0xF3, 0xE0, 0x7C, 0x0F, 0x1E, 0x01,
  0xE0, 0xF9, 0xE0, 0x0F, 0x87, 0x8F, 0x00, 0x3E, 0x78, 0x78, 0x00, 0xF7,
  0xC3, 0xC0, 0x07, 0xFC, 0x3E, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x7C, 0x07,
  0x80, 0x07, 0xE0, 0x3E, 0x00, 0xFF, 0x81, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0xF8, 0xF8, 0x1F, 0xFF, 0x83, 0xC0, 0x3F, 0xF0, 0x1F, 0x00, 0x3C, 0xF7,
  0xDE, 0x79, 0xE7, 0x9C, 0x71, 0xCE, 0x38, 0xE0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x20, 0x1C, 0x01, 0xC0, 0xE0, 0x1F, 0x87, 0x00, 0xFF, 0x30, 0x00, 0xFF,
  0x87, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0x8F, 0x81, 0xDC, 0x00,
  0x1E, 0xF0, 0x01, 0xE3, 0x80, 0x1E, 0x1C, 0x03, 0xE0, 0xF0, 0x0F, 0x03,
  0x80, 0x30, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x70, 0x78, 0x38,
  0x38, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x19, 0xFF, 0xFF, 0xFF, 0xE6,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFE, 0xFE, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0xC7, 0xC0,
  0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3,
  0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xE0,
  0x3E, 0x07, 0xE1, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7,
  0xE7, 0xBF, 0x3C, 0x70, 0xF1, 0x83, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1E, 0x01, 0xF0, 0x06, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFD, 0xFE,
  0x03, 0xC0, 0x3E, 0x01, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0xC0, 0x03, 0xF0, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x07,
  0xCF, 0x00, 0x07, 0xC7, 0x80, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x03,
  0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x03,
  0xE0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE3, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x08, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x10, 0x00, 0xFC, 0x3C, 0x07, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x87, 0xE0, 0x1F,
  0x3F, 0xF0, 0x3D, 0xFF, 0xF0, 0x7F, 0xC7, 0xE0, 0xFE, 0x03, 0xE3, 0xF0,
  0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x83, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x1E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x03, 0xE1,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xE7, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x7C, 0x00,
  0xF0, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xDF,
  0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xF3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1E,
  0x00, 0xFC, 0x3E, 0x07, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFB, 0xC0, 0x3F,
  0xC7, 0x80, 0x04, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x38, 0x1F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x06,
  0x00, 0x00, 0x70, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF7, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x1F, 0xF0, 0x1C, 0x3C, 0x03,
  0xFF, 0xE0, 0xE1, 0xC0, 0x7F, 0xFE, 0x07, 0x9E, 0x07, 0xC0, 0xF0, 0x3C,
  0xE0, 0x3C, 0x07, 0x81, 0xE7, 0x03, 0xC0, 0x38, 0x0F, 0x78, 0x3C, 0x03,
  0xC0, 0x7B, 0xC1, 0xE0, 0x1E, 0x03, 0x9C, 0x0E, 0x00, 0xF0, 0x1C, 0xE0,
  0xF0, 0x07, 0x00, 0xE7, 0x07, 0x80, 0x78, 0x0F, 0x78, 0x3C, 0x03, 0xC0,
  0x73, 0xC1, 0xE0, 0x3E, 0x07, 0x8E, 0x0F, 0x01, 0xF0, 0x3C, 0x70, 0x78,
  0x1F, 0x83, 0xC3, 0x81, 0xE1, 0xDC, 0x3C, 0x1C, 0x0F, 0xFC, 0xFF, 0xC0,
  0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0x80, 0xFC, 0x0F, 0x80, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xC0, 0x3F, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC0, 0xF0, 0x0F, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xE0, 0x1F, 0x80,
  0x78, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x3F, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x18, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x07, 0xF8, 0x3E, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xC0,
  0x3F, 0x80, 0x3C, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00,
  0xFE, 0x07, 0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x00,
  0xE0, 0x3F, 0x00, 0x02, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC7, 0x80, 0x1F, 0xFC, 0x78, 0x01,
  0xFF, 0xCF, 0x80, 0x1F, 0xFC, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x78,
  0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F,
  0x03, 0xF8, 0x01, 0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x1F, 0x80, 0x78, 0x01, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xF8,
  0x00, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3D,
  0xE0, 0x3B, 0xC0, 0x00, 0xFF, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x07, 0xBC,
  0x00, 0x1E, 0xF0, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x79, 0xC0, 0x03, 0xDF,
  0x01, 0xE7, 0x00, 0x1E, 0x78, 0x0F, 0x1C, 0x00, 0x79, 0xE0, 0x3C, 0x70,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x0E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF8,
  0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x78, 0x3C, 0x07, 0x83, 0x81, 0xE0, 0xF0, 0x1E, 0x0E, 0x0F, 0x07, 0xC0,
  0x70, 0x38, 0x3C, 0x1E, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x0F, 0x03, 0xC7,
  0x01, 0xE0, 0x3C, 0x0F, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0xE0, 0x3C, 0x07,
  0x80, 0xF7, 0x80, 0xF0, 0x1E, 0x01, 0xDC, 0x03, 0xC0, 0x78, 0x07, 0xF0,
  0x0F, 0x01, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x78, 0x1F, 0xC0, 0x00, 0xF0, 0x3F, 0x80, 0x01, 0xE0, 0x7F, 0x00,
  0x07, 0x80, 0xEF, 0x00, 0x0F, 0x03, 0xDE, 0x00, 0x1E, 0x07, 0xBC, 0x00,
  0x3C, 0x0F, 0x3C, 0x00, 0x78, 0x1E, 0x78, 0x01, 0xE0, 0x3C, 0x78, 0x03,
  0xC0, 0xF0, 0xF0, 0x07, 0x81, 0xE1, 0xE0, 0x0F, 0x03, 0xC1, 0xE0, 0x3E,
  0x07, 0x83, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0x1E, 0x1E, 0x03,
  0x80, 0x3C, 0x3C, 0x0F, 0x00, 0x3C, 0x78, 0x1E, 0x00, 0x78, 0xF0, 0x3C,
  0x00, 0xF3, 0xC0, 0x78, 0x00, 0xF7, 0x81, 0xE0, 0x01, 0xEF, 0x03, 0xC0,
  0x03, 0xDE, 0x07, 0x80, 0x03, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x1E, 0x00,
  0x07, 0xE0, 0x78, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0x81, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x80, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3C, 0x07, 0xF0, 0x1E, 0x00,
  0xF8, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0,
  0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78,
  0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7E, 0x01,
  0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x83, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3C, 0x07, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03,
  0xE0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0xFC, 0x0F, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF8,
  0x1F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7E, 0x01, 0xC0, 0xF8, 0x00, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x10, 0x00, 0xFC, 0x3E, 0x0F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8,
  0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00,
  0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x3C,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xC0, 0x07, 0x9E,
  0x00, 0x3F, 0x80, 0x0F, 0x3C, 0x00, 0x77, 0x00, 0x3E, 0x78, 0x01, 0xEE,
  0x00, 0x78, 0xF0, 0x03, 0x9C, 0x01, 0xF1, 0xE0, 0x0F, 0x38, 0x03, 0xC3,
  0xC0, 0x1E, 0x70, 0x0F, 0x83, 0xC0, 0x78, 0xE0, 0x1E, 0x07, 0x80, 0xF1,
  0xC0, 0x3C, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0x1E, 0x07, 0x87, 0x01, 0xE0,
  0x3C, 0x1E, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0xF0, 0x70,
  0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x78, 0x78, 0x03, 0xC3, 0x80, 0xF0, 0xF0,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x1E, 0x78,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x1E, 0x70,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x01, 0xEE, 0x00, 0x7B, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x03,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0,
  0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x78, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x1C, 0x0E, 0x07, 0x83, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x80, 0x03, 0x87, 0x00, 0x0F,
  0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x70, 0x00,
  0xF1, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E,
  0x0E, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x0F, 0x01, 0xFF, 0xCF, 0x07,
  0xFF, 0xCE, 0x0F, 0xC1, 0xFE, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1E,
  0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78,
  0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x07, 0xF0, 0x78, 0x0F, 0xE0, 0x7C, 0x1E, 0xE0, 0x3F,
  0xFC, 0xE0, 0x3F, 0xF9, 0xE0, 0x1F, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xC0, 0x07, 0xC7, 0xF8, 0x07, 0x8F, 0xFC, 0x07,
  0xBF, 0xFE, 0x07, 0xB8, 0x3E, 0x07, 0xF0, 0x1E, 0x0F, 0xE0, 0x1F, 0x0F,
  0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x7E, 0x00, 0xF8, 0x7F, 0x01, 0xF0, 0x7F, 0x83, 0xF0, 0x73,
  0xFF, 0xE0, 0x71, 0xFF, 0xC0, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x60, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x08, 0x3E, 0x07, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xC0,
  0xF0, 0x03, 0xFC, 0x3C, 0x03, 0xFF, 0xDE, 0x01, 0xFF, 0xF7, 0x80, 0xFC,
  0x0F, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x1F,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x01, 0xE0, 0x3B, 0x80, 0x7C, 0x1D, 0xE0,
  0x0F, 0xFF, 0x78, 0x03, 0xFF, 0x1E, 0x00, 0x7F, 0x87, 0x80, 0x00, 0x0C,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC1, 0xF0, 0xF8,
  0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x7C,
  0x07, 0xE7, 0x87, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x08, 0x3E, 0x03, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xEE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x02, 0x3E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC3, 0xC0, 0x7F, 0xF9, 0xE0, 0x7F, 0xFC,
  0xE0, 0x7E, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1E, 0x00,
  0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0x80,
  0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F,
  0x80, 0x3F, 0x07, 0xC0, 0x3F, 0x81, 0xE0, 0x3B, 0x80, 0xF8, 0x3B, 0xC0,
  0x3F, 0xFD, 0xE0, 0x1F, 0xF8, 0xF0, 0x03, 0xF8, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x80, 0x0F, 0x80, 0x7C, 0x1F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xC0, 0x07, 0xC7, 0xF8, 0x07, 0x8F, 0xFC, 0x07,
  0xBF, 0xFE, 0x07, 0xB8, 0x3E, 0x07, 0xF0, 0x1E, 0x0F, 0xE0, 0x1F, 0x0F,
  0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F,
  0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0x1E, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x02, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01,
  0x07, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x81, 0xF0,
  0x07, 0x83, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x1F, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xBC, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x1E, 0x00,
  0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x1F, 0xE0, 0x7F, 0x80, 0x79, 0xFF, 0x83, 0xFF, 0x01,
  0xEF, 0xFF, 0x1F, 0xFE, 0x07, 0xB8, 0x3C, 0xF0, 0xF8, 0x1F, 0xC0, 0xF7,
  0x01, 0xE0, 0xFE, 0x01, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC0, 0x1E, 0x0F,
  0x80, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xE0,
  0x07, 0x87, 0xC0, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x78,
  0x00, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x07, 0xC3, 0xC0,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xC0, 0x0F, 0x87, 0x80, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x87, 0xFC, 0x07, 0x9F, 0xFE, 0x07, 0xBF,
  0xFE, 0x07, 0xFC, 0x3E, 0x0F, 0xF0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3E, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00,
  0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x3E, 0x01, 0xE1,
  0xF0, 0x07, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0x80,
  0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x80, 0x0F, 0x9E,
  0x00, 0x3C, 0x78, 0x01, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0xFC, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x38,
  0x7F, 0x80, 0x1E, 0x3F, 0xF0, 0x07, 0xBF, 0xFE, 0x01, 0xEE, 0x0F, 0x80,
  0x7F, 0x01, 0xE0, 0x3F, 0x80, 0x7C, 0x0F, 0xC0, 0x0F, 0x03, 0xE0, 0x03,
  0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x07, 0xF0, 0x1F, 0x01, 0xFE, 0x0F, 0xC0, 0x7B, 0xFF,
  0xE0, 0x1E, 0x7F, 0xF0, 0x0F, 0x8F, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0x0F, 0x03, 0xFF, 0xCF, 0x07, 0xFF, 0xCE, 0x0F, 0xC0, 0xFE, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0x78,
  0x0E, 0xE0, 0x7C, 0x1D, 0xE0, 0x3F, 0xFD, 0xE0, 0x3F, 0xF1, 0xE0, 0x0F,
  0xE3, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x70, 0xFC, 0x1E, 0x7F, 0x83, 0xDF, 0xE0, 0x7B, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xF8,
  0x0C, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x79, 0x00, 0x1F, 0x3C, 0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE1, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF8,
  0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x87, 0x80, 0x7F, 0x0F,
  0x01, 0xDC, 0x1F, 0x0F, 0x78, 0x3F, 0xFC, 0xF0, 0x3F, 0xF1, 0xE0, 0x3F,
  0xC3, 0xC0, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9E, 0x00,
  0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0,
  0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3C,
  0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78,
  0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1D, 0xE0, 0x00,
  0x77, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xE0, 0x07, 0xBC, 0x01, 0xF0, 0x07, 0xDE,
  0x01, 0xF8, 0x03, 0xCF, 0x00, 0xFE, 0x03, 0xE7, 0x80, 0xFF, 0x01, 0xE3,
  0xC0, 0x77, 0x81, 0xF1, 0xE0, 0x7B, 0xC0, 0xF0, 0xF0, 0x39, 0xE0, 0x78,
  0x78, 0x3C, 0xF0, 0x78, 0x3C, 0x1C, 0x78, 0x3C, 0x1E, 0x1E, 0x3C, 0x3C,
  0x0F, 0x0E, 0x1E, 0x1E, 0x07, 0x8F, 0x07, 0x1E, 0x03, 0xC7, 0x83, 0x8F,
  0x01, 0xE7, 0x81, 0xCF, 0x80, 0xF3, 0xC0, 0xE7, 0x80, 0x79, 0xC0, 0x73,
  0xC0, 0x3D, 0xE0, 0x3B, 0xC0, 0x1E, 0xE0, 0x1D, 0xE0, 0x07, 0xF0, 0x0E,
  0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x7C, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x81, 0xE0, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x03,
  0xE0, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x1F,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x87, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x07, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0x80, 0x17, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xE8, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 35, 12, 1, -34 },
  { 54, 14, 13, 18, 5, -34 },
  { 77, 30, 34, 30, 1, -34 },
  { 205, 23, 39, 26, 2, -36 },
  { 318, 31, 34, 38, 4, -34 },
  { 450, 29, 34, 32, 1, -34 },
  { 574, 6, 13, 10, 5, -34 },
  { 584, 15, 41, 14, 2, -34 },
  { 661, 16, 41, 14, -4, -34 },
  { 743, 21, 22, 26, 5, -36 },
  { 801, 22, 23, 27, 3, -28 },
  { 865, 9, 11, 12, -2, -5 },
  { 878, 12, 3, 15, 1, -14 },
  { 883, 6, 7, 12, 1, -6 },
  { 889, 23, 34, 17, -2, -34 },
  { 987, 22, 34, 26, 3, -34 },
  { 1081, 14, 34, 26, 7, -34 },
  { 1141, 25, 34, 26, 0, -34 },
  { 1248, 24, 34, 26, 1, -34 },
  { 1350, 25, 34, 26, 0, -34 },
  { 1457, 23, 34, 26, 2, -34 },
  { 1555, 23, 34, 26, 3, -34 },
  { 1653, 22, 34, 26, 4, -34 },
  { 1747, 24, 34, 26, 2, -34 },
  { 1849, 23, 34, 26, 2, -34 },
  { 1947, 10, 27, 12, 1, -26 },
  { 1981, 13, 32, 12, -2, -26 },
  { 2033, 22, 24, 27, 3, -29 },
  { 2099, 21, 13, 27, 4, -23 },
  { 2134, 22, 24, 27, 3, -29 },
  { 2200, 17, 35, 20, 4, -34 },
  { 2275, 37, 38, 40, 2, -34 },
  { 2451, 27, 34, 26, -3, -34 },
  { 2566, 26, 34, 28, 2, -34 },
  { 2677, 27, 34, 28, 3, -34 },
  { 2792, 28, 34, 31, 2, -34 },
  { 2911, 24, 34, 24, 2, -34 },
  { 3013, 24, 34, 22, 2, -34 },
  { 3115, 28, 34, 32, 3, -34 },
  { 3234, 30, 34, 32, 2, -34 },
  { 3362, 19, 34, 15, -1, -34 },
  { 3443, 20, 43, 13, -7, -34 },
  { 3551, 29, 34, 26, 2, -34 },
  { 3675, 18, 34, 22, 2, -34 },
  { 3752, 38, 34, 40, 2, -34 },
  { 3914, 31, 34, 33, 2, -34 },
  { 4046, 29, 34, 34, 3, -34 },
  { 4170, 25, 34, 27, 2, -34 },
  { 4277, 29, 42, 34, 3, -34 },
  { 4430, 25, 34, 27, 2, -34 },
  { 4537, 23, 34, 24, 1, -34 },
  { 4635, 24, 34, 24, 4, -34 },
  { 4737, 28, 34, 32, 4, -34 },
  { 4856, 26, 34, 26, 4, -34 },
  { 4967, 39, 34, 40, 5, -34 },
  { 5133, 31, 34, 25, -2, -34 },
  { 5265, 24, 34, 24, 4, -34 },
  { 5367, 27, 34, 25, 0, -34 },
  { 5482, 17, 41, 14, 0, -34 },
  { 5570, 9, 34, 17, 5, -34 },
  { 5609, 17, 41, 14, -3, -34 },
  { 5697, 23, 21, 27, 2, -34 },
  { 5758, 19, 3, 19, -4, 4 },
  { 5766, 8, 8, 13, 7, -36 },
  { 5774, 24, 26, 27, 2, -26 },
  { 5852, 24, 36, 27, 1, -36 },
  { 5960, 20, 26, 21, 2, -26 },
  { 6025, 26, 36, 27, 2, -36 },
  { 6142, 20, 26, 23, 2, -26 },
  { 6207, 26, 47, 15, -5, -36 },
  { 6360, 25, 37, 27, 1, -26 },
  { 6476, 24, 36, 27, 1, -36 },
  { 6584, 12, 35, 12, 1, -35 },
  { 6637, 19, 46, 12, -6, -35 },
  { 6747, 24, 36, 23, 1, -36 },
  { 6855, 12, 36, 12, 1, -36 },
  { 6909, 38, 26, 41, 1, -26 },
  { 7033, 24, 26, 27, 1, -26 },
  { 7111, 22, 26, 26, 2, -26 },
  { 7183, 26, 37, 27, -1, -26 },
  { 7304, 24, 37, 27, 2, -26 },
  { 7415, 19, 26, 19, 1, -26 },
  { 7477, 19, 26, 20, 0, -26 },
  { 7539, 15, 31, 16, 2, -31 },
  { 7598, 23, 25, 27, 3, -25 },
  { 7670, 22, 25, 22, 2, -25 },
  { 7739, 33, 25, 34, 3, -25 },
  { 7843, 26, 25, 23, -2, -25 },
  { 7925, 28, 36, 22, -4, -25 },
  { 8051, 22, 25, 21, -1, -25 },
  { 8120, 18, 41, 16, 1, -34 },
  { 8213, 4, 47, 26, 12, -36 },
  { 8237, 18, 41, 16, -2, -34 },
  { 8330, 22, 7, 27, 3, -20 },
};

const GFXfont NotoSans_Italic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_ITALIC47PT7B_H_
