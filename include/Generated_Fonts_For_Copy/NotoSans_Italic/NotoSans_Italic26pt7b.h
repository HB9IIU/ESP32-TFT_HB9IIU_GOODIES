#ifndef _NOTOSANS_ITALIC26PT7B_H_
#define _NOTOSANS_ITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x80,
  0x00, 0xE3, 0x8C, 0x00, 0x67, 0x66, 0xE6, 0xC6, 0xC6, 0xC4, 0xCC, 0x01,
  0x8C, 0x01, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x06, 0x18, 0x7F,
  0xFF, 0x7F, 0xFF, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x62, 0xFF,
  0xFC, 0xFF, 0xFC, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x21,
  0x80, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x1F, 0xF1, 0xFF, 0x1C, 0x80, 0xCC,
  0x06, 0x60, 0x3B, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x6E, 0x03, 0x30,
  0x19, 0x80, 0x9C, 0xCD, 0xC7, 0xFC, 0x0F, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x1E, 0x01, 0x8F, 0xC0, 0xC7, 0x30, 0x61, 0x8C, 0x30, 0x63, 0x0C,
  0x30, 0xC6, 0x0C, 0x33, 0x03, 0x09, 0xC0, 0xC6, 0x6F, 0xB1, 0xB7, 0x67,
  0xD9, 0x8C, 0xEE, 0xC3, 0x03, 0x30, 0xC1, 0x8C, 0x60, 0xC3, 0x18, 0x30,
  0xC6, 0x18, 0x33, 0x0C, 0x0F, 0xC6, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0xF0,
  0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x38, 0x0C, 0x30, 0x0C, 0x70, 0x0F, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3B, 0x87, 0x71, 0x86, 0xE1, 0xCE, 0xC0, 0xFC,
  0xC0, 0x78, 0xC0, 0x70, 0xE0, 0xF8, 0x7F, 0xDC, 0x3F, 0x0E, 0x6F, 0xED,
  0xB0, 0x03, 0x83, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x06,
  0x03, 0x00, 0xC0, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x30,
  0x70, 0xE0, 0x02, 0x00, 0x70, 0x06, 0x0C, 0x60, 0xF6, 0x03, 0xFF, 0x0F,
  0xF1, 0xE0, 0x32, 0x0F, 0x30, 0x63, 0x00, 0x38, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x39, 0x9C, 0xC6, 0x60, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0x7F, 0x83, 0x9C, 0x38, 0x73, 0x83, 0x98,
  0x0D, 0xC0, 0x6E, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0C, 0xC0, 0x6E, 0x03,
  0x70, 0x39, 0x81, 0x8C, 0x1C, 0x71, 0xC1, 0xFC, 0x0F, 0xC0, 0x07, 0x0E,
  0x3E, 0x76, 0xEE, 0x8C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x70, 0x01, 0xE0, 0x3F, 0xE0, 0xE3, 0x82, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF,
  0xCF, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0x8F, 0x1C, 0x20, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0C, 0x0F, 0xC0, 0x78, 0x04, 0xF0, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x81, 0xC7, 0xFE, 0x3F, 0xC0, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xD8, 0x06, 0xE0, 0x33, 0x01, 0x8C,
  0x0E, 0x30, 0x70, 0xC3, 0x87, 0x0C, 0x18, 0x60, 0x63, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x3F, 0xC1, 0xDF,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x81, 0xE7,
  0xFE, 0x3F, 0xC0, 0x01, 0xF0, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x60, 0x06, 0x70, 0xFF, 0xCF, 0x9C, 0xE0, 0xEC, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0xEC, 0x0C, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x7F, 0xFB, 0xFF, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x7F, 0x83, 0x8E, 0x38, 0x31, 0x81, 0x8C,
  0x0C, 0x60, 0xE1, 0x8E, 0x0F, 0xC0, 0x7C, 0x0F, 0x70, 0xE1, 0xC6, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0C, 0x60, 0xE3, 0xFE, 0x0F, 0xE0, 0x03, 0xC0,
  0x7F, 0x07, 0x1C, 0x70, 0x63, 0x03, 0x38, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x31, 0x83, 0x8F, 0xEC, 0x3E, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x03, 0x87, 0xF8, 0x3F, 0x80, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xCE, 0x60, 0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC3, 0x0E, 0x18, 0x70, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x80, 0x0C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x0F,
  0x03, 0xC1, 0xF0, 0x78, 0x0E, 0x00, 0x80, 0x00, 0x1E, 0x3F, 0xE6, 0x38,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x30,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x1F,
  0xF8, 0x03, 0xC1, 0xC0, 0xE0, 0x0E, 0x1C, 0x00, 0x71, 0x80, 0x03, 0x30,
  0xFE, 0x36, 0x1C, 0x63, 0x63, 0x86, 0x36, 0x30, 0x63, 0x46, 0x0C, 0x3C,
  0x60, 0xC3, 0xC6, 0x1C, 0x3C, 0x61, 0xC6, 0x63, 0x7F, 0xC6, 0x3E, 0x78,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF3, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x06, 0x60,
  0x39, 0x80, 0xC6, 0x07, 0x18, 0x18, 0x60, 0xE1, 0x83, 0xFE, 0x1F, 0xFC,
  0xE0, 0x73, 0x01, 0xDC, 0x03, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x0F,
  0x80, 0x3F, 0xE0, 0xC7, 0xC7, 0x07, 0x18, 0x0C, 0x60, 0x31, 0x81, 0xCE,
  0x06, 0x3F, 0xF0, 0xFF, 0x03, 0x07, 0x0C, 0x0E, 0x70, 0x19, 0xC0, 0x66,
  0x03, 0x98, 0x0E, 0x60, 0x73, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0xF0, 0xF0, 0xC7, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x20, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x0C,
  0xFC, 0x1C, 0x1E, 0x18, 0x0E, 0x18, 0x06, 0x18, 0x06, 0x38, 0x07, 0x38,
  0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60,
  0x1C, 0x60, 0x38, 0x60, 0xF0, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xC3, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x3F, 0xE1,
  0xFF, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC3, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xFF, 0x0F, 0xF8, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x00, 0x00,
  0xF8, 0x0F, 0xFC, 0x3C, 0x38, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC1, 0xFB, 0x03, 0xF6, 0x00, 0xEC, 0x01, 0xD8,
  0x03, 0x38, 0x06, 0x70, 0x0C, 0x70, 0x38, 0x7F, 0xF0, 0x7F, 0xC0, 0x0C,
  0x03, 0x86, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x38,
  0x60, 0x1C, 0x30, 0x0C, 0x3F, 0xFE, 0x1F, 0xFF, 0x0C, 0x03, 0x86, 0x01,
  0x87, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x38, 0x60, 0x18, 0x70,
  0x0C, 0x38, 0x06, 0x00, 0x0F, 0xE1, 0xFC, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x83, 0xF8, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x3C, 0x3F, 0x07, 0x80, 0x0C, 0x07, 0x0C, 0x0E, 0x0C, 0x1C, 0x1C, 0x38,
  0x18, 0x70, 0x18, 0xE0, 0x19, 0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3B, 0x80, 0x31, 0x80, 0x71, 0xC0, 0x71, 0xC0, 0x60, 0xC0, 0x60, 0xE0,
  0x60, 0x60, 0xE0, 0x70, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x3F, 0xFF, 0xFC, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3,
  0x80, 0x3E, 0x36, 0x01, 0xE1, 0xB0, 0x1B, 0x0D, 0x80, 0xD8, 0x6C, 0x0D,
  0xC7, 0x60, 0x6C, 0x33, 0x06, 0x61, 0x98, 0x73, 0x0C, 0xC3, 0x18, 0x63,
  0x31, 0xC7, 0x19, 0x8C, 0x30, 0xD8, 0x61, 0x86, 0xC3, 0x0C, 0x3C, 0x38,
  0x61, 0xE1, 0xC7, 0x0E, 0x0C, 0x30, 0x70, 0x60, 0x0C, 0x01, 0xC3, 0x80,
  0x60, 0xE0, 0x18, 0x7C, 0x06, 0x1B, 0x03, 0x86, 0xC0, 0xC1, 0xB8, 0x30,
  0xE6, 0x0C, 0x31, 0x83, 0x0C, 0x31, 0xC3, 0x0C, 0x60, 0xC3, 0x98, 0x70,
  0x66, 0x18, 0x19, 0x86, 0x07, 0xE1, 0x80, 0xF0, 0x60, 0x3C, 0x38, 0x07,
  0x0C, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0xFC, 0x1E, 0x1E, 0x1C, 0x0E, 0x38,
  0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x70,
  0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0xC0, 0xCF, 0x87, 0x06,
  0x18, 0x1C, 0x60, 0x71, 0x81, 0xCE, 0x06, 0x38, 0x38, 0xC3, 0xC3, 0xFE,
  0x0F, 0xC0, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x1E, 0x1E, 0x1C, 0x0E, 0x38,
  0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x70,
  0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x0F, 0x80, 0x3F, 0xC0, 0xCF, 0x87, 0x07, 0x18, 0x1C, 0x60, 0x71,
  0x81, 0xCE, 0x06, 0x38, 0x38, 0xFF, 0xC3, 0xFC, 0x0C, 0x60, 0x71, 0xC1,
  0xC3, 0x06, 0x0E, 0x18, 0x38, 0x60, 0x63, 0x81, 0xCE, 0x03, 0x00, 0x01,
  0xF0, 0x1F, 0xF0, 0xE1, 0x87, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x80, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xFB, 0xFF,
  0xE1, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x18, 0x07, 0x38, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xE0, 0x30,
  0xE0, 0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x73,
  0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x30, 0x30, 0x60, 0xC0, 0xE3,
  0x81, 0xC6, 0x01, 0x9C, 0x03, 0x30, 0x06, 0xE0, 0x0D, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x1F, 0x01, 0xC0, 0x6C,
  0x0F, 0x03, 0xB0, 0x3C, 0x0C, 0xC0, 0xF0, 0x73, 0x06, 0xC1, 0x8C, 0x1B,
  0x0E, 0x30, 0xCC, 0x30, 0xC3, 0x30, 0xC3, 0x18, 0xC6, 0x0C, 0x63, 0x18,
  0x33, 0x0C, 0xE0, 0xCC, 0x33, 0x03, 0x70, 0xDC, 0x0D, 0x81, 0x60, 0x36,
  0x05, 0x80, 0xF0, 0x1C, 0x01, 0xC0, 0x70, 0x06, 0x01, 0x80, 0x00, 0x0C,
  0x03, 0x87, 0x03, 0x81, 0x81, 0x80, 0xC1, 0x80, 0x71, 0xC0, 0x19, 0xC0,
  0x0C, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x66, 0x00, 0x63, 0x00, 0x71, 0xC0, 0x70, 0x60, 0x30, 0x30, 0x30,
  0x1C, 0x38, 0x06, 0x00, 0xE0, 0x1D, 0x80, 0xE6, 0x03, 0x18, 0x1C, 0x70,
  0xE0, 0xC3, 0x03, 0x1C, 0x0C, 0xE0, 0x3B, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x07, 0xC3, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x3E, 0x0F, 0x80, 0xC6, 0x31, 0x8C, 0x31, 0x8C,
  0x63, 0x18, 0xE3, 0x18, 0xC6, 0x31, 0x8E, 0x07, 0xC1, 0xF0, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3E, 0x0F, 0x80,
  0x06, 0x00, 0x30, 0x03, 0xC0, 0x1A, 0x00, 0x98, 0x0C, 0x40, 0x63, 0x06,
  0x0C, 0x30, 0x63, 0x01, 0x98, 0x0D, 0x80, 0x30, 0xFF, 0xFF, 0xF0, 0xCE,
  0x63, 0x0F, 0x98, 0xFE, 0xCE, 0x1E, 0x60, 0x77, 0x03, 0x30, 0x19, 0x80,
  0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC3, 0xC7, 0xF6, 0x1F, 0x20,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x67, 0x87,
  0xFE, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0x60, 0x77, 0x03, 0xB0, 0x19, 0x80,
  0xCC, 0x0E, 0xE0, 0x67, 0x87, 0x37, 0xF1, 0x9F, 0x00, 0x07, 0xE3, 0xFC,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x27, 0xF8, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x03, 0xE6, 0x0F, 0xEC, 0x38, 0x78, 0x60, 0x71,
  0xC0, 0xC3, 0x01, 0x86, 0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0,
  0xE1, 0xC3, 0xC1, 0xFD, 0x81, 0xE6, 0x00, 0x0F, 0xC3, 0xFC, 0xE1, 0x98,
  0x37, 0x06, 0xC3, 0xBF, 0xE7, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x27,
  0xFC, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x98, 0xFE, 0xCE, 0x1E, 0x60, 0x77, 0x03,
  0x30, 0x19, 0x80, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC3, 0xC7,
  0xFE, 0x1F, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC4, 0x1C, 0x3F, 0xC1, 0xFC,
  0x00, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x67,
  0x87, 0xFE, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0x60, 0x67, 0x03, 0x30, 0x19,
  0x81, 0xCC, 0x0C, 0xE0, 0x67, 0x03, 0x30, 0x19, 0x81, 0xC0, 0x0C, 0x70,
  0x80, 0x00, 0x63, 0x8C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x38, 0xE3, 0x0C,
  0x00, 0x00, 0xC0, 0x70, 0x08, 0x00, 0x00, 0x00, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x01, 0x83, 0xE0, 0xF0, 0x00, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xE7, 0x0C, 0x30, 0xC1,
  0x8C, 0x0C, 0xC0, 0xEC, 0x06, 0xE0, 0x3F, 0x01, 0xDC, 0x0C, 0x60, 0xE3,
  0x87, 0x0C, 0x30, 0x71, 0x81, 0x80, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x8E,
  0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0x19, 0xE1, 0xE3,
  0x7F, 0x7F, 0x3C, 0x3C, 0x33, 0x83, 0x83, 0x38, 0x38, 0x33, 0x03, 0x03,
  0x70, 0x70, 0x76, 0x06, 0x07, 0x60, 0x60, 0x66, 0x06, 0x06, 0xE0, 0x60,
  0x6E, 0x0E, 0x0E, 0xC0, 0xC0, 0xEC, 0x0C, 0x0C, 0x3B, 0xF1, 0xBF, 0x8F,
  0x0E, 0x70, 0x73, 0x83, 0xB8, 0x19, 0xC0, 0xCC, 0x0E, 0x60, 0x73, 0x03,
  0xB8, 0x19, 0xC0, 0xCC, 0x0E, 0x60, 0x70, 0x07, 0xC1, 0xFE, 0x38, 0x73,
  0x03, 0x70, 0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x66,
  0x0E, 0x7F, 0xC1, 0xF0, 0x06, 0x78, 0x1B, 0xF8, 0x3C, 0x38, 0x70, 0x70,
  0xE0, 0xE1, 0x81, 0xC7, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x30, 0x38, 0xE0,
  0x61, 0xE1, 0xC3, 0x7F, 0x06, 0x7C, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x00, 0x0F, 0x98, 0xFE, 0xCE, 0x1E, 0x60,
  0x77, 0x03, 0x30, 0x19, 0x80, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39,
  0xC3, 0xC7, 0xFE, 0x1F, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x1B, 0xCD, 0xF3, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x0F, 0xE7, 0xF8,
  0xC1, 0x18, 0x03, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x30, 0x06,
  0x40, 0xCF, 0xF9, 0xFC, 0x00, 0x0C, 0x18, 0x18, 0x7F, 0xFF, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0x7C, 0x7C, 0x38, 0x19,
  0xC0, 0xCC, 0x06, 0x60, 0x73, 0x03, 0x38, 0x19, 0x80, 0xCC, 0x0E, 0x60,
  0x73, 0x07, 0x38, 0x39, 0xC3, 0xC7, 0xF6, 0x3E, 0x60, 0xE0, 0x3E, 0x07,
  0x60, 0x66, 0x0E, 0x60, 0xC6, 0x18, 0x63, 0x86, 0x30, 0x67, 0x06, 0x60,
  0x7E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0xE0, 0xE0, 0xEC, 0x1C, 0x19, 0x87,
  0x87, 0x30, 0xF0, 0xC6, 0x36, 0x38, 0xC6, 0xC6, 0x19, 0x98, 0xC3, 0x33,
  0x30, 0x6C, 0x66, 0x0D, 0x8D, 0x81, 0xE1, 0xB0, 0x3C, 0x3E, 0x07, 0x07,
  0x80, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x30, 0xE0, 0xC3, 0x01, 0x98, 0x06,
  0xE0, 0x1F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x37, 0x01, 0x8C, 0x0E,
  0x38, 0x70, 0x63, 0x81, 0xC0, 0x1C, 0x06, 0x38, 0x1C, 0x30, 0x30, 0x60,
  0xE0, 0xC1, 0x81, 0x86, 0x03, 0x0C, 0x07, 0x30, 0x06, 0xE0, 0x0D, 0x80,
  0x1B, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x03, 0x80,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0x40, 0xF0, 0x38, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0C, 0x03, 0x03, 0x81, 0xC0, 0xF0, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0x30, 0x07, 0x03, 0xC1, 0x80, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x3C, 0x0E, 0x00, 0x78, 0x1F, 0xF3, 0x87,
  0xF8, 0x0C,
};

const GFXglyph NotoSans_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 19, 7, 1, -19 },
  { 16, 8, 7, 10, 3, -19 },
  { 23, 16, 19, 17, 1, -19 },
  { 61, 13, 22, 14, 1, -20 },
  { 97, 18, 19, 21, 2, -19 },
  { 140, 16, 19, 18, 1, -19 },
  { 178, 3, 7, 6, 3, -19 },
  { 181, 9, 23, 8, 1, -19 },
  { 207, 8, 23, 8, -2, -19 },
  { 230, 12, 12, 14, 3, -20 },
  { 248, 12, 12, 15, 2, -15 },
  { 266, 5, 6, 7, -1, -3 },
  { 270, 6, 2, 8, 1, -8 },
  { 272, 3, 3, 7, 1, -3 },
  { 274, 12, 19, 9, -1, -19 },
  { 303, 13, 19, 14, 1, -19 },
  { 334, 8, 19, 14, 4, -19 },
  { 353, 14, 19, 14, 0, -19 },
  { 387, 13, 19, 14, 1, -19 },
  { 418, 14, 19, 14, 0, -19 },
  { 452, 13, 19, 14, 1, -19 },
  { 483, 12, 19, 14, 2, -19 },
  { 512, 13, 19, 14, 2, -19 },
  { 543, 13, 19, 14, 1, -19 },
  { 574, 13, 19, 14, 1, -19 },
  { 605, 5, 14, 7, 1, -14 },
  { 614, 7, 17, 7, -1, -14 },
  { 629, 12, 13, 15, 2, -16 },
  { 649, 12, 7, 15, 2, -13 },
  { 660, 12, 13, 15, 2, -16 },
  { 680, 10, 19, 11, 2, -19 },
  { 704, 20, 21, 22, 1, -19 },
  { 757, 14, 19, 15, -1, -19 },
  { 791, 14, 19, 16, 1, -19 },
  { 825, 14, 19, 15, 2, -19 },
  { 859, 16, 19, 17, 1, -19 },
  { 897, 13, 19, 13, 1, -19 },
  { 928, 13, 19, 12, 1, -19 },
  { 959, 15, 19, 18, 2, -19 },
  { 995, 17, 19, 18, 1, -19 },
  { 1036, 11, 19, 8, -1, -19 },
  { 1063, 11, 24, 7, -4, -19 },
  { 1096, 16, 19, 15, 1, -19 },
  { 1134, 10, 19, 12, 1, -19 },
  { 1158, 21, 19, 22, 1, -19 },
  { 1208, 18, 19, 18, 1, -19 },
  { 1251, 16, 19, 19, 2, -19 },
  { 1289, 14, 19, 15, 1, -19 },
  { 1323, 16, 23, 19, 2, -19 },
  { 1369, 14, 19, 15, 1, -19 },
  { 1403, 14, 19, 13, 0, -19 },
  { 1437, 13, 19, 13, 2, -19 },
  { 1468, 16, 19, 18, 2, -19 },
  { 1506, 15, 19, 14, 2, -19 },
  { 1542, 22, 19, 22, 3, -19 },
  { 1595, 17, 19, 14, -1, -19 },
  { 1636, 14, 19, 13, 2, -19 },
  { 1670, 15, 19, 14, 0, -19 },
  { 1706, 10, 23, 8, 0, -19 },
  { 1735, 5, 19, 9, 3, -19 },
  { 1747, 10, 23, 8, -2, -19 },
  { 1776, 13, 12, 15, 1, -19 },
  { 1796, 10, 2, 10, -2, 2 },
  { 1799, 4, 4, 7, 4, -20 },
  { 1801, 13, 14, 15, 1, -14 },
  { 1824, 13, 20, 15, 1, -20 },
  { 1857, 11, 14, 12, 1, -14 },
  { 1877, 15, 20, 15, 1, -20 },
  { 1915, 11, 14, 13, 1, -14 },
  { 1935, 15, 26, 8, -3, -20 },
  { 1984, 13, 20, 15, 1, -14 },
  { 2017, 13, 20, 15, 1, -20 },
  { 2050, 6, 19, 7, 1, -19 },
  { 2065, 10, 25, 7, -3, -19 },
  { 2097, 13, 20, 13, 1, -20 },
  { 2130, 6, 20, 7, 1, -20 },
  { 2145, 20, 14, 23, 1, -14 },
  { 2180, 13, 14, 15, 1, -14 },
  { 2203, 12, 14, 15, 1, -14 },
  { 2224, 15, 20, 15, -1, -14 },
  { 2262, 13, 20, 15, 1, -14 },
  { 2295, 10, 14, 10, 1, -14 },
  { 2313, 11, 14, 11, 0, -14 },
  { 2333, 8, 17, 9, 1, -17 },
  { 2350, 13, 14, 15, 1, -14 },
  { 2373, 12, 14, 12, 1, -14 },
  { 2394, 19, 14, 19, 1, -14 },
  { 2428, 14, 14, 13, -1, -14 },
  { 2453, 15, 20, 12, -2, -14 },
  { 2491, 11, 14, 12, 0, -14 },
  { 2511, 10, 23, 9, 0, -19 },
  { 2540, 2, 26, 14, 7, -20 },
  { 2547, 10, 23, 9, -1, -19 },
  { 2576, 12, 4, 15, 2, -11 },
};

const GFXfont NotoSans_Italic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_ITALIC26PT7B_H_
