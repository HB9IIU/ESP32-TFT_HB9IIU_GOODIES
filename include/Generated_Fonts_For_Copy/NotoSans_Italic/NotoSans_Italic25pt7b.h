#ifndef _NOTOSANS_ITALIC25PT7B_H_
#define _NOTOSANS_ITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83,
  0x00, 0x00, 0x30, 0x71, 0xC0, 0x67, 0xCF, 0x1E, 0x6C, 0xD1, 0xA2, 0x00,
  0x03, 0x0C, 0x06, 0x10, 0x0C, 0x60, 0x10, 0xC0, 0x61, 0x0F, 0xFF, 0xDF,
  0xFF, 0x86, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x87, 0xFF, 0xEF, 0xFF,
  0xC2, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0xC3, 0x00, 0x01, 0x80,
  0x18, 0x07, 0xE1, 0xFF, 0x39, 0x33, 0x30, 0x33, 0x03, 0x30, 0x3A, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x06, 0xE0, 0x4E, 0x0C, 0xCC, 0xDC, 0xFF, 0x83,
  0xC0, 0x08, 0x01, 0x80, 0x1E, 0x03, 0x1F, 0x03, 0x18, 0xC3, 0x0C, 0x61,
  0x8C, 0x31, 0x86, 0x11, 0x83, 0x19, 0x81, 0x8C, 0xDE, 0xC4, 0xDF, 0x7E,
  0xD8, 0xDE, 0xCC, 0x60, 0x64, 0x30, 0x66, 0x18, 0x63, 0x08, 0x61, 0x8C,
  0x30, 0xC6, 0x30, 0x7E, 0x30, 0x1E, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x30,
  0xC0, 0xE1, 0x81, 0x83, 0x03, 0x8E, 0x03, 0x38, 0x07, 0xC0, 0x0E, 0x00,
  0x7E, 0x01, 0xCE, 0x3F, 0x0C, 0x6C, 0x0D, 0xD8, 0x1F, 0x30, 0x1C, 0x70,
  0x78, 0x7F, 0xF8, 0x7E, 0x38, 0x7F, 0x6D, 0x20, 0x03, 0x06, 0x0C, 0x1C,
  0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C,
  0x18, 0x30, 0x60, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x62, 0x0F, 0x40, 0x3F,
  0xC7, 0x39, 0xB0, 0x76, 0x1C, 0x61, 0x0C, 0x01, 0x00, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x39, 0x9C, 0xC6, 0x60, 0xFF, 0xF0, 0x67, 0xE0, 0x00,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0C, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0x73, 0x83, 0x30, 0x33, 0x03, 0x70,
  0x36, 0x03, 0x60, 0x36, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x6E, 0x06, 0x60,
  0xC6, 0x1C, 0x7F, 0x83, 0xF0, 0x06, 0x3D, 0xFF, 0xEC, 0xC1, 0x87, 0x0E,
  0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x70, 0xC0, 0x03, 0xE0, 0xFF,
  0x83, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xF7, 0xFF, 0x00, 0x0F, 0xC3, 0xFE, 0x18, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x1C, 0x1F, 0x81, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC8, 0x1C, 0xFF, 0x8F, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x1B, 0x01, 0x98, 0x18, 0xC1, 0xCE, 0x1C, 0x60, 0xC3, 0x0C, 0x18,
  0xC0, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x0F, 0xF0, 0xFF, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0xF8,
  0x3F, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE8, 0x1C,
  0xFF, 0x8F, 0xF0, 0x03, 0xF0, 0xFE, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x0E, 0xF8, 0xDF, 0xCE, 0x0C, 0xC0, 0xCC, 0x0E, 0xC0, 0xCC, 0x0C,
  0xC0, 0xCE, 0x18, 0x7F, 0x83, 0xE0, 0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xE0, 0x7F,
  0x87, 0x0C, 0x30, 0x71, 0x83, 0x8C, 0x18, 0x71, 0xC1, 0xFC, 0x07, 0x80,
  0xFE, 0x1C, 0x30, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x81, 0x9C, 0x1C, 0x7F,
  0xC1, 0xFC, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x70, 0x36, 0x03,
  0x60, 0x36, 0x07, 0x70, 0x73, 0xBF, 0x1F, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0xFF, 0x0F, 0xE0, 0x18, 0x73, 0x86, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x73, 0x80, 0x0C, 0x1C, 0x70, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0x0E, 0x18, 0x70, 0xC0, 0x00, 0x30, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x3C,
  0x0F, 0x07, 0xC0, 0xE0, 0x08, 0x00, 0x3F, 0x7F, 0xD0, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x04, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0x01, 0xC0, 0xC0,
  0x0E, 0x18, 0x00, 0x63, 0x07, 0xC6, 0x31, 0xFE, 0x26, 0x38, 0xC3, 0x63,
  0x0C, 0x34, 0x60, 0xC2, 0xC6, 0x08, 0x6C, 0x61, 0x86, 0xC6, 0x18, 0xCC,
  0x72, 0xDC, 0x63, 0xCF, 0x86, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0x3C, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xB0, 0x0E, 0xC0, 0x33, 0x01, 0xCE, 0x06, 0x18, 0x38, 0x60, 0xFF,
  0x87, 0xFE, 0x18, 0x18, 0xC0, 0x67, 0x01, 0x98, 0x07, 0xE0, 0x1F, 0x00,
  0x30, 0x0F, 0xE0, 0x3F, 0xE1, 0xC3, 0x86, 0x07, 0x18, 0x1C, 0x60, 0x73,
  0x81, 0x8C, 0x1C, 0x3F, 0xC0, 0xFF, 0x83, 0x07, 0x1C, 0x0C, 0x60, 0x39,
  0x80, 0xC6, 0x03, 0x18, 0x1C, 0xFF, 0xE3, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xF1, 0xE0, 0x8E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0xF0, 0x70, 0xF0, 0xC0,
  0xE1, 0x80, 0xE3, 0x01, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x60, 0x1C,
  0xC0, 0x3B, 0x80, 0x66, 0x01, 0xCC, 0x07, 0x18, 0x1E, 0x30, 0x78, 0xFF,
  0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x3F, 0xE1, 0xFE, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0xC7, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x3F, 0xE1,
  0xFE, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x78, 0x11, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x05, 0x81, 0xF3, 0x03, 0xE6,
  0x00, 0xCC, 0x01, 0x9C, 0x07, 0x38, 0x0C, 0x38, 0x18, 0x3F, 0xF0, 0x3F,
  0xC0, 0x0C, 0x03, 0x0C, 0x03, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x18,
  0x06, 0x38, 0x06, 0x38, 0x0E, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x0C, 0x70,
  0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xC0,
  0x30, 0x0F, 0xE1, 0xF8, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x3C,
  0x1F, 0xC0, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x07, 0x01, 0xC1, 0xF8, 0x38, 0x00, 0x0C, 0x0E,
  0x18, 0x38, 0x70, 0xE0, 0xC3, 0x81, 0x8E, 0x03, 0x38, 0x0E, 0xE0, 0x1B,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xCE, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x38,
  0x18, 0x30, 0x30, 0x70, 0xE0, 0x61, 0x80, 0xE0, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x01, 0xB1, 0xE0, 0x1E, 0x1A, 0x03, 0x61, 0xB0, 0x36, 0x3B, 0x06,
  0x63, 0x30, 0x6E, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x18, 0xC6, 0x33,
  0x8C, 0x61, 0x31, 0xC6, 0x1E, 0x18, 0x61, 0xE1, 0x86, 0x1C, 0x18, 0xC1,
  0xC3, 0x8C, 0x18, 0x38, 0x0C, 0x01, 0x8F, 0x01, 0xC7, 0x80, 0xC3, 0xC0,
  0x61, 0xB0, 0x30, 0xD8, 0x18, 0xEE, 0x18, 0x63, 0x0C, 0x31, 0x86, 0x18,
  0xE3, 0x0C, 0x33, 0x8C, 0x19, 0x86, 0x06, 0xC3, 0x03, 0x61, 0x81, 0xB0,
  0xC0, 0x78, 0xC0, 0x38, 0x60, 0x1C, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70,
  0x71, 0xC0, 0x77, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0xB8, 0x0E, 0x38,
  0x3C, 0x3F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x87, 0x0E, 0x30, 0x31,
  0x81, 0x8C, 0x0C, 0xE0, 0x66, 0x07, 0x30, 0x71, 0xFF, 0x0F, 0xE0, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x77, 0x00, 0x6C, 0x00, 0xD8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xD8,
  0x03, 0xB8, 0x0E, 0x38, 0x38, 0x3F, 0xE0, 0x3F, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x7F, 0x87, 0x0E, 0x30, 0x31,
  0x81, 0x8C, 0x0C, 0xE0, 0x66, 0x07, 0x30, 0xF1, 0xFE, 0x0F, 0xE0, 0xE3,
  0x06, 0x1C, 0x30, 0x61, 0x83, 0x0C, 0x1C, 0xE0, 0x66, 0x03, 0x80, 0x03,
  0xF0, 0x7F, 0xC7, 0x04, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x90,
  0x1C, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x00, 0x38,
  0x06, 0x70, 0x0C, 0xC0, 0x39, 0x80, 0x73, 0x00, 0xCE, 0x01, 0x98, 0x03,
  0x30, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x03, 0x98,
  0x06, 0x30, 0x1C, 0x70, 0x70, 0x7F, 0xE0, 0x7F, 0x00, 0xE0, 0x1F, 0x80,
  0x66, 0x03, 0x98, 0x0C, 0x60, 0x71, 0x81, 0x86, 0x0E, 0x18, 0x30, 0x61,
  0xC1, 0x86, 0x07, 0x38, 0x0C, 0xC0, 0x37, 0x00, 0xD8, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x60, 0x3E, 0x07, 0x01, 0xB0, 0x38,
  0x1D, 0x83, 0x40, 0xCC, 0x1A, 0x0E, 0x61, 0x98, 0x63, 0x0C, 0xC7, 0x18,
  0x66, 0x30, 0xC6, 0x31, 0x86, 0x31, 0x98, 0x33, 0x0C, 0xC1, 0x98, 0x6C,
  0x0D, 0x83, 0x60, 0x6C, 0x1B, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x0E, 0x06, 0x06, 0x0C, 0x06,
  0x1C, 0x07, 0x38, 0x03, 0x30, 0x03, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0C, 0x60, 0x1C, 0x60, 0x38, 0x70, 0x30,
  0x30, 0x60, 0x30, 0xE0, 0x38, 0xE0, 0x3B, 0x01, 0x98, 0x18, 0xC1, 0xC7,
  0x0C, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x3E, 0x00, 0xF0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0F,
  0xFC, 0x7F, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0x87, 0xC3, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x18, 0x0F, 0x87, 0xC0, 0xCC, 0xCC, 0xCC, 0x66,
  0x66, 0x66, 0x33, 0x33, 0x33, 0x07, 0xC3, 0xE0, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0xF8, 0x3E, 0x00, 0x06, 0x00, 0x60,
  0x0F, 0x00, 0xB0, 0x19, 0x81, 0x98, 0x30, 0xC3, 0x0C, 0x60, 0x66, 0x06,
  0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xCE, 0x63, 0x03, 0x00, 0x7C, 0xCF, 0x3C,
  0x60, 0xE7, 0x07, 0x30, 0x39, 0x81, 0xDC, 0x0C, 0xE0, 0x66, 0x07, 0x38,
  0x39, 0xC3, 0x87, 0xFC, 0x1E, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x8C, 0x33, 0xE3, 0x67, 0x38, 0x33, 0x83, 0x70, 0x37, 0x03,
  0x60, 0x36, 0x07, 0x60, 0x6E, 0x06, 0xF0, 0xCD, 0xFC, 0xDF, 0x00, 0x03,
  0x81, 0xFC, 0xF1, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x08, 0x60, 0xFB, 0x8F, 0x3C, 0x30, 0x71, 0xC1,
  0xC6, 0x07, 0x18, 0x1C, 0xE0, 0x63, 0x81, 0x8C, 0x0E, 0x38, 0x38, 0xE1,
  0xC1, 0xFB, 0x03, 0xCC, 0x00, 0x03, 0x01, 0xF8, 0x73, 0x98, 0x37, 0x0E,
  0xC3, 0x9F, 0xE7, 0xF0, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x47, 0xF8, 0x7F,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xFC,
  0xCF, 0x3C, 0x60, 0xE7, 0x07, 0x30, 0x39, 0x81, 0xDC, 0x0C, 0xE0, 0x66,
  0x07, 0x38, 0x39, 0xC3, 0x87, 0xEC, 0x1E, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x84, 0x1C, 0x3F, 0xC1, 0xF8, 0x00, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x88, 0x33, 0xE3, 0x67, 0x38, 0x33, 0x83, 0x70, 0x37, 0x07,
  0x60, 0x66, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0xEC, 0x0C, 0xC0, 0xC0, 0x1C,
  0x70, 0x00, 0x00, 0xE3, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x8E, 0x30, 0xC3,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x18, 0x06, 0x0F, 0x83, 0x80, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x81, 0x38, 0x63, 0x0C, 0x31, 0x83, 0x30, 0x76, 0x06,
  0xC0, 0x7E, 0x07, 0x60, 0x67, 0x0E, 0x30, 0xC3, 0x8C, 0x18, 0xC1, 0xC0,
  0x0C, 0x71, 0x86, 0x18, 0x63, 0x8C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x38,
  0xC3, 0x0C, 0x00, 0x00, 0xC0, 0x86, 0x7C, 0xFC, 0xD9, 0xB3, 0x9C, 0x3C,
  0x33, 0x87, 0x06, 0xE0, 0xE0, 0xDC, 0x18, 0x1B, 0x03, 0x03, 0x60, 0x60,
  0xEC, 0x1C, 0x1B, 0x83, 0x03, 0x60, 0x60, 0x6C, 0x0C, 0x0D, 0x83, 0x83,
  0x80, 0x00, 0xC3, 0x3F, 0x36, 0x73, 0xC3, 0x38, 0x37, 0x03, 0x70, 0x76,
  0x07, 0x60, 0x66, 0x06, 0xE0, 0xEE, 0x0E, 0xC0, 0xCC, 0x0C, 0x03, 0x01,
  0xFC, 0x3C, 0xE3, 0x07, 0x70, 0x76, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x06, 0xE0, 0xE6, 0x0C, 0x7F, 0x83, 0xF0, 0x00, 0x30, 0x33, 0xE0, 0xD9,
  0xC3, 0x83, 0x0E, 0x0C, 0x30, 0x31, 0xC0, 0xC6, 0x03, 0x18, 0x1C, 0x60,
  0x63, 0x81, 0x8F, 0x0C, 0x37, 0xF0, 0xDF, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x03, 0x00, 0x7C, 0xCF, 0x3C, 0x60,
  0xE7, 0x07, 0x30, 0x39, 0x81, 0xDC, 0x0C, 0xE0, 0x66, 0x07, 0x38, 0x39,
  0xC3, 0x87, 0xEC, 0x1E, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x00, 0xCC, 0xE3, 0x64, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x07, 0xF3,
  0x8C, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x60, 0x1A, 0x0E,
  0xFF, 0x3F, 0x80, 0x08, 0x18, 0x38, 0xFF, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0xE0, 0x7C, 0x7C, 0x38, 0x39, 0x81, 0x8C, 0x0C,
  0x60, 0x67, 0x03, 0x30, 0x39, 0x81, 0x8C, 0x0C, 0x60, 0xE7, 0x07, 0x38,
  0x70, 0xFD, 0x87, 0xCC, 0x00, 0xE0, 0x7E, 0x0E, 0x60, 0xC6, 0x1C, 0x61,
  0x86, 0x38, 0x63, 0x06, 0x70, 0x66, 0x06, 0xE0, 0x6C, 0x03, 0x80, 0x38,
  0x00, 0xE1, 0xC1, 0xD8, 0x70, 0x66, 0x14, 0x39, 0x8D, 0x8C, 0x63, 0x63,
  0x19, 0x99, 0x86, 0x66, 0x61, 0xB1, 0xB0, 0x6C, 0x6C, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xC1, 0xE0, 0x70, 0x70, 0x00, 0x1C, 0x3C, 0x30, 0xC0, 0xC6,
  0x01, 0xB0, 0x07, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xE0, 0x0D, 0x80, 0x67,
  0x03, 0x8C, 0x1C, 0x38, 0xE0, 0x60, 0x1C, 0x0E, 0x38, 0x38, 0x30, 0x60,
  0x61, 0xC0, 0xC3, 0x01, 0x8E, 0x03, 0x18, 0x06, 0x70, 0x04, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xE4, 0x1C, 0x07, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x7F, 0xCF, 0xF8,
  0x01, 0xC0, 0xF0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06,
  0x07, 0x03, 0xC0, 0x38, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x3C, 0x0E, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0xF0, 0x38, 0x00, 0xFC, 0x3C, 0xFF, 0x83, 0xC0,
};

const GFXglyph NotoSans_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 18, 7, 0, -18 },
  { 17, 7, 7, 10, 3, -18 },
  { 24, 15, 18, 16, 1, -18 },
  { 58, 12, 20, 14, 1, -19 },
  { 88, 17, 18, 20, 2, -18 },
  { 127, 15, 18, 17, 1, -18 },
  { 161, 3, 7, 6, 3, -18 },
  { 164, 8, 22, 7, 1, -18 },
  { 186, 8, 22, 7, -2, -18 },
  { 208, 11, 12, 14, 3, -19 },
  { 225, 12, 12, 14, 2, -15 },
  { 243, 5, 6, 6, -1, -3 },
  { 247, 6, 2, 8, 1, -8 },
  { 249, 4, 3, 6, 0, -3 },
  { 251, 12, 18, 9, -1, -18 },
  { 278, 12, 18, 14, 1, -18 },
  { 305, 7, 18, 14, 4, -18 },
  { 321, 13, 18, 14, 0, -18 },
  { 351, 12, 18, 14, 1, -18 },
  { 378, 13, 18, 14, 0, -18 },
  { 408, 12, 18, 14, 1, -18 },
  { 435, 12, 18, 14, 2, -18 },
  { 462, 12, 18, 14, 2, -18 },
  { 489, 13, 18, 14, 1, -18 },
  { 519, 12, 18, 14, 1, -18 },
  { 546, 6, 14, 6, 0, -14 },
  { 557, 7, 17, 6, -1, -14 },
  { 572, 12, 12, 14, 2, -15 },
  { 590, 11, 7, 14, 2, -12 },
  { 600, 12, 12, 14, 2, -15 },
  { 618, 9, 18, 11, 2, -18 },
  { 639, 20, 20, 21, 1, -18 },
  { 689, 14, 18, 14, -1, -18 },
  { 721, 14, 18, 15, 1, -18 },
  { 753, 14, 18, 15, 2, -18 },
  { 785, 15, 18, 17, 1, -18 },
  { 819, 13, 18, 13, 1, -18 },
  { 849, 13, 18, 12, 1, -18 },
  { 879, 15, 18, 17, 2, -18 },
  { 913, 16, 18, 17, 1, -18 },
  { 949, 11, 18, 8, -1, -18 },
  { 974, 11, 23, 7, -4, -18 },
  { 1006, 15, 18, 14, 1, -18 },
  { 1040, 10, 18, 12, 1, -18 },
  { 1063, 20, 18, 21, 1, -18 },
  { 1108, 17, 18, 18, 1, -18 },
  { 1147, 15, 18, 18, 2, -18 },
  { 1181, 13, 18, 14, 1, -18 },
  { 1211, 15, 22, 18, 2, -18 },
  { 1253, 13, 18, 14, 1, -18 },
  { 1283, 13, 18, 13, 0, -18 },
  { 1313, 13, 18, 13, 2, -18 },
  { 1343, 15, 18, 17, 2, -18 },
  { 1377, 14, 18, 14, 2, -18 },
  { 1409, 21, 18, 21, 3, -18 },
  { 1457, 16, 18, 13, -1, -18 },
  { 1493, 13, 18, 13, 2, -18 },
  { 1523, 14, 18, 13, 0, -18 },
  { 1555, 9, 22, 7, 0, -18 },
  { 1580, 4, 18, 9, 3, -18 },
  { 1589, 10, 22, 7, -2, -18 },
  { 1617, 12, 11, 14, 1, -18 },
  { 1634, 10, 2, 10, -2, 2 },
  { 1637, 4, 4, 7, 4, -19 },
  { 1639, 13, 14, 14, 1, -14 },
  { 1662, 12, 19, 14, 1, -19 },
  { 1691, 11, 14, 11, 1, -14 },
  { 1711, 14, 19, 14, 1, -19 },
  { 1745, 11, 14, 12, 1, -14 },
  { 1765, 14, 25, 8, -3, -19 },
  { 1809, 13, 20, 14, 1, -14 },
  { 1842, 12, 19, 14, 1, -19 },
  { 1871, 6, 18, 6, 1, -18 },
  { 1885, 10, 24, 6, -3, -18 },
  { 1915, 12, 19, 12, 1, -19 },
  { 1944, 6, 19, 6, 1, -19 },
  { 1959, 19, 14, 22, 1, -14 },
  { 1993, 12, 14, 14, 1, -14 },
  { 2014, 12, 14, 14, 1, -14 },
  { 2035, 14, 20, 14, -1, -14 },
  { 2070, 13, 20, 14, 1, -14 },
  { 2103, 10, 14, 10, 1, -14 },
  { 2121, 10, 14, 11, 0, -14 },
  { 2139, 8, 16, 8, 1, -16 },
  { 2155, 13, 13, 14, 1, -13 },
  { 2177, 12, 13, 12, 1, -13 },
  { 2197, 18, 13, 18, 1, -13 },
  { 2227, 14, 13, 12, -1, -13 },
  { 2250, 15, 19, 12, -2, -13 },
  { 2286, 11, 13, 11, 0, -13 },
  { 2304, 10, 22, 9, 0, -18 },
  { 2332, 2, 25, 14, 6, -19 },
  { 2339, 10, 22, 9, -1, -18 },
  { 2367, 12, 3, 14, 2, -10 },
};

const GFXfont NotoSans_Italic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_ITALIC25PT7B_H_
