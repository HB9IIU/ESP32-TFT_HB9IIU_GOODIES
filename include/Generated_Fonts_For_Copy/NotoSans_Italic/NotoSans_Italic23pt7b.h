#ifndef _NOTOSANS_ITALIC23PT7B_H_
#define _NOTOSANS_ITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x00, 0x01, 0x86,
  0x38, 0x76, 0xCD, 0x9A, 0x24, 0x59, 0x80, 0x03, 0x10, 0x18, 0xC0, 0x63,
  0x01, 0x08, 0x7F, 0xFD, 0xFF, 0xF0, 0xC4, 0x02, 0x10, 0x18, 0xC0, 0x63,
  0x0F, 0xFF, 0x84, 0x60, 0x31, 0x80, 0xC4, 0x02, 0x10, 0x18, 0xC0, 0x01,
  0x00, 0x60, 0x7F, 0x9D, 0x33, 0x20, 0x64, 0x0D, 0x81, 0xF0, 0x1F, 0x00,
  0xF0, 0x37, 0x06, 0x60, 0xCD, 0x13, 0x3F, 0xC3, 0xE0, 0x18, 0x02, 0x00,
  0x18, 0x02, 0x78, 0x19, 0x98, 0x66, 0x30, 0x8C, 0x63, 0x18, 0xCC, 0x31,
  0x30, 0x66, 0x4E, 0xCD, 0xB7, 0xF6, 0xC4, 0xD9, 0x88, 0x22, 0x10, 0xCC,
  0x63, 0x18, 0xCC, 0x31, 0x18, 0x26, 0x60, 0x78, 0x03, 0x80, 0x3F, 0x01,
  0xC6, 0x06, 0x18, 0x18, 0x60, 0x63, 0x81, 0x9C, 0x03, 0xC0, 0x1E, 0x01,
  0xD8, 0x36, 0x31, 0xB0, 0x66, 0xC1, 0xF3, 0x03, 0x8C, 0x1E, 0x3D, 0xFC,
  0x7E, 0x38, 0x76, 0x64, 0x4C, 0x06, 0x18, 0x60, 0xC3, 0x0C, 0x18, 0x30,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x81, 0x00, 0x06,
  0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x04, 0x00, 0x60, 0x18, 0x23,
  0x0F, 0x40, 0x3F, 0xC3, 0x98, 0xD0, 0x33, 0x0C, 0x60, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x39, 0x9C, 0xC4, 0x60, 0xFF, 0xC0, 0x6F, 0x80, 0x00, 0x60, 0x18,
  0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x03, 0x01, 0xF8, 0x73, 0x9C,
  0x33, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x78, 0x0F, 0x01, 0xE0, 0x6C,
  0x0D, 0xC3, 0x98, 0x63, 0xF8, 0x3E, 0x00, 0x0E, 0x7F, 0xDB, 0x60, 0xC1,
  0x83, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x03, 0x80, 0xFE,
  0x1C, 0x70, 0x83, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0xFE, 0xFF, 0xC0, 0x03,
  0x80, 0xFE, 0x1C, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x1C, 0x0F,
  0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0E, 0x80, 0xCF, 0x7C, 0x7F,
  0x00, 0x00, 0x70, 0x0F, 0x01, 0xA0, 0x3E, 0x03, 0x60, 0x66, 0x0C, 0x61,
  0x8C, 0x30, 0xC6, 0x0C, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x1F, 0xE3, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0F, 0xC1, 0xFC,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0D, 0x03, 0x3B, 0xE7, 0xF0, 0x00,
  0xF0, 0x7E, 0x0E, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0xF8, 0x79,
  0xC6, 0x0C, 0x60, 0xEC, 0x0C, 0xC0, 0xC6, 0x0C, 0x61, 0xC7, 0xF8, 0x3F,
  0x00, 0x7F, 0xF0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x03,
  0x81, 0xFC, 0x61, 0x8C, 0x33, 0x06, 0x70, 0xC6, 0x38, 0x7C, 0x0F, 0x07,
  0x71, 0x87, 0x60, 0x6C, 0x0D, 0x81, 0xB8, 0x33, 0x9C, 0x3F, 0x00, 0x07,
  0x03, 0xF8, 0xE3, 0x18, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x07, 0x70, 0xE7,
  0xF8, 0x7B, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xC7, 0xF8, 0xFC, 0x00, 0x19,
  0xCE, 0x00, 0x00, 0x00, 0x00, 0x18, 0xCE, 0x00, 0x0C, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x0C, 0x61, 0x8C, 0x30, 0x00, 0x40, 0x70, 0x78,
  0x78, 0x78, 0x38, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x04, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x1C, 0x3C, 0x3C, 0x3C, 0x08, 0x00, 0x1C, 0xFF, 0x43, 0x03,
  0x03, 0x03, 0x07, 0x0E, 0x1C, 0x30, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xE0,
  0xC0, 0x03, 0xFE, 0x01, 0xC1, 0xC1, 0xC0, 0x18, 0x60, 0x02, 0x30, 0xF8,
  0xD8, 0x7E, 0x36, 0x31, 0x8D, 0x18, 0x63, 0xC4, 0x10, 0xF1, 0x0C, 0x2C,
  0xC3, 0x1B, 0x19, 0xC6, 0xC7, 0xDF, 0x18, 0x43, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x78, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x06,
  0xC0, 0x36, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x30, 0xFF, 0x87, 0xFC,
  0x60, 0x63, 0x03, 0x30, 0x19, 0x80, 0x78, 0x03, 0x1F, 0xE0, 0xC3, 0x86,
  0x0C, 0x30, 0x73, 0x03, 0x18, 0x18, 0xC3, 0x87, 0xF0, 0x30, 0xE3, 0x03,
  0x18, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x73, 0xFF, 0x1F, 0xE0, 0x01, 0xC0,
  0x7F, 0xC7, 0x04, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0x63, 0xC1, 0x83, 0x86, 0x06, 0x30, 0x1C, 0xC0,
  0x73, 0x01, 0xCC, 0x07, 0x30, 0x19, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x60,
  0x73, 0x87, 0x8F, 0xFC, 0x3F, 0x80, 0x1F, 0xF1, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0xFC, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0xFC, 0x3F, 0x86, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xE0, 0x7F, 0xC7, 0x86, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC1, 0xF6, 0x0F, 0xB0, 0x0D,
  0x80, 0x6C, 0x07, 0x60, 0x33, 0x81, 0x8F, 0xFC, 0x1F, 0xC0, 0x18, 0x06,
  0x30, 0x18, 0x60, 0x30, 0xC0, 0x63, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x1F,
  0xFC, 0x30, 0x18, 0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x1C, 0x06,
  0x30, 0x0C, 0x60, 0x30, 0x1F, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0xD1, 0xF0, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x89, 0xC3, 0xE0, 0x18,
  0x1C, 0x60, 0xC1, 0x86, 0x06, 0x30, 0x31, 0x80, 0xCC, 0x03, 0x60, 0x0F,
  0x80, 0x3F, 0x01, 0x8C, 0x06, 0x30, 0x18, 0x60, 0x61, 0x83, 0x87, 0x0C,
  0x0C, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0xFF, 0xFE, 0x1C, 0x01, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x58, 0x1B, 0x36, 0x05, 0x8D, 0x83, 0x63, 0x61,
  0x98, 0xD8, 0x66, 0x22, 0x31, 0x98, 0x8C, 0xC6, 0x36, 0x31, 0x8D, 0x8C,
  0x63, 0xC3, 0x30, 0xF1, 0xCC, 0x38, 0x63, 0x0C, 0x18, 0x1C, 0x06, 0x38,
  0x0C, 0x78, 0x18, 0xB0, 0x33, 0x60, 0xC6, 0x61, 0x8C, 0xC3, 0x18, 0xC6,
  0x21, 0x88, 0xC3, 0x31, 0x83, 0x63, 0x06, 0xC6, 0x0D, 0x98, 0x0E, 0x30,
  0x1C, 0x60, 0x18, 0x03, 0xC0, 0x3F, 0xC1, 0xC3, 0x8C, 0x06, 0x70, 0x1D,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xB0, 0x06,
  0xC0, 0x3B, 0x00, 0xCE, 0x07, 0x1F, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0x8E,
  0x18, 0x31, 0x83, 0x30, 0x33, 0x03, 0x30, 0x63, 0x0E, 0x3F, 0xC7, 0xC0,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0xC0, 0x3F,
  0xC1, 0xC3, 0x8C, 0x06, 0x70, 0x1D, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xB0, 0x06, 0xC0, 0x3B, 0x00, 0xCE, 0x06, 0x1F,
  0xF0, 0x3F, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x1F, 0xE1,
  0x8F, 0x18, 0x31, 0x83, 0x30, 0x33, 0x03, 0x30, 0x63, 0xFE, 0x3F, 0x86,
  0x30, 0x61, 0x86, 0x18, 0x61, 0x8E, 0x0C, 0xC0, 0xCC, 0x0E, 0x03, 0xC0,
  0xFF, 0x1C, 0x21, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x81, 0xCF, 0xF8, 0xFF, 0x00,
  0xFF, 0xF0, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x30, 0x0C, 0xC0, 0x63, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x03,
  0x18, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x18, 0xC0, 0x63, 0x03,
  0x07, 0xFC, 0x0F, 0xC0, 0xC0, 0x3E, 0x01, 0xB0, 0x18, 0xC0, 0xC6, 0x0C,
  0x30, 0xE1, 0x86, 0x0C, 0x70, 0x63, 0x03, 0x38, 0x19, 0x80, 0xD8, 0x02,
  0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x60, 0x76, 0x0E, 0x06, 0x60,
  0xA0, 0xC6, 0x1A, 0x0C, 0x61, 0xA1, 0x86, 0x32, 0x18, 0x63, 0x21, 0x86,
  0x62, 0x30, 0x66, 0x33, 0x06, 0xC3, 0x60, 0x6C, 0x36, 0x06, 0x83, 0xC0,
  0x78, 0x3C, 0x07, 0x03, 0x80, 0x70, 0x38, 0x06, 0x03, 0x00, 0x0C, 0x0E,
  0x18, 0x30, 0x18, 0xE0, 0x31, 0x80, 0x66, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0D, 0x80, 0x33, 0x00, 0xC6, 0x03, 0x86, 0x06, 0x0C,
  0x18, 0x18, 0x60, 0x18, 0xC0, 0x76, 0x0E, 0x60, 0xC6, 0x18, 0x63, 0x03,
  0x30, 0x36, 0x03, 0xC0, 0x3C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0x86, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x3E, 0x1E, 0x00, 0xC3, 0x18, 0xC6, 0x30, 0x86, 0x31, 0x8C,
  0x63, 0x08, 0x63, 0x0F, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x1E,
  0x1F, 0x00, 0x04, 0x01, 0x80, 0x38, 0x0D, 0x01, 0xB0, 0x63, 0x0C, 0x63,
  0x06, 0x60, 0xC8, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xE6, 0x23, 0x06,
  0x01, 0xFB, 0x38, 0xE7, 0x0E, 0x60, 0x66, 0x06, 0xC0, 0xCC, 0x0C, 0xC0,
  0xCC, 0x1C, 0xC3, 0xC7, 0x68, 0x7D, 0x80, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x10, 0x6F, 0x8F, 0x39, 0xC3, 0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x36,
  0x0F, 0xC1, 0xB8, 0x77, 0x9C, 0x9F, 0x00, 0x03, 0x07, 0xF3, 0x89, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xCC, 0x3F, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x23, 0x0F, 0xD0, 0xE3, 0x8E,
  0x1C, 0x60, 0x63, 0x03, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0xE3, 0x0F,
  0x0E, 0xD0, 0x7D, 0x80, 0x06, 0x07, 0xE3, 0x9D, 0xC3, 0x60, 0xD8, 0xEF,
  0xF3, 0xE0, 0xC0, 0x30, 0x0E, 0x01, 0xCC, 0x3F, 0x00, 0x00, 0x30, 0x07,
  0xC0, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0x80, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x03, 0xC0, 0x08, 0x00,
  0x06, 0x01, 0xFB, 0x38, 0xE7, 0x0E, 0x60, 0x66, 0x06, 0xC0, 0xCC, 0x0C,
  0xC0, 0xCC, 0x1C, 0xC3, 0xC7, 0x78, 0x7D, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x87, 0x0F, 0xE0, 0x10, 0x00, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x10,
  0x6F, 0x8F, 0x19, 0xC3, 0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x66, 0x0D, 0x81,
  0xB0, 0x36, 0x0C, 0xC1, 0x80, 0x18, 0xC4, 0x00, 0x18, 0xC6, 0x63, 0x18,
  0xC6, 0x63, 0x18, 0xC0, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x06, 0x03, 0x03, 0x87, 0x81, 0x00, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x02, 0x61, 0x8C, 0x61, 0x98, 0x66, 0x0D, 0x81, 0xF0, 0x3E, 0x06, 0x61,
  0x8C, 0x30, 0xC6, 0x18, 0xC1, 0x80, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x63,
  0x18, 0xC6, 0x63, 0x18, 0xC0, 0x01, 0x03, 0x0D, 0xF3, 0xE3, 0xCD, 0x9C,
  0xE1, 0xC3, 0x70, 0x60, 0xD8, 0x38, 0x36, 0x0C, 0x19, 0x83, 0x06, 0x60,
  0xC1, 0xB0, 0x30, 0x6C, 0x18, 0x3B, 0x06, 0x0C, 0xC1, 0x83, 0x00, 0x01,
  0x86, 0xFC, 0xF3, 0x9C, 0x37, 0x06, 0xE0, 0xD8, 0x3B, 0x06, 0x60, 0xD8,
  0x1B, 0x03, 0x60, 0xEC, 0x18, 0x1F, 0x87, 0x19, 0xC3, 0xB0, 0x36, 0x07,
  0x80, 0xF0, 0x1E, 0x06, 0xC0, 0xDC, 0x31, 0xFE, 0x1F, 0x00, 0x00, 0x40,
  0x6F, 0x83, 0xCE, 0x1C, 0x31, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x39, 0xC1, 0x8E, 0x1C, 0x79, 0xC3, 0x7C, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x00, 0x06, 0x01, 0xFB, 0x38, 0xE7, 0x0E, 0x60,
  0x66, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC3, 0xC7, 0x78, 0x7D,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x01, 0x1B,
  0xCF, 0x07, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x06, 0x0F, 0xCC, 0x26, 0x03, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x01,
  0x80, 0xDD, 0xEF, 0xE0, 0x18, 0x30, 0xC7, 0xF3, 0x06, 0x18, 0x30, 0x60,
  0xC1, 0x86, 0x0C, 0x1D, 0x1E, 0x00, 0x30, 0x73, 0x06, 0x30, 0x66, 0x06,
  0x60, 0x66, 0x0C, 0x60, 0xCE, 0x0C, 0xC1, 0xCC, 0x3C, 0xEE, 0x87, 0xD8,
  0xC0, 0xF8, 0x1B, 0x06, 0x30, 0xC6, 0x30, 0xC6, 0x19, 0x83, 0x30, 0x6C,
  0x0D, 0x81, 0xE0, 0x38, 0x00, 0xC1, 0x83, 0xE1, 0xC1, 0xB0, 0xF1, 0x98,
  0xD8, 0xC4, 0x6C, 0xC2, 0x26, 0x61, 0x33, 0x60, 0x91, 0xB0, 0x58, 0xD0,
  0x28, 0x78, 0x1C, 0x38, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x63, 0x03, 0x30,
  0x0B, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x19, 0x81, 0x8C, 0x1C,
  0x31, 0xC1, 0x80, 0x18, 0x1C, 0x60, 0x60, 0xC3, 0x03, 0x0C, 0x0C, 0x60,
  0x31, 0x80, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x16, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0xF0, 0x01, 0x00, 0x00, 0x3F,
  0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0F,
  0xF3, 0xFC, 0x03, 0x83, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x38,
  0x70, 0x0C, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0xC1, 0xE1, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x3C, 0x18, 0x00, 0x70, 0x7F, 0x18, 0xFC,
};

const GFXglyph NotoSans_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 9, 2, -16 },
  { 19, 14, 16, 15, 1, -16 },
  { 47, 11, 18, 13, 1, -17 },
  { 72, 15, 17, 18, 2, -17 },
  { 104, 14, 17, 15, 1, -17 },
  { 134, 4, 6, 5, 2, -16 },
  { 137, 7, 20, 7, 1, -16 },
  { 155, 8, 20, 7, -2, -16 },
  { 175, 11, 11, 13, 2, -18 },
  { 191, 10, 11, 13, 2, -14 },
  { 205, 5, 6, 6, -1, -3 },
  { 209, 5, 2, 7, 1, -7 },
  { 211, 3, 3, 6, 0, -3 },
  { 213, 11, 16, 8, -1, -16 },
  { 235, 11, 17, 13, 1, -17 },
  { 259, 7, 16, 13, 3, -16 },
  { 273, 12, 17, 13, 0, -17 },
  { 299, 12, 17, 13, 0, -17 },
  { 325, 12, 16, 13, 0, -16 },
  { 349, 11, 16, 13, 1, -16 },
  { 371, 12, 17, 13, 1, -17 },
  { 397, 11, 16, 13, 2, -16 },
  { 419, 11, 17, 13, 1, -17 },
  { 443, 11, 17, 13, 1, -17 },
  { 467, 5, 13, 6, 0, -13 },
  { 476, 6, 16, 6, -1, -13 },
  { 488, 10, 11, 13, 2, -14 },
  { 502, 10, 6, 13, 2, -11 },
  { 510, 10, 11, 13, 2, -14 },
  { 524, 8, 17, 10, 2, -17 },
  { 541, 18, 18, 20, 1, -16 },
  { 582, 13, 16, 13, -1, -16 },
  { 608, 13, 16, 14, 1, -16 },
  { 634, 13, 17, 14, 2, -17 },
  { 662, 14, 16, 15, 1, -16 },
  { 690, 12, 16, 12, 1, -16 },
  { 714, 12, 16, 11, 1, -16 },
  { 738, 13, 17, 16, 2, -17 },
  { 766, 15, 16, 16, 1, -16 },
  { 796, 9, 16, 7, 0, -16 },
  { 814, 10, 20, 6, -4, -16 },
  { 839, 14, 16, 13, 1, -16 },
  { 867, 9, 16, 11, 1, -16 },
  { 885, 18, 16, 19, 1, -16 },
  { 921, 15, 16, 16, 1, -16 },
  { 951, 14, 17, 17, 2, -17 },
  { 981, 12, 16, 13, 1, -16 },
  { 1005, 14, 21, 17, 2, -17 },
  { 1042, 12, 16, 13, 1, -16 },
  { 1066, 12, 17, 12, 0, -17 },
  { 1092, 12, 16, 12, 2, -16 },
  { 1116, 14, 16, 16, 2, -16 },
  { 1144, 13, 16, 13, 2, -16 },
  { 1170, 20, 16, 20, 2, -16 },
  { 1210, 15, 16, 12, -1, -16 },
  { 1240, 12, 16, 12, 2, -16 },
  { 1264, 13, 16, 12, 0, -16 },
  { 1290, 9, 20, 7, 0, -16 },
  { 1313, 5, 16, 8, 2, -16 },
  { 1323, 9, 20, 7, -2, -16 },
  { 1346, 11, 11, 13, 1, -17 },
  { 1362, 9, 2, 9, -2, 2 },
  { 1365, 4, 4, 6, 3, -18 },
  { 1367, 12, 13, 13, 1, -13 },
  { 1387, 11, 17, 13, 1, -17 },
  { 1411, 10, 13, 10, 1, -13 },
  { 1428, 13, 17, 13, 1, -17 },
  { 1456, 10, 13, 11, 1, -13 },
  { 1473, 13, 24, 7, -3, -18 },
  { 1512, 12, 19, 13, 1, -13 },
  { 1541, 11, 17, 13, 1, -17 },
  { 1565, 5, 17, 6, 1, -17 },
  { 1576, 9, 23, 6, -3, -17 },
  { 1602, 11, 17, 11, 1, -17 },
  { 1626, 5, 17, 6, 1, -17 },
  { 1637, 18, 13, 20, 1, -13 },
  { 1667, 11, 13, 13, 1, -13 },
  { 1685, 11, 12, 13, 1, -12 },
  { 1702, 13, 19, 13, -1, -13 },
  { 1733, 12, 19, 13, 1, -13 },
  { 1762, 9, 13, 9, 1, -13 },
  { 1777, 9, 13, 10, 0, -13 },
  { 1792, 7, 15, 8, 1, -15 },
  { 1806, 12, 12, 13, 1, -12 },
  { 1824, 11, 12, 11, 1, -12 },
  { 1841, 17, 12, 17, 1, -12 },
  { 1867, 13, 12, 11, -1, -12 },
  { 1887, 14, 18, 11, -2, -12 },
  { 1919, 10, 12, 10, 0, -12 },
  { 1934, 9, 20, 8, 0, -16 },
  { 1957, 2, 23, 13, 6, -17 },
  { 1963, 9, 20, 8, -1, -16 },
  { 1986, 10, 3, 13, 2, -10 },
};

const GFXfont NotoSans_Italic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_ITALIC23PT7B_H_
