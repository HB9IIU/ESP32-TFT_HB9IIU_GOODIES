#ifndef _NOTOSANS_ITALIC20PT7B_H_
#define _NOTOSANS_ITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x20, 0x80, 0x00, 0x63, 0x80,
  0x6D, 0x34, 0xB2, 0x88, 0x04, 0x60, 0x44, 0x0C, 0x40, 0x8C, 0x7F, 0xF1,
  0x88, 0x11, 0x81, 0x10, 0xFF, 0xEF, 0xFE, 0x23, 0x02, 0x20, 0x62, 0x04,
  0x60, 0x02, 0x01, 0x81, 0xFC, 0xD2, 0x64, 0x19, 0x03, 0xC0, 0x70, 0x0F,
  0x02, 0xC0, 0x90, 0x6C, 0xDE, 0x3F, 0x01, 0x00, 0xC0, 0x78, 0x36, 0x61,
  0x33, 0x11, 0x19, 0x88, 0x98, 0x44, 0xBA, 0x6B, 0xFE, 0xD1, 0x0D, 0x88,
  0x4C, 0xC4, 0x46, 0x62, 0x26, 0x1B, 0x60, 0x70, 0x02, 0x01, 0xF8, 0x19,
  0x83, 0x08, 0x31, 0x81, 0x38, 0x1E, 0x01, 0xC0, 0x7C, 0x3C, 0x62, 0xC3,
  0x68, 0x1C, 0xC1, 0x8E, 0x7C, 0x7C, 0x60, 0x69, 0x68, 0x0C, 0x63, 0x0C,
  0x61, 0x84, 0x30, 0xC3, 0x0C, 0x20, 0xC3, 0x0C, 0x30, 0x60, 0x0C, 0x08,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x04, 0x18,
  0xE0, 0x04, 0x06, 0x33, 0x1F, 0x00, 0xF8, 0xE1, 0x90, 0xCC, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x36, 0x64, 0xC0, 0xF8, 0x7C, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00,
  0x02, 0x07, 0xE3, 0x98, 0xC3, 0x60, 0xD8, 0x34, 0x0F, 0x03, 0xC0, 0xB0,
  0x6C, 0x1B, 0x04, 0xC3, 0x19, 0x83, 0xC0, 0x1C, 0xEE, 0xA6, 0x18, 0x61,
  0x0C, 0x30, 0xC3, 0x08, 0x61, 0x80, 0x1F, 0xC3, 0x18, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0F, 0xF9,
  0xFF, 0x00, 0x1F, 0xC3, 0x18, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x03, 0x80,
  0x98, 0x01, 0x80, 0x10, 0x06, 0x00, 0xCC, 0x30, 0xFC, 0x00, 0x00, 0xE0,
  0x38, 0x0F, 0x03, 0x60, 0xC8, 0x11, 0x06, 0x61, 0x8C, 0x61, 0x9F, 0xFF,
  0xFF, 0x01, 0x80, 0x30, 0x06, 0x00, 0x1F, 0xC4, 0x03, 0x00, 0xC0, 0x20,
  0x1F, 0x07, 0xF0, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x87, 0x3F, 0x00,
  0x0F, 0xC7, 0x03, 0x00, 0xC0, 0x60, 0x1B, 0xC5, 0xBB, 0x86, 0xC1, 0xB0,
  0x6C, 0x1B, 0x0C, 0x67, 0x0F, 0x80, 0xFF, 0x80, 0xC0, 0xC0, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x00, 0x02, 0x07,
  0xE3, 0x0C, 0xC3, 0x30, 0xCC, 0x61, 0xB0, 0x78, 0x77, 0x18, 0xCC, 0x1B,
  0x06, 0xC1, 0xB9, 0xC7, 0xE0, 0x1F, 0x18, 0xD8, 0x2C, 0x14, 0x0B, 0x0D,
  0x86, 0xFF, 0x19, 0x80, 0x80, 0xC0, 0xC8, 0xE7, 0xC0, 0x31, 0xCC, 0x00,
  0x00, 0x00, 0x03, 0x38, 0x18, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC6,
  0x18, 0xC2, 0x00, 0x00, 0xC0, 0xF0, 0xE0, 0xE0, 0xE0, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x10, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0xF0, 0xE0, 0xE0, 0x20, 0x00,
  0xFD, 0x0C, 0x18, 0x30, 0x61, 0x8E, 0x18, 0x60, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0xF8, 0x18, 0x18, 0x60, 0x19, 0x80, 0x16, 0x3F, 0x28, 0xC4,
  0x73, 0x18, 0xE4, 0x31, 0xC8, 0x43, 0x91, 0x8F, 0x37, 0xB6, 0x39, 0xC6,
  0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0x60, 0x6C, 0x18, 0x83, 0x10, 0xC2, 0x1F, 0xE7, 0xFC, 0xC1, 0xB0, 0x36,
  0x07, 0x80, 0xC0, 0x1F, 0xC6, 0x18, 0xC1, 0x98, 0x33, 0x04, 0x43, 0x9F,
  0xC3, 0x0C, 0x60, 0xCC, 0x19, 0x03, 0x60, 0xCF, 0xF9, 0xFC, 0x00, 0x0F,
  0xF1, 0xC2, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x39, 0x81, 0xF8, 0x1F, 0x83, 0x0E, 0x30,
  0x63, 0x03, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03, 0x60, 0x66, 0x06, 0x40,
  0xCC, 0x1C, 0xFF, 0x8F, 0xE0, 0x1F, 0xCC, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x07, 0xF1, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xCC, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x07, 0xF1, 0xFC, 0x60, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0x07, 0xF1, 0xC1, 0x38, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x61, 0xF4, 0x1E, 0xC0, 0x6C, 0x06, 0x60, 0x66, 0x04, 0x38,
  0xC1, 0xFC, 0x18, 0x19, 0x80, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x10, 0x11,
  0xFF, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x10, 0x11, 0x81, 0x8C, 0x0C, 0x60,
  0x60, 0x3F, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30,
  0x30, 0x20, 0xF8, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0xF8, 0x70, 0x00,
  0x18, 0x73, 0x0C, 0x31, 0x83, 0x30, 0x36, 0x02, 0xC0, 0x7C, 0x07, 0x40,
  0x66, 0x06, 0x60, 0x43, 0x0C, 0x30, 0xC1, 0x8C, 0x18, 0x18, 0x60, 0xC1,
  0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0F, 0xFF, 0xC0, 0x18, 0x07,
  0x3C, 0x0F, 0x3C, 0x0A, 0x3C, 0x1E, 0x2C, 0x16, 0x24, 0x36, 0x64, 0x64,
  0x64, 0x64, 0x64, 0xCC, 0x44, 0x8C, 0x47, 0x8C, 0xC7, 0x08, 0xC7, 0x18,
  0xC6, 0x18, 0x18, 0x19, 0xC0, 0xCF, 0x06, 0x78, 0x22, 0x41, 0x13, 0x19,
  0x88, 0xCC, 0x66, 0x63, 0x22, 0x0B, 0x10, 0x79, 0x83, 0xCC, 0x0E, 0x60,
  0x60, 0x01, 0x00, 0x7F, 0x07, 0x1C, 0x60, 0x63, 0x01, 0xB0, 0x0D, 0x80,
  0x6C, 0x03, 0xC0, 0x1E, 0x01, 0xB0, 0x0C, 0xC0, 0xE6, 0x06, 0x1C, 0xE0,
  0x7E, 0x00, 0x1F, 0x8C, 0x73, 0x0C, 0xC1, 0x30, 0xC8, 0x36, 0x19, 0xFC,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x00, 0x7F, 0x07,
  0x1C, 0x60, 0x63, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0xC0, 0x1E, 0x01,
  0xB0, 0x0C, 0xC0, 0xE6, 0x06, 0x1C, 0xE0, 0x7E, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x1F, 0x8C, 0x73, 0x0C, 0xC1, 0x30, 0xC8, 0x36, 0x39, 0xF8,
  0x66, 0x18, 0x84, 0x33, 0x0C, 0xC1, 0xB0, 0x60, 0x0F, 0xC6, 0x13, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x18, 0x06, 0xC7,
  0x3F, 0x80, 0xFF, 0xC3, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x00, 0x60, 0x36, 0x02, 0x60,
  0x66, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xC8, 0x0C, 0x80,
  0x8C, 0x18, 0xE7, 0x07, 0xE0, 0xC0, 0x78, 0x1B, 0x06, 0x60, 0xCC, 0x31,
  0x86, 0x11, 0x82, 0x30, 0x4C, 0x0D, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x00, 0xC1, 0x81, 0xE0, 0xC1, 0xB0, 0xF0, 0xD8, 0x58, 0xCC, 0x6C, 0x66,
  0x36, 0x63, 0x33, 0x31, 0x99, 0x90, 0x58, 0xD8, 0x2C, 0x68, 0x14, 0x3C,
  0x0E, 0x1E, 0x06, 0x0E, 0x03, 0x03, 0x00, 0x18, 0x18, 0x61, 0x83, 0x18,
  0x09, 0x80, 0x68, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x0D, 0x00, 0xCC, 0x06,
  0x60, 0x61, 0x86, 0x0C, 0x60, 0x60, 0xC1, 0xF0, 0x64, 0x31, 0x88, 0x66,
  0x1B, 0x02, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x00,
  0x1F, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xF9, 0xFF, 0x00, 0x1E, 0x30, 0x60, 0x81,
  0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xF0, 0xCC,
  0x44, 0x46, 0x66, 0x62, 0x23, 0x33, 0x1E, 0x0C, 0x18, 0x20, 0xC1, 0x83,
  0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0xF0, 0x08, 0x07, 0x01,
  0x40, 0xC8, 0x23, 0x18, 0x44, 0x1B, 0x02, 0x80, 0xC0, 0xFF, 0xCC, 0x80,
  0x1E, 0x4F, 0xF6, 0x1D, 0x86, 0xC1, 0xB0, 0x6C, 0x1B, 0x0C, 0xC3, 0x3B,
  0x47, 0xB0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0x0B, 0xE7, 0x09, 0x83,
  0x60, 0xD0, 0x24, 0x1B, 0x06, 0xC3, 0x29, 0xCB, 0xE0, 0x0F, 0x3F, 0x60,
  0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE2, 0x7E, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x61, 0xEC, 0x7F, 0x98, 0x73, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x61,
  0x8C, 0x31, 0xDE, 0x1E, 0xC0, 0x1E, 0x3F, 0x61, 0x63, 0xC7, 0xFE, 0xC0,
  0xC0, 0xC0, 0x62, 0x7E, 0x01, 0xE0, 0x60, 0x08, 0x03, 0x00, 0xF8, 0x3F,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x03, 0xC0, 0x60, 0x00, 0x0F, 0x23, 0xFC, 0xC3,
  0x98, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0C, 0x61, 0x8E, 0xF0, 0xF6, 0x00,
  0xC0, 0x11, 0x06, 0x3F, 0x83, 0xE0, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x71,
  0x7D, 0xC2, 0xC1, 0x61, 0xB0, 0xD0, 0x78, 0x3C, 0x16, 0x1A, 0x0C, 0x13,
  0x10, 0x32, 0x66, 0x64, 0x4C, 0xCC, 0x80, 0x01, 0x03, 0x01, 0x00, 0x03,
  0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0xF0, 0xE0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x31, 0xC8, 0xC6, 0x61,
  0xB0, 0x78, 0x1E, 0x0E, 0xC3, 0x30, 0xC6, 0x31, 0x88, 0x30, 0x19, 0x8C,
  0x63, 0x11, 0x8C, 0x62, 0x11, 0x8C, 0x62, 0x00, 0x27, 0x1C, 0x5F, 0x7D,
  0xC7, 0x0B, 0x0E, 0x16, 0x18, 0x6C, 0x30, 0xD0, 0x41, 0xE0, 0x83, 0xC3,
  0x05, 0x86, 0x1A, 0x0C, 0x30, 0x13, 0xC2, 0xF8, 0xE1, 0x98, 0x23, 0x0C,
  0x61, 0x98, 0x33, 0x06, 0x60, 0x8C, 0x33, 0x06, 0x00, 0x1E, 0x1F, 0x98,
  0x6C, 0x3C, 0x0E, 0x0F, 0x07, 0x83, 0xC3, 0x33, 0x8F, 0x00, 0x13, 0x82,
  0xF8, 0xE1, 0x18, 0x33, 0x06, 0x40, 0x88, 0x33, 0x06, 0x61, 0x8E, 0x71,
  0x7C, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x1E, 0x4F, 0xF6, 0x1D,
  0x86, 0xC1, 0xB0, 0x6C, 0x1B, 0x0C, 0xC3, 0x3B, 0xC7, 0xB0, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x27, 0x2E, 0x70, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0xC0, 0x80, 0x1E, 0x3F, 0x60, 0x60, 0x30, 0x1C, 0x0E, 0x06, 0x06,
  0x86, 0xFC, 0x10, 0xC7, 0xFF, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x32, 0x70,
  0x30, 0xD8, 0x36, 0x0D, 0x82, 0x61, 0x90, 0x6C, 0x1B, 0x0C, 0xC3, 0x33,
  0xC7, 0xB0, 0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x62, 0x21, 0x30, 0x90, 0x78,
  0x38, 0x1C, 0x00, 0xC3, 0x0F, 0x0C, 0x3C, 0x71, 0xB1, 0x46, 0xCD, 0x33,
  0x24, 0xCD, 0x92, 0x34, 0x58, 0xF1, 0x41, 0x87, 0x06, 0x18, 0x00, 0x10,
  0x63, 0x18, 0x26, 0x06, 0x80, 0xF0, 0x0C, 0x03, 0x80, 0xD8, 0x33, 0x04,
  0x33, 0x86, 0x00, 0x18, 0x31, 0x83, 0x18, 0x61, 0x86, 0x08, 0xC0, 0x88,
  0x0D, 0x80, 0xD0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0xF0, 0x0E, 0x00, 0x3F, 0x9F, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x60, 0x60, 0x3F, 0x80, 0x07, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x70,
  0xE0, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x70, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x04, 0x03, 0x0C,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0xE0, 0x7C, 0x63, 0xE0,
};

const GFXglyph NotoSans_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 6, 5, 8, 2, -14 },
  { 16, 12, 14, 13, 1, -14 },
  { 37, 10, 16, 11, 1, -15 },
  { 57, 13, 14, 16, 2, -14 },
  { 80, 12, 15, 13, 1, -15 },
  { 103, 3, 5, 4, 2, -14 },
  { 105, 6, 17, 6, 1, -14 },
  { 118, 7, 17, 6, -2, -14 },
  { 133, 9, 9, 11, 2, -15 },
  { 144, 10, 10, 11, 1, -12 },
  { 157, 4, 5, 5, -1, -2 },
  { 160, 5, 1, 6, 1, -6 },
  { 161, 3, 2, 5, 0, -2 },
  { 162, 10, 14, 7, -1, -14 },
  { 180, 10, 15, 11, 1, -15 },
  { 199, 6, 14, 11, 3, -14 },
  { 210, 11, 14, 11, 0, -14 },
  { 230, 11, 14, 11, 0, -14 },
  { 250, 11, 14, 11, 0, -14 },
  { 270, 10, 14, 11, 1, -14 },
  { 288, 10, 14, 11, 1, -14 },
  { 306, 9, 14, 11, 2, -14 },
  { 322, 10, 15, 11, 1, -15 },
  { 341, 9, 14, 11, 1, -14 },
  { 357, 5, 11, 5, 0, -11 },
  { 364, 6, 14, 5, -1, -11 },
  { 375, 10, 10, 11, 1, -12 },
  { 388, 9, 6, 11, 2, -10 },
  { 395, 10, 10, 11, 1, -12 },
  { 408, 7, 14, 9, 2, -14 },
  { 421, 15, 16, 17, 1, -14 },
  { 451, 11, 14, 11, -1, -14 },
  { 471, 11, 14, 12, 1, -14 },
  { 491, 12, 14, 12, 1, -14 },
  { 512, 12, 14, 13, 1, -14 },
  { 533, 10, 14, 10, 1, -14 },
  { 551, 10, 14, 10, 1, -14 },
  { 569, 12, 14, 14, 1, -14 },
  { 590, 13, 14, 14, 1, -14 },
  { 613, 8, 14, 6, 0, -14 },
  { 627, 9, 18, 5, -3, -14 },
  { 648, 12, 14, 11, 1, -14 },
  { 669, 7, 14, 10, 1, -14 },
  { 682, 16, 14, 17, 1, -14 },
  { 710, 13, 14, 14, 1, -14 },
  { 733, 13, 15, 14, 1, -15 },
  { 758, 10, 14, 11, 1, -14 },
  { 776, 13, 18, 14, 1, -15 },
  { 806, 10, 14, 11, 1, -14 },
  { 824, 10, 14, 10, 0, -14 },
  { 842, 10, 14, 10, 2, -14 },
  { 860, 12, 14, 14, 2, -14 },
  { 881, 11, 14, 11, 2, -14 },
  { 901, 17, 14, 17, 2, -14 },
  { 931, 13, 14, 11, -1, -14 },
  { 954, 10, 14, 10, 2, -14 },
  { 972, 11, 14, 11, 0, -14 },
  { 992, 7, 17, 6, 0, -14 },
  { 1007, 4, 14, 7, 2, -14 },
  { 1014, 7, 17, 6, -1, -14 },
  { 1029, 10, 9, 11, 1, -14 },
  { 1041, 8, 1, 8, -2, 2 },
  { 1042, 3, 3, 6, 3, -15 },
  { 1044, 10, 11, 11, 1, -11 },
  { 1058, 10, 15, 12, 1, -15 },
  { 1077, 8, 11, 9, 1, -11 },
  { 1088, 11, 15, 12, 1, -15 },
  { 1109, 8, 11, 10, 1, -11 },
  { 1120, 11, 20, 6, -2, -15 },
  { 1148, 11, 16, 12, 0, -11 },
  { 1170, 9, 15, 12, 1, -15 },
  { 1187, 4, 15, 5, 1, -15 },
  { 1195, 8, 20, 5, -3, -15 },
  { 1215, 10, 15, 10, 1, -15 },
  { 1234, 5, 15, 5, 1, -15 },
  { 1244, 15, 11, 18, 1, -11 },
  { 1265, 11, 11, 12, 0, -11 },
  { 1281, 9, 11, 11, 1, -11 },
  { 1294, 11, 16, 12, 0, -11 },
  { 1316, 10, 16, 12, 1, -11 },
  { 1336, 8, 11, 8, 1, -11 },
  { 1347, 8, 11, 9, 0, -11 },
  { 1358, 6, 13, 7, 1, -13 },
  { 1368, 10, 11, 12, 1, -11 },
  { 1382, 9, 11, 9, 1, -11 },
  { 1395, 14, 11, 14, 1, -11 },
  { 1415, 11, 11, 10, -1, -11 },
  { 1431, 12, 16, 9, -2, -11 },
  { 1455, 9, 11, 9, 0, -11 },
  { 1468, 8, 17, 7, 0, -14 },
  { 1485, 2, 20, 11, 5, -15 },
  { 1490, 8, 17, 7, -1, -14 },
  { 1507, 10, 2, 11, 1, -8 },
};

const GFXfont NotoSans_Italic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_ITALIC20PT7B_H_
