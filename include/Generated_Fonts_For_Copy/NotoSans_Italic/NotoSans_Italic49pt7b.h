#ifndef _NOTOSANS_ITALIC49PT7B_H_
#define _NOTOSANS_ITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x07, 0x00, 0x3E, 0x3E, 0x78, 0x7C, 0xF0,
  0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x70, 0x78,
  0xE0, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x00, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0xE0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xC7, 0x0E, 0x0F, 0x87, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x9E, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x39, 0xF0, 0x00, 0x38, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0x70, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0xF0,
  0x00, 0x70, 0xF0, 0x80, 0xF1, 0xF0, 0xF0, 0xE7, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x1E, 0x07, 0xFE, 0x00, 0x1E, 0x07, 0xFF, 0x00, 0x0E,
  0x03, 0xC3, 0xC0, 0x0F, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xC0, 0xF0, 0x0F,
  0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0x70, 0x1E, 0x07,
  0x80, 0x78, 0x0F, 0x07, 0x80, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0x83,
  0xC0, 0x0F, 0x01, 0xC3, 0xC0, 0x07, 0x01, 0xE3, 0xC0, 0x03, 0x80, 0xE1,
  0xE3, 0xF9, 0xE0, 0xF1, 0xE7, 0xFE, 0xF0, 0x79, 0xE7, 0xFF, 0x78, 0x78,
  0xE3, 0xC3, 0xDF, 0xF8, 0xF3, 0xC1, 0xEF, 0xF8, 0xF1, 0xC0, 0xF3, 0xF8,
  0xF1, 0xE0, 0x78, 0x00, 0x70, 0xF0, 0x3C, 0x00, 0x78, 0x70, 0x1E, 0x00,
  0x78, 0x78, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x80, 0x38, 0x1E, 0x03, 0x80,
  0x3C, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x03, 0x80, 0xE0,
  0x1C, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0x78, 0x78,
  0x1E, 0x00, 0x1F, 0xF8, 0x0E, 0x00, 0x0F, 0xF8, 0x0F, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0,
  0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xF7, 0xC0, 0x1F, 0x1F, 0x0F, 0x00, 0x78, 0xF8, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0x0F, 0x3E, 0x00, 0xF8, 0x7C, 0xF0, 0x03, 0xE3, 0xE3, 0xC0,
  0x07, 0xCF, 0x0F, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x3F, 0xE0, 0xF0, 0x00,
  0x7F, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xF0, 0x3E, 0x00, 0x7F,
  0xC0, 0x7E, 0x0F, 0xEF, 0x81, 0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0xF0, 0x3E,
  0x03, 0xFF, 0x00, 0xFC, 0x3E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x3C, 0x70,
  0xE1, 0xC7, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0C, 0x03,
  0x80, 0x1E, 0x0F, 0x00, 0x7F, 0x1C, 0x00, 0xFF, 0xB8, 0x00, 0x3F, 0xF7,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x87, 0xC0, 0x7B, 0x80,
  0x01, 0xE7, 0x00, 0x07, 0xCF, 0x00, 0x1F, 0x0E, 0x00, 0x7C, 0x1E, 0x00,
  0xF0, 0x3C, 0x00, 0xE0, 0x7C, 0x00, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC0,
  0x7F, 0xFB, 0xFF, 0x9F, 0xFD, 0xFF, 0xE0, 0x39, 0xFF, 0xFF, 0xFF, 0xE7,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xEF,
  0x80, 0x03, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x01,
  0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C,
  0x1E, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x1F, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xDE, 0x7E, 0x3C, 0x78, 0x78, 0x41,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xF0,
  0xFE, 0x01, 0xE0, 0x0F, 0x80, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x3C, 0x01, 0xF0, 0x08, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x84, 0x00, 0x07, 0xC3, 0x80, 0x07, 0xC1, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0xBC, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x3E, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF8,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x06, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x80, 0x01, 0xF0, 0xC0, 0x03, 0xF0, 0xF8,
  0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x02, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x3F, 0x80, 0x3C, 0xFF, 0xC0, 0x7D, 0xFF, 0xF0, 0x7B,
  0xFF, 0xF0, 0x7F, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x00, 0x78, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8,
  0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x07, 0xC3, 0xF0, 0x01, 0xF7, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0xF8,
  0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1E, 0x00,
  0x7E, 0x1F, 0x01, 0xFE, 0x0F, 0xEF, 0xFE, 0x0F, 0xFF, 0xBC, 0x07, 0xFF,
  0x3C, 0x01, 0xFC, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x7F, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xC0, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0xF9, 0xF8, 0x7F, 0x30, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x3F, 0xF0, 0x1E,
  0x78, 0x03, 0xFF, 0xE0, 0xF3, 0xC0, 0x7F, 0xFE, 0x07, 0x9C, 0x07, 0xC0,
  0xF0, 0x1D, 0xE0, 0x7C, 0x07, 0x80, 0xEE, 0x03, 0xC0, 0x3C, 0x07, 0xF0,
  0x3C, 0x01, 0xC0, 0x3F, 0x81, 0xE0, 0x1E, 0x01, 0xFC, 0x1E, 0x00, 0xF0,
  0x1F, 0xC0, 0xF0, 0x07, 0x80, 0xFE, 0x07, 0x80, 0x78, 0x07, 0xF0, 0x38,
  0x03, 0xC0, 0x3B, 0x81, 0xC0, 0x1E, 0x03, 0xDC, 0x0E, 0x01, 0xF0, 0x1C,
  0xE0, 0x78, 0x0F, 0x81, 0xE7, 0x03, 0xC0, 0xDC, 0x1E, 0x3C, 0x1F, 0x1E,
  0xF3, 0xF1, 0xE0, 0x7F, 0xE7, 0xFF, 0x0F, 0x01, 0xFE, 0x1F, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x18, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xC0,
  0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x1F,
  0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x01, 0xF0,
  0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x3F, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xC7, 0xE0, 0x3F, 0x80, 0x0C, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x01, 0xFF, 0x1F, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0xF0, 0x78, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x7F, 0x01,
  0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x1F,
  0xE0, 0x3F, 0x80, 0x06, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0xFF, 0x3C, 0x00, 0x7F, 0xF1, 0xE0, 0x03, 0xFF, 0x8F, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3F, 0x00, 0x07, 0x80, 0xFC,
  0x00, 0x7C, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0x80,
  0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0xF0, 0x1F, 0x80,
  0x03, 0xC0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x01,
  0xE1, 0xF8, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x1E, 0x7E, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFE, 0xF0, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0xF7, 0x00, 0x01, 0xEF, 0x01, 0xEE, 0x00, 0x03, 0xDE, 0x03, 0xDE, 0x00,
  0x0F, 0x7C, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x1E, 0x78, 0x00, 0x79, 0xE0,
  0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x03, 0xCF, 0x81, 0xF3, 0xC0,
  0x0F, 0x1F, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x07, 0x87, 0x00, 0x78, 0x78,
  0x0F, 0x0E, 0x00, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xE0, 0x7C, 0x3C,
  0x07, 0x87, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x78, 0x1E,
  0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x07, 0x83, 0xC3, 0xC0, 0xF8, 0x1F, 0x03,
  0x87, 0x81, 0xF0, 0x3C, 0x07, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0xF0, 0x1F, 0x01, 0xE0, 0x3D, 0xE0, 0x3E, 0x07, 0x80,
  0x7F, 0x80, 0x78, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x1E, 0x01, 0xFC, 0x01,
  0xE0, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xE0,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xC0, 0x3F, 0x00,
  0x01, 0xE0, 0x3F, 0xC0, 0x00, 0xF0, 0x1F, 0xE0, 0x00, 0x78, 0x0F, 0xF0,
  0x00, 0x7C, 0x07, 0xBC, 0x00, 0x3C, 0x03, 0xDE, 0x00, 0x1E, 0x03, 0xCF,
  0x80, 0x0F, 0x01, 0xE3, 0xC0, 0x0F, 0x80, 0xF1, 0xE0, 0x07, 0x80, 0x78,
  0xF8, 0x03, 0xC0, 0x7C, 0x3C, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xF0, 0x1E,
  0x07, 0x80, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xF0, 0x3C, 0x07,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x1F, 0x0F, 0x80,
  0xF0, 0x07, 0x87, 0x80, 0x78, 0x03, 0xC3, 0xC0, 0x7C, 0x00, 0xF1, 0xE0,
  0x3C, 0x00, 0x78, 0xF0, 0x1E, 0x00, 0x3C, 0xF8, 0x0F, 0x00, 0x0F, 0x78,
  0x07, 0x80, 0x07, 0xBC, 0x07, 0x80, 0x03, 0xFE, 0x03, 0xC0, 0x00, 0xFF,
  0x01, 0xE0, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF3,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x7F, 0x03, 0xC1, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3C, 0x00, 0xFC, 0x0F, 0x01, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0x81, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x7C,
  0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0,
  0x78, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0x07, 0xE0,
  0x06, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0xC0, 0x07, 0xE0, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xCF, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x3C, 0x00,
  0x78, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x3E,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xE0, 0x01, 0xE7, 0xC0, 0x07,
  0xF0, 0x01, 0xF1, 0xE0, 0x07, 0xB8, 0x00, 0xF0, 0xF0, 0x03, 0xDC, 0x00,
  0xF8, 0x78, 0x03, 0xCE, 0x00, 0x78, 0x3C, 0x01, 0xE7, 0x00, 0x7C, 0x1E,
  0x00, 0xF3, 0x80, 0x3C, 0x0F, 0x00, 0xF1, 0xC0, 0x1E, 0x07, 0x80, 0x78,
  0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x0F,
  0x80, 0xF0, 0x3C, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x0F, 0x07, 0xC0, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x0F, 0x78, 0x00, 0xEF, 0x00, 0x07, 0xB8, 0x00, 0x77, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x3C, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x38,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xEF, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xC7, 0x80, 0x03, 0xC3, 0x80,
  0x03, 0x83, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x01, 0xE0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x38,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E,
  0xF0, 0x00, 0x0F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xC3, 0xC0, 0x7F, 0xF1, 0xE0, 0x7F, 0xFC, 0xE0, 0x7E,
  0x0F, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F,
  0x0F, 0x80, 0x1F, 0x83, 0xC0, 0x1F, 0xC1, 0xF0, 0x1D, 0xC0, 0xFC, 0x3D,
  0xE0, 0x3F, 0xFC, 0xF0, 0x0F, 0xFC, 0x78, 0x03, 0xF8, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x7F,
  0x80, 0x3C, 0xFF, 0xE0, 0x3E, 0xFF, 0xF8, 0x1E, 0xF0, 0x7C, 0x0F, 0xF0,
  0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xF0, 0x07, 0xC3, 0xF0, 0x01, 0xE1, 0xF0,
  0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x7F, 0x00, 0xF8, 0x3D, 0xE1, 0xF8, 0x1E, 0xFF, 0xF8,
  0x0E, 0x3F, 0xF8, 0x0F, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x03, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x02, 0x07, 0xE0, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x7F, 0xC3, 0xC0, 0x1F,
  0xFC, 0xF8, 0x07, 0xFF, 0xDE, 0x01, 0xF8, 0x3F, 0xC0, 0x7C, 0x03, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E,
  0x00, 0xFE, 0x03, 0xC0, 0x1F, 0xC0, 0x7C, 0x07, 0xF0, 0x0F, 0xC3, 0xDE,
  0x00, 0xFF, 0xF3, 0xC0, 0x0F, 0xFC, 0x78, 0x00, 0xFE, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x0F,
  0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0xF9, 0xE0,
  0x07, 0x8F, 0x00, 0xFC, 0xF8, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0x07,
  0xE0, 0x78, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x20,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x08, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xF0, 0xF0, 0x0F, 0xFE, 0x3C, 0x07, 0xFF, 0xCE, 0x03, 0xF0, 0x7F,
  0x81, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03,
  0xF0, 0x7C, 0x01, 0xFC, 0x0F, 0x00, 0x7F, 0x03, 0xE0, 0x7F, 0x80, 0xFC,
  0x3D, 0xE0, 0x1F, 0xFE, 0x78, 0x03, 0xFF, 0x3E, 0x00, 0x7F, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x20, 0x01, 0xF0, 0x0F, 0x00,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x7F, 0x80, 0x3C, 0xFF, 0xE0, 0x3C, 0xFF, 0xF8, 0x1E,
  0xF0, 0x7C, 0x0F, 0xF0, 0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xF0, 0x07, 0xC3,
  0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x78, 0x03,
  0xE0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x0F, 0x03,
  0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xE3,
  0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7B, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xCF, 0x00, 0x07, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x1E, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x0F, 0xF0, 0x1F, 0xF0, 0x0E, 0x3F, 0xF0, 0x7F, 0xF0, 0x3C,
  0xFF, 0xF1, 0xFF, 0xF0, 0x7B, 0xC3, 0xE7, 0x83, 0xE0, 0xFE, 0x03, 0xDE,
  0x07, 0xC1, 0xF8, 0x07, 0xF0, 0x07, 0x83, 0xE0, 0x07, 0xE0, 0x0F, 0x0F,
  0xC0, 0x1F, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x78, 0x00, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xE0, 0x03, 0xC3,
  0xE0, 0x07, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xE0, 0x07, 0xC3, 0xC0, 0x07,
  0x80, 0x0F, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x01,
  0xE3, 0xFF, 0x01, 0xE3, 0xFF, 0xC0, 0xF3, 0xFF, 0xE0, 0x7B, 0xE1, 0xF8,
  0x3F, 0xC0, 0x7C, 0x1F, 0xC0, 0x3E, 0x1F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78,
  0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78,
  0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3D, 0xF0, 0x00,
  0x7B, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x3E,
  0x1F, 0x80, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x1F, 0xE0, 0x03, 0x8F,
  0xFE, 0x00, 0xF3, 0xFF, 0xE0, 0x1E, 0xF0, 0x7C, 0x03, 0xFC, 0x07, 0xC0,
  0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x01, 0xE0, 0x7C, 0x00,
  0x3C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xF0, 0x0F, 0x80, 0xF7, 0x87, 0xE0,
  0x1E, 0xFF, 0xF8, 0x03, 0xCF, 0xFE, 0x00, 0x78, 0xFF, 0x80, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xC3, 0xC0, 0x7F, 0xF1,
  0xE0, 0x7F, 0xFC, 0xE0, 0x7E, 0x0F, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x00,
  0xFC, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x83, 0xC0, 0x1F, 0xC1,
  0xF0, 0x3F, 0xC0, 0xFC, 0x3D, 0xE0, 0x3F, 0xFC, 0xF0, 0x0F, 0xFC, 0xF8,
  0x03, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x38, 0x7F, 0x03, 0x8F,
  0xF0, 0x79, 0xFE, 0x07, 0xBE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0x80, 0xE0, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x80, 0x0F, 0x8F, 0x01,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x20, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x03,
  0xF0, 0xF0, 0x07, 0xF0, 0xF8, 0x1F, 0xE0, 0xFC, 0x3D, 0xE0, 0xFF, 0xF9,
  0xE0, 0x7F, 0xF1, 0xE0, 0x3F, 0xC1, 0xC0, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E,
  0x1E, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80,
  0xF0, 0x1E, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x0F,
  0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0x71,
  0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x7E, 0x00, 0xFB, 0xC0,
  0x1F, 0x80, 0x3E, 0xF0, 0x0F, 0xE0, 0x0F, 0x3C, 0x03, 0xB8, 0x07, 0xCF,
  0x01, 0xEF, 0x01, 0xE3, 0xC0, 0x7B, 0xC0, 0xF8, 0xF0, 0x3C, 0xF0, 0x3C,
  0x3C, 0x0F, 0x3C, 0x1F, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC1, 0xE3, 0xC3,
  0xE0, 0xF0, 0x70, 0xF0, 0xF0, 0x3C, 0x3C, 0x3C, 0x3C, 0x0F, 0x0E, 0x0F,
  0x1E, 0x03, 0xC7, 0x83, 0xC7, 0x80, 0xF1, 0xC0, 0xF3, 0xE0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x07, 0x38, 0x07, 0x3C, 0x01, 0xDE, 0x01, 0xDE, 0x00, 0x77,
  0x80, 0x77, 0x80, 0x1D, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00,
  0x78, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E,
  0x78, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00,
  0x78, 0x1F, 0x80, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0x7F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0xC0, 0x1F, 0xFC, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 36, 13, 1, -35 },
  { 55, 15, 13, 19, 5, -35 },
  { 80, 31, 35, 32, 1, -35 },
  { 216, 24, 40, 27, 2, -37 },
  { 336, 33, 35, 39, 4, -35 },
  { 481, 30, 36, 33, 2, -36 },
  { 616, 7, 13, 11, 5, -35 },
  { 628, 16, 43, 14, 2, -35 },
  { 714, 16, 43, 14, -4, -35 },
  { 800, 23, 22, 27, 5, -37 },
  { 864, 23, 24, 28, 3, -29 },
  { 933, 10, 12, 13, -2, -6 },
  { 948, 13, 4, 15, 1, -15 },
  { 955, 6, 7, 13, 1, -6 },
  { 961, 24, 35, 17, -2, -35 },
  { 1066, 23, 36, 27, 3, -36 },
  { 1170, 15, 35, 27, 7, -35 },
  { 1236, 26, 35, 27, 0, -35 },
  { 1350, 25, 35, 27, 1, -35 },
  { 1460, 26, 35, 27, 0, -35 },
  { 1574, 24, 35, 27, 2, -35 },
  { 1679, 24, 35, 27, 3, -35 },
  { 1784, 24, 35, 27, 4, -35 },
  { 1889, 25, 36, 27, 2, -36 },
  { 2002, 24, 35, 27, 2, -35 },
  { 2107, 10, 28, 13, 1, -27 },
  { 2142, 13, 33, 13, -2, -27 },
  { 2196, 24, 24, 28, 3, -30 },
  { 2268, 22, 13, 28, 4, -24 },
  { 2304, 24, 24, 28, 3, -30 },
  { 2376, 18, 36, 21, 4, -35 },
  { 2457, 37, 39, 42, 3, -35 },
  { 2638, 28, 35, 28, -3, -35 },
  { 2761, 27, 35, 29, 2, -35 },
  { 2880, 27, 35, 29, 4, -35 },
  { 2999, 29, 35, 33, 2, -35 },
  { 3126, 25, 35, 25, 2, -35 },
  { 3236, 25, 35, 23, 2, -35 },
  { 3346, 29, 35, 33, 4, -35 },
  { 3473, 32, 35, 33, 2, -35 },
  { 3613, 20, 35, 16, -1, -35 },
  { 3701, 22, 44, 13, -8, -35 },
  { 3822, 30, 35, 28, 2, -35 },
  { 3954, 19, 35, 23, 2, -35 },
  { 4038, 39, 35, 41, 2, -35 },
  { 4209, 33, 35, 35, 2, -35 },
  { 4354, 30, 36, 35, 4, -36 },
  { 4489, 26, 35, 28, 2, -35 },
  { 4603, 30, 44, 35, 4, -36 },
  { 4768, 26, 35, 28, 2, -35 },
  { 4882, 24, 35, 25, 1, -35 },
  { 4987, 25, 35, 25, 4, -35 },
  { 5097, 30, 35, 33, 4, -35 },
  { 5229, 27, 35, 27, 5, -35 },
  { 5348, 41, 35, 42, 5, -35 },
  { 5528, 33, 35, 26, -3, -35 },
  { 5673, 24, 35, 25, 5, -35 },
  { 5778, 28, 35, 26, 0, -35 },
  { 5901, 18, 43, 14, 0, -35 },
  { 5998, 9, 35, 17, 5, -35 },
  { 6038, 19, 43, 14, -4, -35 },
  { 6141, 24, 22, 28, 2, -35 },
  { 6207, 21, 4, 19, -5, 4 },
  { 6218, 8, 8, 14, 7, -38 },
  { 6226, 25, 27, 28, 2, -27 },
  { 6311, 25, 37, 28, 1, -37 },
  { 6427, 21, 27, 22, 2, -27 },
  { 6498, 27, 37, 28, 2, -37 },
  { 6623, 21, 27, 24, 2, -27 },
  { 6694, 27, 49, 16, -5, -37 },
  { 6860, 26, 39, 28, 1, -27 },
  { 6987, 25, 37, 28, 1, -37 },
  { 7103, 12, 36, 13, 1, -36 },
  { 7157, 19, 48, 13, -6, -36 },
  { 7271, 25, 37, 24, 1, -37 },
  { 7387, 13, 37, 13, 1, -37 },
  { 7448, 39, 27, 43, 1, -27 },
  { 7580, 25, 27, 28, 1, -27 },
  { 7665, 23, 27, 28, 2, -27 },
  { 7743, 27, 39, 28, -1, -27 },
  { 7875, 25, 39, 28, 2, -27 },
  { 7997, 20, 27, 20, 1, -27 },
  { 8065, 20, 27, 21, 0, -27 },
  { 8133, 16, 32, 16, 2, -32 },
  { 8197, 24, 26, 28, 3, -26 },
  { 8275, 23, 26, 23, 2, -26 },
  { 8350, 34, 26, 35, 3, -26 },
  { 8461, 27, 26, 24, -2, -26 },
  { 8549, 30, 38, 23, -5, -26 },
  { 8692, 23, 26, 22, -1, -26 },
  { 8767, 19, 43, 17, 1, -35 },
  { 8870, 3, 49, 27, 13, -37 },
  { 8889, 19, 43, 17, -2, -35 },
  { 8992, 24, 6, 28, 3, -20 },
};

const GFXfont NotoSans_Italic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic49pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_ITALIC49PT7B_H_
