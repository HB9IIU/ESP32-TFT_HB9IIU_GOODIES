#ifndef _NOTOSANS_ITALIC13PT7B_H_
#define _NOTOSANS_ITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x44, 0x04, 0xC0, 0x55, 0x90, 0x0B, 0x09, 0x1F, 0xE2,
  0x41, 0x47, 0xF8, 0x90, 0x50, 0x48, 0x00, 0x08, 0x38, 0xA9, 0x43, 0x03,
  0x05, 0x0A, 0xF8, 0x40, 0x80, 0x71, 0x49, 0x25, 0x12, 0xEE, 0xE8, 0xA4,
  0x92, 0x4A, 0xC7, 0x00, 0x1E, 0x22, 0x26, 0x18, 0x38, 0x49, 0xC6, 0xC6,
  0x7B, 0x58, 0x34, 0x48, 0x88, 0x88, 0x88, 0x80, 0x31, 0x11, 0x11, 0x12,
  0x24, 0xC0, 0x12, 0x47, 0x0F, 0x51, 0x20, 0x20, 0x82, 0x3F, 0x20, 0x82,
  0x00, 0x2D, 0x40, 0xF0, 0x70, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x20,
  0xC0, 0x79, 0x1C, 0x61, 0x86, 0x38, 0xA6, 0xF0, 0x3E, 0x22, 0x26, 0x44,
  0x40, 0x3E, 0x04, 0x08, 0x20, 0xC3, 0x08, 0x20, 0xFC, 0x3E, 0x04, 0x08,
  0x63, 0x80, 0x81, 0x06, 0xF8, 0x06, 0x18, 0x51, 0x26, 0x48, 0xBF, 0x84,
  0x08, 0x3E, 0x40, 0x81, 0xC4, 0xC0, 0x81, 0x02, 0xF8, 0x3D, 0x84, 0x2E,
  0xCA, 0x38, 0xA2, 0x70, 0xFC, 0x30, 0x84, 0x10, 0x82, 0x10, 0xC0, 0x7D,
  0x14, 0x5E, 0x72, 0x28, 0xA2, 0xF0, 0x7B, 0x18, 0x63, 0xDC, 0xA0, 0x84,
  0xE0, 0x68, 0x00, 0xB0, 0x32, 0x00, 0x02, 0x64, 0x80, 0x04, 0x66, 0x20,
  0x70, 0x30, 0xFC, 0x0F, 0xC0, 0x81, 0x81, 0x81, 0x3B, 0x00, 0xF8, 0x42,
  0x22, 0x20, 0x10, 0xC0, 0x1F, 0x18, 0x24, 0xE6, 0x49, 0xA2, 0x69, 0x2A,
  0x4A, 0x6C, 0xC0, 0x1F, 0x80, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x3E, 0x22,
  0x42, 0xC3, 0x7C, 0x8D, 0x1A, 0x6F, 0x90, 0xA1, 0x46, 0xF8, 0x3E, 0xC1,
  0x04, 0x08, 0x10, 0x20, 0x60, 0x7C, 0x7C, 0x85, 0x0A, 0x1C, 0x30, 0x61,
  0xC6, 0xF0, 0x7D, 0x04, 0x10, 0xFA, 0x08, 0x20, 0xF0, 0x7D, 0x04, 0x10,
  0xFA, 0x08, 0x20, 0x80, 0x3F, 0x60, 0x40, 0x80, 0x8E, 0x82, 0x86, 0xC4,
  0x7C, 0x61, 0x43, 0x42, 0x42, 0x7E, 0x82, 0x84, 0x84, 0x84, 0x39, 0x88,
  0x42, 0x11, 0x08, 0xE0, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0xCE,
  0x00, 0x66, 0x99, 0x63, 0x8F, 0x12, 0x26, 0x44, 0x8C, 0x64, 0x44, 0xC8,
  0x88, 0xF0, 0x60, 0xD8, 0x56, 0x19, 0x4A, 0xD2, 0xA5, 0x29, 0xDA, 0x64,
  0x91, 0x00, 0x61, 0x61, 0x51, 0x52, 0xD2, 0x8A, 0x8A, 0x86, 0x84, 0x3E,
  0x63, 0x41, 0x81, 0x81, 0x83, 0x82, 0xC6, 0x7C, 0x7D, 0x14, 0x51, 0xFA,
  0x08, 0x20, 0x80, 0x3E, 0x63, 0x41, 0x81, 0x81, 0x83, 0x82, 0xC6, 0x7C,
  0x08, 0x04, 0x7D, 0x14, 0x51, 0xFA, 0x49, 0xA2, 0x8C, 0x3E, 0xC1, 0x81,
  0x01, 0x81, 0x81, 0x06, 0xF8, 0xFE, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x20,
  0x40, 0x61, 0x43, 0x42, 0x42, 0xC2, 0x82, 0x84, 0x84, 0x78, 0x83, 0x89,
  0x12, 0x44, 0x8A, 0x14, 0x30, 0x60, 0xC4, 0x39, 0x49, 0x29, 0x2D, 0x65,
  0x28, 0xA5, 0x18, 0xC3, 0x18, 0x42, 0x00, 0x31, 0x89, 0x83, 0x81, 0x80,
  0xC0, 0xA0, 0x90, 0xCC, 0xC2, 0x00, 0xC6, 0x99, 0x22, 0x87, 0x04, 0x18,
  0x20, 0x40, 0x3E, 0x0C, 0x30, 0x41, 0x04, 0x18, 0x20, 0xFC, 0x39, 0x08,
  0xC4, 0x21, 0x08, 0xC4, 0x38, 0xC9, 0x24, 0x91, 0x20, 0x38, 0x44, 0x21,
  0x08, 0xC4, 0x21, 0x38, 0x10, 0x50, 0xA2, 0x24, 0x58, 0x40, 0xF8, 0x90,
  0x77, 0x38, 0xE2, 0x8A, 0x6E, 0x80, 0x30, 0x40, 0x81, 0xE2, 0x2C, 0x50,
  0xA3, 0x45, 0x70, 0x7E, 0x21, 0x08, 0x43, 0xC0, 0x02, 0x08, 0x13, 0xAC,
  0xD1, 0xA2, 0x44, 0x99, 0xD0, 0x7E, 0x63, 0xE8, 0x43, 0xC0, 0x0E, 0x30,
  0x41, 0xE1, 0x02, 0x08, 0x10, 0x20, 0x41, 0x82, 0x0C, 0x00, 0x3A, 0xCD,
  0x1A, 0x24, 0x49, 0x9D, 0x06, 0x09, 0xE0, 0x30, 0x40, 0x81, 0xE2, 0x2C,
  0x51, 0x22, 0x45, 0x88, 0x23, 0x02, 0x24, 0x44, 0x4C, 0x08, 0x30, 0x02,
  0x08, 0x41, 0x04, 0x10, 0xC2, 0x08, 0xE0, 0x30, 0x40, 0x81, 0x32, 0x8A,
  0x1C, 0x2C, 0x49, 0x98, 0x32, 0x22, 0x24, 0x44, 0x4C, 0x3D, 0xC4, 0xCD,
  0x99, 0xA2, 0x24, 0x44, 0x88, 0xB3, 0x30, 0x3E, 0xC5, 0x8A, 0x34, 0x48,
  0xB1, 0x00, 0x7B, 0x38, 0x63, 0x8A, 0x2F, 0x00, 0x3C, 0x45, 0x8A, 0x14,
  0x68, 0xBE, 0x40, 0x81, 0x00, 0x77, 0x38, 0xE2, 0x8A, 0x6E, 0x86, 0x10,
  0x40, 0x3C, 0x86, 0x10, 0x41, 0x0C, 0x00, 0x7A, 0x10, 0x61, 0x8F, 0xC0,
  0x44, 0xF4, 0x88, 0x88, 0xE0, 0x47, 0x18, 0xE2, 0x8A, 0x6E, 0x80, 0x8E,
  0x29, 0x24, 0xA2, 0x8C, 0x00, 0x99, 0xCC, 0xAA, 0x55, 0x4A, 0xA6, 0x63,
  0x30, 0x46, 0x50, 0xE1, 0x83, 0x09, 0x22, 0x00, 0x23, 0x22, 0x24, 0x24,
  0x28, 0x28, 0x10, 0x30, 0x20, 0xC0, 0x7C, 0x21, 0x08, 0x61, 0x0F, 0x80,
  0x18, 0x88, 0x42, 0x61, 0x88, 0x42, 0x18, 0xFF, 0xF8, 0x31, 0x22, 0x21,
  0x24, 0x44, 0x80, 0xFC,
};

const GFXglyph NotoSans_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 3, 5, 1, -9 },
  { 8, 9, 9, 8, 0, -9 },
  { 19, 7, 11, 7, 0, -10 },
  { 29, 9, 9, 10, 1, -9 },
  { 40, 8, 9, 9, 0, -9 },
  { 49, 2, 3, 3, 1, -9 },
  { 50, 4, 11, 4, 1, -9 },
  { 56, 4, 11, 4, -1, -9 },
  { 62, 6, 6, 7, 1, -10 },
  { 67, 6, 7, 7, 1, -8 },
  { 73, 3, 4, 3, -1, -2 },
  { 75, 4, 1, 4, 0, -4 },
  { 76, 2, 2, 3, 0, -2 },
  { 77, 7, 9, 5, -1, -9 },
  { 85, 6, 9, 7, 1, -9 },
  { 92, 4, 9, 7, 2, -9 },
  { 97, 7, 9, 7, 0, -9 },
  { 105, 7, 9, 7, 0, -9 },
  { 113, 7, 9, 7, 0, -9 },
  { 121, 7, 9, 7, 0, -9 },
  { 129, 6, 9, 7, 1, -9 },
  { 136, 6, 9, 7, 1, -9 },
  { 143, 6, 9, 7, 1, -9 },
  { 150, 6, 9, 7, 1, -9 },
  { 157, 3, 7, 3, 0, -7 },
  { 160, 4, 9, 3, -1, -7 },
  { 165, 6, 6, 7, 1, -8 },
  { 170, 6, 3, 7, 1, -6 },
  { 173, 6, 6, 7, 1, -8 },
  { 178, 5, 9, 6, 1, -9 },
  { 184, 10, 10, 11, 1, -9 },
  { 197, 8, 9, 7, -1, -9 },
  { 206, 7, 9, 8, 1, -9 },
  { 214, 7, 9, 8, 1, -9 },
  { 222, 7, 9, 9, 1, -9 },
  { 230, 6, 9, 7, 1, -9 },
  { 237, 6, 9, 6, 1, -9 },
  { 244, 8, 9, 9, 1, -9 },
  { 253, 8, 9, 9, 1, -9 },
  { 262, 5, 9, 4, 0, -9 },
  { 268, 6, 11, 4, -2, -9 },
  { 277, 7, 9, 7, 1, -9 },
  { 285, 4, 9, 6, 1, -9 },
  { 290, 10, 9, 11, 1, -9 },
  { 302, 8, 9, 9, 1, -9 },
  { 311, 8, 9, 9, 1, -9 },
  { 320, 6, 9, 7, 1, -9 },
  { 327, 8, 11, 9, 1, -9 },
  { 338, 6, 9, 7, 1, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 7, 9, 7, 1, -9 },
  { 361, 8, 9, 9, 1, -9 },
  { 370, 7, 9, 7, 1, -9 },
  { 378, 11, 9, 11, 1, -9 },
  { 391, 9, 9, 7, -1, -9 },
  { 402, 7, 9, 7, 1, -9 },
  { 410, 7, 9, 7, 0, -9 },
  { 418, 5, 11, 4, 0, -9 },
  { 425, 3, 9, 5, 1, -9 },
  { 429, 5, 11, 4, -1, -9 },
  { 436, 7, 6, 7, 0, -9 },
  { 442, 5, 1, 5, -1, 1 },
  { 443, 2, 2, 4, 2, -10 },
  { 444, 6, 7, 7, 1, -7 },
  { 450, 7, 10, 8, 0, -10 },
  { 459, 5, 7, 6, 1, -7 },
  { 464, 7, 10, 8, 1, -10 },
  { 473, 5, 7, 6, 1, -7 },
  { 478, 7, 13, 4, -1, -10 },
  { 490, 7, 10, 8, 0, -7 },
  { 499, 7, 10, 8, 0, -10 },
  { 508, 4, 10, 3, 0, -10 },
  { 513, 6, 13, 3, -2, -10 },
  { 523, 7, 10, 6, 0, -10 },
  { 532, 4, 10, 3, 0, -10 },
  { 537, 11, 7, 11, 0, -7 },
  { 547, 7, 7, 8, 0, -7 },
  { 554, 6, 7, 7, 1, -7 },
  { 560, 7, 10, 8, 0, -7 },
  { 569, 6, 10, 8, 1, -7 },
  { 577, 6, 7, 5, 0, -7 },
  { 583, 5, 7, 6, 0, -7 },
  { 588, 4, 9, 4, 1, -9 },
  { 593, 6, 7, 8, 1, -7 },
  { 599, 6, 7, 6, 1, -7 },
  { 605, 9, 7, 9, 1, -7 },
  { 613, 7, 7, 6, 0, -7 },
  { 620, 8, 10, 6, -1, -7 },
  { 630, 6, 7, 6, 0, -7 },
  { 636, 5, 11, 5, 0, -9 },
  { 643, 1, 13, 7, 3, -10 },
  { 645, 4, 11, 5, 0, -9 },
  { 651, 6, 1, 7, 1, -5 },
};

const GFXfont NotoSans_Italic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_ITALIC13PT7B_H_
