#ifndef _NOTOSANS_ITALIC30PT7B_H_
#define _NOTOSANS_ITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0x83,
  0x06, 0x1C, 0x00, 0x00, 0xC3, 0x87, 0x0E, 0x00, 0x73, 0xB9, 0xD8, 0xEC,
  0x66, 0x36, 0x1B, 0x18, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x06, 0x0C, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x0F, 0xFF, 0xF9, 0xFF, 0xFE, 0x07,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x81, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0xE1, 0x80, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x61,
  0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x1F, 0xE0, 0xFF, 0xE3, 0xD9, 0x86, 0x30, 0x0C, 0x60, 0x19, 0x80, 0x33,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xCE, 0x01, 0x9C,
  0x03, 0x38, 0x04, 0x72, 0x19, 0xC7, 0xFF, 0x0F, 0xFC, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x10, 0xFC, 0x03, 0x0E, 0x60,
  0x30, 0x63, 0x83, 0x06, 0x1C, 0x38, 0x30, 0xE1, 0x81, 0x86, 0x18, 0x0C,
  0x31, 0xC0, 0xE1, 0x9C, 0x07, 0x1C, 0xCF, 0x38, 0xCC, 0xFC, 0xCE, 0xEC,
  0x67, 0xEE, 0xE3, 0x8C, 0x66, 0x1C, 0x06, 0x30, 0xE0, 0x71, 0x86, 0x07,
  0x1C, 0x30, 0x30, 0xE1, 0x83, 0x07, 0x1C, 0x38, 0x18, 0xC3, 0x80, 0xFC,
  0x38, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x79, 0xC0, 0x18, 0x38,
  0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xC0, 0x38, 0xF0, 0x07, 0x78, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x39, 0xC1, 0xDC, 0x38, 0x7E, 0x07,
  0x3B, 0x81, 0xCC, 0xE0, 0x3F, 0x38, 0x07, 0x8E, 0x03, 0xE3, 0xC1, 0xF8,
  0x7F, 0xE7, 0x0F, 0xE0, 0xE0, 0x77, 0x66, 0x6C, 0xC0, 0x01, 0xC0, 0xC0,
  0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC0, 0x30, 0x0C, 0x00, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x10, 0x60, 0xF3, 0x03, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0x0D, 0x00, 0x76, 0x03, 0x98, 0x1C, 0x70, 0x20, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x3C, 0xE3, 0x1C, 0x63, 0x8C, 0x00, 0xFF, 0xFC,
  0x5F, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0x0E, 0x38, 0x1C,
  0xE0, 0x77, 0x01, 0xDC, 0x07, 0x60, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x0E, 0xC0, 0x73, 0x81, 0xCE, 0x0E,
  0x1C, 0x78, 0x7F, 0xC0, 0xFC, 0x00, 0x03, 0x87, 0xCF, 0xFF, 0x67, 0x32,
  0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38,
  0x1C, 0x0C, 0x06, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE,
  0x06, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFC,
  0xFF, 0xF8, 0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0x40, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC6, 0x07, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x76, 0x00, 0x6E, 0x00, 0xCE, 0x01, 0xCC, 0x03, 0x8C,
  0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x30, 0x38, 0x70, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x07, 0xFE, 0x0F, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x41, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF3,
  0x03, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x07, 0xF0, 0x7F, 0xC3,
  0xC0, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x9F, 0x86,
  0xFF, 0x3E, 0x0E, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B,
  0x80, 0xCE, 0x07, 0x1C, 0x38, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0xFF,
  0xFC, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x70, 0x70, 0xC0, 0x63, 0x80,
  0xC7, 0x03, 0x86, 0x07, 0x0E, 0x1C, 0x0E, 0xF0, 0x0F, 0x80, 0x7F, 0x03,
  0xC7, 0x0F, 0x07, 0x1C, 0x06, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x39, 0xC0,
  0xE3, 0x83, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xE0, 0xE3, 0x80, 0xC7, 0x01, 0xCC, 0x03, 0x98, 0x07, 0x30, 0x0E,
  0x60, 0x38, 0xE0, 0x71, 0xE3, 0xE1, 0xFF, 0xC1, 0xF3, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x84, 0x0F, 0x0F, 0xFC, 0x1F, 0xE0,
  0x00, 0x08, 0xF3, 0xCE, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0E,
  0x38, 0xE0, 0x02, 0x0F, 0x0F, 0x0E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x38, 0x38, 0x70, 0x70, 0x60, 0xC0, 0xC0, 0x00,
  0x04, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x03, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x07, 0xFC, 0x7F, 0xE2,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1E, 0x01,
  0xE0, 0x70, 0x00, 0xC1, 0x80, 0x01, 0xC7, 0x01, 0x01, 0x9C, 0x1F, 0xE3,
  0x30, 0x79, 0xC7, 0xE1, 0x83, 0x0F, 0x87, 0x06, 0x1F, 0x0C, 0x1C, 0x3E,
  0x38, 0x38, 0x6C, 0x70, 0x60, 0xD8, 0xC1, 0xC3, 0xB1, 0xC3, 0x86, 0x63,
  0x8F, 0x1C, 0xC3, 0xF3, 0xF1, 0xC3, 0x83, 0x81, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x10, 0x03, 0xE1, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60,
  0x03, 0x30, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xC3, 0x80, 0xE0,
  0xC0, 0xE0, 0x60, 0x7F, 0xF0, 0x7F, 0xF8, 0x38, 0x0E, 0x38, 0x07, 0x1C,
  0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x18, 0x07, 0xFE,
  0x07, 0xFF, 0x83, 0x81, 0xC1, 0xC0, 0x70, 0xC0, 0x38, 0x60, 0x1C, 0x70,
  0x0C, 0x38, 0x0E, 0x1C, 0x3E, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0x03, 0x83,
  0x80, 0xE1, 0x80, 0x70, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F,
  0x18, 0x1F, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC1,
  0xFF, 0xC1, 0xE0, 0x21, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x81, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xE0,
  0xF8, 0x38, 0x0E, 0x0C, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x8E,
  0x00, 0xE3, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x07, 0x86, 0x0F,
  0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x10, 0x7F, 0xE0, 0xFF, 0xE0,
  0x07, 0xFF, 0x0F, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x7F,
  0xFC, 0x3C, 0x02, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0xFE, 0xE0, 0x7F, 0x38,
  0x00, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x1C, 0x01, 0x87, 0x80,
  0xE0, 0xF0, 0x38, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x70, 0xE0,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x1C,
  0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x30, 0x03, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x60, 0xE0, 0x0E,
  0x00, 0x07, 0xF0, 0x3C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0xFE, 0x07, 0xF0, 0x1C, 0x00, 0x06, 0x03, 0xE1, 0xC0, 0xF0, 0x38, 0x3C,
  0x07, 0x0F, 0x00, 0xC3, 0xC0, 0x18, 0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x00,
  0x1D, 0xC0, 0x03, 0x70, 0x00, 0xFF, 0x00, 0x1E, 0x60, 0x03, 0x8E, 0x00,
  0x61, 0xC0, 0x0C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x30, 0x0E, 0x07, 0x01,
  0x80, 0xE0, 0x30, 0x0E, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x17,
  0xFE, 0xFF, 0xE0, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0D, 0x80, 0x1F,
  0x0D, 0x80, 0x3F, 0x0D, 0x80, 0x36, 0x1D, 0x80, 0x6E, 0x1D, 0x80, 0xEE,
  0x1D, 0x80, 0xCE, 0x19, 0xC1, 0xCC, 0x19, 0xC1, 0x8C, 0x38, 0xC3, 0x9C,
  0x38, 0xC3, 0x1C, 0x38, 0xC7, 0x1C, 0x30, 0xC6, 0x18, 0x30, 0xCE, 0x18,
  0x70, 0xCC, 0x38, 0x70, 0xF8, 0x38, 0x60, 0xF8, 0x38, 0x60, 0x70, 0x30,
  0x60, 0x70, 0x70, 0xE0, 0x60, 0x70, 0x07, 0x00, 0x30, 0xF0, 0x07, 0x0F,
  0x80, 0x70, 0xF8, 0x07, 0x0D, 0x80, 0x61, 0xDC, 0x06, 0x1C, 0xC0, 0xE1,
  0xCE, 0x0E, 0x18, 0xE0, 0xC1, 0x86, 0x0C, 0x38, 0x71, 0xC3, 0x87, 0x1C,
  0x38, 0x31, 0xC3, 0x03, 0x98, 0x30, 0x19, 0x87, 0x01, 0xB8, 0x70, 0x1F,
  0x86, 0x00, 0xF8, 0x60, 0x0F, 0x06, 0x00, 0xF0, 0xE0, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xC1, 0xC0, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x1E, 0xE0, 0x03, 0x8E, 0x00, 0xF1, 0xE0, 0x3C, 0x1E, 0x1F, 0x01, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x0E, 0x07,
  0x0C, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x18, 0x1E,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xC1, 0xC0, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x6E, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1C,
  0xE0, 0x03, 0x8E, 0x00, 0xE1, 0xE0, 0x3C, 0x1E, 0x1F, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xFC, 0x0F, 0xFE, 0x0E, 0x0F, 0x0E, 0x07, 0x0C,
  0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x18, 0x3C, 0x3F,
  0xF8, 0x3F, 0xE0, 0x38, 0xE0, 0x30, 0x60, 0x30, 0x70, 0x70, 0x70, 0x70,
  0x38, 0x70, 0x38, 0x60, 0x38, 0x60, 0x1C, 0xE0, 0x1C, 0x00, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF0, 0xE0, 0x23, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC4, 0x0F, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xE3, 0x80, 0x18,
  0x70, 0x07, 0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE1,
  0x80, 0x1C, 0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x86,
  0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x0E,
  0x03, 0x81, 0xE0, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0xE0, 0x07, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x60, 0x38, 0x60,
  0x70, 0x60, 0x70, 0x60, 0xE0, 0x60, 0xE0, 0x71, 0xC0, 0x71, 0x80, 0x73,
  0x80, 0x73, 0x00, 0x77, 0x00, 0x36, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x1E, 0x01, 0xB8, 0x0F, 0x01,
  0xDC, 0x07, 0x80, 0xEE, 0x06, 0xC0, 0xE7, 0x03, 0x60, 0x71, 0x83, 0xB0,
  0x70, 0xC1, 0x98, 0x38, 0x61, 0xCE, 0x18, 0x30, 0xC7, 0x1C, 0x18, 0xE3,
  0x8C, 0x0C, 0x61, 0xCE, 0x06, 0x70, 0xE6, 0x03, 0x30, 0x77, 0x01, 0xB8,
  0x1B, 0x80, 0xD8, 0x0D, 0x80, 0x6C, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x18, 0x38, 0x01, 0xC7, 0x00, 0x0C, 0x70,
  0x00, 0xEE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x80, 0x01, 0xD8, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0x70,
  0xC0, 0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x06, 0x03, 0x80, 0x70, 0xF0,
  0x07, 0x00, 0xE0, 0x1F, 0xC0, 0x39, 0x80, 0xE3, 0x03, 0x87, 0x07, 0x0E,
  0x1C, 0x0C, 0x70, 0x18, 0xE0, 0x3B, 0x80, 0x76, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x01, 0x1F, 0xFF,
  0x0F, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xFC, 0x1F, 0x80, 0xE1, 0x86, 0x18, 0x61, 0xC7, 0x1C, 0x30, 0xC3, 0x0C,
  0x38, 0xE3, 0x86, 0x18, 0x61, 0x87, 0x1C, 0x07, 0xE0, 0xFC, 0x03, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0xFC, 0x1F, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x3E, 0x00, 0x6C, 0x01, 0x9C, 0x03, 0x18, 0x0C, 0x38, 0x18, 0x30,
  0x60, 0x70, 0xC0, 0x63, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xE3, 0x8C, 0x71, 0x80, 0x07, 0xE7, 0x0F, 0xF6, 0x1E, 0x3E,
  0x38, 0x1E, 0x38, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C,
  0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x78, 0x60, 0x78, 0x70, 0xF8, 0x7F, 0xB0,
  0x3F, 0x30, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x7C, 0x1B, 0xFC, 0x36, 0x3C, 0xF8, 0x39, 0xE0,
  0x73, 0x80, 0xE7, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70, 0x1C, 0xE0, 0x39,
  0xC0, 0x73, 0x81, 0xCF, 0x87, 0x19, 0xFC, 0x33, 0xF0, 0x00, 0x07, 0xF8,
  0x7F, 0x87, 0x84, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x10, 0xFF, 0x83, 0xF8,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x0F, 0xCC, 0x0F, 0xF6, 0x0F, 0x0F, 0x0E, 0x07, 0x87,
  0x03, 0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0, 0x18,
  0x70, 0x1C, 0x38, 0x1E, 0x0C, 0x0F, 0x07, 0x0F, 0x83, 0xFD, 0x80, 0xFC,
  0xC0, 0x07, 0xF0, 0x7F, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC7,
  0xCF, 0xFC, 0x7F, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x10,
  0xFF, 0x83, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x71, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x07, 0xE7, 0x0F, 0xF6, 0x1E, 0x1E, 0x38, 0x1E, 0x38,
  0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x18, 0xE0,
  0x38, 0xE0, 0x78, 0x60, 0x78, 0x71, 0xF8, 0x7F, 0xB0, 0x3F, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0xC1, 0xC0, 0xFF, 0xC0, 0xFF,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x7C, 0x1B, 0xFC, 0x36, 0x1C, 0xF8, 0x39, 0xE0, 0x73,
  0x80, 0xE7, 0x01, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x31, 0x80,
  0x63, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x00, 0x0E, 0x1C, 0x38,
  0x00, 0x00, 0x07, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70,
  0xC1, 0x87, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x0F, 0xC0, 0xF8,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x0F, 0x1C, 0x38, 0x30, 0xE0, 0xE3, 0x81, 0xCE, 0x03,
  0xB8, 0x06, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7B, 0x80, 0xE3, 0x81, 0x87,
  0x03, 0x07, 0x0E, 0x0E, 0x1C, 0x0C, 0x38, 0x1C, 0x00, 0x06, 0x1C, 0x38,
  0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70,
  0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x00, 0x18, 0xF8, 0x7C, 0x1B, 0xFC, 0xFE,
  0x1B, 0x1D, 0x8E, 0x3C, 0x0F, 0x07, 0x3C, 0x0E, 0x07, 0x38, 0x1C, 0x06,
  0x38, 0x1C, 0x06, 0x30, 0x1C, 0x0E, 0x70, 0x18, 0x0E, 0x70, 0x18, 0x0E,
  0x70, 0x38, 0x0C, 0x60, 0x38, 0x1C, 0x60, 0x38, 0x1C, 0xE0, 0x30, 0x1C,
  0xE0, 0x70, 0x1C, 0xE0, 0x70, 0x38, 0x1C, 0xFC, 0x37, 0xF8, 0x7C, 0x39,
  0xF0, 0x73, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x18, 0x0E, 0x70, 0x1C, 0xE0,
  0x39, 0xC0, 0x73, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38,
  0x07, 0xF0, 0x3F, 0xE1, 0xC3, 0xCE, 0x07, 0x30, 0x0D, 0xC0, 0x37, 0x00,
  0xD8, 0x03, 0x60, 0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x0E, 0x70, 0x39, 0xE1,
  0xC3, 0xFE, 0x07, 0xF0, 0x06, 0x3E, 0x03, 0x7F, 0x81, 0xB1, 0xE0, 0xF0,
  0x70, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x18, 0x07, 0x1C, 0x03, 0x8E,
  0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE1, 0xF0, 0xE0, 0xEF, 0xE0,
  0x77, 0xE0, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE7, 0x0F, 0xF6, 0x1E, 0x3E, 0x38,
  0x1E, 0x38, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C, 0xE0,
  0x18, 0xE0, 0x38, 0xE0, 0x78, 0x60, 0x78, 0x71, 0xF8, 0x7F, 0xB0, 0x3F,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x19, 0xF1, 0xBE, 0x1B, 0x03, 0xE0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x0F, 0xF1, 0xFF, 0x38, 0x13, 0x80, 0x38, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xEC, 0x1C,
  0xFF, 0xC7, 0xF8, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x7F, 0xFF, 0xF1, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0xE0, 0xF8, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xCE, 0x03, 0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x63, 0x81,
  0xC6, 0x03, 0x8C, 0x0F, 0x1C, 0x7E, 0x3F, 0xD8, 0x3F, 0x30, 0xE0, 0x1D,
  0x80, 0x76, 0x03, 0x98, 0x0E, 0x70, 0x71, 0xC1, 0x87, 0x0E, 0x1C, 0x30,
  0x71, 0xC0, 0xCE, 0x03, 0x38, 0x0C, 0xC0, 0x37, 0x00, 0xD8, 0x03, 0xE0,
  0x0F, 0x00, 0xC0, 0xF0, 0x3E, 0x07, 0x83, 0xB0, 0x7C, 0x1D, 0x83, 0x61,
  0xCC, 0x1B, 0x0E, 0x61, 0x98, 0x63, 0x0C, 0xC7, 0x1C, 0xC6, 0x30, 0xE6,
  0x33, 0x87, 0x71, 0x98, 0x3B, 0x0D, 0xC1, 0xF8, 0x6C, 0x0D, 0x83, 0x60,
  0x6C, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x1C, 0x07, 0x0E, 0x0E,
  0x06, 0x1C, 0x07, 0x38, 0x07, 0x30, 0x03, 0x70, 0x03, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0x60, 0x1C, 0x70, 0x38, 0x30,
  0x70, 0x38, 0xE0, 0x38, 0x0E, 0x01, 0xC1, 0x80, 0x70, 0x60, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x0C, 0x30, 0x03, 0x1C,
  0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x70, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xF0,
  0x1F, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x1E, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xE0, 0x0E, 0x07, 0xC1, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x06, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0x10, 0x05, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7E,
};

const GFXglyph NotoSans_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 21, 8, 1, -21 },
  { 20, 9, 7, 12, 3, -21 },
  { 28, 19, 21, 19, 1, -21 },
  { 78, 15, 25, 17, 1, -23 },
  { 125, 21, 22, 24, 2, -22 },
  { 183, 18, 22, 20, 1, -22 },
  { 233, 4, 7, 7, 3, -21 },
  { 237, 10, 26, 9, 1, -21 },
  { 270, 9, 26, 9, -2, -21 },
  { 300, 14, 14, 17, 3, -23 },
  { 325, 14, 15, 17, 2, -18 },
  { 352, 6, 7, 8, -1, -3 },
  { 358, 7, 2, 9, 1, -9 },
  { 360, 3, 4, 8, 1, -4 },
  { 362, 14, 21, 11, -1, -21 },
  { 399, 14, 22, 17, 2, -22 },
  { 438, 9, 21, 17, 4, -21 },
  { 462, 16, 22, 17, 0, -22 },
  { 506, 15, 22, 17, 1, -22 },
  { 548, 16, 21, 17, 0, -21 },
  { 590, 15, 21, 17, 1, -21 },
  { 630, 14, 22, 17, 2, -22 },
  { 669, 15, 21, 17, 2, -21 },
  { 709, 15, 22, 17, 1, -22 },
  { 751, 15, 22, 17, 1, -22 },
  { 793, 6, 17, 8, 1, -17 },
  { 806, 8, 21, 8, -1, -17 },
  { 827, 14, 15, 17, 2, -18 },
  { 854, 14, 8, 17, 2, -15 },
  { 868, 14, 15, 17, 2, -18 },
  { 895, 12, 22, 13, 2, -22 },
  { 928, 23, 24, 25, 2, -21 },
  { 997, 17, 21, 17, -2, -21 },
  { 1042, 17, 21, 18, 1, -21 },
  { 1087, 17, 22, 18, 2, -22 },
  { 1134, 18, 21, 20, 1, -21 },
  { 1182, 16, 21, 15, 1, -21 },
  { 1224, 16, 21, 14, 1, -21 },
  { 1266, 18, 22, 20, 2, -22 },
  { 1316, 20, 21, 20, 1, -21 },
  { 1369, 12, 21, 10, -1, -21 },
  { 1401, 13, 27, 8, -5, -21 },
  { 1445, 19, 21, 17, 1, -21 },
  { 1495, 12, 21, 14, 1, -21 },
  { 1527, 24, 21, 25, 1, -21 },
  { 1590, 20, 21, 21, 1, -21 },
  { 1643, 19, 22, 22, 2, -22 },
  { 1696, 16, 21, 17, 1, -21 },
  { 1738, 19, 27, 22, 2, -22 },
  { 1803, 16, 21, 17, 1, -21 },
  { 1845, 15, 22, 15, 1, -22 },
  { 1887, 15, 21, 15, 3, -21 },
  { 1927, 19, 21, 20, 2, -21 },
  { 1977, 16, 21, 17, 3, -21 },
  { 2019, 25, 21, 26, 3, -21 },
  { 2085, 20, 21, 16, -2, -21 },
  { 2138, 15, 21, 15, 3, -21 },
  { 2178, 17, 21, 16, 0, -21 },
  { 2223, 11, 26, 9, 0, -21 },
  { 2259, 6, 21, 11, 3, -21 },
  { 2275, 11, 26, 9, -2, -21 },
  { 2311, 15, 14, 17, 1, -22 },
  { 2338, 13, 2, 12, -3, 3 },
  { 2342, 5, 5, 8, 4, -23 },
  { 2346, 16, 16, 17, 1, -16 },
  { 2378, 15, 23, 17, 1, -23 },
  { 2422, 13, 16, 14, 1, -16 },
  { 2448, 17, 23, 17, 1, -23 },
  { 2497, 13, 16, 15, 1, -16 },
  { 2523, 16, 30, 10, -3, -23 },
  { 2583, 16, 23, 17, 1, -16 },
  { 2629, 15, 23, 17, 1, -23 },
  { 2673, 7, 22, 8, 1, -22 },
  { 2693, 12, 29, 8, -4, -22 },
  { 2737, 15, 23, 15, 1, -23 },
  { 2781, 7, 23, 8, 1, -23 },
  { 2802, 24, 16, 26, 1, -16 },
  { 2850, 15, 16, 17, 1, -16 },
  { 2880, 14, 16, 17, 1, -16 },
  { 2908, 17, 23, 17, -1, -16 },
  { 2957, 16, 23, 17, 1, -16 },
  { 3003, 12, 16, 12, 1, -16 },
  { 3027, 12, 16, 13, 0, -16 },
  { 3051, 10, 20, 10, 1, -20 },
  { 3076, 15, 16, 17, 2, -16 },
  { 3106, 14, 16, 14, 1, -16 },
  { 3134, 21, 16, 22, 2, -16 },
  { 3176, 16, 16, 14, -1, -16 },
  { 3208, 18, 23, 14, -3, -16 },
  { 3260, 13, 16, 13, 0, -16 },
  { 3286, 12, 26, 11, 0, -21 },
  { 3325, 2, 30, 17, 8, -23 },
  { 3333, 11, 26, 11, -1, -21 },
  { 3369, 14, 4, 17, 2, -13 },
};

const GFXfont NotoSans_Italic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_ITALIC30PT7B_H_
