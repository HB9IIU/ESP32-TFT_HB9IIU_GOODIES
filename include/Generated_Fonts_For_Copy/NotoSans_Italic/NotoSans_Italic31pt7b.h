#ifndef _NOTOSANS_ITALIC31PT7B_H_
#define _NOTOSANS_ITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x70, 0x00, 0x00, 0x60, 0xF0, 0xE0, 0xE0, 0x71,
  0xDC, 0x67, 0x39, 0x8E, 0x63, 0x18, 0xC6, 0x33, 0x0C, 0x00, 0xE1, 0x80,
  0x18, 0x30, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x0F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03,
  0x06, 0x00, 0x61, 0xC1, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x0C,
  0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x03, 0x86, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0xC0, 0x7F, 0xE1,
  0xFF, 0xC7, 0x30, 0x8C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x76, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0x9C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0xE6, 0x3B, 0xCF, 0xFF, 0x1F, 0xF8, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0F, 0x80, 0x70, 0xFE, 0x03, 0x0C, 0x30, 0x30, 0xE1,
  0x83, 0x86, 0x0C, 0x38, 0x30, 0x61, 0x81, 0x87, 0x18, 0x0C, 0x39, 0xC0,
  0xE1, 0x8C, 0x47, 0x0C, 0xCF, 0x98, 0xCC, 0xEE, 0xFE, 0xEE, 0x33, 0xE6,
  0x61, 0x80, 0x67, 0x0C, 0x07, 0x38, 0x60, 0x71, 0x83, 0x03, 0x0C, 0x18,
  0x30, 0x61, 0xC3, 0x83, 0x0C, 0x38, 0x18, 0xE1, 0x80, 0xFE, 0x38, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0,
  0x60, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0x39, 0xE0, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0x8E, 0x0E, 0xE0, 0xE3, 0xB8, 0x1C,
  0x67, 0x01, 0xDC, 0xE0, 0x1F, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x38, 0x3F,
  0x87, 0xFF, 0x78, 0x7F, 0x87, 0x80, 0x77, 0x76, 0x66, 0x6C, 0x01, 0xC0,
  0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x00, 0x01, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x61, 0x83, 0xE4, 0x03, 0xF1, 0xC1, 0xFF, 0x07, 0x9C, 0x36, 0x01,
  0xDC, 0x1E, 0x30, 0x30, 0xC0, 0x43, 0x80, 0x08, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x1C, 0xE3, 0x8C, 0x71, 0x8E, 0x30, 0xFF, 0xFE, 0xFE, 0x6F,
  0xEE, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x78,
  0x70, 0xE0, 0xE3, 0x80, 0xC7, 0x01, 0x9C, 0x03, 0xB8, 0x07, 0x60, 0x0F,
  0xC0, 0x1B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x70,
  0x1C, 0xE0, 0x39, 0xC0, 0xE3, 0x81, 0xC3, 0x8F, 0x07, 0xFC, 0x07, 0xF0,
  0x00, 0x03, 0xC1, 0xE1, 0xF8, 0xFE, 0xFB, 0x98, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x0E, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x0F, 0x04,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0x07, 0xF8, 0x3F, 0xF8, 0x30, 0x78, 0x40, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x3C, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x72, 0x00,
  0xE6, 0x07, 0x8F, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x30, 0x07, 0x38, 0x03, 0x1C,
  0x03, 0x8C, 0x03, 0x86, 0x03, 0x87, 0x03, 0x83, 0x83, 0x81, 0xC3, 0x80,
  0xC1, 0xC0, 0x63, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x19, 0x80,
  0x1F, 0xF0, 0x3F, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x80, 0x38, 0xC0, 0xF0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x73, 0xE0, 0xFF, 0xE1, 0xF1, 0xE7, 0x81,
  0xCF, 0x01, 0x9C, 0x03, 0xB8, 0x06, 0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x73,
  0x81, 0xC3, 0x87, 0x87, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03,
  0xFC, 0x07, 0xFE, 0x0F, 0x0E, 0x0E, 0x07, 0x0C, 0x07, 0x0C, 0x07, 0x0C,
  0x06, 0x0E, 0x0E, 0x07, 0x3C, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x3C,
  0x38, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x70,
  0x1C, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xF8, 0x78,
  0x70, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCC, 0x03, 0x98, 0x07, 0x30, 0x0E,
  0x70, 0x1C, 0xE0, 0x79, 0xF7, 0xF1, 0xFE, 0xC0, 0xF3, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC4, 0x0F, 0x0F, 0xFC, 0x1F, 0xE0,
  0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8F,
  0x38, 0xE0, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x0C, 0x0E,
  0x0E, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0xC7, 0xFE, 0x30, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0xE1,
  0xC0, 0x00, 0xC3, 0x00, 0x01, 0xCC, 0x0F, 0xF1, 0xB8, 0x3F, 0xC3, 0x60,
  0xE1, 0x87, 0xC3, 0x07, 0x0F, 0x0E, 0x0E, 0x1E, 0x18, 0x18, 0x3C, 0x30,
  0x30, 0x78, 0xE0, 0xE1, 0xF1, 0xC1, 0xC3, 0x63, 0x87, 0x8E, 0xC3, 0x9B,
  0x39, 0x87, 0xE7, 0xE3, 0x83, 0x87, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x10, 0x07, 0xC3, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x37, 0x00,
  0x1D, 0xC0, 0x06, 0x70, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x38,
  0x30, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x0E,
  0x1C, 0x01, 0x87, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x07, 0x70, 0x01, 0xFC,
  0x00, 0x70, 0x07, 0xFC, 0x03, 0xFF, 0x83, 0x83, 0xE1, 0xC0, 0x70, 0xE0,
  0x38, 0x70, 0x1C, 0x30, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0F, 0xFF, 0x07,
  0xFC, 0x07, 0xFF, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E,
  0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x0F, 0x87, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x18, 0x3C, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x30, 0x1F, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x38, 0x7E, 0x07, 0x01,
  0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0x80, 0x1C, 0x70, 0x07, 0x8E, 0x01, 0xE1, 0xC0, 0x78,
  0x38, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1E, 0x07, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0xFE, 0x70, 0x1F, 0xCE, 0x03, 0xF9, 0xC0, 0x07, 0x38, 0x00, 0xE7,
  0x00, 0x18, 0xF0, 0x07, 0x0E, 0x00, 0xE1, 0xE0, 0x1C, 0x1F, 0x07, 0x01,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0C, 0x00, 0xE1, 0xC0,
  0x0E, 0x1C, 0x00, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x38,
  0x01, 0xC3, 0x80, 0x18, 0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x30, 0x70, 0x03, 0x07, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x70,
  0x07, 0xF8, 0x3F, 0x80, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x03, 0xFC, 0x0F, 0xE0, 0x3E,
  0x00, 0x07, 0x01, 0xE0, 0xC0, 0x78, 0x38, 0x1E, 0x07, 0x07, 0x80, 0xE1,
  0xE0, 0x1C, 0x78, 0x03, 0x1E, 0x00, 0xE7, 0x80, 0x1D, 0xE0, 0x03, 0xF8,
  0x00, 0x6F, 0x00, 0x1F, 0x60, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x1C,
  0x01, 0x83, 0x80, 0x70, 0x30, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x06, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE1, 0xF0, 0x03, 0x60, 0xD8, 0x03, 0xB0, 0x6C, 0x01, 0xB8, 0x37, 0x01,
  0xDC, 0x3B, 0x80, 0xCE, 0x1D, 0xC0, 0xE6, 0x0E, 0x60, 0x67, 0x06, 0x30,
  0x73, 0x87, 0x18, 0x31, 0xC3, 0x8C, 0x38, 0xE1, 0xC6, 0x38, 0x60, 0xC3,
  0x98, 0x70, 0x61, 0xDC, 0x38, 0x70, 0xEC, 0x1C, 0x38, 0x3E, 0x0E, 0x1C,
  0x1E, 0x06, 0x0C, 0x0F, 0x07, 0x06, 0x07, 0x03, 0x87, 0x03, 0x81, 0xC0,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0xE0, 0x0E, 0x1F, 0x00, 0x60, 0xDC,
  0x07, 0x06, 0xE0, 0x38, 0x33, 0x01, 0xC3, 0x9C, 0x0C, 0x1C, 0xE0, 0x60,
  0xC3, 0x07, 0x06, 0x1C, 0x38, 0x70, 0x61, 0xC3, 0x83, 0x8C, 0x1C, 0x1C,
  0x60, 0xC0, 0x67, 0x06, 0x03, 0xB8, 0x70, 0x1D, 0xC3, 0x80, 0x6C, 0x1C,
  0x03, 0xE0, 0xC0, 0x0F, 0x06, 0x00, 0x78, 0x70, 0x03, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0xF0, 0x3E, 0x0F, 0x0F, 0x00, 0xE1, 0xC0, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x0E,
  0x70, 0x03, 0xCE, 0x00, 0xF1, 0xE0, 0x3C, 0x1E, 0x1F, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0x87, 0xC1, 0xC0, 0xE0,
  0xE0, 0x30, 0x70, 0x1C, 0x30, 0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07,
  0x86, 0x07, 0x87, 0xFF, 0x83, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3E, 0x0F, 0x0F, 0x00, 0xE1,
  0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x77, 0x00, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xE0, 0x3C, 0x1E,
  0x0F, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x03,
  0x87, 0xC1, 0xC0, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x30, 0x0E, 0x38, 0x0E,
  0x1C, 0x07, 0x0E, 0x07, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0x60, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x06, 0x0E,
  0x03, 0x86, 0x01, 0xC7, 0x00, 0x70, 0x07, 0xFC, 0x1F, 0xFC, 0x78, 0x30,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC6, 0x0F, 0x8F, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x71, 0x80, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x01, 0xC6, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x38, 0xE0, 0x06, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x0C, 0x01,
  0xC1, 0xC0, 0x78, 0x3C, 0x1E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xE0,
  0x03, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE1,
  0x80, 0xE0, 0xC0, 0x70, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x1C,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0x67, 0x00, 0x37, 0x00, 0x1B,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x0E,
  0x01, 0xF8, 0x07, 0x80, 0x6E, 0x01, 0xE0, 0x3B, 0x80, 0xD8, 0x0E, 0x60,
  0x36, 0x07, 0x18, 0x1D, 0x81, 0xC6, 0x06, 0x60, 0xE1, 0x83, 0x98, 0x38,
  0x60, 0xC6, 0x0C, 0x18, 0x71, 0x87, 0x06, 0x18, 0x61, 0x81, 0x8E, 0x18,
  0xE0, 0x63, 0x06, 0x38, 0x19, 0xC1, 0x9C, 0x07, 0x70, 0x67, 0x01, 0xD8,
  0x19, 0x80, 0x6E, 0x06, 0xE0, 0x1B, 0x01, 0xB0, 0x07, 0xC0, 0x6C, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x78, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00,
  0x63, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00, 0x0E,
  0x70, 0x00, 0xE1, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x01, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x78, 0x01, 0xC0, 0xE0, 0x0F, 0xE0, 0x1E,
  0x60, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x70, 0x70, 0x30, 0xE0, 0x30, 0xC0,
  0x39, 0xC0, 0x3B, 0x80, 0x1B, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x1F, 0x83, 0xF0, 0x00, 0xE1, 0x86, 0x18, 0x71,
  0xC7, 0x1C, 0x30, 0xC3, 0x0E, 0x38, 0xE1, 0x86, 0x18, 0x61, 0xC7, 0x1C,
  0x30, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x06, 0xC0, 0x0E,
  0x60, 0x0C, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x18, 0x30, 0x18, 0x30,
  0x0C, 0x70, 0x0C, 0x60, 0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7,
  0x18, 0xE3, 0x80, 0x03, 0xE3, 0x07, 0xF3, 0x0F, 0x3F, 0x1C, 0x1E, 0x38,
  0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x1C, 0x60,
  0x1C, 0xE0, 0x3C, 0x60, 0x38, 0x70, 0x78, 0x70, 0xD8, 0x7F, 0x98, 0x3F,
  0x38, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x3C, 0x1D, 0xFC, 0x3F, 0xBC, 0x78, 0x38, 0xE0, 0x33,
  0xC0, 0x67, 0x00, 0xCE, 0x01, 0x98, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0,
  0x73, 0x80, 0xE7, 0x03, 0x9F, 0x0F, 0x3B, 0xFC, 0x63, 0xE0, 0x01, 0xF0,
  0x3F, 0xC3, 0xCE, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x87, 0xFC,
  0x1F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0x1C, 0x07, 0xF7, 0x03, 0xCF,
  0xC1, 0xC1, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x30, 0x60, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC1, 0x80, 0xE0, 0x70,
  0x78, 0x1C, 0x36, 0x07, 0xFB, 0x80, 0xFC, 0xE0, 0x03, 0xE0, 0x1F, 0xE0,
  0xF3, 0x87, 0x07, 0x38, 0x1C, 0xE0, 0xE7, 0x07, 0x9D, 0xFC, 0x7F, 0xE1,
  0xF8, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x83, 0x0F, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xE3, 0x07, 0xF3,
  0x1F, 0x3F, 0x1C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0x60, 0x38, 0x70, 0x78,
  0x70, 0xF8, 0x7F, 0xB8, 0x3F, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x81, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x3C, 0x1D,
  0xFC, 0x3F, 0xBC, 0x78, 0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE, 0x03,
  0x98, 0x07, 0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0x06, 0x1C, 0x38, 0x20, 0x00, 0x07, 0x0E,
  0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C,
  0x38, 0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xFC, 0x0F, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x07, 0x1C, 0x1C, 0x38, 0x70, 0x61, 0xC1, 0xC7, 0x03, 0x9C, 0x07,
  0x70, 0x0D, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xE3, 0x81, 0xC7, 0x03, 0x86,
  0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x3C, 0x07, 0x06, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x1C, 0x78, 0x3C, 0x1D,
  0xFC, 0x7F, 0x1B, 0x9C, 0xEF, 0x1E, 0x0D, 0x87, 0x1C, 0x0F, 0x03, 0x3C,
  0x0E, 0x03, 0x38, 0x0E, 0x07, 0x38, 0x1C, 0x07, 0x30, 0x1C, 0x07, 0x70,
  0x1C, 0x07, 0x70, 0x1C, 0x06, 0x70, 0x18, 0x0E, 0x70, 0x38, 0x0E, 0x60,
  0x38, 0x0E, 0xE0, 0x38, 0x0C, 0xE0, 0x38, 0x1C, 0xE0, 0x30, 0x1C, 0x1C,
  0x78, 0x3B, 0xFC, 0x7F, 0x78, 0xF8, 0x73, 0xE0, 0xE7, 0x81, 0xCE, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xDC,
  0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xE0, 0x38, 0x01, 0xE0, 0x0F, 0xF0, 0x7F,
  0xF0, 0xE0, 0xE3, 0x80, 0xE6, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x60, 0x0E,
  0xC0, 0x1F, 0x80, 0x37, 0x00, 0xE6, 0x01, 0xCE, 0x07, 0x1E, 0x1C, 0x1F,
  0xF0, 0x1F, 0xC0, 0x07, 0x1E, 0x03, 0xBF, 0x81, 0xBD, 0xE0, 0xF0, 0x70,
  0x70, 0x18, 0x78, 0x0C, 0x38, 0x06, 0x1C, 0x03, 0x0C, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0xF8, 0x78, 0x77,
  0xF8, 0x39, 0xF8, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xE3, 0x07, 0xF3, 0x0F, 0x3F,
  0x1C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C,
  0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0x60, 0x38, 0x70, 0x78, 0x70, 0xF8,
  0x7F, 0xB8, 0x3F, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x71, 0xDF, 0x1B, 0xF1, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0xC7,
  0x9C, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0x07, 0x9F, 0xF8, 0x7F, 0x80,
  0x06, 0x03, 0x80, 0xC0, 0xFF, 0x7F, 0xE7, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xE0,
  0xF8, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0x80, 0x67, 0x01, 0xCE, 0x03,
  0x9C, 0x07, 0x30, 0x0E, 0xE0, 0x19, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0xCC,
  0x07, 0x1C, 0x1E, 0x38, 0x6C, 0x7F, 0xB8, 0x7E, 0x70, 0xE0, 0x0E, 0xC0,
  0x39, 0x80, 0x73, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x70,
  0x70, 0xE0, 0x63, 0x80, 0xC7, 0x01, 0x9C, 0x03, 0x30, 0x06, 0xE0, 0x0D,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xC0, 0x70, 0x1F, 0x01, 0xC0, 0xEC, 0x0F,
  0x03, 0xB8, 0x3C, 0x1C, 0xE1, 0xB0, 0x73, 0x86, 0xC3, 0x8E, 0x3B, 0x0E,
  0x38, 0xCC, 0x30, 0xE7, 0x31, 0xC3, 0x98, 0xE6, 0x0E, 0xE3, 0xB8, 0x3B,
  0x0E, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x00, 0x1C, 0x03, 0x87, 0x03, 0x83, 0x83, 0x80, 0xE3,
  0x80, 0x73, 0x80, 0x19, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xF8, 0x01, 0xCC, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0xE0, 0xE0,
  0xE0, 0x70, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0xC0, 0x38, 0x18, 0x07,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x18, 0x70,
  0x03, 0x0E, 0x00, 0x63, 0x80, 0x0E, 0x60, 0x01, 0xDC, 0x00, 0x3B, 0x00,
  0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xF0, 0x1F, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x01, 0xE0, 0x7C, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x78,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x01, 0xF0, 0x0E, 0x03, 0xE0, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x78, 0x0F, 0x80,
  0xE0, 0x00, 0x3E, 0x03, 0xFF, 0x0F, 0x9F, 0xFC, 0x07, 0xC0,
};

const GFXglyph NotoSans_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 22, 8, 1, -22 },
  { 23, 10, 8, 12, 3, -22 },
  { 33, 19, 22, 20, 1, -22 },
  { 86, 15, 26, 17, 1, -24 },
  { 135, 21, 22, 25, 2, -22 },
  { 193, 19, 22, 21, 1, -22 },
  { 246, 4, 8, 7, 3, -22 },
  { 250, 10, 27, 9, 1, -22 },
  { 284, 10, 27, 9, -2, -22 },
  { 318, 14, 15, 17, 3, -24 },
  { 345, 15, 15, 18, 2, -18 },
  { 374, 6, 8, 8, -1, -4 },
  { 380, 8, 3, 10, 1, -10 },
  { 383, 4, 4, 8, 1, -4 },
  { 385, 15, 22, 11, -1, -22 },
  { 427, 15, 22, 17, 2, -22 },
  { 469, 10, 22, 17, 4, -22 },
  { 497, 16, 22, 17, 0, -22 },
  { 541, 15, 22, 17, 1, -22 },
  { 583, 17, 22, 17, 0, -22 },
  { 630, 16, 22, 17, 1, -22 },
  { 674, 15, 22, 17, 2, -22 },
  { 716, 14, 22, 17, 3, -22 },
  { 755, 16, 22, 17, 1, -22 },
  { 799, 15, 22, 17, 1, -22 },
  { 841, 6, 17, 8, 1, -17 },
  { 854, 9, 21, 8, -2, -17 },
  { 878, 15, 15, 18, 2, -19 },
  { 907, 15, 8, 18, 2, -15 },
  { 922, 15, 15, 18, 2, -19 },
  { 951, 12, 22, 13, 2, -22 },
  { 984, 23, 25, 26, 2, -22 },
  { 1056, 18, 22, 17, -2, -22 },
  { 1106, 17, 22, 19, 1, -22 },
  { 1153, 18, 22, 18, 2, -22 },
  { 1203, 19, 22, 21, 1, -22 },
  { 1256, 16, 22, 16, 1, -22 },
  { 1300, 16, 22, 15, 1, -22 },
  { 1344, 19, 22, 21, 2, -22 },
  { 1397, 20, 22, 21, 1, -22 },
  { 1452, 13, 22, 10, -1, -22 },
  { 1488, 14, 28, 8, -5, -22 },
  { 1537, 19, 22, 17, 1, -22 },
  { 1590, 12, 22, 15, 1, -22 },
  { 1623, 25, 22, 26, 1, -22 },
  { 1692, 21, 22, 22, 1, -22 },
  { 1750, 19, 22, 22, 2, -22 },
  { 1803, 17, 22, 18, 1, -22 },
  { 1850, 19, 27, 22, 2, -22 },
  { 1915, 17, 22, 18, 1, -22 },
  { 1962, 15, 22, 16, 1, -22 },
  { 2004, 15, 22, 16, 3, -22 },
  { 2046, 19, 22, 21, 2, -22 },
  { 2099, 17, 22, 17, 3, -22 },
  { 2146, 26, 22, 27, 3, -22 },
  { 2218, 21, 22, 16, -2, -22 },
  { 2276, 16, 22, 16, 3, -22 },
  { 2320, 18, 22, 16, 0, -22 },
  { 2370, 11, 27, 9, 0, -22 },
  { 2408, 6, 22, 11, 3, -22 },
  { 2425, 11, 27, 9, -2, -22 },
  { 2463, 16, 14, 18, 1, -22 },
  { 2491, 13, 2, 12, -3, 3 },
  { 2495, 5, 5, 9, 5, -24 },
  { 2499, 16, 17, 18, 1, -17 },
  { 2533, 15, 24, 18, 1, -24 },
  { 2578, 13, 17, 14, 1, -17 },
  { 2606, 18, 24, 18, 1, -24 },
  { 2660, 14, 17, 15, 1, -17 },
  { 2690, 17, 31, 10, -3, -24 },
  { 2756, 16, 24, 18, 1, -17 },
  { 2804, 15, 24, 18, 1, -24 },
  { 2849, 7, 23, 8, 1, -23 },
  { 2870, 12, 30, 8, -4, -23 },
  { 2915, 15, 24, 15, 1, -24 },
  { 2960, 8, 24, 8, 1, -24 },
  { 2984, 24, 17, 27, 1, -17 },
  { 3035, 15, 17, 18, 1, -17 },
  { 3067, 15, 17, 17, 1, -17 },
  { 3099, 17, 24, 18, -1, -17 },
  { 3150, 16, 24, 18, 1, -17 },
  { 3198, 12, 17, 12, 1, -17 },
  { 3224, 13, 17, 13, 0, -17 },
  { 3252, 10, 20, 10, 1, -20 },
  { 3277, 15, 17, 18, 2, -17 },
  { 3309, 15, 17, 14, 1, -17 },
  { 3341, 22, 17, 22, 2, -17 },
  { 3388, 17, 17, 15, -1, -17 },
  { 3425, 19, 24, 14, -3, -17 },
  { 3482, 14, 17, 14, 0, -17 },
  { 3512, 12, 27, 11, 0, -22 },
  { 3553, 2, 31, 17, 8, -24 },
  { 3561, 12, 27, 11, -1, -22 },
  { 3602, 15, 4, 18, 2, -13 },
};

const GFXfont NotoSans_Italic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_ITALIC31PT7B_H_
