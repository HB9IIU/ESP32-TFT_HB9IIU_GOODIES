#ifndef _NOTOSANS_ITALIC69PT7B_H_
#define _NOTOSANS_ITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F,
  0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFC, 0x78, 0x3E, 0x01, 0xFC, 0x1E, 0x01, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x1E, 0x00,
  0x00, 0x1F, 0xE7, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1E, 0xFF, 0x80, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x03, 0xE1, 0xFC, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x07, 0x81, 0xF8, 0x30, 0x01, 0xE1,
  0xFE, 0x0F, 0x80, 0xF8, 0xFF, 0x03, 0xFF, 0xBF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x10, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF0,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0xF8,
  0x3F, 0xC3, 0xC0, 0x1F, 0x07, 0xC3, 0xFF, 0x8F, 0x80, 0x7C, 0x3F, 0x1F,
  0xFF, 0x3E, 0x03, 0xF1, 0xF8, 0xFF, 0xFE, 0xF8, 0x0F, 0x87, 0xC7, 0xF1,
  0xFB, 0xF0, 0x7C, 0x3E, 0x1F, 0x03, 0xFF, 0xFF, 0xF1, 0xF8, 0xFC, 0x07,
  0xDF, 0xFF, 0x8F, 0xC7, 0xE0, 0x1F, 0x3F, 0xFC, 0x3E, 0x1F, 0x00, 0x7C,
  0x7F, 0xE1, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x1F,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF8,
  0x7F, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x83, 0xFE, 0x3F, 0x00,
  0x07, 0xE0, 0xFF, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0xC0, 0x7F, 0x00, 0x3F,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0xFF, 0x81, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0xF8,
  0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xF1, 0xFF,
  0xEF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x0F,
  0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x7F, 0x01, 0xE0, 0x00, 0x7F, 0xC1, 0xE0, 0x00, 0xFF, 0xF1, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF8, 0xF0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xE0, 0x7C,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x07, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1F, 0x1F,
  0xDF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xE7, 0xE7, 0xFE, 0x3F, 0x3F, 0xC3, 0xF0, 0xFC, 0x1F, 0x83, 0x80,
  0xFC, 0x18, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xE0, 0x00, 0xFF,
  0x00, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x60, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x00, 0x7F, 0x83,
  0x80, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0x3F, 0x87, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x20, 0x00, 0x01, 0xFC, 0x0C, 0x00, 0x01, 0xFE, 0x03,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7E, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x87, 0xFF, 0x80, 0x0F,
  0xE7, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xFF, 0x00, 0xFD, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x87, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFE, 0x0F, 0xE0,
  0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x07, 0xEF, 0xC0, 0xFF,
  0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xE3, 0xF0, 0x01,
  0xFF, 0xC1, 0xF8, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x0C, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xF8, 0x7F, 0xE1, 0xF0, 0x03, 0xFC, 0x60, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x83, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x3E, 0x1F, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x3E,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xC0, 0x07, 0xC0,
  0x0F, 0xBF, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7D, 0xF0, 0x07, 0xC0, 0x03,
  0xF0, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x03, 0xE0,
  0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xBE, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x7D, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xEF,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x01,
  0xF3, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x9F, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x00,
  0x7F, 0x00, 0x7E, 0x3E, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x07, 0xDF, 0x07, 0xF0, 0x7C,
  0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x0F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1E, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x01,
  0xFE, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x1F,
  0x80, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x7F, 0x00, 0x01, 0xFF, 0xFE, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x8F, 0xE0, 0x00,
  0x7F, 0xFF, 0x87, 0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00,
  0x03, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0x00, 0x00, 0x00, 0x7F, 0xCF,
  0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x03, 0xE7, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0,
  0x0F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x0F, 0x9F, 0x80, 0x00, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xE0,
  0x07, 0xF8, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x00, 0x1F,
  0xC0, 0x70, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xFB, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xCF, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0x83,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x7C, 0x00, 0x7F, 0xFE, 0x0F, 0x80, 0x1F, 0xFF, 0xE3, 0xE0, 0x0F,
  0xFF, 0xFC, 0x7C, 0x03, 0xFF, 0xDF, 0xCF, 0x80, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0x80, 0xFD, 0xF0, 0x07, 0xFC, 0xFF, 0x3E, 0x00, 0xFF, 0xFF,
  0xC7, 0xC0, 0x0F, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xF8, 0x3E, 0x00, 0x0F,
  0xFE, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x60, 0x00, 0x07, 0xE0, 0x7F, 0xC0, 0x01, 0xF8, 0x3F, 0xFE, 0x00, 0x3F,
  0x1F, 0xFF, 0xE0, 0x07, 0xE7, 0xFF, 0xFC, 0x00, 0xFD, 0xFE, 0xFF, 0xC0,
  0x1F, 0x7E, 0x03, 0xF8, 0x07, 0xEF, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x03,
  0xF0, 0x1F, 0xF0, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x03, 0xE7, 0xE3,
  0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0xF8, 0x03, 0xE0,
  0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xF8, 0x0F, 0xF8,
  0x01, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x20, 0x3F, 0xC0, 0x07, 0x00,
  0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0x81, 0xF8, 0x00, 0x1F, 0xFF, 0x87, 0xE0, 0x01, 0xFF, 0xFF, 0x1F, 0x00,
  0x0F, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0xF3, 0xFB, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0xF7, 0xC0,
  0x07, 0xF8, 0x0F, 0x9F, 0x00, 0x0F, 0xFC, 0xFE, 0x7C, 0x00, 0x3F, 0xFF,
  0xF3, 0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0xF8, 0x3E, 0x00,
  0x01, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xFC, 0x7F, 0x01, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x30, 0x3F, 0xC0, 0x07, 0x80, 0xFF, 0xC3,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x83, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0x00,
  0x0F, 0xFF, 0xC1, 0xF0, 0x03, 0xFF, 0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0xF3,
  0xE0, 0x0F, 0xFE, 0x7F, 0x3E, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xC0,
  0x07, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xFC,
  0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x01,
  0xEF, 0x80, 0x3F, 0xC0, 0x7E, 0xF8, 0x01, 0xFF, 0x9F, 0xDF, 0x80, 0x1F,
  0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFF, 0x1F, 0x80, 0x07, 0xFF, 0xC3, 0xF0,
  0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x00, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x03,
  0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x0C, 0x00, 0x03, 0xF0, 0x3F, 0xF0, 0x01, 0xF8, 0x3F, 0xFE, 0x00, 0x7E,
  0x3F, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xF8, 0x07, 0xEF, 0xFB, 0xFE, 0x01,
  0xF7, 0xE0, 0x1F, 0xC0, 0xFD, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x00, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x03,
  0xF0, 0x7F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xE0, 0x00, 0x1F,
  0xE1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC7, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x1F, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3E, 0x7F, 0xBF,
  0xE3, 0xFD, 0xFF, 0x80, 0x7D, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x01, 0xFB,
  0xC0, 0x1F, 0x9E, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xFF, 0x00, 0x1F, 0x87, 0xFF, 0xF0, 0x07, 0xE3, 0xFF,
  0xFE, 0x01, 0xF9, 0xFF, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xF0, 0x3F, 0x7F,
  0x03, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0xFF,
  0x80, 0x03, 0xF0, 0x3F, 0xE0, 0x00, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0x07,
  0xF8, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x01, 0xFF,
  0x00, 0x00, 0x7E, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x7F, 0xFF, 0x80, 0x01,
  0xF1, 0xFF, 0xFF, 0x00, 0x03, 0xE7, 0xFB, 0xFF, 0x00, 0x07, 0xDF, 0x80,
  0xFE, 0x00, 0x1F, 0xBC, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xDF, 0x8F, 0xFE,
  0x00, 0x1F, 0xBF, 0xFF, 0xF8, 0x00, 0x7E, 0x3F, 0xFF, 0xE0, 0x00, 0xFC,
  0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x7F, 0xFE, 0x0F, 0x80, 0x3F, 0xFF,
  0xE3, 0xE0, 0x0F, 0xFF, 0xFE, 0x7C, 0x03, 0xFF, 0x9F, 0xCF, 0x80, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x07, 0xFE, 0x03,
  0xF8, 0x01, 0xEF, 0x80, 0x7F, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0x7E,
  0x00, 0xFF, 0xFF, 0xCF, 0xC0, 0x0F, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xF8,
  0x7E, 0x00, 0x0F, 0xFC, 0x0F, 0xC0, 0x00, 0x1C, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xD0, 0x0F, 0x81, 0xFE, 0x01, 0xF8, 0x7F, 0xE0, 0x1F, 0x8F, 0xFE, 0x01,
  0xF1, 0xFF, 0xE0, 0x1F, 0x3F, 0xFE, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xFE, 0x03, 0xF8, 0x01, 0xE0, 0x7F,
  0x00, 0x02, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x8C, 0x00,
  0x07, 0xF0, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFE,
  0x0F, 0xC0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0x00, 0x0F, 0xFC, 0x0F, 0xC0, 0x07, 0xBE, 0x03, 0xF8, 0x07,
  0xCF, 0x80, 0xFF, 0xCF, 0xE3, 0xE0, 0x1F, 0xFF, 0xF9, 0xF8, 0x03, 0xFF,
  0xF8, 0x7E, 0x00, 0xFF, 0xFC, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03,
  0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xE0,
  0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xBF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7C, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x7C, 0x01, 0xFC, 0x1F, 0x80, 0x3E, 0x3E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x8F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xC3,
  0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0,
  0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0,
  0x3E, 0x0F, 0xE0, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x1F, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE7, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0x1F, 0xFE, 0x00, 0x01, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_Italic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 18, 50, 18, 1, -49 },
  { 114, 20, 18, 27, 8, -49 },
  { 159, 43, 49, 45, 2, -49 },
  { 423, 34, 56, 38, 2, -52 },
  { 661, 46, 51, 55, 6, -50 },
  { 955, 43, 51, 46, 2, -50 },
  { 1230, 9, 18, 15, 8, -49 },
  { 1251, 22, 60, 20, 3, -49 },
  { 1416, 22, 60, 20, -5, -49 },
  { 1581, 32, 32, 38, 7, -53 },
  { 1709, 32, 33, 39, 5, -41 },
  { 1841, 14, 17, 18, -3, -8 },
  { 1871, 17, 5, 22, 2, -21 },
  { 1882, 9, 9, 18, 1, -8 },
  { 1893, 33, 49, 25, -3, -49 },
  { 2096, 33, 51, 38, 4, -50 },
  { 2307, 21, 49, 38, 10, -49 },
  { 2436, 36, 50, 38, 0, -50 },
  { 2661, 34, 51, 38, 2, -50 },
  { 2878, 37, 49, 38, 0, -49 },
  { 3105, 34, 50, 38, 3, -49 },
  { 3318, 34, 51, 38, 4, -50 },
  { 3535, 33, 49, 38, 6, -49 },
  { 3738, 34, 51, 38, 3, -50 },
  { 3955, 33, 51, 38, 3, -50 },
  { 4166, 15, 39, 18, 1, -38 },
  { 4240, 19, 47, 18, -3, -38 },
  { 4352, 32, 34, 39, 5, -42 },
  { 4488, 32, 19, 39, 5, -34 },
  { 4564, 32, 34, 39, 5, -42 },
  { 4700, 26, 51, 30, 5, -50 },
  { 4866, 53, 55, 59, 4, -49 },
  { 5231, 39, 49, 39, -4, -49 },
  { 5470, 38, 49, 41, 3, -49 },
  { 5703, 39, 51, 41, 5, -50 },
  { 5952, 41, 49, 46, 3, -49 },
  { 6204, 35, 49, 35, 3, -49 },
  { 6419, 35, 49, 33, 3, -49 },
  { 6634, 41, 51, 47, 5, -50 },
  { 6896, 44, 49, 47, 3, -49 },
  { 7166, 27, 49, 22, -1, -49 },
  { 7332, 30, 62, 19, -11, -49 },
  { 7565, 42, 49, 39, 3, -49 },
  { 7823, 26, 49, 33, 3, -49 },
  { 7983, 55, 49, 58, 3, -49 },
  { 8320, 46, 49, 49, 3, -49 },
  { 8602, 43, 51, 50, 5, -50 },
  { 8877, 36, 49, 39, 3, -49 },
  { 9098, 43, 62, 50, 5, -50 },
  { 9432, 36, 49, 40, 3, -49 },
  { 9653, 35, 51, 35, 1, -50 },
  { 9877, 35, 49, 35, 6, -49 },
  { 10092, 42, 50, 47, 5, -49 },
  { 10355, 38, 49, 38, 6, -49 },
  { 10588, 58, 49, 59, 7, -49 },
  { 10944, 46, 49, 36, -4, -49 },
  { 11226, 35, 49, 35, 6, -49 },
  { 11441, 41, 49, 37, -1, -49 },
  { 11693, 27, 60, 20, -1, -49 },
  { 11896, 13, 49, 25, 7, -49 },
  { 11976, 26, 60, 20, -5, -49 },
  { 12171, 34, 32, 39, 3, -50 },
  { 12307, 28, 5, 27, -6, 6 },
  { 12325, 11, 11, 19, 10, -53 },
  { 12341, 35, 39, 39, 3, -38 },
  { 12512, 35, 53, 40, 2, -52 },
  { 12744, 29, 39, 31, 3, -38 },
  { 12886, 38, 53, 40, 3, -52 },
  { 13138, 29, 39, 34, 3, -38 },
  { 13280, 39, 70, 22, -8, -53 },
  { 13622, 36, 55, 40, 2, -38 },
  { 13870, 34, 52, 40, 2, -52 },
  { 14091, 17, 51, 18, 2, -51 },
  { 14200, 28, 68, 18, -9, -51 },
  { 14438, 34, 52, 34, 2, -52 },
  { 14659, 17, 52, 18, 2, -52 },
  { 14770, 55, 38, 60, 2, -38 },
  { 15032, 34, 38, 40, 2, -38 },
  { 15194, 33, 38, 39, 3, -37 },
  { 15351, 39, 55, 40, -2, -38 },
  { 15620, 35, 55, 40, 3, -38 },
  { 15861, 28, 38, 27, 2, -38 },
  { 15994, 28, 39, 30, 0, -38 },
  { 16131, 22, 46, 23, 3, -45 },
  { 16258, 34, 38, 40, 4, -37 },
  { 16420, 33, 37, 32, 3, -37 },
  { 16573, 49, 37, 50, 4, -37 },
  { 16800, 38, 37, 33, -3, -37 },
  { 16976, 42, 54, 32, -6, -37 },
  { 17260, 31, 37, 31, -1, -37 },
  { 17404, 27, 60, 24, 1, -49 },
  { 17607, 5, 69, 38, 18, -52 },
  { 17651, 27, 60, 24, -3, -49 },
  { 17854, 32, 9, 39, 5, -29 },
};

const GFXfont NotoSans_Italic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic69pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_ITALIC69PT7B_H_
