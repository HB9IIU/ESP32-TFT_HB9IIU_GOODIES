#ifndef _NOTOSANS_ITALIC29PT7B_H_
#define _NOTOSANS_ITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC1, 0x83,
  0x06, 0x18, 0x00, 0x00, 0x83, 0x87, 0x0E, 0x00, 0x73, 0xB9, 0xD8, 0xCC,
  0x66, 0x36, 0x33, 0x19, 0x8C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x86, 0x00, 0xC3, 0x83, 0xFF, 0xFC, 0xFF, 0xFF, 0x06,
  0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x60, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x01, 0xFF,
  0x0F, 0xFC, 0x73, 0x11, 0x98, 0x0E, 0x60, 0x39, 0x80, 0x76, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x0D, 0xC0, 0x33, 0x00, 0x8C, 0x06, 0x32, 0x19,
  0xCF, 0xFE, 0x3F, 0xF0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0xE1, 0xF8, 0x0C, 0x31, 0x81, 0x87, 0x18, 0x38, 0x61, 0x83, 0x06,
  0x18, 0x60, 0xE1, 0x8C, 0x0C, 0x19, 0xC0, 0xC3, 0x19, 0xCC, 0x33, 0x7E,
  0x67, 0x66, 0x77, 0xEE, 0xC3, 0x3C, 0xCC, 0x30, 0x19, 0xC3, 0x03, 0x18,
  0x30, 0x71, 0x86, 0x06, 0x18, 0x60, 0xC1, 0x86, 0x18, 0x18, 0xC3, 0x81,
  0xFC, 0x70, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x71, 0xC0, 0x38,
  0x30, 0x0E, 0x0C, 0x03, 0x07, 0x00, 0xE1, 0xC0, 0x39, 0xE0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF7, 0x07, 0x70, 0xC1, 0x98, 0x38, 0xEE,
  0x07, 0x73, 0x00, 0xF8, 0xC0, 0x3C, 0x38, 0x0F, 0x0F, 0x07, 0xE1, 0xFF,
  0xB8, 0x3F, 0x87, 0x80, 0x77, 0x66, 0x6C, 0xCC, 0x01, 0xC0, 0xE0, 0x70,
  0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x86, 0x0F, 0x30, 0x3F, 0x84, 0x1F, 0xE1, 0xE7,
  0x1F, 0x01, 0xCC, 0x1C, 0x60, 0x43, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0xE3,
  0x1C, 0x63, 0x0C, 0x00, 0xFF, 0xFC, 0x5F, 0xF0, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x7F,
  0x87, 0x9E, 0x70, 0x73, 0x81, 0xB8, 0x0D, 0xC0, 0x6C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xD8, 0x0E, 0xC0,
  0x77, 0x07, 0x38, 0x70, 0xFF, 0x03, 0xF0, 0x00, 0x03, 0x83, 0xC7, 0xC7,
  0xEF, 0x73, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x80, 0x01, 0xF8, 0x0F, 0xF8,
  0x3C, 0x78, 0x20, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xCF, 0xFF, 0x80,
  0x03, 0xF0, 0x3F, 0xE1, 0xE3, 0xC2, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x78, 0x3F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xCC, 0x0F, 0x3F, 0xF8, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x6C, 0x00,
  0xEC, 0x01, 0xCC, 0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x18, 0x0C, 0x18, 0x18,
  0x38, 0x38, 0x38, 0x70, 0x30, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x1B, 0x80,
  0x7F, 0xC0, 0x67, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE3, 0x03, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x0F, 0xF0, 0xF8, 0x47, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x67, 0xC1, 0xBF, 0x8F, 0x87, 0x3C, 0x0C, 0xE0, 0x33, 0x80, 0xEC,
  0x03, 0x30, 0x0C, 0xC0, 0x73, 0x81, 0x8F, 0x0E, 0x1F, 0xF0, 0x3F, 0x80,
  0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3C, 0x70, 0x60, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x06, 0x0E, 0x0E, 0x78, 0x0F, 0xC0, 0x3F, 0x00, 0xF7, 0x83,
  0x87, 0x0E, 0x07, 0x18, 0x0E, 0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x71, 0xC1,
  0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xE3, 0x86, 0x07,
  0x38, 0x1C, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x1C, 0xC0, 0x73, 0x83,
  0xCF, 0xFF, 0x0F, 0x98, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x88, 0x1C, 0x3F, 0xE0, 0xFF, 0x00, 0x18, 0xF3, 0x8E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x43, 0x8E, 0x38, 0x06, 0x0F, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x70, 0x70, 0x60,
  0xC0, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x38, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x1F, 0x8F, 0xF9,
  0xC7, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0xF0, 0x3C,
  0x0E, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x01, 0xC0, 0x78,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0x7C, 0x1E, 0x03, 0x80,
  0x1C, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0x63, 0x03, 0xE1, 0xD8, 0x3F, 0xC3,
  0x61, 0xC3, 0x0F, 0x0E, 0x1C, 0x3C, 0x30, 0x60, 0xF1, 0x81, 0x87, 0xC6,
  0x0E, 0x1B, 0x18, 0x38, 0x6C, 0x61, 0xC3, 0xB1, 0xC5, 0x9C, 0xC3, 0xF7,
  0xE3, 0x07, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0x00,
  0x7C, 0x78, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0x60, 0x03, 0x30, 0x03, 0x98, 0x01,
  0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0xC0, 0xE0, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x38, 0x06, 0x1C, 0x03, 0x1C, 0x01, 0x8E, 0x00,
  0xEE, 0x00, 0x7E, 0x00, 0x38, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x0C,
  0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x1E, 0x1F,
  0xF8, 0x3F, 0xF0, 0x38, 0x38, 0x38, 0x1C, 0x30, 0x0E, 0x30, 0x0E, 0x70,
  0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x60, 0x78, 0xFF, 0xF0, 0xFF, 0xC0, 0x00,
  0xFE, 0x03, 0xFF, 0x07, 0xC7, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7C,
  0x18, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81,
  0x80, 0xE0, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x06, 0x38, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x73, 0x80, 0x39, 0x80, 0x1C, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x1E, 0x18, 0x3E, 0x1F, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0xFF, 0xC1, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xFF, 0xE1, 0xFF, 0x83, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0xC1, 0xF1, 0xE1, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x1F, 0xDC, 0x0F, 0xEE,
  0x00, 0x77, 0x00, 0x33, 0x80, 0x19, 0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x0F, 0x03, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x06, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x07, 0x00, 0x60, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x0C, 0x18, 0x01, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1C, 0x01, 0x83,
  0x80, 0x30, 0x60, 0x0E, 0x0C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x06, 0x0E,
  0x00, 0xC1, 0x80, 0x38, 0x30, 0x07, 0x0E, 0x00, 0xE0, 0x07, 0xF0, 0x7F,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x08,
  0x00, 0x06, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x0C, 0x1C,
  0x07, 0x0E, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x19, 0xC0, 0x06, 0xE0, 0x03,
  0xF8, 0x00, 0xF7, 0x00, 0x38, 0xC0, 0x0C, 0x38, 0x03, 0x0E, 0x01, 0xC1,
  0x80, 0x70, 0x70, 0x1C, 0x0C, 0x06, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x1C,
  0x00, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x7F, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xB0, 0x0D, 0x87,
  0x60, 0x3B, 0x0C, 0xC0, 0x6E, 0x19, 0x81, 0x9C, 0x33, 0x07, 0x38, 0xE6,
  0x0C, 0x61, 0xCE, 0x38, 0xC3, 0x1C, 0x63, 0x86, 0x19, 0xC7, 0x0C, 0x33,
  0x0E, 0x38, 0x6E, 0x18, 0x70, 0xD8, 0x30, 0xC1, 0xE0, 0xE1, 0x83, 0xC1,
  0xC7, 0x07, 0x03, 0x8E, 0x0E, 0x06, 0x00, 0x0E, 0x00, 0x70, 0xF0, 0x06,
  0x0F, 0x00, 0x60, 0xF0, 0x0E, 0x0F, 0x80, 0xE1, 0xD8, 0x0E, 0x1D, 0xC0,
  0xC1, 0x9C, 0x0C, 0x18, 0xC1, 0xC1, 0x8E, 0x1C, 0x38, 0x61, 0x83, 0x86,
  0x18, 0x30, 0x71, 0x83, 0x03, 0x38, 0x30, 0x3B, 0x87, 0x03, 0xB0, 0x70,
  0x1B, 0x06, 0x01, 0xF0, 0x60, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x80, 0xF8, 0xF0, 0x78, 0x0E, 0x3C, 0x03, 0x8E,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E,
  0x70, 0x07, 0x1C, 0x03, 0x83, 0xC3, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x60, 0x70, 0xC0, 0x63, 0x80, 0xC7,
  0x01, 0x8E, 0x03, 0x18, 0x0E, 0x30, 0x3C, 0xE1, 0xF1, 0xFF, 0xC3, 0xFC,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xF8, 0xF0, 0x78,
  0x0E, 0x3C, 0x03, 0x8E, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0x83, 0xC3, 0xC0, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0C, 0x0E, 0x0C,
  0x06, 0x1C, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x18, 0x1C, 0x3F,
  0xF8, 0x3F, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x30, 0x60, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x30, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0x03, 0xF0, 0x3F,
  0xF1, 0xE3, 0x87, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC8, 0x1E, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0x80, 0x18, 0x60, 0x06, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x60, 0x06, 0x38, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x0C, 0x18, 0x07, 0x07, 0x07, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xC0,
  0x07, 0xC0, 0x0E, 0xC0, 0x0E, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0,
  0x30, 0xE0, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x61, 0xC0, 0x61,
  0x80, 0x73, 0x80, 0x77, 0x00, 0x77, 0x00, 0x76, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x07, 0xE0, 0x3C, 0x07, 0xE0,
  0x3C, 0x06, 0xE0, 0x7C, 0x0E, 0xE0, 0x6C, 0x0C, 0xE0, 0xEC, 0x1C, 0xE0,
  0xCC, 0x1C, 0xE0, 0xCC, 0x38, 0xE1, 0x8C, 0x38, 0xE1, 0x8C, 0x30, 0x63,
  0x8C, 0x70, 0x63, 0x0C, 0x60, 0x67, 0x0C, 0xE0, 0x66, 0x0C, 0xC0, 0x6E,
  0x0D, 0xC0, 0x6C, 0x0D, 0x80, 0x7C, 0x0D, 0x80, 0x78, 0x0F, 0x80, 0x78,
  0x0F, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x30,
  0x0E, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x01, 0x83, 0x00, 0x1C, 0x70, 0x00,
  0xCE, 0x00, 0x0D, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x39, 0x80, 0x07, 0x18, 0x00, 0x61, 0xC0,
  0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0x60, 0xF0, 0x07,
  0x00, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xB8, 0x1C, 0x60, 0x71, 0x83, 0x87,
  0x1C, 0x0C, 0x70, 0x33, 0x80, 0xDC, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07,
  0xE0, 0xF8, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0xE0, 0xFC, 0x1F, 0x00, 0xC3,
  0x8E, 0x18, 0x61, 0x86, 0x1C, 0x71, 0xC3, 0x0C, 0x30, 0xC3, 0x8E, 0x18,
  0x61, 0x86, 0x1C, 0x07, 0xE0, 0xFC, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x07, 0xE0,
  0xFC, 0x1F, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xE0, 0x0C, 0xC0,
  0x33, 0x01, 0x86, 0x06, 0x1C, 0x30, 0x30, 0xC0, 0xE7, 0x01, 0x98, 0x07,
  0xE0, 0x0C, 0x7F, 0xFF, 0xFF, 0xE3, 0x8C, 0x30, 0x03, 0xC6, 0x1F, 0xCC,
  0x7D, 0xF9, 0xE0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x30, 0x0C, 0x60,
  0x19, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x0F, 0x0E, 0x3E, 0x1F, 0xEC,
  0x1F, 0x18, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC7, 0x06, 0x7E, 0x1B, 0xBC, 0xF8, 0x73, 0xC0, 0xCE, 0x03, 0x38,
  0x0C, 0xC0, 0x37, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xE7, 0x03, 0xBE,
  0x1C, 0xDF, 0xE3, 0x3F, 0x00, 0x03, 0xE0, 0xFF, 0x1E, 0x33, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x04, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x03, 0x8E, 0x0F, 0xEE, 0x1F, 0x7E, 0x3C,
  0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x18, 0x60, 0x18, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0xF0, 0x71, 0xB0, 0x7F, 0xB0, 0x3E,
  0x30, 0x03, 0xC0, 0x7F, 0x87, 0x9C, 0x70, 0x73, 0x83, 0xB8, 0x19, 0xC3,
  0xCF, 0xFC, 0x7F, 0x87, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x10,
  0xFF, 0x83, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xF8, 0x07, 0xF8, 0x09, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x03, 0xC6, 0x1F, 0xCC, 0x7D, 0xF9, 0xE0, 0xE3, 0x81, 0xCE, 0x03,
  0x9C, 0x07, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0xCE,
  0x0F, 0x0E, 0x36, 0x1F, 0xEC, 0x1F, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x0C, 0x3C, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC7, 0x06, 0x7E, 0x1B,
  0x1C, 0xF8, 0x73, 0xC0, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0x9C,
  0x06, 0x70, 0x39, 0x80, 0xE6, 0x03, 0xB8, 0x0C, 0xE0, 0x33, 0x01, 0xC0,
  0x0E, 0x1C, 0x30, 0x00, 0x03, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x0E,
  0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xFC, 0x0F,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC1, 0xC6, 0x0E, 0x18, 0x70, 0xE3, 0x83, 0x9C, 0x0E, 0xE0, 0x37, 0x00,
  0xFC, 0x07, 0xF0, 0x1E, 0xE0, 0x73, 0x81, 0x87, 0x06, 0x1C, 0x38, 0x38,
  0xE0, 0xE3, 0x01, 0xC0, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18,
  0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18, 0x00,
  0x18, 0xF0, 0x78, 0x33, 0xF1, 0xF8, 0x6E, 0xEF, 0x79, 0xF0, 0xF8, 0x73,
  0xC1, 0xE0, 0xE7, 0x03, 0x81, 0xCE, 0x07, 0x03, 0x18, 0x0C, 0x06, 0x70,
  0x38, 0x1C, 0xE0, 0x70, 0x39, 0xC0, 0xE0, 0x73, 0x01, 0x80, 0xC6, 0x03,
  0x01, 0x9C, 0x0E, 0x07, 0x38, 0x1C, 0x0E, 0x60, 0x38, 0x1C, 0x18, 0xF0,
  0x67, 0xF1, 0xBB, 0xCF, 0x87, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x07,
  0x70, 0x1D, 0xC0, 0x67, 0x03, 0x98, 0x0E, 0xE0, 0x3B, 0x80, 0xCE, 0x07,
  0x38, 0x1C, 0x03, 0xC0, 0x3F, 0xC1, 0xF7, 0x8E, 0x06, 0x38, 0x1D, 0xC0,
  0x77, 0x01, 0xD8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xB8, 0x0E, 0x60,
  0x71, 0xC3, 0xC3, 0xFE, 0x07, 0xE0, 0x06, 0x3C, 0x06, 0x7E, 0x06, 0xEF,
  0x0F, 0x87, 0x0F, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x3E, 0x1C, 0x3F, 0xF8,
  0x33, 0xF0, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x03, 0xC6, 0x1F, 0xCC, 0x7D, 0xF9, 0xE0, 0xE3,
  0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x60, 0x19, 0xC0, 0x73, 0x80,
  0xE7, 0x03, 0xCE, 0x0F, 0x0E, 0x36, 0x1F, 0xFC, 0x1F, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x18, 0xE3, 0x3C, 0x6F, 0x9F, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x07, 0xC1,
  0xFF, 0x3C, 0x63, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xC8, 0x1C, 0xFF, 0x87, 0xF0, 0x04, 0x03,
  0x01, 0xC0, 0xFF, 0xFF, 0x86, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x1F, 0x83, 0xE0, 0x38, 0x1C,
  0xC0, 0x77, 0x01, 0xDC, 0x06, 0x70, 0x19, 0x80, 0xE6, 0x03, 0xB8, 0x0C,
  0xE0, 0x33, 0x81, 0xCC, 0x07, 0x30, 0x3C, 0xC1, 0xE3, 0x8D, 0x8F, 0xF6,
  0x1F, 0x18, 0xE0, 0x1D, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x60, 0x71, 0x83,
  0x87, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x03, 0x38, 0x0D, 0xC0, 0x36,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0xC0, 0xE0, 0x7C, 0x0E, 0x07, 0xC1,
  0xE0, 0xEC, 0x1E, 0x0E, 0xC3, 0xE0, 0xCC, 0x36, 0x1C, 0xC3, 0x61, 0x8C,
  0x67, 0x38, 0xC6, 0x73, 0x0C, 0xC7, 0x70, 0xCC, 0x36, 0x0D, 0x83, 0x60,
  0xD8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x1C, 0x07,
  0x0C, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x07, 0x30, 0x03, 0x70, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0C, 0xE0, 0x1C, 0x60,
  0x38, 0x70, 0x70, 0x30, 0xE0, 0x38, 0x0E, 0x01, 0xC1, 0x80, 0x60, 0x60,
  0x38, 0x18, 0x0C, 0x06, 0x07, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x70,
  0x03, 0x1C, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00,
  0xD8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x30, 0x1E, 0x03, 0xE0, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0,
  0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04,
  0x00, 0xF0, 0x3E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x1E, 0x07, 0xC1, 0xE0, 0x30, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x07, 0xC0, 0xF0, 0x10, 0x00, 0x7E,
  0x07, 0xFF, 0x7C, 0x3F, 0xA0, 0x1C,
};

const GFXglyph NotoSans_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 21, 8, 1, -21 },
  { 20, 9, 8, 11, 3, -21 },
  { 29, 18, 21, 19, 1, -21 },
  { 77, 14, 24, 16, 1, -22 },
  { 119, 20, 21, 23, 2, -21 },
  { 172, 18, 21, 20, 1, -21 },
  { 220, 4, 8, 6, 3, -21 },
  { 224, 10, 26, 8, 1, -21 },
  { 257, 9, 26, 8, -2, -21 },
  { 287, 13, 13, 16, 3, -22 },
  { 309, 14, 14, 17, 2, -17 },
  { 334, 6, 7, 7, -1, -3 },
  { 340, 7, 2, 9, 1, -9 },
  { 342, 3, 4, 7, 1, -4 },
  { 344, 14, 21, 10, -1, -21 },
  { 381, 13, 21, 16, 2, -21 },
  { 416, 9, 21, 16, 4, -21 },
  { 440, 15, 21, 16, 0, -21 },
  { 480, 14, 21, 16, 1, -21 },
  { 517, 16, 21, 16, 0, -21 },
  { 559, 15, 21, 16, 1, -21 },
  { 599, 14, 21, 16, 2, -21 },
  { 636, 14, 21, 16, 2, -21 },
  { 673, 15, 21, 16, 1, -21 },
  { 713, 14, 21, 16, 1, -21 },
  { 750, 6, 16, 7, 1, -16 },
  { 762, 8, 20, 7, -1, -16 },
  { 782, 14, 15, 17, 2, -18 },
  { 809, 13, 8, 17, 2, -14 },
  { 822, 14, 15, 17, 2, -18 },
  { 849, 11, 21, 12, 2, -21 },
  { 878, 22, 24, 25, 2, -21 },
  { 944, 17, 21, 16, -2, -21 },
  { 989, 16, 21, 17, 1, -21 },
  { 1031, 16, 21, 17, 2, -21 },
  { 1073, 17, 21, 19, 1, -21 },
  { 1118, 15, 21, 15, 1, -21 },
  { 1158, 15, 21, 14, 1, -21 },
  { 1198, 17, 21, 20, 2, -21 },
  { 1243, 19, 21, 20, 1, -21 },
  { 1293, 12, 21, 9, -1, -21 },
  { 1325, 13, 27, 8, -5, -21 },
  { 1369, 18, 21, 16, 1, -21 },
  { 1417, 11, 21, 14, 1, -21 },
  { 1446, 23, 21, 24, 1, -21 },
  { 1507, 20, 21, 21, 1, -21 },
  { 1560, 18, 21, 21, 2, -21 },
  { 1608, 15, 21, 16, 1, -21 },
  { 1648, 18, 26, 21, 2, -21 },
  { 1707, 16, 21, 17, 1, -21 },
  { 1749, 14, 21, 15, 1, -21 },
  { 1786, 14, 21, 15, 3, -21 },
  { 1823, 18, 21, 20, 2, -21 },
  { 1871, 16, 21, 16, 3, -21 },
  { 1913, 24, 21, 25, 3, -21 },
  { 1976, 20, 21, 15, -2, -21 },
  { 2029, 14, 21, 15, 3, -21 },
  { 2066, 17, 21, 15, 0, -21 },
  { 2111, 11, 26, 8, 0, -21 },
  { 2147, 6, 21, 10, 3, -21 },
  { 2163, 11, 26, 8, -2, -21 },
  { 2199, 14, 13, 17, 1, -21 },
  { 2222, 12, 2, 11, -3, 3 },
  { 2225, 5, 4, 8, 4, -22 },
  { 2228, 15, 16, 16, 1, -16 },
  { 2258, 14, 22, 17, 1, -22 },
  { 2297, 12, 16, 13, 1, -16 },
  { 2321, 16, 22, 17, 1, -22 },
  { 2365, 13, 16, 14, 1, -16 },
  { 2391, 16, 29, 9, -3, -22 },
  { 2449, 15, 23, 17, 1, -16 },
  { 2493, 14, 22, 17, 1, -22 },
  { 2532, 7, 21, 7, 1, -21 },
  { 2551, 12, 28, 7, -4, -21 },
  { 2593, 14, 22, 14, 1, -22 },
  { 2632, 7, 22, 7, 1, -22 },
  { 2652, 23, 16, 25, 1, -16 },
  { 2698, 14, 16, 17, 1, -16 },
  { 2726, 14, 16, 16, 1, -16 },
  { 2754, 16, 23, 17, -1, -16 },
  { 2800, 15, 23, 17, 1, -16 },
  { 2844, 11, 16, 12, 1, -16 },
  { 2866, 12, 16, 13, 0, -16 },
  { 2890, 10, 19, 10, 1, -19 },
  { 2914, 14, 16, 17, 2, -16 },
  { 2942, 14, 16, 14, 1, -16 },
  { 2970, 20, 16, 21, 2, -16 },
  { 3010, 16, 16, 14, -1, -16 },
  { 3042, 18, 23, 14, -3, -16 },
  { 3094, 13, 16, 13, 0, -16 },
  { 3120, 12, 26, 10, 0, -21 },
  { 3159, 2, 29, 16, 8, -22 },
  { 3167, 11, 26, 10, -1, -21 },
  { 3203, 14, 4, 17, 2, -12 },
};

const GFXfont NotoSans_Italic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_ITALIC29PT7B_H_
