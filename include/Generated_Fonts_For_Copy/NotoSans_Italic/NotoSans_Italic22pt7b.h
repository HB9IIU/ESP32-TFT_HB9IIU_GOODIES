#ifndef _NOTOSANS_ITALIC22PT7B_H_
#define _NOTOSANS_ITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x08, 0x01, 0x86,
  0x38, 0x66, 0xCD, 0x92, 0x24, 0xD9, 0x80, 0x02, 0x30, 0x31, 0x81, 0x88,
  0x08, 0xC0, 0xC6, 0x3F, 0xFC, 0x21, 0x01, 0x18, 0x18, 0xC0, 0xC4, 0x3F,
  0xFC, 0x63, 0x03, 0x10, 0x10, 0x80, 0x8C, 0x0C, 0x60, 0x03, 0x00, 0x60,
  0x3E, 0x0F, 0xF3, 0x24, 0x4C, 0x09, 0x81, 0xA0, 0x1C, 0x01, 0xE0, 0x36,
  0x06, 0xC0, 0x99, 0x13, 0x3F, 0xC3, 0xE0, 0x10, 0x02, 0x00, 0x38, 0x0C,
  0xF8, 0x31, 0x10, 0x46, 0x31, 0x0C, 0x46, 0x10, 0x98, 0x23, 0x26, 0x46,
  0xDE, 0xFB, 0x66, 0xED, 0x8C, 0x13, 0x18, 0x66, 0x21, 0x88, 0x46, 0x11,
  0x88, 0x36, 0x70, 0x38, 0x07, 0x80, 0x7E, 0x06, 0x30, 0x30, 0xC1, 0x8C,
  0x0C, 0xE0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0x38, 0xF0, 0xCD, 0x83, 0xEC,
  0x0E, 0x60, 0xE3, 0x9F, 0x8F, 0xC6, 0x6D, 0xA5, 0x80, 0x06, 0x18, 0x60,
  0xC3, 0x04, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0,
  0x81, 0x80, 0x0C, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x18,
  0x30, 0x61, 0x83, 0x0C, 0x18, 0x63, 0x80, 0x06, 0x01, 0x88, 0x63, 0x90,
  0x7C, 0x43, 0xF1, 0xC0, 0xD8, 0x62, 0x08, 0xC0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0x76,
  0x4C, 0xFF, 0xC0, 0x6F, 0x80, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x07, 0x83, 0xF8, 0xE3, 0x18, 0x37, 0x06, 0xC0, 0xD8,
  0x1B, 0x03, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x18, 0xC7, 0x1D, 0xC1,
  0xF0, 0x06, 0x3C, 0xF7, 0x64, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x0C, 0x38, 0x07, 0xC1, 0xFE, 0x18, 0x60, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xCF, 0xFC, 0x07, 0xC1, 0xFE, 0x18, 0x60, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0xF8, 0x0F, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC8, 0x0C,
  0xE3, 0x87, 0xF0, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0x60, 0x64,
  0x0C, 0xC1, 0x8C, 0x30, 0xC6, 0x0C, 0x60, 0x8F, 0xFF, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x1F, 0xE3, 0xFC, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0F,
  0x83, 0xFC, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x19, 0x03, 0x31, 0xC7,
  0xF0, 0x03, 0xE1, 0xFC, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x19, 0xC3, 0xFC,
  0x70, 0xCC, 0x1B, 0x03, 0x60, 0x6C, 0x0C, 0xC3, 0x1D, 0xC1, 0xF0, 0x7F,
  0xFF, 0xF0, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x07, 0x83, 0xF8, 0x61, 0x98,
  0x33, 0x06, 0x61, 0x86, 0x70, 0x78, 0x3F, 0x0C, 0x33, 0x03, 0x60, 0x6C,
  0x0D, 0x83, 0x1C, 0xE1, 0xF8, 0x0F, 0x07, 0xF3, 0x0D, 0x83, 0x60, 0x58,
  0x16, 0x0D, 0x83, 0x73, 0xCF, 0xB0, 0x0C, 0x06, 0x01, 0x80, 0xCD, 0xE3,
  0xF0, 0x19, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x19, 0xC0, 0x0C, 0x71, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC3, 0x18, 0x63, 0x0C, 0x00, 0x00, 0xC0, 0xF0,
  0xE0, 0xE0, 0xE0, 0x30, 0x07, 0x80, 0x78, 0x07, 0x80, 0x30, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x78, 0x70, 0xF0, 0x30, 0x00, 0x3C, 0xFE, 0x83, 0x03, 0x03,
  0x07, 0x0E, 0x1C, 0x38, 0x60, 0x60, 0x40, 0x00, 0x40, 0xC0, 0xC0, 0x00,
  0xF0, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x00, 0x63, 0x00, 0x1B, 0x0F, 0xCD,
  0x8C, 0x66, 0x8C, 0x23, 0xC4, 0x31, 0xE6, 0x18, 0xF3, 0x08, 0x59, 0x8C,
  0x6C, 0x7B, 0xE2, 0x18, 0xE1, 0x80, 0x00, 0x60, 0x00, 0x1E, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xE0, 0x16, 0x03, 0x60, 0x66, 0x06,
  0x60, 0xC6, 0x0C, 0x61, 0xFE, 0x1F, 0xF3, 0x03, 0x30, 0x36, 0x03, 0x60,
  0x3C, 0x03, 0x1F, 0x81, 0xFE, 0x18, 0x71, 0x83, 0x30, 0x33, 0x03, 0x30,
  0x63, 0xFC, 0x7F, 0xC6, 0x0E, 0x60, 0x66, 0x06, 0x60, 0x6C, 0x0C, 0xFF,
  0xCF, 0xF0, 0x07, 0xE0, 0xFF, 0x38, 0x13, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x7F,
  0x83, 0xF8, 0x1F, 0x80, 0xFF, 0x06, 0x1C, 0x30, 0x63, 0x01, 0x98, 0x0C,
  0xC0, 0x66, 0x03, 0x60, 0x1B, 0x01, 0xD8, 0x0C, 0xC0, 0x66, 0x06, 0x60,
  0xE3, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xFC, 0x7F, 0x8C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x7F, 0x8C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x07, 0xE0, 0x7F, 0xCE, 0x04, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC1, 0xF6, 0x13, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x70, 0x31, 0xFF,
  0x07, 0xF8, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x06, 0x30, 0x18, 0xC0,
  0x63, 0x01, 0x8F, 0xFE, 0x3F, 0xF1, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60,
  0x23, 0x01, 0x8C, 0x06, 0x30, 0x18, 0x1F, 0x1F, 0x0C, 0x0C, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0xF8, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x3E, 0x1E, 0x00, 0x18, 0x18, 0xC1,
  0x86, 0x18, 0x21, 0x83, 0x18, 0x19, 0x80, 0xD8, 0x07, 0xC0, 0x7E, 0x03,
  0xB0, 0x18, 0xC0, 0xC6, 0x06, 0x18, 0x60, 0xC3, 0x07, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xFF, 0xFF, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0x40, 0x78, 0x50, 0x1E,
  0x34, 0x0D, 0x8D, 0x83, 0x43, 0x61, 0xB0, 0xD8, 0x4C, 0x66, 0x33, 0x19,
  0x88, 0xC6, 0x26, 0x61, 0x8B, 0x18, 0x42, 0xC6, 0x30, 0xE1, 0x8C, 0x38,
  0x63, 0x0C, 0x30, 0x18, 0x06, 0x38, 0x08, 0x70, 0x30, 0xA0, 0x63, 0x60,
  0xC6, 0xC1, 0x8C, 0xC6, 0x19, 0x8C, 0x63, 0x18, 0xC3, 0x31, 0x86, 0x63,
  0x05, 0x84, 0x0F, 0x18, 0x1E, 0x30, 0x1C, 0x60, 0x30, 0x07, 0xC0, 0xFF,
  0x8E, 0x0C, 0xE0, 0x76, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x6C, 0x07, 0x70, 0x71, 0xFF, 0x07, 0xF0, 0x1F,
  0x83, 0xF8, 0x61, 0x8C, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x87, 0x7F, 0xCF,
  0xE1, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0x07, 0xC0, 0xFF,
  0x8E, 0x0C, 0xE0, 0x76, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x6C, 0x07, 0x70, 0x71, 0xFF, 0x07, 0xF0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x1F, 0x81, 0xFE, 0x18, 0x61, 0x86,
  0x30, 0x73, 0x06, 0x30, 0x63, 0x1C, 0x7F, 0x87, 0xF0, 0x63, 0x06, 0x38,
  0x61, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0x07, 0xC1, 0xFC, 0x60, 0x9C, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x03, 0x3F, 0xE7, 0xF0, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x30, 0x19, 0x80, 0xCC, 0x06, 0xC0, 0x66, 0x03, 0x30, 0x19,
  0x80, 0xD8, 0x06, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x60,
  0x63, 0xFE, 0x0F, 0xE0, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x0C, 0xC0, 0xC4,
  0x18, 0x61, 0x86, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x07,
  0x80, 0x38, 0x03, 0x00, 0xC0, 0xE0, 0x78, 0x1C, 0x1B, 0x03, 0x83, 0x60,
  0xF0, 0xC4, 0x16, 0x18, 0x86, 0xC6, 0x10, 0x98, 0xC3, 0x33, 0x10, 0x66,
  0x66, 0x0D, 0x8C, 0xC1, 0xB1, 0xB0, 0x3C, 0x36, 0x07, 0x86, 0x80, 0xE0,
  0xF0, 0x1C, 0x0C, 0x03, 0x01, 0x80, 0x1C, 0x0C, 0x30, 0x60, 0xC1, 0x81,
  0x8C, 0x06, 0x60, 0x1B, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0xC8, 0x06, 0x30, 0x18, 0xC0, 0xC1, 0x86, 0x06, 0x30, 0x18, 0xC0, 0x78,
  0x19, 0x83, 0x30, 0xC6, 0x30, 0xC6, 0x09, 0x81, 0xE0, 0x3C, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0x0F,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x60, 0x40, 0xC0, 0xC0, 0xF0, 0xC4, 0x46, 0x66, 0x66, 0x23, 0x33, 0x33,
  0x31, 0x0F, 0x87, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x3E, 0x00, 0x0C,
  0x01, 0x80, 0x78, 0x0D, 0x03, 0x30, 0x62, 0x08, 0x63, 0x04, 0x40, 0xD8,
  0x0C, 0xFF, 0x80, 0xC6, 0x23, 0x0F, 0x27, 0xFC, 0xC3, 0xB0, 0x66, 0x0D,
  0x81, 0xB0, 0x36, 0x0E, 0xC1, 0x98, 0x71, 0x9E, 0x3C, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x67, 0x0F, 0xF1, 0xC6, 0x70, 0x6C, 0x0D,
  0x81, 0xB0, 0x66, 0x0D, 0xC1, 0xB8, 0x67, 0x9C, 0x9E, 0x00, 0x0F, 0x9F,
  0xCC, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x1C, 0x87, 0xC0,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0xF6, 0x3F, 0xE3, 0x0E,
  0x60, 0xC6, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0xCC, 0x18, 0xC3, 0x86, 0x78,
  0x79, 0x80, 0x0F, 0x1F, 0xCC, 0x6C, 0x36, 0x1F, 0xFB, 0xF1, 0x80, 0xC0,
  0x60, 0x1C, 0xC7, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0x00, 0x30, 0x03, 0x00,
  0xFC, 0x1F, 0xC0, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0xF0, 0x0E,
  0x00, 0x0F, 0x27, 0xFC, 0xC3, 0xB0, 0x66, 0x0D, 0x81, 0xB0, 0x36, 0x0E,
  0xC1, 0x98, 0x71, 0x9E, 0x3C, 0xC0, 0x10, 0x06, 0x00, 0xC6, 0x70, 0xFC,
  0x00, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x67, 0x0F, 0xF1, 0xC6,
  0x70, 0x6C, 0x19, 0x83, 0x30, 0x66, 0x0D, 0x81, 0x30, 0x66, 0x0C, 0xC1,
  0x80, 0x18, 0xC0, 0x03, 0x18, 0xCC, 0x63, 0x18, 0xCC, 0x63, 0x18, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x17, 0x0F, 0x00, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x61, 0xCC, 0x61, 0x98, 0x66, 0x0D,
  0x81, 0xF0, 0x3E, 0x06, 0xE1, 0x8C, 0x31, 0x86, 0x18, 0xC3, 0x80, 0x18,
  0xC6, 0x63, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x63, 0x18, 0xC0, 0x33, 0x8F,
  0x1F, 0xEF, 0xCE, 0x3C, 0x6E, 0x1C, 0x36, 0x0C, 0x1B, 0x06, 0x0D, 0x83,
  0x0C, 0xC3, 0x06, 0xC1, 0x83, 0x60, 0xC1, 0xB0, 0x60, 0xD8, 0x60, 0xC0,
  0x37, 0xC7, 0xF8, 0xE3, 0xB8, 0x76, 0x0C, 0xC1, 0x98, 0x37, 0x06, 0xC1,
  0xD8, 0x33, 0x06, 0x60, 0xC0, 0x0F, 0x0F, 0xE3, 0x0D, 0x83, 0x60, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x67, 0x70, 0xF8, 0x19, 0xC1, 0xFE, 0x1C,
  0x63, 0x83, 0x30, 0x33, 0x03, 0x30, 0x63, 0x06, 0x70, 0x67, 0x0C, 0x79,
  0xC6, 0xF0, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0x27,
  0xFC, 0xC3, 0xB0, 0x66, 0x0D, 0x81, 0xB0, 0x36, 0x0E, 0xC1, 0x98, 0x71,
  0x9E, 0x3C, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x37, 0x3F,
  0x38, 0x70, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x1F,
  0xCC, 0x0C, 0x03, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xB1, 0x9F, 0x80,
  0x18, 0x61, 0xFF, 0xF3, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0E, 0x8F,
  0x00, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x66, 0x0C, 0xC1, 0x98, 0x36, 0x0E,
  0xC1, 0x98, 0x73, 0xBE, 0x3C, 0xC0, 0xC0, 0xF0, 0x3C, 0x1B, 0x0E, 0x43,
  0x19, 0x86, 0x61, 0xB0, 0x6C, 0x1E, 0x07, 0x81, 0xC0, 0xC1, 0x83, 0xC3,
  0x86, 0xC2, 0x86, 0xC6, 0x8C, 0xC6, 0x8C, 0xCC, 0x98, 0x4C, 0x98, 0x58,
  0xB0, 0x58, 0xB0, 0x50, 0xA0, 0x70, 0xE0, 0x60, 0xE0, 0x18, 0x31, 0x86,
  0x0C, 0xC0, 0xD8, 0x05, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x19, 0x03, 0x18,
  0x71, 0x8E, 0x0C, 0x18, 0x18, 0xC0, 0xC6, 0x0C, 0x10, 0x60, 0xC6, 0x06,
  0x60, 0x33, 0x01, 0xB0, 0x0D, 0x80, 0x68, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x17, 0x00, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x03, 0xFC, 0x01, 0x83,
  0xC1, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x78, 0x3C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x0E, 0x00, 0xFF, 0xFF, 0xFC, 0x0C,
  0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x06, 0x03, 0xC1, 0xC1,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x3C, 0x00, 0xF8, 0x67, 0xF8,
  0x30,
};

const GFXglyph NotoSans_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 9, 2, -16 },
  { 19, 13, 16, 14, 1, -16 },
  { 45, 11, 18, 12, 1, -17 },
  { 70, 15, 16, 18, 2, -16 },
  { 100, 13, 16, 15, 1, -16 },
  { 126, 3, 6, 5, 2, -16 },
  { 129, 7, 19, 6, 1, -16 },
  { 146, 7, 19, 6, -2, -16 },
  { 163, 10, 10, 12, 2, -17 },
  { 176, 10, 11, 13, 2, -13 },
  { 190, 4, 6, 6, -1, -3 },
  { 193, 5, 2, 7, 1, -7 },
  { 195, 3, 3, 6, 0, -3 },
  { 197, 11, 16, 8, -1, -16 },
  { 219, 11, 16, 12, 1, -16 },
  { 241, 7, 16, 12, 3, -16 },
  { 255, 12, 16, 12, 0, -16 },
  { 279, 12, 16, 12, 0, -16 },
  { 303, 12, 16, 12, 0, -16 },
  { 327, 11, 16, 12, 1, -16 },
  { 349, 11, 16, 12, 1, -16 },
  { 371, 10, 16, 12, 2, -16 },
  { 391, 11, 16, 12, 1, -16 },
  { 413, 10, 16, 12, 1, -16 },
  { 433, 5, 12, 6, 0, -12 },
  { 441, 6, 15, 6, -1, -12 },
  { 453, 10, 10, 13, 2, -13 },
  { 466, 10, 6, 13, 2, -11 },
  { 474, 10, 10, 13, 2, -13 },
  { 487, 8, 16, 9, 2, -16 },
  { 503, 17, 18, 19, 1, -16 },
  { 542, 12, 16, 12, -1, -16 },
  { 566, 12, 16, 13, 1, -16 },
  { 590, 12, 16, 13, 2, -16 },
  { 614, 13, 16, 15, 1, -16 },
  { 640, 11, 16, 11, 1, -16 },
  { 662, 11, 16, 11, 1, -16 },
  { 684, 13, 16, 15, 2, -16 },
  { 710, 14, 16, 15, 1, -16 },
  { 738, 8, 16, 7, 0, -16 },
  { 754, 9, 20, 6, -3, -16 },
  { 777, 13, 16, 12, 1, -16 },
  { 803, 8, 16, 11, 1, -16 },
  { 819, 18, 16, 19, 1, -16 },
  { 855, 15, 16, 16, 1, -16 },
  { 885, 13, 16, 16, 2, -16 },
  { 911, 11, 16, 12, 1, -16 },
  { 933, 13, 20, 16, 2, -16 },
  { 966, 12, 16, 13, 1, -16 },
  { 990, 11, 16, 11, 0, -16 },
  { 1012, 11, 16, 11, 2, -16 },
  { 1034, 13, 16, 15, 2, -16 },
  { 1060, 12, 16, 12, 2, -16 },
  { 1084, 19, 16, 19, 2, -16 },
  { 1122, 14, 16, 12, -1, -16 },
  { 1150, 11, 16, 11, 2, -16 },
  { 1172, 13, 16, 12, 0, -16 },
  { 1198, 8, 19, 6, 0, -16 },
  { 1217, 4, 16, 8, 2, -16 },
  { 1225, 9, 19, 6, -2, -16 },
  { 1247, 11, 10, 13, 1, -16 },
  { 1261, 9, 1, 9, -2, 2 },
  { 1263, 4, 4, 6, 3, -17 },
  { 1265, 11, 12, 13, 1, -12 },
  { 1282, 11, 17, 13, 1, -17 },
  { 1306, 9, 12, 10, 1, -12 },
  { 1320, 12, 17, 13, 1, -17 },
  { 1346, 9, 12, 11, 1, -12 },
  { 1360, 12, 22, 7, -2, -17 },
  { 1393, 11, 17, 13, 1, -12 },
  { 1417, 11, 17, 13, 1, -17 },
  { 1441, 5, 16, 6, 1, -16 },
  { 1451, 9, 21, 6, -3, -16 },
  { 1475, 11, 17, 11, 1, -17 },
  { 1499, 5, 17, 6, 1, -17 },
  { 1510, 17, 12, 19, 1, -12 },
  { 1536, 11, 12, 13, 1, -12 },
  { 1553, 10, 12, 12, 1, -12 },
  { 1568, 12, 17, 13, 0, -12 },
  { 1594, 11, 17, 13, 1, -12 },
  { 1618, 8, 12, 9, 1, -12 },
  { 1630, 9, 12, 10, 0, -12 },
  { 1644, 7, 14, 7, 1, -14 },
  { 1657, 11, 12, 13, 1, -12 },
  { 1674, 10, 12, 10, 1, -12 },
  { 1689, 16, 12, 16, 1, -12 },
  { 1713, 12, 12, 11, -1, -12 },
  { 1731, 13, 17, 10, -2, -12 },
  { 1759, 10, 12, 10, 0, -12 },
  { 1774, 9, 19, 8, 0, -16 },
  { 1796, 1, 22, 12, 6, -17 },
  { 1799, 9, 19, 8, -1, -16 },
  { 1821, 10, 3, 13, 2, -9 },
};

const GFXfont NotoSans_Italic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_ITALIC22PT7B_H_
