#ifndef _NOTOSANS_ITALIC38PT7B_H_
#define _NOTOSANS_ITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x81, 0xE0, 0xF8, 0x78, 0x3C, 0x08, 0x00, 0x78, 0xF7, 0x8E,
  0x70, 0xE7, 0x0E, 0x71, 0xC6, 0x1C, 0x61, 0xCE, 0x18, 0xE1, 0x8C, 0x18,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x00, 0x70, 0x30,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x60, 0x00, 0xE0, 0xE0,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0,
  0x01, 0xC1, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80,
  0x03, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0x07, 0x00,
  0x06, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC1,
  0xE6, 0x70, 0x79, 0xC2, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07,
  0x38, 0x00, 0xF7, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1D, 0xE0, 0x03, 0x9C, 0x00, 0x63, 0xC0, 0x0C, 0x78, 0x03,
  0x8E, 0x00, 0x71, 0xC6, 0x0C, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xC1, 0xFE, 0x00, 0xE0, 0xE3, 0x80, 0x70,
  0x38, 0x70, 0x1C, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x07, 0x01, 0x81, 0xC1,
  0x80, 0xE0, 0x60, 0xE0, 0x38, 0x38, 0x70, 0x0E, 0x0E, 0x38, 0x03, 0x83,
  0x8E, 0x38, 0xE0, 0xC7, 0x3F, 0x38, 0x73, 0x9F, 0xEE, 0x39, 0xCE, 0x39,
  0xFE, 0x77, 0x07, 0x3F, 0x39, 0xC1, 0xC2, 0x1C, 0x70, 0x70, 0x0E, 0x38,
  0x1C, 0x03, 0x8E, 0x06, 0x01, 0xC3, 0x83, 0x80, 0xE0, 0xE0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x1C, 0x0E, 0x03, 0x87, 0x07, 0x00, 0xF3, 0x83,
  0x80, 0x1F, 0xC1, 0xE0, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0xC0,
  0x03, 0xCF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x78, 0x0F, 0x3C, 0x3C, 0x0E, 0x78, 0x1C, 0x1C,
  0x70, 0x1E, 0x3C, 0xF0, 0x0F, 0x38, 0xF0, 0x07, 0x70, 0xF0, 0x07, 0xF0,
  0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xE0, 0x78, 0x0F, 0xE0, 0x7E, 0x7E, 0xF0,
  0x3F, 0xFC, 0x78, 0x1F, 0xF0, 0x3C, 0x7B, 0xDC, 0xE7, 0x31, 0x9C, 0xE6,
  0x00, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x04, 0x0E, 0x07, 0x86, 0x03, 0xF3, 0x00, 0x7F, 0x87, 0x07, 0xFF,
  0x81, 0xFF, 0xC1, 0xF0, 0x01, 0xDC, 0x01, 0xC6, 0x01, 0xE3, 0x81, 0xE1,
  0xC0, 0x60, 0x70, 0x00, 0x38, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x70, 0x70, 0xE0,
  0x7F, 0xFF, 0xEF, 0xF8, 0x27, 0xBF, 0xEF, 0x20, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x3E, 0x0F, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0x77,
  0x80, 0x1D, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x1E, 0xF0, 0x07,
  0x3C, 0x03, 0xCF, 0x00, 0xE1, 0xC0, 0x78, 0x78, 0x3C, 0x0F, 0xBE, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x3F, 0x07, 0xE1, 0xFE, 0x3E, 0xEF,
  0xDE, 0x71, 0xC2, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0x7E, 0x03, 0x80, 0xF0, 0x20, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x3F, 0xE0,
  0x1F, 0xFF, 0x07, 0xE3, 0xE0, 0x60, 0x1E, 0x08, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x23, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0xC0, 0x1F, 0x1F, 0xBF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x03, 0x9C, 0x00, 0x71,
  0xC0, 0x0E, 0x1C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0x80, 0xF0,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x78, 0x38, 0x07, 0x07, 0x80, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x3B, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x18, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xC6, 0x00, 0xF8, 0xFC, 0xFE, 0x1F, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFE,
  0x20, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x7E, 0x07, 0xBF, 0xE0, 0xFF, 0xFE,
  0x1F, 0x83, 0xC3, 0xE0, 0x3C, 0x78, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x0E,
  0x78, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x78,
  0x78, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xE3, 0xE0, 0xF0, 0x3C, 0x1C,
  0x03, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x3C,
  0x1E, 0x03, 0xC7, 0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0xF9,
  0xE0, 0x3C, 0x1E, 0x0F, 0x01, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x79, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x0F, 0xCF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3E, 0x3E, 0x1E, 0x07, 0x87, 0x00, 0xE3, 0xC0, 0x3C, 0xE0, 0x0F,
  0x78, 0x01, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0xCE,
  0x01, 0xE3, 0xC1, 0xF8, 0x7F, 0xEE, 0x1F, 0xF7, 0x81, 0xF1, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x0E, 0x1E, 0x1F,
  0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0xF0, 0xF8, 0xF0, 0xF0, 0x40, 0x01, 0xC0, 0x78, 0x0F, 0x81,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x70,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x7F,
  0xC7, 0xFF, 0x9F, 0xBF, 0x20, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC3, 0x80, 0x38, 0x07, 0x38, 0x0F, 0xFC, 0x39, 0xC0, 0xFF, 0xE1,
  0xDC, 0x0E, 0x0E, 0x0E, 0xE0, 0xE0, 0x70, 0x77, 0x0E, 0x03, 0x83, 0xF0,
  0x70, 0x1C, 0x1F, 0x87, 0x01, 0xC0, 0xFC, 0x38, 0x0E, 0x07, 0xE1, 0xC0,
  0x70, 0x37, 0x0E, 0x07, 0x83, 0xB8, 0x70, 0x3C, 0x1D, 0xC3, 0x83, 0xE1,
  0xCE, 0x0F, 0x77, 0xBC, 0x70, 0x7F, 0x1F, 0xC1, 0xC0, 0xF0, 0x7C, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x02, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00,
  0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0xE0,
  0xF0, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70,
  0x01, 0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x78, 0x00, 0x39, 0xC0, 0x00,
  0xEF, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x70, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x01, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3C, 0x0F, 0x83, 0x80, 0x3C, 0x38, 0x01, 0xC3, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70,
  0x07, 0xCF, 0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x00, 0x02, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C,
  0x01, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x01, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xC0,
  0x7C, 0x0F, 0x00, 0xF8, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00,
  0x38, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x70, 0x01, 0xF1,
  0xC0, 0x0F, 0x87, 0x00, 0x7C, 0x3C, 0x0F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xC0, 0x08, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xFF, 0xB8, 0x03, 0xFC, 0xE0,
  0x1F, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xF0, 0x00,
  0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x78, 0x7E, 0x01, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x07,
  0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F,
  0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E,
  0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38,
  0x00, 0x70, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1F, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x3E,
  0x0E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0xF0, 0x3C, 0x01,
  0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x07, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0x73, 0xC0, 0x00, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xDC, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0x70, 0x70,
  0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xE0, 0x07, 0x01, 0xE0, 0x0E, 0x03, 0xC0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0F, 0x03,
  0x80, 0x1E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0xC3, 0xB0, 0x00, 0x7E, 0x0E, 0xE0, 0x03, 0xB8, 0x3B, 0x80,
  0x0E, 0xE0, 0xEE, 0x00, 0x77, 0x83, 0xB8, 0x01, 0xDE, 0x1E, 0xE0, 0x0E,
  0x70, 0x73, 0x80, 0x39, 0xC1, 0xCE, 0x01, 0xC7, 0x07, 0x18, 0x07, 0x3C,
  0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC1, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x0E,
  0x1C, 0x38, 0x78, 0x38, 0x70, 0xE1, 0xE0, 0xE1, 0xC7, 0x07, 0x07, 0x87,
  0x1C, 0x1C, 0x1C, 0x0C, 0xE0, 0x70, 0x70, 0x33, 0x83, 0xC1, 0xC0, 0xFC,
  0x0F, 0x0F, 0x03, 0xF0, 0x38, 0x38, 0x0F, 0x80, 0xE0, 0xE0, 0x3E, 0x03,
  0x83, 0x80, 0xF0, 0x1E, 0x0E, 0x03, 0x80, 0x78, 0x00, 0x07, 0x80, 0x03,
  0x83, 0xC0, 0x03, 0xC1, 0xF0, 0x01, 0xE1, 0xF8, 0x00, 0xE0, 0xFE, 0x00,
  0x70, 0x77, 0x00, 0x38, 0x3B, 0x80, 0x3C, 0x1D, 0xE0, 0x1C, 0x1E, 0x70,
  0x0E, 0x0E, 0x38, 0x07, 0x07, 0x0E, 0x03, 0x83, 0x87, 0x03, 0xC1, 0xC3,
  0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x3C, 0x78, 0x38,
  0x0E, 0x3C, 0x1C, 0x07, 0x1C, 0x1E, 0x01, 0xCE, 0x0E, 0x00, 0xE7, 0x07,
  0x00, 0x7B, 0x83, 0x80, 0x1F, 0xC3, 0xC0, 0x0F, 0xC1, 0xC0, 0x07, 0xE0,
  0xE0, 0x01, 0xF0, 0x70, 0x00, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xDF, 0xC0, 0xF8, 0x07,
  0xC3, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x7C, 0x07, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x70, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x0E, 0x0E, 0x00,
  0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0,
  0x3E, 0x1C, 0x07, 0xC3, 0xC7, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x3F, 0xDF, 0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x9E,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01,
  0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x70, 0x3E, 0x0F, 0x00, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0,
  0x0F, 0x1E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x3C, 0x1C,
  0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x38, 0x38, 0x03,
  0x83, 0xC0, 0x78, 0x1C, 0x07, 0x81, 0xE0, 0x70, 0x1E, 0x07, 0x00, 0xE0,
  0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0xE0, 0x07,
  0x80, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xF0,
  0x0C, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x80, 0x3E,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00,
  0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x7B, 0x80, 0x03,
  0xDC, 0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00, 0x1E, 0x38, 0x00, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x81, 0xC0, 0x38, 0x0E, 0x03, 0xC0,
  0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x07,
  0x00, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xC0, 0x01,
  0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x07,
  0xC0, 0x0E, 0xE0, 0x07, 0xC0, 0x1E, 0xF0, 0x0F, 0xC0, 0x1C, 0xF0, 0x0F,
  0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x38, 0xF0, 0x1D, 0xC0, 0x78, 0xF0, 0x1D,
  0xC0, 0x70, 0xF0, 0x39, 0xC0, 0xF0, 0xF0, 0x39, 0xC0, 0xE0, 0x70, 0x71,
  0xC0, 0xE0, 0x70, 0x71, 0xC1, 0xE0, 0x70, 0xE1, 0xC1, 0xC0, 0x70, 0xE1,
  0xC3, 0xC0, 0x71, 0xC1, 0xC3, 0x80, 0x71, 0xC0, 0xC7, 0x80, 0x73, 0xC0,
  0xC7, 0x00, 0x73, 0x80, 0xC7, 0x00, 0x73, 0x80, 0xEE, 0x00, 0x77, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x83,
  0xC0, 0x01, 0xC3, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1D,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0xE0,
  0x3C, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF7, 0x00, 0x1E,
  0x78, 0x03, 0xC7, 0x80, 0x38, 0x38, 0x07, 0x83, 0x80, 0xF0, 0x38, 0x0E,
  0x03, 0xC1, 0xE0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x00, 0xEF,
  0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x00, 0xE1, 0xC3, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x87, 0x0E, 0x1C, 0x38, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x80, 0x06, 0x30, 0x01, 0xC7, 0x00, 0x38,
  0x60, 0x0E, 0x0E, 0x01, 0xC0, 0xC0, 0x70, 0x1C, 0x0E, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x03, 0x8C, 0x00, 0x73, 0x80, 0x07, 0xF0, 0x00, 0xE0, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xC7, 0x0E, 0x38, 0x70, 0x00, 0xF0,
  0x00, 0x7F, 0x1C, 0x3F, 0xF3, 0x8F, 0x87, 0xE1, 0xE0, 0x7C, 0x78, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x1E,
  0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0xF8,
  0xF0, 0x3F, 0x1E, 0x0F, 0xC1, 0xF7, 0xB8, 0x3F, 0xE7, 0x03, 0xF8, 0xE0,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x0E, 0x01, 0xC7, 0xF0,
  0x39, 0xFF, 0x07, 0x71, 0xE0, 0xF8, 0x1E, 0x3E, 0x01, 0xC7, 0xC0, 0x38,
  0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x07, 0x9C, 0x00, 0xF3,
  0x80, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x8F,
  0x81, 0xE1, 0xFC, 0xF8, 0x73, 0xFE, 0x0E, 0x3F, 0x80, 0x00, 0xF8, 0x03,
  0xFF, 0x0F, 0xFE, 0x1F, 0x06, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x08, 0x7E, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0xE0, 0xE0, 0x1F, 0xCF, 0x03, 0xFF, 0x78, 0x3E, 0x1F, 0x81, 0xE0,
  0x7C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x87,
  0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x07,
  0x83, 0x80, 0x3C, 0x1C, 0x03, 0xE0, 0xF0, 0x3F, 0x07, 0x83, 0xF0, 0x1F,
  0x7B, 0x80, 0xFF, 0x9C, 0x03, 0xF8, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xFC,
  0x0F, 0xFE, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x70, 0x0E,
  0x70, 0x3E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x08, 0x7E, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x40, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC7, 0x07,
  0xFE, 0x70, 0xF8, 0x7E, 0x0F, 0x03, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x70, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00, 0xF8, 0x78, 0x1F,
  0x87, 0x83, 0xF0, 0x3E, 0xF7, 0x03, 0xFE, 0x70, 0x1F, 0xCF, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0xC0,
  0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x0E, 0x01, 0xC7, 0xF0, 0x39, 0xFF, 0x07,
  0x70, 0xF0, 0xF8, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1C,
  0x01, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70,
  0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xF1, 0xC0,
  0x1C, 0x78, 0x03, 0x8F, 0x00, 0xF0, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38,
  0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x21, 0xE0, 0x78,
  0x38, 0x1E, 0x07, 0x07, 0x80, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x1E, 0x00,
  0xE7, 0x80, 0x1D, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xCF, 0x00, 0x70, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x3C, 0x0E,
  0x07, 0x81, 0xC0, 0x70, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0xE0,
  0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x38, 0xFE, 0x1F, 0xE0, 0xE7, 0xF8, 0xFF, 0xC3, 0xB8, 0xF7,
  0x0F, 0x0F, 0x81, 0xF8, 0x1C, 0x7C, 0x07, 0xC0, 0x71, 0xE0, 0x1E, 0x01,
  0xC7, 0x80, 0x78, 0x07, 0x1C, 0x01, 0xC0, 0x3C, 0xF0, 0x0F, 0x00, 0xF3,
  0xC0, 0x3C, 0x03, 0x8E, 0x00, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0x38, 0xE0,
  0x1E, 0x01, 0xE7, 0x80, 0x78, 0x07, 0x1E, 0x01, 0xC0, 0x1C, 0x70, 0x07,
  0x00, 0x71, 0xC0, 0x1C, 0x03, 0xC7, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xC0,
  0x38, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xC7, 0xF8, 0x3B, 0xFF,
  0x07, 0xF1, 0xF1, 0xF8, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xF3,
  0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0xF0, 0x7C, 0x3C, 0x3E, 0x07, 0x8F, 0x00, 0xE7, 0x80, 0x39, 0xC0,
  0x0F, 0x70, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03,
  0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x3C, 0xF0, 0x0E, 0x1E, 0x07, 0x87,
  0xEF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x7F,
  0x00, 0xE7, 0xFC, 0x07, 0x71, 0xE0, 0x3E, 0x07, 0x83, 0xE0, 0x1C, 0x1F,
  0x00, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x1E,
  0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0,
  0x1C, 0x1E, 0x01, 0xE0, 0xF8, 0x1E, 0x07, 0xF3, 0xE0, 0x7B, 0xFE, 0x03,
  0x8F, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x1C, 0x3F, 0xF3, 0x8F, 0x87, 0xE1,
  0xE0, 0x7C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x9E,
  0x00, 0x73, 0xC0, 0x1E, 0x78, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x38,
  0x03, 0xC7, 0x00, 0xF8, 0xF0, 0x3F, 0x1E, 0x0F, 0xC1, 0xF7, 0xB8, 0x3F,
  0xE7, 0x03, 0xF9, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x1C, 0x7C, 0x3B, 0xF8, 0x77, 0x10, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0x0F, 0xFE,
  0x1E, 0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x80, 0x78, 0xF1, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xFF, 0xFF, 0xE1, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF9, 0x07, 0xF0,
  0x3F, 0x00, 0x1E, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x1E, 0x00, 0xE3,
  0xC0, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x8E,
  0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x38,
  0x07, 0xC7, 0x01, 0xF8, 0xF0, 0x7E, 0x1F, 0x3D, 0xC1, 0xFF, 0x38, 0x1F,
  0xC7, 0x00, 0xE0, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0xF3, 0xC0, 0x38, 0xF0,
  0x1E, 0x1C, 0x07, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x1C, 0x1C,
  0x07, 0x0F, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x1E, 0x70, 0x03, 0xBC, 0x00,
  0xEE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xE0,
  0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x3B, 0xC0, 0xF8, 0x0F, 0x78, 0x1B, 0x01,
  0xCF, 0x07, 0x60, 0x79, 0xE0, 0xEE, 0x0E, 0x3C, 0x39, 0xC3, 0xC7, 0x87,
  0x38, 0x70, 0x71, 0xC7, 0x1E, 0x0E, 0x38, 0xE3, 0x81, 0xCE, 0x1C, 0x70,
  0x39, 0xC3, 0x9C, 0x07, 0x30, 0x73, 0x80, 0xEE, 0x0E, 0xF0, 0x1D, 0xC1,
  0xDC, 0x03, 0xF0, 0x3B, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x70, 0x1E,
  0x07, 0x83, 0xC0, 0x38, 0x78, 0x03, 0x87, 0x00, 0x1C, 0xE0, 0x01, 0xDE,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xB8, 0x00, 0x7B, 0xC0, 0x0F, 0x1C, 0x01, 0xE1, 0xE0, 0x1C,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x07, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x0F,
  0x03, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x78,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xE0,
  0x01, 0xC1, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x80,
  0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x3E, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0x80, 0x3F, 0x00,
};

const GFXglyph NotoSans_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 28, 10, 1, -27 },
  { 33, 12, 10, 15, 4, -27 },
  { 48, 24, 27, 25, 1, -27 },
  { 129, 19, 31, 21, 1, -29 },
  { 203, 26, 28, 30, 3, -28 },
  { 294, 24, 28, 26, 1, -28 },
  { 378, 5, 10, 8, 4, -27 },
  { 385, 12, 33, 11, 2, -27 },
  { 435, 12, 33, 11, -3, -27 },
  { 485, 17, 18, 21, 4, -29 },
  { 524, 18, 19, 22, 3, -23 },
  { 567, 8, 9, 10, -2, -4 },
  { 576, 10, 3, 12, 1, -12 },
  { 580, 5, 6, 10, 1, -5 },
  { 584, 19, 27, 14, -2, -27 },
  { 649, 18, 28, 21, 2, -28 },
  { 712, 12, 27, 21, 5, -27 },
  { 753, 20, 28, 21, 0, -28 },
  { 823, 19, 28, 21, 1, -28 },
  { 890, 20, 27, 21, 0, -27 },
  { 958, 19, 27, 21, 1, -27 },
  { 1023, 19, 28, 21, 2, -28 },
  { 1090, 18, 27, 21, 3, -27 },
  { 1151, 19, 28, 21, 2, -28 },
  { 1218, 18, 28, 21, 2, -28 },
  { 1281, 8, 22, 10, 1, -21 },
  { 1303, 11, 26, 10, -2, -21 },
  { 1339, 18, 19, 22, 3, -23 },
  { 1382, 17, 11, 22, 3, -19 },
  { 1406, 18, 19, 22, 3, -23 },
  { 1449, 14, 29, 16, 3, -28 },
  { 1500, 29, 30, 32, 2, -27 },
  { 1609, 22, 27, 21, -2, -27 },
  { 1684, 20, 27, 23, 2, -27 },
  { 1752, 21, 28, 22, 3, -28 },
  { 1826, 22, 27, 25, 2, -27 },
  { 1901, 19, 27, 20, 2, -27 },
  { 1966, 19, 27, 18, 2, -27 },
  { 2031, 22, 28, 26, 3, -28 },
  { 2108, 24, 27, 26, 2, -27 },
  { 2189, 15, 27, 12, -1, -27 },
  { 2240, 17, 34, 10, -6, -27 },
  { 2313, 23, 27, 21, 2, -27 },
  { 2391, 14, 27, 18, 2, -27 },
  { 2439, 30, 27, 32, 2, -27 },
  { 2541, 25, 27, 27, 2, -27 },
  { 2626, 23, 28, 27, 3, -28 },
  { 2707, 20, 27, 22, 2, -27 },
  { 2775, 23, 34, 27, 3, -28 },
  { 2873, 20, 27, 22, 2, -27 },
  { 2941, 19, 28, 19, 1, -28 },
  { 3008, 19, 27, 19, 3, -27 },
  { 3073, 23, 27, 26, 3, -27 },
  { 3151, 21, 27, 21, 3, -27 },
  { 3222, 32, 27, 33, 4, -27 },
  { 3330, 25, 27, 20, -2, -27 },
  { 3415, 20, 27, 19, 3, -27 },
  { 3483, 22, 27, 20, 0, -27 },
  { 3558, 14, 33, 11, 0, -27 },
  { 3616, 7, 27, 14, 4, -27 },
  { 3640, 15, 33, 11, -3, -27 },
  { 3702, 19, 17, 22, 1, -27 },
  { 3743, 16, 3, 15, -4, 3 },
  { 3749, 6, 6, 11, 6, -29 },
  { 3754, 19, 21, 22, 2, -21 },
  { 3804, 19, 29, 22, 1, -29 },
  { 3873, 16, 21, 17, 2, -21 },
  { 3915, 21, 29, 22, 2, -29 },
  { 3992, 16, 21, 19, 2, -21 },
  { 4034, 21, 38, 12, -4, -29 },
  { 4134, 20, 30, 22, 1, -21 },
  { 4209, 19, 29, 22, 1, -29 },
  { 4278, 9, 28, 10, 1, -28 },
  { 4310, 15, 37, 10, -5, -28 },
  { 4380, 19, 29, 19, 1, -29 },
  { 4449, 10, 29, 10, 1, -29 },
  { 4486, 30, 21, 33, 1, -21 },
  { 4565, 19, 21, 22, 1, -21 },
  { 4615, 18, 21, 21, 2, -21 },
  { 4663, 21, 30, 22, -1, -21 },
  { 4742, 19, 30, 22, 2, -21 },
  { 4814, 15, 21, 15, 1, -21 },
  { 4854, 16, 21, 16, 0, -21 },
  { 4896, 12, 25, 13, 2, -25 },
  { 4934, 19, 20, 22, 2, -20 },
  { 4982, 18, 20, 18, 2, -20 },
  { 5027, 27, 20, 27, 2, -20 },
  { 5095, 20, 20, 18, -1, -20 },
  { 5145, 24, 29, 18, -4, -20 },
  { 5232, 18, 20, 17, -1, -20 },
  { 5277, 15, 33, 13, 0, -27 },
  { 5339, 3, 38, 21, 10, -29 },
  { 5354, 14, 33, 13, -1, -27 },
  { 5412, 18, 5, 22, 3, -16 },
};

const GFXfont NotoSans_Italic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_ITALIC38PT7B_H_
