#ifndef _NOTOSANS_ITALIC44PT7B_H_
#define _NOTOSANS_ITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x01, 0x00, 0x7C, 0x7B, 0xC3,
  0xDE, 0x3C, 0xE1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7,
  0x06, 0x30, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x01, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x03, 0x81, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xF3, 0x86, 0x07, 0x8E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC7,
  0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x70, 0x00, 0x7D, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x31, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x71,
  0xE0, 0x03, 0x87, 0x8C, 0x0E, 0x3C, 0x3F, 0xBF, 0xF0, 0xFF, 0xFF, 0x81,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x7F,
  0x80, 0x07, 0x07, 0xFC, 0x00, 0x70, 0x78, 0xF0, 0x07, 0x87, 0x83, 0x80,
  0x78, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC0,
  0xE0, 0x38, 0x3C, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x1E, 0x1C, 0x01, 0xC0,
  0xE1, 0xE0, 0x0E, 0x07, 0x1E, 0x00, 0x70, 0x78, 0xE3, 0xF3, 0x83, 0x8E,
  0x3F, 0xDC, 0x3C, 0xF3, 0xFF, 0xF3, 0xCF, 0x3C, 0x7F, 0xFC, 0x73, 0xC1,
  0xDF, 0xC7, 0x1C, 0x0E, 0x3C, 0x78, 0xE0, 0x70, 0x07, 0x8F, 0x03, 0x80,
  0x38, 0x70, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x3C, 0x1C, 0x0F, 0x01, 0xC0,
  0xE0, 0x70, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x1E, 0x01, 0xC1,
  0xC0, 0xE0, 0x0E, 0x1E, 0x0E, 0x00, 0x7F, 0xE0, 0xF0, 0x01, 0xFE, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x0F,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x7E, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xF3, 0xC0, 0x3C, 0x7C, 0x7C, 0x07, 0x9E, 0x07, 0x81, 0xE7, 0xC0,
  0x78, 0x3C, 0xF0, 0x07, 0x8F, 0x1C, 0x00, 0xFB, 0xC7, 0x80, 0x0F, 0xF8,
  0xF0, 0x00, 0xFE, 0x1E, 0x00, 0x1F, 0x81, 0xE0, 0x03, 0xF0, 0x3C, 0x00,
  0xFE, 0x07, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0x3E, 0x07, 0xFF, 0xC3, 0xE0,
  0x7F, 0xE0, 0x3E, 0x7D, 0xE7, 0x9C, 0x71, 0xCF, 0x38, 0xE3, 0x8C, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x04, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0xC6, 0x00, 0xFF, 0x60,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF0, 0x10, 0xF7,
  0x00, 0x1E, 0x38, 0x03, 0xE3, 0x80, 0x7C, 0x3C, 0x03, 0x83, 0xC0, 0x10,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x70, 0x38, 0x38, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0xF8,
  0x1F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x03, 0x9E, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x3D, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xF3, 0x80, 0x0F,
  0x9C, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xF0,
  0x3E, 0x07, 0xC3, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x83, 0xFE, 0x3F, 0x73, 0xFB, 0xC7, 0xCF,
  0x1C, 0x3C, 0x20, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xEF, 0xE0, 0x1C, 0x03, 0xE0, 0x30, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFE, 0xFE, 0x03, 0x80, 0x7C, 0x08, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x08, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x20, 0x00, 0xF0, 0xF0, 0x0F, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xDC, 0x00, 0x03,
  0xBC, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x70, 0x01, 0xE0,
  0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00,
  0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x02, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x08, 0x00, 0x7C, 0x38, 0x07, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFE, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x3C, 0xFF, 0x81, 0xEF, 0xFE, 0x0F, 0xF3, 0xF8,
  0xFE, 0x03, 0xC7, 0xE0, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xF0, 0x0F, 0x07, 0xC1, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFC, 0xFE, 0x07, 0xC0, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0,
  0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x9F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0x00, 0xF8, 0x78,
  0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0x7C, 0x07, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0x78,
  0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xE7,
  0xC0, 0x3E, 0x1F, 0x07, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xBC, 0x0F, 0xF1,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x08, 0x07, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0x07, 0xC7, 0xE3,
  0xF0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x60,
  0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xE3, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x7C, 0x03,
  0xC7, 0x80, 0xFF, 0xF0, 0xF1, 0xC0, 0x7F, 0xF8, 0x1C, 0xF0, 0x3E, 0x0E,
  0x07, 0x38, 0x1E, 0x07, 0x81, 0xDE, 0x0F, 0x01, 0xE0, 0x77, 0x03, 0x80,
  0x70, 0x1D, 0xC1, 0xE0, 0x1C, 0x07, 0x70, 0x70, 0x0F, 0x01, 0xFC, 0x1C,
  0x03, 0xC0, 0xFF, 0x07, 0x00, 0xE0, 0x3B, 0xC1, 0xC0, 0x78, 0x0E, 0xF0,
  0x70, 0x1E, 0x07, 0xBC, 0x1C, 0x0F, 0x81, 0xCF, 0x07, 0x07, 0xE0, 0xE1,
  0xC1, 0xF7, 0xBF, 0xF8, 0x70, 0x3F, 0xC7, 0xFC, 0x1E, 0x07, 0xE0, 0xFC,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x1F, 0x80,
  0x3C, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x03,
  0x80, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xF0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x1F, 0x07,
  0x80, 0x1F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0xFC, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x1E,
  0x00, 0xF8, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0x70, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0x80, 0x30, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x0E, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0x01, 0xFC, 0x07, 0x80,
  0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x3F,
  0x01, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0x81, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0xFE, 0xF8, 0x03,
  0xFF, 0x3E, 0x00, 0xFF, 0xCF, 0x00, 0x3F, 0xF3, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00,
  0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1C,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0xD0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x43, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xC0,
  0x07, 0xE0, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x1F, 0x00,
  0x78, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x07, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xBC, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xDE, 0x00, 0x1E, 0xF0, 0x39, 0xC0, 0x03, 0x9E, 0x07, 0x38, 0x00, 0xF7,
  0x81, 0xE7, 0x00, 0x1C, 0xF0, 0x3C, 0xE0, 0x07, 0x9E, 0x07, 0x9C, 0x00,
  0xE3, 0xC0, 0xE3, 0x80, 0x3C, 0x70, 0x3C, 0x78, 0x07, 0x1E, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x0E, 0x0F, 0x03,
  0x83, 0x83, 0xC1, 0xC0, 0xF0, 0x70, 0x70, 0x78, 0x1E, 0x0E, 0x1E, 0x0F,
  0x03, 0xC1, 0xC3, 0x81, 0xE0, 0x70, 0x3C, 0xF0, 0x3C, 0x0E, 0x07, 0x9C,
  0x0F, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x78, 0x0E, 0xE0, 0x3C, 0x0F, 0x01,
  0xFC, 0x07, 0x81, 0xC0, 0x3F, 0x00, 0xF0, 0x78, 0x07, 0xC0, 0x3C, 0x0F,
  0x00, 0xF8, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x1E,
  0x07, 0xE0, 0x00, 0xF0, 0x7F, 0x00, 0x07, 0x03, 0xFC, 0x00, 0x78, 0x1D,
  0xE0, 0x03, 0xC0, 0xE7, 0x80, 0x1E, 0x07, 0x3C, 0x00, 0xE0, 0x79, 0xE0,
  0x0F, 0x03, 0xC7, 0x80, 0x78, 0x1E, 0x3C, 0x03, 0xC0, 0xE0, 0xE0, 0x1E,
  0x0F, 0x07, 0x80, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0xE0, 0x3C, 0x1E, 0x0F, 0x00, 0xF0, 0xE0, 0x78, 0x07,
  0x8F, 0x03, 0xC0, 0x1C, 0x78, 0x1C, 0x00, 0xF3, 0xC0, 0xE0, 0x07, 0x9E,
  0x0F, 0x00, 0x1C, 0xE0, 0x78, 0x00, 0xFF, 0x03, 0xC0, 0x07, 0xF8, 0x1C,
  0x00, 0x1F, 0xC1, 0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1E, 0x07, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80,
  0x7E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1E, 0x07, 0xE0,
  0x78, 0x03, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0,
  0x07, 0xC3, 0xC0, 0x1F, 0x07, 0x81, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC0,
  0xF0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xC0, 0x38, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x20, 0x03, 0xF0, 0xE0,
  0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x7C,
  0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x7C,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x38, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1D, 0xE0, 0x00,
  0x1D, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x1E,
  0xF0, 0x03, 0xF0, 0x03, 0xCF, 0x00, 0x7F, 0x00, 0x3C, 0xF0, 0x07, 0x70,
  0x07, 0x8F, 0x00, 0xF7, 0x00, 0x78, 0xF0, 0x0E, 0x78, 0x0F, 0x0F, 0x01,
  0xE7, 0x80, 0xF0, 0xF0, 0x1E, 0x78, 0x0F, 0x0F, 0x01, 0xC7, 0x81, 0xE0,
  0xF0, 0x3C, 0x78, 0x1E, 0x0F, 0x03, 0x87, 0x83, 0xC0, 0xF0, 0x78, 0x78,
  0x3C, 0x0F, 0x07, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x38, 0x78, 0x0F, 0x0E,
  0x03, 0x87, 0x00, 0x71, 0xE0, 0x38, 0xF0, 0x07, 0x1C, 0x03, 0x8E, 0x00,
  0x73, 0xC0, 0x39, 0xE0, 0x07, 0x38, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x07, 0x78, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7D, 0xC0, 0x01,
  0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE0, 0xE0, 0x0F, 0x03,
  0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x70, 0x7C, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x39, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78,
  0x78, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x1E, 0x03,
  0x80, 0x70, 0x07, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xF1,
  0xC0, 0x01, 0xCF, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x78, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x00, 0x7C,
  0x1C, 0x07, 0xFC, 0x70, 0x7F, 0xFB, 0xC3, 0xF9, 0xEF, 0x0F, 0x81, 0xF8,
  0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x8F,
  0x00, 0x7C, 0x3E, 0x03, 0xF0, 0x7C, 0x3D, 0xC1, 0xFF, 0xEF, 0x03, 0xFF,
  0x3C, 0x07, 0xF0, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x79, 0xFF, 0x01, 0xEF,
  0xFE, 0x07, 0x7C, 0xF8, 0x3F, 0x81, 0xF0, 0xFC, 0x03, 0xC3, 0xE0, 0x0F,
  0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7E, 0x03, 0xE1,
  0xFC, 0x1F, 0x87, 0x7F, 0xFC, 0x1C, 0xFF, 0xE0, 0xE1, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0x8E, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x06, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x3C, 0x01,
  0xFF, 0x3C, 0x07, 0xFF, 0xBC, 0x0F, 0xC7, 0xBC, 0x0F, 0x81, 0xF8, 0x1F,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0,
  0x07, 0xE0, 0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x78, 0x3F, 0xC0, 0x7F,
  0xFB, 0xC0, 0x3F, 0xF3, 0xC0, 0x1F, 0xC3, 0x80, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x1F, 0xFF, 0x07, 0xE3, 0xE0, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x80,
  0x79, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x01, 0xF1, 0xE7, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0x81, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x87, 0xC0, 0x70, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E, 0x0E, 0x01,
  0xFF, 0x1C, 0x0F, 0xFF, 0x78, 0x3F, 0x0E, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x07, 0xE1,
  0xE0, 0x0F, 0x83, 0xE0, 0x3F, 0x03, 0xE1, 0xFE, 0x07, 0xFF, 0xBC, 0x07,
  0xFE, 0x78, 0x07, 0xF1, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x10, 0x01, 0xE0, 0x30, 0x07,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x1F, 0x80, 0x79, 0xFF, 0x01, 0xEF, 0xFE, 0x07, 0x78,
  0x7C, 0x3F, 0x80, 0xF0, 0xFC, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C,
  0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x0F,
  0x80, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x78, 0x0F, 0x81,
  0xE0, 0x7C, 0x07, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC3,
  0xC0, 0x0E, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00,
  0x1D, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xF7, 0x80, 0x0F, 0x8F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x07,
  0xC0, 0x1F, 0x00, 0xE3, 0xFE, 0x0F, 0xF8, 0x1C, 0xFF, 0xC7, 0xFF, 0x03,
  0xBC, 0x7C, 0xF1, 0xF0, 0xFE, 0x07, 0xB8, 0x1E, 0x1F, 0x80, 0xFE, 0x03,
  0xC3, 0xE0, 0x1F, 0x80, 0x78, 0x7C, 0x03, 0xE0, 0x0F, 0x0F, 0x00, 0x7C,
  0x01, 0xE3, 0xE0, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x0F, 0x0F, 0x00,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0x07,
  0x87, 0x80, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0x1E, 0x3C, 0x00, 0xF0,
  0x03, 0x87, 0x80, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x1E, 0x1C, 0x00,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x87, 0xE0, 0x1C, 0x7F,
  0xE0, 0x73, 0xFF, 0x83, 0xDF, 0x3F, 0x0F, 0xF0, 0x3C, 0x3F, 0x00, 0xF0,
  0xFC, 0x03, 0xC3, 0xE0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F,
  0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x8F, 0xC1,
  0xF0, 0x1F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0x01, 0xC1, 0xF0, 0x01, 0xC7, 0xFC, 0x01, 0xCF,
  0xFE, 0x01, 0xDF, 0x3E, 0x03, 0xF8, 0x1F, 0x03, 0xF0, 0x0F, 0x03, 0xE0,
  0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x1F, 0x00,
  0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0xC1, 0xF8, 0x1D, 0xFF, 0xF0, 0x1C, 0xFF,
  0xE0, 0x3C, 0x7F, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x1C, 0x07, 0xFC, 0x70, 0x7F, 0xFB, 0xC3, 0xF1, 0xEF,
  0x0F, 0x81, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3,
  0xC0, 0x1F, 0x8F, 0x00, 0x7C, 0x3E, 0x03, 0xF0, 0x78, 0x3F, 0xC1, 0xFF,
  0xEF, 0x03, 0xFF, 0x3C, 0x07, 0xF1, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x07, 0xC1, 0xC7, 0xF0, 0x73, 0xF8, 0x1D, 0xFE, 0x0F,
  0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3E, 0x1E, 0x1F, 0x00, 0x87, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF2, 0x00, 0x7C, 0xE0, 0x3E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x78, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x8F, 0x00, 0x7C, 0x3E, 0x03, 0xF0,
  0x78, 0x3F, 0xC1, 0xFF, 0xEF, 0x03, 0xFF, 0x3C, 0x07, 0xF0, 0xE0, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xC7, 0x00, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00,
  0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0xFE, 0x00, 0xF8,
  0x07, 0xF8, 0x07, 0xE0, 0x1E, 0xE0, 0x1F, 0x80, 0x7B, 0x80, 0xFE, 0x03,
  0xCE, 0x03, 0xB8, 0x0F, 0x38, 0x1E, 0xE0, 0x78, 0xF0, 0x73, 0x81, 0xE3,
  0xC3, 0xCE, 0x0F, 0x0F, 0x0E, 0x38, 0x3C, 0x3C, 0x38, 0xF1, 0xE0, 0xF1,
  0xC3, 0xC7, 0x83, 0xC7, 0x0F, 0x1C, 0x0F, 0x3C, 0x3C, 0xF0, 0x3C, 0xE0,
  0xF3, 0xC0, 0xF7, 0x81, 0xDE, 0x03, 0xDC, 0x07, 0x78, 0x0F, 0xF0, 0x1D,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x1F, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0x7B, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x80, 0x03,
  0xC7, 0x80, 0x07, 0x83, 0xC0, 0x0F, 0x03, 0xC0, 0x1F, 0x01, 0xC0, 0x3E,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x40, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x9F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x07, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xE8, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 32, 11, 1, -31 },
  { 45, 13, 11, 17, 5, -31 },
  { 63, 28, 31, 28, 1, -31 },
  { 172, 22, 36, 24, 1, -33 },
  { 271, 29, 32, 35, 4, -32 },
  { 387, 27, 32, 30, 1, -32 },
  { 495, 6, 11, 10, 5, -31 },
  { 504, 14, 38, 13, 2, -31 },
  { 571, 14, 38, 13, -3, -31 },
  { 638, 20, 21, 24, 5, -34 },
  { 691, 21, 21, 25, 3, -26 },
  { 747, 9, 11, 11, -2, -5 },
  { 760, 11, 4, 14, 1, -14 },
  { 766, 5, 6, 11, 1, -5 },
  { 770, 21, 31, 16, -2, -31 },
  { 852, 21, 32, 24, 3, -32 },
  { 936, 14, 31, 24, 6, -31 },
  { 991, 23, 32, 24, 0, -32 },
  { 1083, 22, 32, 24, 1, -32 },
  { 1171, 24, 31, 24, 0, -31 },
  { 1264, 22, 31, 24, 2, -31 },
  { 1350, 21, 32, 24, 3, -32 },
  { 1434, 21, 31, 24, 4, -31 },
  { 1516, 22, 32, 24, 2, -32 },
  { 1604, 21, 32, 24, 2, -32 },
  { 1688, 9, 25, 11, 1, -24 },
  { 1717, 12, 30, 11, -2, -24 },
  { 1762, 21, 22, 25, 3, -27 },
  { 1820, 21, 11, 25, 3, -21 },
  { 1849, 21, 22, 25, 3, -27 },
  { 1907, 17, 33, 19, 3, -32 },
  { 1978, 34, 35, 37, 2, -31 },
  { 2127, 26, 31, 25, -3, -31 },
  { 2228, 24, 31, 26, 2, -31 },
  { 2321, 25, 32, 26, 3, -32 },
  { 2421, 26, 31, 29, 2, -31 },
  { 2522, 22, 31, 23, 2, -31 },
  { 2608, 22, 31, 21, 2, -31 },
  { 2694, 26, 32, 30, 3, -32 },
  { 2798, 28, 31, 30, 2, -31 },
  { 2907, 18, 31, 14, -1, -31 },
  { 2977, 19, 39, 12, -7, -31 },
  { 3070, 27, 31, 25, 2, -31 },
  { 3175, 16, 31, 21, 2, -31 },
  { 3237, 35, 31, 37, 2, -31 },
  { 3373, 29, 31, 31, 2, -31 },
  { 3486, 27, 32, 32, 3, -32 },
  { 3594, 23, 31, 25, 2, -31 },
  { 3684, 27, 39, 32, 3, -32 },
  { 3816, 23, 31, 25, 2, -31 },
  { 3906, 22, 32, 22, 1, -32 },
  { 3994, 22, 31, 22, 4, -31 },
  { 4080, 27, 31, 30, 3, -31 },
  { 4185, 24, 31, 24, 4, -31 },
  { 4278, 36, 31, 38, 5, -31 },
  { 4418, 29, 31, 23, -2, -31 },
  { 4531, 22, 31, 22, 4, -31 },
  { 4617, 25, 31, 23, 0, -31 },
  { 4714, 16, 38, 13, 0, -31 },
  { 4790, 8, 31, 16, 5, -31 },
  { 4821, 16, 38, 13, -3, -31 },
  { 4897, 22, 20, 25, 2, -32 },
  { 4952, 18, 3, 17, -4, 4 },
  { 4959, 8, 7, 12, 6, -34 },
  { 4966, 22, 24, 25, 2, -24 },
  { 5032, 22, 33, 25, 1, -33 },
  { 5123, 18, 24, 20, 2, -24 },
  { 5177, 24, 33, 25, 2, -33 },
  { 5276, 19, 24, 22, 2, -24 },
  { 5333, 24, 45, 14, -5, -34 },
  { 5468, 23, 35, 25, 1, -24 },
  { 5569, 22, 33, 25, 1, -33 },
  { 5660, 11, 32, 11, 1, -32 },
  { 5704, 18, 43, 11, -6, -32 },
  { 5801, 22, 33, 22, 1, -33 },
  { 5892, 11, 33, 11, 1, -33 },
  { 5938, 35, 24, 39, 1, -24 },
  { 6043, 22, 24, 25, 1, -24 },
  { 6109, 21, 24, 25, 2, -24 },
  { 6172, 24, 35, 25, -1, -24 },
  { 6277, 22, 35, 25, 2, -24 },
  { 6374, 18, 24, 18, 1, -24 },
  { 6428, 18, 24, 19, 0, -24 },
  { 6482, 14, 29, 15, 2, -29 },
  { 6533, 22, 24, 25, 2, -24 },
  { 6599, 21, 24, 21, 2, -24 },
  { 6662, 30, 24, 32, 3, -24 },
  { 6752, 24, 24, 21, -2, -24 },
  { 6824, 27, 35, 21, -4, -24 },
  { 6943, 20, 24, 20, -1, -24 },
  { 7003, 18, 38, 15, 0, -31 },
  { 7089, 4, 44, 24, 11, -33 },
  { 7111, 17, 38, 15, -2, -31 },
  { 7192, 21, 5, 25, 3, -18 },
};

const GFXfont NotoSans_Italic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic44pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_ITALIC44PT7B_H_
