#ifndef _NOTOSANS_ITALIC65PT7B_H_
#define _NOTOSANS_ITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0x87, 0xF3, 0xF0, 0x7E, 0x3F, 0x07,
  0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78,
  0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x3C,
  0x7E, 0x01, 0xFC, 0x3C, 0x0C, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x78,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0x03, 0xF8, 0xF0, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xCF, 0xE0, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x03,
  0xF0, 0x80, 0x0F, 0x07, 0xE0, 0xE0, 0x0F, 0x0F, 0xC0, 0xFE, 0x1F, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xF8, 0x00, 0x00, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x0F,
  0xE3, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x3F, 0x00, 0x0F,
  0x80, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x1F, 0x0F, 0xF8, 0xF8, 0x07, 0xC3, 0xE1, 0xFF, 0xCF, 0x80, 0x78, 0x7C,
  0x7F, 0xFE, 0xF8, 0x0F, 0x87, 0xC7, 0xFF, 0xE7, 0xC1, 0xF0, 0xF8, 0xFC,
  0x3F, 0x7E, 0x7F, 0x1F, 0x1F, 0x81, 0xF7, 0xFF, 0xE3, 0xE1, 0xF0, 0x1F,
  0x3F, 0xFC, 0x3E, 0x3E, 0x01, 0xF1, 0xFF, 0x87, 0xC3, 0xE0, 0x1F, 0x07,
  0xE0, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0,
  0x78, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x3F,
  0x00, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0x01, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0x0F,
  0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x7F,
  0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xDF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xF0,
  0x0F, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x7F, 0xF7,
  0x80, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xBC, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xE0, 0x0F, 0xC0, 0x01, 0x00, 0x3F, 0x00, 0x04, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1E, 0x3F,
  0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0x7C, 0xFF, 0xCF, 0xC7, 0xF8, 0xFC, 0x7E, 0x0F, 0xC3, 0xC0, 0xF8, 0x10,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x10,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0xC0, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x40,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x40, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x0F, 0xF0, 0x01, 0xF8, 0x7F, 0xF8, 0x03, 0xF3, 0xFF, 0xF8, 0x07,
  0xCF, 0xFF, 0xF8, 0x1F, 0xBF, 0x9F, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x7F,
  0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x7E, 0x07, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x03, 0xF8, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0xCF,
  0xC0, 0x0F, 0xFE, 0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x01, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xF8, 0x07, 0xF8, 0x70, 0x01, 0xFC, 0x20, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x7C, 0x3E, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0x1F, 0x80, 0x3F, 0xE3,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0xC0, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0xC0,
  0x0F, 0x80, 0x3C, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x3E, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xCF, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF7, 0xC0, 0x3E,
  0x00, 0x1F, 0x00, 0x7D, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xDF, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF7, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0x7D, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xBE, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xEF,
  0x80, 0x78, 0x00, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0x7F, 0x00, 0xFC,
  0x78, 0x07, 0xC0, 0x1F, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x0E, 0xF0, 0x1F,
  0x07, 0xC0, 0x7E, 0x0F, 0xBE, 0x1F, 0xC1, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF,
  0xE0, 0x7C, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xF0, 0x3F,
  0xF0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF,
  0xF3, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x3F, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF8,
  0x07, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x7E, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xBF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x07, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x00,
  0x04, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xFF, 0xE3, 0xF0, 0x00,
  0x3F, 0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x03, 0xFF, 0xF8,
  0xFC, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x00,
  0x3F, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x07,
  0xC3, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF9, 0xF8,
  0x00, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00, 0x03,
  0xEF, 0xC0, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xE0, 0x00,
  0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x3E, 0x1E, 0x00, 0x03, 0xF1, 0xF8, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE3, 0xF0,
  0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83,
  0xF0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0x00,
  0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x01, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xFC, 0x01,
  0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0xF8,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7D,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x3E, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xCF, 0xC0, 0x00,
  0x7E, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x01, 0xF8,
  0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0x07, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x00,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x07,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x1F, 0x00,
  0x00, 0xFD, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0x80,
  0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xE0,
  0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7C, 0x01, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x38, 0x03, 0xF8, 0x00, 0x04, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3F,
  0xE0, 0x3F, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x17, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xBC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x07,
  0xE0, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x01, 0xF0,
  0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x3E, 0x01,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xF0,
  0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x78,
  0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x7C, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0xF8,
  0x0F, 0x80, 0x1F, 0xFF, 0x07, 0x80, 0x1F, 0xFF, 0xC7, 0xC0, 0x1F, 0xFF,
  0xF3, 0xE0, 0x1F, 0xF1, 0xF9, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xC0,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF8,
  0x1F, 0x80, 0x07, 0xFC, 0x07, 0xE0, 0x07, 0xFE, 0x03, 0xF8, 0x07, 0xFF,
  0x01, 0xFE, 0x0F, 0xDF, 0x00, 0x7F, 0xFF, 0xCF, 0x80, 0x1F, 0xFF, 0xC7,
  0xC0, 0x07, 0xFF, 0x83, 0xE0, 0x01, 0xFF, 0x81, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0xE0, 0x01, 0xF8, 0x7F, 0xF8, 0x01, 0xF1, 0xFF, 0xFC, 0x03, 0xF3,
  0xFF, 0xFC, 0x03, 0xF7, 0xF3, 0xFE, 0x03, 0xEF, 0x80, 0x7E, 0x03, 0xEF,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0x3F, 0x07, 0xFC, 0x00, 0x3F, 0x07, 0xF8,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x03, 0xF0, 0x7F, 0xC0, 0x07, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0x7D, 0xF0,
  0x7F, 0xC0, 0x7C, 0xFF, 0xFF, 0x80, 0xF8, 0xFF, 0xFF, 0x00, 0xF8, 0x7F,
  0xFE, 0x00, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xF8, 0x7C, 0x07, 0xF8, 0x01, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x18, 0x0F, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x03, 0xFF, 0xE1, 0xF0,
  0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x0F, 0xFF, 0xF9, 0xF0, 0x01, 0xFF, 0x1F,
  0xBF, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0xE0, 0x07, 0xF0, 0x0F, 0x7E, 0x00, 0x7F, 0x83, 0xE7, 0xC0, 0x03, 0xFF,
  0xFC, 0x7C, 0x00, 0x1F, 0xFF, 0x87, 0xC0, 0x00, 0xFF, 0xF0, 0x7C, 0x00,
  0x07, 0xFE, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xF1, 0xFE, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x00, 0xF8, 0x7F, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x9F, 0x80, 0x7F, 0xE3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x7F,
  0x00, 0x1C, 0x0F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0x04, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x87, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07,
  0xC0, 0x07, 0xFF, 0xC1, 0xF0, 0x03, 0xFF, 0xF8, 0x78, 0x01, 0xFF, 0xFF,
  0x3E, 0x00, 0xFF, 0x8F, 0xEF, 0x80, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0xF0, 0x0F,
  0xE0, 0x1E, 0xFC, 0x03, 0xFC, 0x1F, 0x3E, 0x00, 0x7F, 0xFF, 0xCF, 0x80,
  0x0F, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0xE0, 0x7C,
  0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x02, 0x00,
  0x01, 0xFC, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0x01, 0xF8, 0x7F,
  0xF8, 0x01, 0xF1, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFE, 0x03, 0xF7, 0xF9,
  0xFE, 0x03, 0xEF, 0x80, 0x7F, 0x03, 0xEF, 0x00, 0x3F, 0x03, 0xFE, 0x00,
  0x3F, 0x07, 0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x21, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0xFE, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xE0, 0x3F,
  0x80, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xE0,
  0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3E, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xC7, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xF9,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3E, 0x7F, 0x3F, 0xC7, 0xF3, 0xFE, 0x07,
  0xDF, 0x01, 0xF9, 0xF0, 0x1F, 0xC0, 0xFB, 0xC0, 0x1F, 0x7C, 0x01, 0xF8,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x3F, 0xF0, 0x01, 0xF0, 0xFF, 0xFC, 0x03,
  0xF1, 0xFF, 0xFE, 0x03, 0xF3, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x3F, 0x07,
  0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xFC, 0x00,
  0x07, 0xC1, 0xFF, 0xE0, 0x00, 0xF8, 0xFF, 0xFE, 0x00, 0x1F, 0x3F, 0xFF,
  0xC0, 0x07, 0xCF, 0xE7, 0xFC, 0x00, 0xFB, 0xE0, 0x1F, 0x80, 0x1F, 0x78,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x1F,
  0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xEF, 0x83, 0xFE, 0x00, 0x7C,
  0xFF, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xF8, 0x00,
  0x7E, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x1F, 0xFF, 0x07, 0x80,
  0x1F, 0xFF, 0xC3, 0xC0, 0x1F, 0xFF, 0xF3, 0xE0, 0x1F, 0xF1, 0xF9, 0xF0,
  0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0x7E, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xFC, 0x07, 0xE0,
  0x07, 0xFE, 0x03, 0xF8, 0x07, 0xBF, 0x01, 0xFE, 0x0F, 0x9F, 0x00, 0x7F,
  0xFF, 0xCF, 0x80, 0x1F, 0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0x87, 0xE0, 0x01,
  0xFF, 0x03, 0xE0, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x3F, 0xC0, 0x7C, 0x3F, 0xF0, 0x1F, 0x1F, 0xF8, 0x07, 0xCF, 0xFE, 0x03,
  0xE7, 0xFF, 0x80, 0xFB, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFC, 0x0F, 0xE0, 0x03,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x08, 0x00, 0x07, 0xE1, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x10,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x1F, 0xC0, 0xF8, 0x00,
  0x3F, 0xC0, 0xF8, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xC0, 0xFC, 0x03,
  0xEF, 0xC0, 0xFF, 0x0F, 0xCF, 0x80, 0x7F, 0xFF, 0x8F, 0x80, 0x7F, 0xFF,
  0x0F, 0x80, 0x3F, 0xFE, 0x0F, 0x80, 0x1F, 0xF8, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F,
  0xC7, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x3E,
  0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xEF, 0x80, 0x07, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0xE0, 0x03, 0xF3,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x9F, 0x80, 0x1E, 0xF8, 0x01, 0xF8, 0xFC,
  0x01, 0xF7, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x3F, 0x00,
  0xF9, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x0F, 0xC0, 0x7C,
  0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xE3, 0xE0, 0x3F, 0x03, 0xF0, 0x1E, 0x1F,
  0x01, 0xF8, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0x87, 0xC0,
  0xFC, 0x07, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0xF0, 0x7E,
  0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x00,
  0x3E, 0x3E, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x0F,
  0x9F, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0x80, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00, 0xFB, 0xC0,
  0x07, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x20, 0x00, 0x1F, 0xF8,
};

const GFXglyph NotoSans_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 17, 47, 17, 1, -46 },
  { 101, 20, 16, 25, 7, -46 },
  { 141, 41, 46, 42, 2, -46 },
  { 377, 32, 53, 36, 2, -49 },
  { 589, 44, 48, 52, 5, -47 },
  { 853, 40, 48, 44, 2, -47 },
  { 1093, 9, 16, 14, 7, -46 },
  { 1111, 21, 56, 19, 3, -46 },
  { 1258, 21, 56, 19, -5, -46 },
  { 1405, 30, 31, 36, 7, -50 },
  { 1522, 30, 32, 37, 5, -39 },
  { 1642, 13, 16, 17, -3, -8 },
  { 1668, 16, 5, 20, 2, -20 },
  { 1678, 8, 9, 17, 1, -8 },
  { 1687, 32, 46, 23, -3, -46 },
  { 1871, 31, 48, 36, 4, -47 },
  { 2057, 20, 46, 36, 9, -46 },
  { 2172, 34, 47, 36, 0, -47 },
  { 2372, 33, 48, 36, 1, -47 },
  { 2570, 35, 46, 36, 0, -46 },
  { 2772, 33, 47, 36, 2, -46 },
  { 2966, 31, 48, 36, 4, -47 },
  { 3152, 32, 46, 36, 5, -46 },
  { 3336, 32, 48, 36, 3, -47 },
  { 3528, 31, 48, 36, 3, -47 },
  { 3714, 14, 37, 17, 1, -36 },
  { 3779, 18, 44, 17, -3, -36 },
  { 3878, 30, 32, 37, 5, -40 },
  { 3998, 30, 18, 37, 5, -32 },
  { 4066, 30, 32, 37, 5, -40 },
  { 4186, 25, 48, 28, 5, -47 },
  { 4336, 50, 52, 55, 3, -46 },
  { 4661, 37, 46, 37, -4, -46 },
  { 4874, 35, 46, 39, 3, -46 },
  { 5076, 36, 48, 38, 5, -47 },
  { 5292, 38, 46, 43, 3, -46 },
  { 5511, 33, 46, 33, 3, -46 },
  { 5701, 33, 46, 31, 3, -46 },
  { 5891, 38, 48, 44, 5, -47 },
  { 6119, 41, 46, 44, 3, -46 },
  { 6355, 26, 46, 21, -1, -46 },
  { 6505, 28, 58, 18, -10, -46 },
  { 6708, 39, 46, 37, 3, -46 },
  { 6933, 24, 46, 31, 3, -46 },
  { 7071, 52, 46, 55, 3, -46 },
  { 7370, 43, 46, 46, 3, -46 },
  { 7618, 40, 48, 47, 5, -47 },
  { 7858, 34, 46, 37, 3, -46 },
  { 8054, 40, 58, 47, 5, -47 },
  { 8344, 34, 46, 37, 3, -46 },
  { 8540, 33, 48, 33, 1, -47 },
  { 8738, 32, 46, 33, 6, -46 },
  { 8922, 40, 47, 44, 5, -46 },
  { 9157, 36, 46, 36, 6, -46 },
  { 9364, 54, 46, 56, 7, -46 },
  { 9675, 43, 46, 34, -3, -46 },
  { 9923, 33, 46, 33, 6, -46 },
  { 10113, 38, 46, 35, -1, -46 },
  { 10332, 25, 56, 19, -1, -46 },
  { 10507, 12, 46, 23, 7, -46 },
  { 10576, 25, 56, 19, -5, -46 },
  { 10751, 33, 30, 37, 2, -47 },
  { 10875, 27, 4, 26, -6, 6 },
  { 10889, 11, 11, 18, 9, -50 },
  { 10905, 33, 36, 37, 3, -35 },
  { 11054, 32, 50, 38, 2, -49 },
  { 11254, 27, 36, 29, 3, -35 },
  { 11376, 36, 50, 38, 3, -49 },
  { 11601, 27, 36, 32, 3, -35 },
  { 11723, 36, 66, 21, -7, -50 },
  { 12020, 34, 51, 38, 2, -35 },
  { 12237, 32, 49, 38, 2, -49 },
  { 12433, 16, 48, 17, 2, -48 },
  { 12529, 25, 64, 17, -8, -48 },
  { 12729, 32, 49, 32, 2, -49 },
  { 12925, 16, 49, 17, 2, -49 },
  { 13023, 51, 35, 57, 2, -35 },
  { 13247, 32, 36, 38, 2, -36 },
  { 13391, 31, 36, 37, 3, -35 },
  { 13531, 35, 51, 38, -1, -35 },
  { 13755, 33, 51, 38, 3, -35 },
  { 13966, 26, 35, 26, 2, -35 },
  { 14080, 27, 36, 28, 0, -35 },
  { 14202, 21, 44, 22, 3, -43 },
  { 14318, 32, 36, 38, 4, -35 },
  { 14462, 30, 35, 30, 3, -35 },
  { 14594, 45, 35, 47, 4, -35 },
  { 14791, 35, 35, 31, -2, -35 },
  { 14945, 39, 51, 30, -6, -35 },
  { 15194, 30, 35, 29, -1, -35 },
  { 15326, 25, 56, 23, 1, -46 },
  { 15501, 5, 65, 36, 17, -49 },
  { 15542, 24, 56, 23, -2, -46 },
  { 15710, 30, 8, 37, 5, -27 },
};

const GFXfont NotoSans_Italic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic65pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_ITALIC65PT7B_H_
