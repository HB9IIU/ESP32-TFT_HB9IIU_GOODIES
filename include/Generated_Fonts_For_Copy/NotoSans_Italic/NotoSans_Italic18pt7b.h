#ifndef _NOTOSANS_ITALIC18PT7B_H_
#define _NOTOSANS_ITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x63, 0x18, 0x84, 0x22, 0x00, 0xCC, 0x00, 0x4E, 0x77,
  0x29, 0x00, 0x0C, 0xC1, 0x10, 0x22, 0x0C, 0xC7, 0xFE, 0x22, 0x04, 0xC1,
  0x90, 0xFF, 0xC4, 0x41, 0x98, 0x22, 0x04, 0x40, 0x04, 0x04, 0x1F, 0x2D,
  0x68, 0x68, 0x78, 0x1C, 0x1E, 0x12, 0x12, 0x96, 0xFC, 0x30, 0x20, 0x38,
  0x33, 0x61, 0x11, 0x10, 0x89, 0x0C, 0xD8, 0x64, 0xB9, 0x6B, 0x4E, 0xD3,
  0x0D, 0x98, 0x48, 0x84, 0x44, 0x63, 0x66, 0x0E, 0x00, 0x1E, 0x02, 0x60,
  0xC4, 0x18, 0x83, 0x30, 0x38, 0x0E, 0x03, 0x63, 0xC6, 0xD0, 0x72, 0x0C,
  0x63, 0xC7, 0xCC, 0x7E, 0x80, 0x0C, 0x43, 0x08, 0x61, 0x0C, 0x30, 0x82,
  0x08, 0x20, 0x83, 0x0C, 0x10, 0x10, 0xC2, 0x10, 0x84, 0x21, 0x08, 0xC6,
  0x23, 0x31, 0x10, 0x0C, 0x08, 0x88, 0xE8, 0x1F, 0x28, 0xE8, 0x4C, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x36,
  0x6C, 0x7F, 0xC0, 0x78, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x00, 0x1E, 0x19, 0x88, 0x4C, 0x34,
  0x1E, 0x0F, 0x05, 0x82, 0xC3, 0x61, 0xB1, 0x88, 0xC7, 0xC0, 0x1B, 0xF5,
  0x23, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x00, 0x0F, 0x0E, 0x60, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0xFF, 0x00,
  0x0F, 0x1C, 0xC0, 0x20, 0x10, 0x18, 0x18, 0x70, 0x06, 0x01, 0x00, 0x80,
  0x58, 0xEF, 0xE0, 0x01, 0x80, 0xE0, 0x28, 0x16, 0x0D, 0x86, 0x43, 0x11,
  0x8C, 0xC3, 0x3F, 0xF0, 0x20, 0x08, 0x06, 0x00, 0x1F, 0x9F, 0x8C, 0x04,
  0x06, 0x03, 0xE1, 0x98, 0x06, 0x03, 0x01, 0x80, 0x91, 0xCF, 0xC0, 0x0F,
  0x8E, 0x4C, 0x04, 0x06, 0x02, 0xF3, 0x8D, 0x86, 0xC3, 0x61, 0xB0, 0xCC,
  0xC7, 0xC0, 0x7F, 0xBF, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x10, 0x18,
  0x08, 0x0C, 0x0C, 0x0C, 0x00, 0x1F, 0x19, 0x88, 0x64, 0x33, 0x10, 0xF0,
  0xF0, 0xCC, 0xC3, 0x41, 0xB0, 0xD8, 0xC7, 0xC0, 0x1E, 0x33, 0x61, 0x41,
  0x41, 0x43, 0x63, 0x3F, 0x03, 0x02, 0x06, 0x8C, 0xF8, 0x33, 0x20, 0x00,
  0x00, 0x6C, 0x18, 0xC4, 0x00, 0x00, 0x00, 0x33, 0x11, 0x80, 0x00, 0x81,
  0xC3, 0x86, 0x0C, 0x03, 0x80, 0x70, 0x07, 0x00, 0x80, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x38, 0x71, 0xC0,
  0x80, 0x00, 0x3C, 0xCC, 0x08, 0x10, 0x61, 0x86, 0x18, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0xE0, 0x38, 0xC3, 0x01, 0x88, 0x02, 0x47, 0xCF, 0x31,
  0x3C, 0x8C, 0xE6, 0x23, 0x98, 0x8A, 0x66, 0x6C, 0xEF, 0x10, 0x00, 0x60,
  0x00, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0x80, 0xE0, 0x28, 0x1A, 0x04, 0x83,
  0x21, 0x88, 0x63, 0x3F, 0xCC, 0x36, 0x0D, 0x83, 0xC0, 0x40, 0x3F, 0x0F,
  0xE3, 0x0C, 0x83, 0x20, 0x98, 0xE7, 0xE1, 0x8C, 0x41, 0xB0, 0x6C, 0x1B,
  0x1C, 0xFE, 0x00, 0x07, 0xC7, 0x33, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0xC4, 0x3F, 0x00, 0x3F, 0x0F, 0xE3, 0x0C,
  0x83, 0x20, 0x58, 0x16, 0x05, 0x03, 0x40, 0xF0, 0x6C, 0x1B, 0x3C, 0xFC,
  0x00, 0x3F, 0x9F, 0xCC, 0x04, 0x02, 0x03, 0x09, 0xF8, 0xC0, 0x40, 0x60,
  0x30, 0x18, 0x4F, 0xC0, 0x3F, 0x9F, 0xCC, 0x04, 0x02, 0x03, 0x01, 0xF8,
  0xFC, 0x40, 0x60, 0x30, 0x18, 0x08, 0x00, 0x07, 0xC3, 0x9C, 0xC0, 0x30,
  0x06, 0x00, 0x80, 0x30, 0xF6, 0x1E, 0xC0, 0xD8, 0x19, 0x82, 0x38, 0xC3,
  0xF8, 0x30, 0x26, 0x0C, 0xC1, 0x90, 0x32, 0x04, 0xC0, 0x9F, 0xF3, 0x06,
  0x40, 0xD8, 0x13, 0x02, 0x60, 0xC8, 0x18, 0x3E, 0x10, 0x60, 0xC1, 0x02,
  0x0C, 0x18, 0x30, 0x40, 0x83, 0x0F, 0x00, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0xF0, 0x30,
  0xE6, 0x30, 0xCC, 0x11, 0x02, 0x40, 0xD0, 0x1E, 0x03, 0x60, 0x44, 0x18,
  0xC3, 0x18, 0x61, 0x88, 0x30, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20,
  0x41, 0x83, 0x06, 0x1F, 0xC0, 0x38, 0x0C, 0xE0, 0x72, 0x83, 0xCA, 0x0A,
  0x28, 0x69, 0xA1, 0x26, 0x8D, 0x93, 0x26, 0x4D, 0x93, 0x34, 0x4C, 0x73,
  0x31, 0x8C, 0x84, 0x30, 0x30, 0x33, 0x83, 0x38, 0x22, 0x82, 0x2C, 0x66,
  0x46, 0x66, 0x44, 0x64, 0x42, 0x4C, 0x3C, 0xC3, 0xCC, 0x18, 0x81, 0x80,
  0x0F, 0x83, 0x98, 0xC1, 0xB0, 0x16, 0x02, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0D, 0x83, 0x39, 0xC3, 0xF0, 0x3E, 0x1F, 0xCC, 0x64, 0x12, 0x1B,
  0x0D, 0x9C, 0xFC, 0x40, 0x60, 0x30, 0x18, 0x08, 0x00, 0x0F, 0x83, 0x98,
  0xC1, 0xB0, 0x16, 0x02, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x09, 0x83,
  0x39, 0xC3, 0xF0, 0x04, 0x00, 0xC0, 0x0C, 0x3E, 0x1F, 0xCC, 0x64, 0x12,
  0x1B, 0x0D, 0xFC, 0xF8, 0x44, 0x63, 0x30, 0x98, 0x68, 0x30, 0x0F, 0x8C,
  0xCC, 0x06, 0x03, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x01, 0x80, 0xD0, 0xCF,
  0xC0, 0xFF, 0xFF, 0x86, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x00, 0x30, 0x26, 0x0C, 0x81, 0x90, 0x36, 0x04, 0xC0,
  0x98, 0x32, 0x06, 0x40, 0xD8, 0x13, 0x06, 0x31, 0x83, 0xE0, 0x80, 0xE0,
  0x68, 0x13, 0x0C, 0xC2, 0x31, 0x8C, 0x43, 0x30, 0x48, 0x16, 0x05, 0x01,
  0xC0, 0x60, 0x00, 0xC3, 0x07, 0x86, 0x0B, 0x0C, 0x36, 0x28, 0x4C, 0x51,
  0x99, 0xB3, 0x32, 0x64, 0x6C, 0xD8, 0xD1, 0xA1, 0xE3, 0xC3, 0x87, 0x07,
  0x0E, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x86, 0x08, 0xC0, 0xC8, 0x05, 0x80,
  0x70, 0x06, 0x00, 0xF0, 0x0B, 0x01, 0x10, 0x31, 0x86, 0x18, 0xC0, 0xC0,
  0x81, 0xE1, 0xB1, 0x88, 0xC4, 0xC3, 0xC1, 0xC0, 0x60, 0x20, 0x30, 0x18,
  0x0C, 0x04, 0x00, 0x1F, 0xCF, 0xF0, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x0C, 0x06, 0x03, 0x00, 0xFF, 0x00, 0x1E, 0x20, 0x41, 0x83,
  0x06, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x34, 0x70, 0x9B, 0x64,
  0x92, 0x6D, 0x92, 0x1E, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30,
  0x40, 0x83, 0x06, 0x08, 0x70, 0x18, 0x0C, 0x0F, 0x04, 0x86, 0x62, 0x13,
  0x0D, 0x03, 0xFF, 0x99, 0x80, 0x1C, 0x9F, 0xD8, 0xD8, 0x6C, 0x36, 0x1A,
  0x0D, 0x8C, 0xCE, 0x39, 0x00, 0x18, 0x06, 0x01, 0x80, 0x40, 0x13, 0x0F,
  0xE3, 0x88, 0xC3, 0x20, 0x98, 0x26, 0x19, 0x86, 0x73, 0x37, 0x80, 0x1E,
  0x7D, 0x86, 0x0C, 0x18, 0x20, 0x60, 0xC4, 0xF8, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x1D, 0x8F, 0xE6, 0x33, 0x0C, 0xC3, 0x30, 0xC8, 0x33, 0x18, 0xCA,
  0x1C, 0x80, 0x1C, 0x6D, 0x8E, 0x1D, 0xFF, 0x20, 0x60, 0xC4, 0xF8, 0x01,
  0xC0, 0xF0, 0x60, 0x18, 0x0F, 0x07, 0xC0, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x38, 0x00, 0x0E, 0x47,
  0xF3, 0x19, 0x86, 0x61, 0x98, 0x64, 0x19, 0x8C, 0x65, 0x0E, 0xC0, 0x30,
  0x08, 0x86, 0x3F, 0x00, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x31, 0xFC, 0xE2,
  0x61, 0x20, 0xB0, 0xD8, 0x6C, 0x24, 0x16, 0x18, 0x18, 0x80, 0x23, 0x18,
  0x84, 0x63, 0x18, 0x8C, 0x00, 0x06, 0x08, 0x00, 0x20, 0xC1, 0x82, 0x04,
  0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x10, 0xE0, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x19, 0x98, 0xD8, 0x58, 0x28, 0x3E, 0x19, 0x0C, 0xC4, 0x66, 0x18,
  0x18, 0xC6, 0x21, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x60, 0x17, 0x1C, 0x7F,
  0x7C, 0xC3, 0x19, 0x8C, 0x32, 0x18, 0x4C, 0x30, 0x98, 0x43, 0x30, 0x86,
  0x43, 0x0D, 0x86, 0x10, 0x37, 0x1F, 0xCE, 0x26, 0x12, 0x1B, 0x0D, 0x86,
  0xC3, 0x41, 0x61, 0x80, 0x1C, 0x3F, 0x63, 0xC1, 0xC1, 0xC1, 0x83, 0xC2,
  0xC6, 0x7C, 0x13, 0x0F, 0xE3, 0x88, 0xC3, 0x20, 0x98, 0x26, 0x19, 0x86,
  0x73, 0x17, 0x8C, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x1C, 0x9F, 0xD8, 0xD8,
  0x6C, 0x36, 0x1A, 0x0D, 0x8C, 0xCA, 0x3B, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x17, 0x3E, 0x38, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0x1E, 0x7D,
  0x83, 0x03, 0x03, 0x81, 0x03, 0x8D, 0xF0, 0x30, 0x87, 0xFE, 0x61, 0x04,
  0x30, 0xC3, 0x0C, 0x3C, 0x61, 0xB0, 0xD8, 0x48, 0x24, 0x36, 0x1B, 0x0D,
  0x8C, 0xCA, 0x39, 0x00, 0x81, 0xC3, 0xC6, 0xC6, 0xCC, 0xC8, 0x58, 0x50,
  0x70, 0x60, 0xC6, 0x1E, 0x30, 0xB3, 0x8D, 0x94, 0x4D, 0xA6, 0x69, 0x23,
  0x4B, 0x1C, 0x50, 0xE2, 0x87, 0x18, 0x00, 0x30, 0xC6, 0x61, 0x90, 0x2C,
  0x0E, 0x03, 0x01, 0xE0, 0xC8, 0x23, 0x38, 0x40, 0x10, 0x23, 0x0C, 0x63,
  0x0C, 0x61, 0x98, 0x12, 0x02, 0xC0, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x81, 0xE0, 0x00, 0x3F, 0x3F, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60,
  0xC0, 0xFC, 0x06, 0x18, 0x20, 0xC1, 0x82, 0x04, 0x70, 0xE0, 0x40, 0x81,
  0x02, 0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x18, 0x10, 0x60, 0xC1,
  0x02, 0x07, 0x0E, 0x30, 0x40, 0x81, 0x06, 0x18, 0x60, 0x20, 0xFE, 0xE1,
  0xC0,
};

const GFXglyph NotoSans_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 5, 5, 7, 2, -13 },
  { 14, 11, 13, 12, 1, -13 },
  { 32, 8, 15, 10, 1, -14 },
  { 47, 13, 13, 14, 1, -13 },
  { 69, 11, 13, 12, 1, -13 },
  { 87, 2, 5, 4, 2, -13 },
  { 89, 6, 16, 5, 1, -13 },
  { 101, 5, 16, 5, -1, -13 },
  { 111, 8, 9, 10, 2, -14 },
  { 120, 9, 9, 10, 1, -11 },
  { 131, 4, 4, 5, -1, -2 },
  { 133, 5, 2, 6, 0, -6 },
  { 135, 3, 2, 5, 0, -2 },
  { 136, 9, 13, 6, -1, -13 },
  { 151, 9, 13, 10, 1, -13 },
  { 166, 5, 13, 10, 3, -13 },
  { 175, 10, 13, 10, 0, -13 },
  { 192, 9, 13, 10, 0, -13 },
  { 207, 10, 13, 10, 0, -13 },
  { 224, 9, 13, 10, 1, -13 },
  { 239, 9, 13, 10, 1, -13 },
  { 254, 9, 13, 10, 1, -13 },
  { 269, 9, 13, 10, 1, -13 },
  { 284, 8, 13, 10, 1, -13 },
  { 297, 4, 10, 5, 0, -10 },
  { 302, 5, 12, 5, -1, -10 },
  { 310, 9, 9, 10, 1, -11 },
  { 321, 9, 5, 10, 1, -9 },
  { 327, 9, 9, 10, 1, -11 },
  { 338, 7, 13, 8, 1, -13 },
  { 350, 14, 15, 15, 1, -13 },
  { 377, 10, 13, 10, -1, -13 },
  { 394, 10, 13, 11, 1, -13 },
  { 411, 10, 13, 11, 1, -13 },
  { 428, 10, 13, 12, 1, -13 },
  { 445, 9, 13, 9, 1, -13 },
  { 460, 9, 13, 9, 1, -13 },
  { 475, 11, 13, 12, 1, -13 },
  { 493, 11, 13, 12, 1, -13 },
  { 511, 7, 13, 6, 0, -13 },
  { 523, 8, 16, 5, -3, -13 },
  { 539, 11, 13, 10, 1, -13 },
  { 557, 7, 13, 9, 1, -13 },
  { 569, 14, 13, 15, 1, -13 },
  { 592, 12, 13, 13, 1, -13 },
  { 612, 11, 13, 13, 1, -13 },
  { 630, 9, 13, 10, 1, -13 },
  { 645, 11, 16, 13, 1, -13 },
  { 667, 9, 13, 10, 1, -13 },
  { 682, 9, 13, 9, 0, -13 },
  { 697, 9, 13, 9, 2, -13 },
  { 712, 11, 13, 12, 1, -13 },
  { 730, 10, 13, 10, 2, -13 },
  { 747, 15, 13, 15, 2, -13 },
  { 772, 12, 13, 9, -1, -13 },
  { 792, 9, 13, 9, 2, -13 },
  { 807, 10, 13, 10, 0, -13 },
  { 824, 7, 16, 5, 0, -13 },
  { 838, 3, 13, 6, 2, -13 },
  { 843, 7, 16, 5, -1, -13 },
  { 857, 9, 8, 10, 1, -13 },
  { 866, 8, 1, 7, -2, 2 },
  { 867, 3, 3, 5, 3, -14 },
  { 869, 9, 10, 10, 1, -10 },
  { 881, 10, 14, 10, 0, -14 },
  { 899, 7, 10, 8, 1, -10 },
  { 908, 10, 14, 10, 1, -14 },
  { 926, 7, 10, 9, 1, -10 },
  { 935, 10, 18, 6, -2, -14 },
  { 958, 10, 14, 10, 0, -10 },
  { 976, 9, 14, 10, 0, -14 },
  { 992, 5, 13, 5, 0, -13 },
  { 1001, 7, 17, 5, -2, -13 },
  { 1016, 9, 14, 9, 0, -14 },
  { 1032, 5, 14, 5, 0, -14 },
  { 1041, 15, 10, 16, 0, -10 },
  { 1060, 9, 10, 10, 0, -10 },
  { 1072, 8, 10, 10, 1, -10 },
  { 1082, 10, 14, 10, 0, -10 },
  { 1100, 9, 14, 10, 1, -10 },
  { 1116, 8, 10, 7, 0, -10 },
  { 1126, 7, 10, 8, 0, -10 },
  { 1135, 6, 12, 6, 1, -12 },
  { 1144, 9, 10, 10, 1, -10 },
  { 1156, 8, 10, 8, 1, -10 },
  { 1166, 13, 10, 13, 1, -10 },
  { 1183, 10, 10, 9, -1, -10 },
  { 1196, 11, 14, 8, -2, -10 },
  { 1216, 8, 10, 8, 0, -10 },
  { 1226, 7, 16, 6, 0, -13 },
  { 1240, 1, 18, 10, 5, -14 },
  { 1243, 7, 16, 6, -1, -13 },
  { 1257, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_Italic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_ITALIC18PT7B_H_
