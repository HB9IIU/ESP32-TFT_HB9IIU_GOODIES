#ifndef _NOTOSANS_ITALIC63PT7B_H_
#define _NOTOSANS_ITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0xF8, 0x1F, 0x1F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xE0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFD, 0xE3, 0xF0, 0x0F, 0xC3,
  0xC0, 0xC0, 0x3F, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3F, 0x1E, 0x00,
  0x00, 0x3F, 0xBC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF1, 0xFC, 0x00,
  0x01, 0xE1, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF0, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x30, 0x07, 0x87, 0xF0, 0x7C, 0x0F,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x00, 0xF0,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x78, 0x3E,
  0x00, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0xFF,
  0x0F, 0x80, 0xF8, 0x7C, 0x7F, 0xF9, 0xF0, 0x1F, 0x1F, 0x1F, 0xFF, 0x3E,
  0x07, 0xC3, 0xC7, 0xFF, 0xF3, 0xE1, 0xF8, 0xF8, 0xF8, 0x3E, 0x7F, 0xFE,
  0x3E, 0x3E, 0x03, 0xCF, 0xFF, 0x8F, 0x87, 0x80, 0x78, 0xFF, 0xE1, 0xF1,
  0xF0, 0x0F, 0x8F, 0xF8, 0x7C, 0x3E, 0x01, 0xF0, 0x30, 0x1F, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x1F,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x00, 0x7D, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x02, 0x0F, 0xE3, 0xF0, 0x00, 0xF8, 0x3F, 0x83, 0xF0,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0x1F, 0x8F,
  0xC0, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x3E, 0x00, 0x0F,
  0xC3, 0xF0, 0xFC, 0x00, 0x0F, 0xCF, 0xC1, 0xF8, 0x00, 0x0F, 0xFF, 0x83,
  0xF0, 0x00, 0x1F, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x7E,
  0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x80, 0x0F, 0x80, 0x06, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xF8, 0x1E, 0x00, 0x1F, 0xF0, 0xE0, 0x01, 0xFF, 0xE7, 0x00, 0x00, 0xFF,
  0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xC1, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x7F,
  0x03, 0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x38, 0x07,
  0xE0, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0C, 0x3F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7E, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0x7C, 0x7F, 0xCF, 0x9F, 0xE3, 0xF1, 0xF8, 0x7E, 0x1C, 0x0F, 0xC3, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x70,
  0x00, 0x7F, 0x00, 0x10, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x70, 0x00, 0x7F, 0x00,
  0x40, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0xC0, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x00, 0x1F, 0xC0, 0xF0,
  0x00, 0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x20, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x7F, 0xC0, 0x0F, 0xC7, 0xFF, 0x80, 0x3E, 0x7F, 0xFF, 0x81, 0xFB, 0xFF,
  0xFE, 0x07, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x07,
  0xE1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0xF8,
  0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7F, 0x1F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x07, 0xFE, 0x0F, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF, 0x9F, 0x00, 0x7F, 0xFC,
  0xFC, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x80, 0x03,
  0xFC, 0x03, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xC0, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x83, 0xFE, 0x3C, 0x00,
  0xFE, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0xFF, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0xFF, 0xE0, 0x3C, 0x1F, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0x1F, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0x8F, 0x80, 0x7F,
  0x00, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x00, 0x7C, 0x01, 0xF3, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xFB, 0xE0, 0x1F,
  0x00, 0x1F, 0x00, 0x7D, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0xF8, 0x0F,
  0x80, 0x0F, 0x80, 0x1E, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x3C, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0xBE, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xDF, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xCF, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xE7, 0xC0,
  0x7C, 0x00, 0xFC, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xF1, 0xF0,
  0x1F, 0x00, 0x7F, 0x00, 0xF8, 0xF8, 0x0F, 0x80, 0x7F, 0x80, 0xF8, 0x3C,
  0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x1F, 0x01, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F,
  0x80, 0x7F, 0xF8, 0x7F, 0xFC, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03,
  0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0xFE, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x03,
  0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x81, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x7F, 0x80, 0x3F, 0xF0, 0x00, 0xE0, 0x0F, 0xF8, 0x00, 0x04,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xE0,
  0x03, 0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x01,
  0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x03, 0xFE, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0x00, 0x04, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x9F, 0x80, 0x01, 0xFF, 0xF8, 0xFC,
  0x00, 0x0F, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x07, 0xFF,
  0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F,
  0x80, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00,
  0xF8, 0x3F, 0x80, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x07,
  0xDF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0x7C,
  0x00, 0x00, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xF7,
  0xC0, 0x00, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x1F,
  0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xFC, 0x03,
  0xF3, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF8,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x07, 0xC1, 0xE0, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3C,
  0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE3, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xEF, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7B, 0xE0, 0x07, 0xE0, 0x1F,
  0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0x7C, 0x01,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x7E, 0x00, 0x03, 0xF0,
  0x07, 0xCF, 0x80, 0x00, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x87, 0xE0,
  0x01, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x07,
  0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x00, 0x1F,
  0x8F, 0x80, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0xF8,
  0x03, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x00,
  0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x3E, 0x00,
  0x3F, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x3F, 0xC0, 0x3E,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xE3, 0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0x04, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x80, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF7, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x78, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x78, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x7C,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3F, 0x00, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x00,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xFC,
  0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x07, 0xC1,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xE0,
  0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x7E, 0x00, 0x07, 0xC7,
  0xC0, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xCF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3C, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x3D, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01,
  0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0xF8, 0x1F, 0x00, 0x3F, 0xFC, 0x1E, 0x00, 0xFF, 0xFE, 0x1E, 0x01,
  0xFF, 0xFF, 0x3E, 0x03, 0xFE, 0x3F, 0xBE, 0x07, 0xF8, 0x07, 0xFE, 0x07,
  0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0x7E,
  0x00, 0x7F, 0xC0, 0x7E, 0x01, 0xF7, 0xC0, 0x7F, 0x83, 0xE7, 0x80, 0x3F,
  0xFF, 0xC7, 0x80, 0x3F, 0xFF, 0x8F, 0x80, 0x1F, 0xFF, 0x0F, 0x80, 0x07,
  0xFC, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0xF8, 0x7F, 0xF8, 0x03, 0xF1, 0xFF,
  0xF8, 0x07, 0xE7, 0xFF, 0xF8, 0x0F, 0x9F, 0x8F, 0xF0, 0x1F, 0x7C, 0x07,
  0xF0, 0x3F, 0xE0, 0x07, 0xE0, 0xFF, 0x80, 0x0F, 0xC1, 0xFE, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C,
  0x3F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00,
  0x1F, 0xC1, 0xFF, 0x00, 0x7F, 0x03, 0xEF, 0x83, 0xFE, 0x0F, 0x9F, 0xFF,
  0xF8, 0x1F, 0x1F, 0xFF, 0xC0, 0x3E, 0x1F, 0xFF, 0x00, 0x78, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0x81, 0xFE, 0x00,
  0x20, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x08, 0x0F, 0xF0, 0x1E, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0xE1, 0xF0, 0x00, 0xFF, 0xFE,
  0x3E, 0x00, 0x3F, 0xFF, 0xE7, 0xC0, 0x0F, 0xF8, 0xFE, 0xF8, 0x03, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xF8, 0x01, 0xF8, 0x07, 0xDF, 0x00, 0x3F, 0xC1, 0xF7, 0xC0, 0x03,
  0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0xC3, 0xE0,
  0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE1, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x3F, 0x1F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0x81, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x07, 0xF0, 0x00, 0xC0,
  0x7F, 0x80, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xBF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x0F, 0x80, 0x0F, 0xFF, 0x07, 0x80, 0x1F, 0xFF, 0xC3, 0xC0, 0x1F, 0xFF,
  0xF3, 0xE0, 0x1F, 0xF1, 0xFD, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0,
  0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xF8,
  0x07, 0xE0, 0x0F, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x1F, 0xBE,
  0x00, 0x7F, 0xFF, 0x9F, 0x00, 0x3F, 0xFF, 0x8F, 0x80, 0x0F, 0xFF, 0x8F,
  0xC0, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x3F, 0x80, 0x0F, 0xFB,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x0F, 0xF8, 0x00, 0xF8, 0x7F, 0xF8, 0x03, 0xF1,
  0xFF, 0xF8, 0x07, 0xE7, 0xFF, 0xF8, 0x0F, 0x9F, 0x87, 0xF0, 0x1F, 0x7C,
  0x07, 0xF0, 0x3F, 0xE0, 0x07, 0xE0, 0xFF, 0x80, 0x0F, 0xC1, 0xFE, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0xFE, 0x00, 0x3E, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xE0, 0xFE,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x7C, 0xFE, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF7, 0xF0, 0x00,
  0x07, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xCF, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x78,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0x8F, 0xFF, 0xE1, 0xFF, 0xFE, 0x03, 0xE7, 0xE3, 0xF8, 0xFC, 0x7F, 0x80,
  0xFB, 0xC0, 0x7E, 0x7C, 0x07, 0xE0, 0x3F, 0xE0, 0x0F, 0xBC, 0x00, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x0F, 0xC3, 0xFF,
  0xE0, 0x1F, 0x0F, 0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0xC0, 0x7C, 0xFF, 0xFF,
  0xC0, 0xFB, 0xE0, 0x3F, 0x83, 0xFF, 0x80, 0x3F, 0x07, 0xFC, 0x00, 0x7E,
  0x0F, 0xF0, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x0F, 0x07,
  0xFF, 0x80, 0x07, 0xC3, 0xFF, 0xF0, 0x01, 0xF1, 0xFF, 0xFE, 0x00, 0x7C,
  0xFC, 0x7F, 0x80, 0x1F, 0x7C, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xF0,
  0x0F, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xEF, 0x83, 0xFC,
  0x00, 0xFB, 0xFF, 0xFF, 0x00, 0x7E, 0x7F, 0xFF, 0x80, 0x1F, 0x8F, 0xFF,
  0x80, 0x07, 0xC1, 0xFF, 0x80, 0x01, 0xF0, 0x06, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0x00, 0x3F, 0xFC, 0x1E, 0x00, 0xFF, 0xFE, 0x1E, 0x01, 0xFF,
  0xFF, 0x3E, 0x03, 0xFE, 0x1F, 0xBE, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xF0,
  0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x00,
  0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xC0, 0x7F, 0x87, 0xEF, 0x80, 0x3F, 0xFF,
  0xCF, 0x80, 0x3F, 0xFF, 0x8F, 0x80, 0x1F, 0xFF, 0x1F, 0x80, 0x07, 0xFC,
  0x1F, 0x80, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0xF0, 0x7F, 0xC0, 0xF8, 0x7F, 0xC0,
  0x7C, 0x7F, 0xE0, 0x3E, 0x7F, 0xF0, 0x1F, 0x7C, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0x81, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE2, 0x00, 0x03, 0xF0, 0xE0, 0x01, 0xFC, 0x3E,
  0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x04, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xE0,
  0x7C, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0xFF, 0xC0, 0x7E, 0x01, 0xF7, 0xC0,
  0x7F, 0x07, 0xEF, 0x80, 0x7F, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0x8F, 0x80,
  0x1F, 0xFF, 0x0F, 0x80, 0x0F, 0xFC, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x0F, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xEF, 0x80, 0x07, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xCF, 0x80, 0x0F, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x78, 0x01, 0xF8,
  0xF8, 0x01, 0xE7, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x78, 0x03, 0xF0, 0xF8,
  0x03, 0xC7, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x78, 0x07, 0xE0, 0xF8, 0x07,
  0xC7, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x78, 0x0F, 0xC0, 0xF8, 0x0F, 0x87,
  0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x80, 0xF8, 0x1F, 0x07, 0x81,
  0xF0, 0x0F, 0x83, 0xE0, 0x78, 0x3F, 0x00, 0xFC, 0x3E, 0x07, 0xC3, 0xE0,
  0x0F, 0xC3, 0xC0, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x07, 0xC7, 0xE0, 0x0F,
  0xC7, 0x80, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0xC0, 0x07, 0xCF,
  0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x80, 0x07, 0x9F, 0x00,
  0x7D, 0xF0, 0x00, 0x79, 0xE0, 0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x7F,
  0xE0, 0x00, 0x7B, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00,
  0x1E, 0x7E, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xE7, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x04, 0xFF,
  0xFC, 0x00, 0x37, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xEC, 0x00, 0x0F, 0xFF, 0x20, 0x00, 0x07,
  0xF0,
};

const GFXglyph NotoSans_Italic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 46, 16, 1, -45 },
  { 93, 19, 16, 25, 7, -45 },
  { 131, 39, 45, 41, 2, -45 },
  { 351, 31, 52, 35, 2, -48 },
  { 553, 43, 47, 50, 5, -46 },
  { 806, 39, 47, 42, 2, -46 },
  { 1036, 8, 16, 14, 7, -45 },
  { 1052, 20, 55, 18, 3, -45 },
  { 1190, 21, 55, 18, -5, -45 },
  { 1335, 29, 29, 35, 6, -48 },
  { 1441, 30, 30, 36, 4, -37 },
  { 1554, 13, 15, 16, -3, -7 },
  { 1579, 16, 5, 20, 2, -19 },
  { 1589, 8, 9, 16, 1, -8 },
  { 1598, 31, 45, 22, -3, -45 },
  { 1773, 30, 47, 35, 4, -46 },
  { 1950, 19, 45, 35, 9, -45 },
  { 2057, 33, 46, 35, 0, -46 },
  { 2247, 32, 47, 35, 1, -46 },
  { 2435, 34, 45, 35, 0, -45 },
  { 2627, 32, 46, 35, 2, -45 },
  { 2811, 30, 47, 35, 4, -46 },
  { 2988, 30, 45, 35, 5, -45 },
  { 3157, 31, 47, 35, 3, -46 },
  { 3340, 30, 47, 35, 3, -46 },
  { 3517, 13, 36, 16, 1, -35 },
  { 3576, 17, 43, 16, -3, -35 },
  { 3668, 30, 31, 36, 4, -38 },
  { 3785, 29, 17, 36, 5, -31 },
  { 3847, 30, 31, 36, 4, -38 },
  { 3964, 24, 47, 27, 5, -46 },
  { 4105, 49, 51, 53, 3, -45 },
  { 4418, 36, 45, 35, -4, -45 },
  { 4621, 34, 45, 38, 3, -45 },
  { 4813, 35, 47, 37, 5, -46 },
  { 5019, 37, 45, 42, 3, -45 },
  { 5228, 32, 45, 32, 3, -45 },
  { 5408, 32, 45, 30, 3, -45 },
  { 5588, 37, 47, 43, 5, -46 },
  { 5806, 40, 45, 43, 3, -45 },
  { 6031, 25, 45, 20, -1, -45 },
  { 6172, 28, 57, 17, -10, -45 },
  { 6372, 38, 45, 35, 3, -45 },
  { 6586, 23, 45, 30, 3, -45 },
  { 6716, 50, 45, 53, 3, -45 },
  { 6998, 42, 45, 45, 3, -45 },
  { 7235, 38, 47, 45, 5, -46 },
  { 7459, 33, 45, 36, 3, -45 },
  { 7645, 38, 57, 45, 5, -46 },
  { 7916, 33, 45, 36, 3, -45 },
  { 8102, 32, 47, 32, 1, -46 },
  { 8290, 31, 45, 32, 6, -45 },
  { 8465, 38, 46, 43, 5, -45 },
  { 8684, 35, 45, 35, 6, -45 },
  { 8881, 52, 45, 54, 7, -45 },
  { 9174, 41, 45, 33, -3, -45 },
  { 9405, 32, 45, 32, 6, -45 },
  { 9585, 37, 45, 33, -1, -45 },
  { 9794, 24, 55, 18, -1, -45 },
  { 9959, 12, 45, 22, 7, -45 },
  { 10027, 24, 55, 18, -5, -45 },
  { 10192, 32, 28, 36, 2, -45 },
  { 10304, 26, 4, 25, -6, 6 },
  { 10317, 11, 10, 18, 9, -48 },
  { 10331, 32, 35, 36, 3, -34 },
  { 10471, 31, 49, 36, 2, -48 },
  { 10661, 26, 35, 29, 3, -34 },
  { 10775, 35, 49, 36, 3, -48 },
  { 10990, 27, 35, 31, 3, -34 },
  { 11109, 35, 63, 20, -7, -48 },
  { 11385, 33, 49, 36, 2, -34 },
  { 11588, 31, 48, 36, 2, -48 },
  { 11774, 15, 46, 16, 2, -46 },
  { 11861, 25, 61, 16, -8, -46 },
  { 12052, 31, 48, 31, 2, -48 },
  { 12238, 15, 48, 16, 2, -48 },
  { 12328, 50, 34, 55, 2, -34 },
  { 12541, 31, 35, 36, 2, -35 },
  { 12677, 30, 35, 35, 3, -34 },
  { 12809, 34, 49, 36, -1, -34 },
  { 13018, 32, 49, 36, 3, -34 },
  { 13214, 25, 34, 25, 2, -34 },
  { 13321, 26, 35, 27, 0, -34 },
  { 13435, 20, 42, 21, 3, -41 },
  { 13540, 32, 35, 36, 3, -34 },
  { 13680, 29, 34, 29, 3, -34 },
  { 13804, 44, 34, 46, 4, -34 },
  { 13991, 34, 34, 30, -2, -34 },
  { 14136, 38, 49, 29, -6, -34 },
  { 14369, 29, 34, 28, -1, -34 },
  { 14493, 24, 55, 22, 1, -45 },
  { 14658, 5, 63, 35, 16, -48 },
  { 14698, 24, 55, 22, -2, -45 },
  { 14863, 30, 8, 36, 4, -26 },
};

const GFXfont NotoSans_Italic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic63pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_ITALIC63PT7B_H_
