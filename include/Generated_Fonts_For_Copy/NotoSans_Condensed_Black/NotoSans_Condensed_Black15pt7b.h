#ifndef _NOTOSANS_CONDENSED_BLACK15PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB0, 0xDB, 0x00, 0xDF, 0x7D, 0xF7, 0x1B, 0x1A, 0x16,
  0x7F, 0x7F, 0x36, 0xFF, 0xFF, 0x2C, 0x6C, 0x6C, 0x33, 0xFF, 0xFC, 0xF1,
  0xE3, 0xCF, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0xCC, 0x36, 0x61, 0xB2, 0x0D,
  0xB2, 0x3D, 0xF8, 0xDB, 0x60, 0xDB, 0x0C, 0xD8, 0x67, 0x86, 0x1C, 0x1C,
  0x0F, 0x87, 0x61, 0xD8, 0x3E, 0x0F, 0x77, 0xFF, 0xBE, 0xE7, 0x9F, 0xE7,
  0xDC, 0xFF, 0x76, 0xEC, 0xCC, 0xCC, 0xCC, 0xE6, 0x70, 0xE6, 0x73, 0x33,
  0x33, 0x33, 0x76, 0xE0, 0x18, 0xB7, 0xF9, 0xC7, 0xCD, 0xC0, 0x30, 0xC3,
  0x3F, 0xFC, 0xC3, 0x00, 0x76, 0x6E, 0xFF, 0xDF, 0x00, 0x0C, 0x31, 0xC6,
  0x18, 0xC3, 0x1C, 0x61, 0x8E, 0x00, 0x73, 0xEF, 0xF3, 0xCF, 0x3C, 0xF3,
  0xDF, 0xF7, 0x80, 0x19, 0xDF, 0xFD, 0x8C, 0x63, 0x18, 0xC6, 0x39, 0xF9,
  0xBA, 0x70, 0xE3, 0x87, 0x1C, 0x71, 0xFF, 0xF8, 0x3D, 0xFD, 0x38, 0x73,
  0xC7, 0x0F, 0x87, 0x8F, 0xFF, 0xF0, 0x0E, 0x1E, 0x1E, 0x3E, 0x3E, 0x6E,
  0xEE, 0xFF, 0xFF, 0x0E, 0x0E, 0xFF, 0xFF, 0xF0, 0xFB, 0xF1, 0xC3, 0x9F,
  0xFF, 0x80, 0x1E, 0x7D, 0xC3, 0x07, 0xCF, 0xF9, 0xB3, 0x66, 0xFC, 0xF0,
  0xFF, 0xFF, 0xC7, 0x18, 0xE3, 0x8C, 0x71, 0xCE, 0x00, 0x3C, 0xFD, 0x9B,
  0x77, 0xE7, 0x9F, 0xB3, 0xE6, 0xFC, 0xF0, 0x38, 0xF9, 0xBF, 0x3E, 0x6F,
  0xDF, 0x83, 0x0E, 0xF9, 0xE0, 0xDC, 0x01, 0xBE, 0x76, 0x00, 0x00, 0x76,
  0x6E, 0x04, 0x77, 0xB8, 0xF0, 0xF0, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x83,
  0x87, 0x87, 0x7F, 0xCC, 0x00, 0x7B, 0xF4, 0xC3, 0x1C, 0xE3, 0x00, 0x31,
  0xC3, 0x00, 0x1E, 0x07, 0xF1, 0x83, 0x6F, 0xED, 0xB5, 0x66, 0xEC, 0xD5,
  0xBE, 0xDF, 0xD8, 0x01, 0xCC, 0x1F, 0x80, 0x1C, 0x0F, 0x0F, 0x86, 0xC3,
  0x73, 0xB9, 0xDC, 0xFE, 0x7F, 0xF1, 0xF8, 0xE0, 0xF9, 0xFF, 0xBF, 0x7F,
  0xFF, 0xBB, 0xF3, 0xEF, 0xFF, 0xF0, 0x3C, 0xFF, 0xD7, 0x0C, 0x18, 0x30,
  0x70, 0xE2, 0xF8, 0xF0, 0xF8, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xEE, 0xFE, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xE7, 0xFE, 0xFF, 0xFF,
  0xCE, 0x7F, 0xFC, 0xE7, 0x38, 0x3F, 0x7E, 0xF2, 0xE0, 0xC0, 0xCF, 0xCF,
  0xE7, 0xE7, 0x7F, 0x3F, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xFF, 0xCC, 0x63, 0x18, 0xC6, 0x33, 0xFE, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x78, 0xE7, 0xEE, 0xEE, 0xFC, 0xFC,
  0xF8, 0xFC, 0xEC, 0xEE, 0xEE, 0xE7, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF9, 0xFD, 0xBF, 0xB7, 0xF6,
  0xFE, 0xF7, 0xCE, 0xF9, 0xDF, 0x3B, 0x80, 0xE3, 0xF9, 0xFC, 0xFF, 0x7D,
  0xBE, 0xFF, 0x7F, 0x9F, 0xCF, 0xE3, 0xF1, 0xE0, 0x3C, 0x7E, 0xE7, 0xE7,
  0xC3, 0xC3, 0xC3, 0xE3, 0xE7, 0x7F, 0x3E, 0xF9, 0xFB, 0xFF, 0x7E, 0xFF,
  0xFF, 0x70, 0xE1, 0xC3, 0x80, 0x3C, 0x3F, 0x39, 0xDC, 0xEC, 0x36, 0x1B,
  0x0D, 0xC6, 0xE7, 0x3F, 0x8F, 0x81, 0xC0, 0x70, 0x3C, 0xF8, 0xFC, 0xEE,
  0xEE, 0xEE, 0xFC, 0xF8, 0xFC, 0xEE, 0xEE, 0xE7, 0x3C, 0xFD, 0xD3, 0x07,
  0x8F, 0x87, 0x87, 0xCF, 0xFD, 0xF0, 0xFF, 0xFF, 0xF9, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFE, 0x7C, 0xE3, 0xF1, 0xD8, 0xCE, 0xE7, 0x73, 0xB8, 0xD8, 0x6C,
  0x3E, 0x0E, 0x07, 0x00, 0xE7, 0x3F, 0x39, 0xD9, 0xCE, 0xCE, 0x66, 0x7B,
  0x3E, 0xD9, 0xF7, 0xC7, 0xBE, 0x3D, 0xE1, 0xE7, 0x0E, 0x38, 0xE7, 0x33,
  0x9D, 0x87, 0xC3, 0xC0, 0xE0, 0xF0, 0x7C, 0x76, 0x3B, 0xB8, 0xE0, 0xE3,
  0xB3, 0x9D, 0xCE, 0xC3, 0xE1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00,
  0xFF, 0xFF, 0xF8, 0x61, 0xC3, 0x0E, 0x38, 0x71, 0xFF, 0xF8, 0xFF, 0x6D,
  0xB6, 0xDB, 0x6F, 0xC0, 0xC1, 0x86, 0x1C, 0x30, 0xC3, 0x86, 0x18, 0x30,
  0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x18, 0x3C, 0x3C,
  0x6E, 0x66, 0xE7, 0xFF, 0xFF, 0xE3, 0x7E, 0x7C, 0x1B, 0xF6, 0x7C, 0xDF,
  0xBB, 0xC1, 0x83, 0x06, 0xEF, 0xF9, 0xF3, 0xE7, 0xEF, 0xFB, 0x70, 0x7F,
  0xEC, 0x30, 0xC3, 0x1F, 0x9E, 0x0E, 0x1C, 0x3F, 0xFF, 0xF9, 0xF3, 0xE7,
  0xCF, 0xFD, 0xF8, 0x7B, 0xFC, 0xFF, 0xFF, 0x0F, 0xDF, 0x3D, 0xE7, 0x3E,
  0xF9, 0xC7, 0x1C, 0x71, 0xC7, 0x00, 0xFF, 0xFF, 0x3E, 0x7C, 0xF9, 0xFF,
  0xBF, 0x0F, 0xFB, 0xF3, 0x80, 0xC1, 0x83, 0x07, 0xEF, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x38, 0xFC, 0xFF, 0xFF, 0x33, 0x30, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0xF6, 0xC1, 0x83, 0x06, 0x7D, 0xDB, 0x3E, 0x7E, 0xFD, 0x9F, 0x38,
  0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0xBB, 0xE7, 0x7C, 0xEF, 0x9D, 0xF3,
  0xBE, 0x77, 0xFD, 0xFF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0x7D, 0xFB, 0x3E,
  0x7C, 0xF9, 0xFF, 0x3C, 0xDD, 0xFF, 0x3E, 0x7C, 0xFD, 0xFF, 0x6E, 0xC1,
  0x83, 0x06, 0x00, 0xFF, 0xFF, 0x3E, 0x7C, 0xF9, 0xFF, 0xBF, 0x0E, 0x1C,
  0x38, 0x70, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0x7F, 0xBF, 0x1E, 0x3E, 0x3F,
  0xFE, 0x33, 0xBF, 0xF7, 0x39, 0xCE, 0x79, 0xC0, 0xCF, 0x9F, 0x3E, 0x7C,
  0xFD, 0xFF, 0xBB, 0xE7, 0x66, 0x66, 0x7E, 0x3C, 0x3C, 0x3C, 0x38, 0xEF,
  0x76, 0xF6, 0x6F, 0x66, 0xF6, 0x6B, 0xE7, 0xBC, 0x39, 0xC3, 0x9C, 0xE7,
  0x7E, 0x3C, 0x3C, 0x3C, 0x7C, 0x6E, 0xE7, 0xE7, 0x66, 0x66, 0x7E, 0x3C,
  0x3C, 0x3C, 0x18, 0x18, 0x78, 0x70, 0x60, 0xFF, 0xF1, 0x8E, 0x71, 0xCF,
  0xFF, 0x19, 0xCC, 0x63, 0x3B, 0xDE, 0x31, 0x8C, 0x73, 0x84, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE3, 0xC3, 0x0C, 0x30, 0xC3, 0xCF, 0x30, 0xC3, 0x1C, 0xF2,
  0x00, 0x73, 0xFE, 0x78,
};

const GFXglyph NotoSans_Condensed_Black15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 4, 1, -11 },
  { 6, 6, 4, 7, 1, -11 },
  { 9, 8, 11, 9, 0, -11 },
  { 20, 6, 12, 8, 1, -11 },
  { 29, 13, 11, 13, 0, -11 },
  { 47, 10, 11, 10, 0, -11 },
  { 61, 2, 4, 4, 1, -11 },
  { 62, 4, 13, 5, 1, -11 },
  { 69, 4, 13, 5, 0, -11 },
  { 76, 7, 6, 7, 0, -11 },
  { 82, 6, 7, 8, 1, -9 },
  { 88, 4, 4, 4, 0, -2 },
  { 90, 4, 2, 5, 0, -5 },
  { 91, 3, 3, 4, 1, -3 },
  { 93, 6, 11, 6, 0, -11 },
  { 102, 6, 11, 8, 1, -11 },
  { 111, 5, 11, 8, 1, -11 },
  { 118, 7, 11, 8, 0, -11 },
  { 128, 7, 11, 8, 0, -11 },
  { 138, 8, 11, 8, 0, -11 },
  { 149, 6, 11, 8, 1, -11 },
  { 158, 7, 11, 8, 0, -11 },
  { 168, 6, 11, 8, 1, -11 },
  { 177, 7, 11, 8, 0, -11 },
  { 187, 7, 11, 8, 0, -11 },
  { 197, 3, 8, 4, 1, -8 },
  { 200, 4, 10, 4, 0, -8 },
  { 205, 6, 7, 8, 1, -9 },
  { 211, 6, 5, 8, 1, -8 },
  { 215, 6, 7, 8, 1, -9 },
  { 221, 6, 11, 7, 0, -11 },
  { 230, 11, 12, 12, 1, -11 },
  { 247, 9, 11, 9, 0, -11 },
  { 260, 7, 11, 9, 1, -11 },
  { 270, 7, 11, 8, 1, -11 },
  { 280, 8, 11, 9, 1, -11 },
  { 291, 5, 11, 7, 1, -11 },
  { 298, 5, 11, 7, 1, -11 },
  { 305, 8, 11, 10, 1, -11 },
  { 316, 8, 11, 10, 1, -11 },
  { 327, 5, 11, 6, 0, -11 },
  { 334, 5, 14, 5, -1, -11 },
  { 343, 8, 11, 9, 1, -11 },
  { 354, 6, 11, 7, 1, -11 },
  { 363, 11, 11, 13, 1, -11 },
  { 379, 9, 11, 11, 1, -11 },
  { 392, 8, 11, 10, 1, -11 },
  { 403, 7, 11, 8, 1, -11 },
  { 413, 9, 14, 10, 1, -11 },
  { 429, 8, 11, 9, 1, -11 },
  { 440, 7, 11, 7, 0, -11 },
  { 450, 7, 11, 7, 0, -11 },
  { 460, 8, 11, 10, 1, -11 },
  { 471, 9, 11, 9, 0, -11 },
  { 484, 13, 11, 13, 0, -11 },
  { 502, 9, 11, 9, 0, -11 },
  { 515, 9, 11, 9, 0, -11 },
  { 528, 7, 11, 8, 0, -11 },
  { 538, 3, 14, 5, 1, -11 },
  { 544, 6, 11, 6, 0, -11 },
  { 553, 4, 14, 5, 0, -11 },
  { 560, 8, 7, 8, 0, -11 },
  { 567, 8, 2, 8, 0, 1 },
  { 569, 4, 2, 5, 1, -11 },
  { 570, 7, 8, 8, 0, -8 },
  { 577, 7, 11, 8, 1, -11 },
  { 587, 6, 8, 7, 1, -8 },
  { 593, 7, 11, 8, 1, -11 },
  { 603, 6, 8, 8, 1, -8 },
  { 609, 6, 11, 5, 0, -11 },
  { 618, 7, 12, 8, 1, -8 },
  { 629, 7, 11, 9, 1, -11 },
  { 639, 2, 12, 4, 1, -12 },
  { 642, 4, 16, 4, -1, -12 },
  { 650, 7, 11, 8, 1, -11 },
  { 660, 2, 11, 4, 1, -11 },
  { 663, 11, 8, 13, 1, -8 },
  { 674, 7, 8, 9, 1, -8 },
  { 681, 7, 8, 8, 1, -8 },
  { 688, 7, 12, 8, 1, -8 },
  { 699, 7, 12, 8, 1, -8 },
  { 710, 5, 8, 6, 1, -8 },
  { 715, 6, 8, 6, 0, -8 },
  { 721, 5, 10, 6, 0, -10 },
  { 728, 7, 8, 9, 1, -8 },
  { 735, 8, 8, 8, 0, -8 },
  { 743, 12, 8, 12, 0, -8 },
  { 755, 8, 8, 8, 0, -8 },
  { 763, 8, 12, 8, 0, -8 },
  { 775, 6, 8, 6, 0, -8 },
  { 781, 5, 14, 6, 0, -11 },
  { 790, 2, 15, 7, 2, -12 },
  { 794, 6, 14, 6, 0, -11 },
  { 805, 7, 3, 8, 0, -7 },
};

const GFXfont NotoSans_Condensed_Black15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_BLACK15PT7B_H_
