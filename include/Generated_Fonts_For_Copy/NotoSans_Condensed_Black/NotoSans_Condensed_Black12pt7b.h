#ifndef _NOTOSANS_CONDENSED_BLACK12PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black12pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0xC3, 0x60, 0xFF, 0xB9, 0x34, 0x78, 0xB3, 0xF2, 0x9F,
  0xBF, 0x3C, 0x78, 0x11, 0xFD, 0x9C, 0x78, 0x79, 0xDE, 0x30, 0x40, 0x63,
  0x1C, 0x8D, 0x63, 0x58, 0x75, 0xDB, 0xD0, 0xB4, 0x6F, 0x11, 0xC0, 0x38,
  0x7C, 0x6C, 0x7C, 0x7B, 0x7F, 0xCE, 0xFE, 0x7F, 0xFA, 0x36, 0x66, 0x4C,
  0x46, 0x66, 0x30, 0xC6, 0x66, 0x23, 0x36, 0x66, 0xC0, 0x33, 0xEF, 0xDC,
  0x78, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x6D, 0x60, 0xFF, 0xF0, 0x18, 0xC4,
  0x63, 0x31, 0x88, 0xC0, 0x31, 0xE6, 0xFB, 0xEF, 0xB6, 0xDE, 0x78, 0x19,
  0xDF, 0xF1, 0x8C, 0x63, 0x18, 0x33, 0xE5, 0xC6, 0x18, 0xC6, 0x3F, 0xFC,
  0x33, 0xE5, 0xC6, 0x70, 0x70, 0xFF, 0xF8, 0x18, 0x63, 0x9E, 0x7B, 0x6F,
  0xC6, 0x18, 0xF7, 0xB1, 0xCF, 0x1C, 0x7F, 0xF0, 0x19, 0xE6, 0x16, 0xFF,
  0xBE, 0xDF, 0x78, 0xFF, 0xF0, 0xC6, 0x18, 0xE3, 0x0C, 0x60, 0x31, 0xE6,
  0xDE, 0x31, 0xFC, 0xFF, 0x78, 0x31, 0xEE, 0xF3, 0xFD, 0xF0, 0xDE, 0x70,
  0xB8, 0x3C, 0x4D, 0x00, 0xDA, 0xC0, 0x0C, 0xEE, 0x1E, 0x1C, 0x10, 0xFC,
  0x0F, 0xFF, 0xC1, 0xC1, 0xCE, 0xE2, 0x00, 0x77, 0xE6, 0x33, 0x30, 0x0C,
  0x60, 0x0C, 0x1F, 0x99, 0x6B, 0xDD, 0x6E, 0xB5, 0x7E, 0x92, 0x73, 0x0F,
  0x00, 0x38, 0x70, 0xF3, 0x66, 0xCD, 0x9F, 0xF3, 0xC6, 0xE3, 0xED, 0xB6,
  0xF3, 0x6D, 0xFE, 0xF8, 0x37, 0xF3, 0x8C, 0x63, 0x1F, 0x78, 0xE3, 0xED,
  0xF3, 0xCF, 0x3D, 0xFE, 0xF0, 0xFF, 0xCC, 0xFC, 0xCF, 0xF0, 0xFF, 0xCC,
  0xFF, 0xCC, 0xC0, 0x39, 0xFC, 0x70, 0xDF, 0x7C, 0xFF, 0x7C, 0xCF, 0x3C,
  0xF3, 0xFF, 0x3C, 0xF3, 0xCC, 0xFF, 0x66, 0x66, 0x67, 0xF0, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xFC, 0xCF, 0x7D, 0xBC, 0xF3, 0xED, 0xB6, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCF, 0xF0, 0xE3, 0xE7, 0xE7, 0xE5, 0xF7, 0xFF, 0xDF, 0xDB,
  0xDB, 0xC7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xEF, 0xCE, 0x31, 0xFB, 0x36,
  0x6C, 0xF9, 0xF3, 0x7E, 0x78, 0xE7, 0xF7, 0xBF, 0xFB, 0x18, 0xC0, 0x31,
  0xFB, 0x36, 0x6C, 0xF9, 0xF3, 0x7E, 0x78, 0x38, 0x38, 0xE3, 0xED, 0xB6,
  0xFB, 0xCD, 0xB6, 0xCC, 0x39, 0xFE, 0x98, 0x78, 0xE1, 0xFE, 0xF8, 0xFF,
  0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF,
  0x78, 0xC7, 0xCD, 0xBB, 0x66, 0xCD, 0x8F, 0x1C, 0x38, 0xCC, 0xF3, 0x3C,
  0xED, 0xBB, 0x6E, 0xDE, 0xE7, 0xB8, 0xEE, 0x33, 0x80, 0xCE, 0xD9, 0xB1,
  0xC3, 0x87, 0x1F, 0x36, 0xEE, 0xC7, 0xD9, 0xB3, 0xC3, 0x87, 0x0C, 0x18,
  0x30, 0xFF, 0xF1, 0x86, 0x31, 0xC6, 0x3F, 0xFC, 0xFA, 0xAA, 0xAC, 0xC6,
  0x18, 0xC2, 0x18, 0xC3, 0x18, 0xFD, 0xB6, 0xDB, 0x6F, 0x80, 0x10, 0xC3,
  0x9E, 0x4F, 0x30, 0xFC, 0xE3, 0x39, 0xF0, 0xDF, 0xCF, 0xF7, 0xC0, 0xC6,
  0x3D, 0xFD, 0xEF, 0x7F, 0xF8, 0x3B, 0xD9, 0xCE, 0x3D, 0xE0, 0x0C, 0x32,
  0xDF, 0x6F, 0xBE, 0xDF, 0x7C, 0x31, 0xF6, 0xFF, 0xC1, 0xB7, 0xC0, 0x77,
  0x7F, 0x66, 0x66, 0x60, 0x2D, 0xF6, 0xFB, 0xED, 0xF7, 0xC3, 0x7D, 0xE0,
  0xC6, 0x3D, 0xFD, 0xEF, 0x7B, 0xD8, 0xEF, 0xFF, 0xC0, 0x32, 0x33, 0x33,
  0x33, 0x33, 0xFE, 0xC3, 0x0D, 0xF6, 0xF3, 0xCF, 0x36, 0xDC, 0xFF, 0xFF,
  0xC0, 0xB3, 0x7F, 0xB6, 0xFB, 0x3D, 0x9E, 0xCF, 0x66, 0xB7, 0xF7, 0xBD,
  0xEF, 0x60, 0x39, 0xF6, 0xFB, 0xED, 0xF3, 0x80, 0xB7, 0xF7, 0xBD, 0xFF,
  0xF8, 0xC6, 0x00, 0x2D, 0xF6, 0xFB, 0xED, 0xF7, 0xC3, 0x0C, 0x30, 0xBF,
  0xCC, 0xCC, 0xC0, 0x77, 0xF8, 0xE3, 0xFF, 0xC0, 0x67, 0xF6, 0x66, 0x77,
  0xDE, 0xF7, 0xBD, 0xFF, 0xE0, 0xCF, 0x36, 0xDE, 0x78, 0xE3, 0x00, 0xCD,
  0xEE, 0xDF, 0x6F, 0xB7, 0x73, 0xB9, 0xDC, 0xCD, 0xF7, 0x8E, 0x79, 0xEC,
  0xC0, 0xCF, 0x36, 0xDE, 0x78, 0xE3, 0x0C, 0x71, 0x80, 0xFF, 0xCC, 0x66,
  0x7F, 0xE0, 0x13, 0x66, 0x6E, 0xE6, 0x63, 0x30, 0xFF, 0xFF, 0xFF, 0xCE,
  0x66, 0x63, 0x76, 0x6E, 0xE0, 0xFE, 0x70,
};

const GFXglyph NotoSans_Condensed_Black12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 6, 1, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 10, 6, 0, -9 },
  { 23, 10, 9, 10, 0, -9 },
  { 35, 8, 9, 8, 0, -9 },
  { 44, 2, 4, 3, 1, -9 },
  { 45, 4, 11, 4, 0, -9 },
  { 51, 4, 11, 4, 0, -9 },
  { 57, 6, 5, 6, 0, -9 },
  { 61, 6, 6, 6, 0, -7 },
  { 66, 3, 4, 3, 0, -2 },
  { 68, 4, 2, 4, 0, -4 },
  { 69, 2, 2, 3, 1, -2 },
  { 70, 5, 9, 5, 0, -9 },
  { 76, 6, 9, 6, 0, -9 },
  { 83, 5, 9, 6, 0, -9 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 6, 9, 6, 0, -9 },
  { 110, 5, 9, 6, 1, -9 },
  { 116, 6, 9, 6, 0, -9 },
  { 123, 6, 9, 6, 0, -9 },
  { 130, 6, 9, 6, 0, -9 },
  { 137, 6, 9, 6, 0, -9 },
  { 144, 2, 7, 3, 1, -7 },
  { 146, 3, 9, 3, 0, -7 },
  { 150, 6, 6, 6, 0, -7 },
  { 155, 6, 4, 6, 0, -6 },
  { 158, 6, 6, 6, 0, -7 },
  { 163, 5, 9, 5, 0, -9 },
  { 169, 9, 10, 10, 0, -9 },
  { 181, 7, 9, 7, 0, -9 },
  { 189, 6, 9, 7, 1, -9 },
  { 196, 5, 9, 7, 1, -9 },
  { 202, 6, 9, 8, 1, -9 },
  { 209, 4, 9, 6, 1, -9 },
  { 214, 4, 9, 6, 1, -9 },
  { 219, 6, 9, 8, 1, -9 },
  { 226, 6, 9, 8, 1, -9 },
  { 233, 4, 9, 5, 0, -9 },
  { 238, 4, 12, 4, -1, -9 },
  { 244, 6, 9, 7, 1, -9 },
  { 251, 4, 9, 6, 1, -9 },
  { 256, 8, 9, 10, 1, -9 },
  { 265, 7, 9, 9, 1, -9 },
  { 273, 7, 9, 8, 1, -9 },
  { 281, 5, 9, 7, 1, -9 },
  { 287, 7, 11, 8, 1, -9 },
  { 297, 6, 9, 7, 1, -9 },
  { 304, 6, 9, 6, 0, -9 },
  { 311, 6, 9, 6, 0, -9 },
  { 318, 6, 9, 8, 1, -9 },
  { 325, 7, 9, 7, 0, -9 },
  { 333, 10, 9, 11, 0, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 7, 9, 7, 0, -9 },
  { 361, 6, 9, 6, 0, -9 },
  { 368, 2, 11, 4, 1, -9 },
  { 371, 5, 9, 5, 0, -9 },
  { 377, 3, 11, 4, 0, -9 },
  { 382, 6, 6, 6, 0, -9 },
  { 387, 6, 1, 6, 0, 1 },
  { 388, 4, 2, 4, 0, -9 },
  { 389, 6, 7, 6, 0, -7 },
  { 395, 5, 9, 7, 1, -9 },
  { 401, 5, 7, 6, 0, -7 },
  { 406, 6, 9, 7, 0, -9 },
  { 413, 6, 7, 6, 0, -7 },
  { 419, 4, 9, 4, 0, -9 },
  { 424, 6, 10, 7, 0, -7 },
  { 432, 5, 9, 7, 1, -9 },
  { 438, 2, 9, 3, 1, -9 },
  { 441, 4, 12, 3, -1, -9 },
  { 447, 6, 9, 7, 1, -9 },
  { 454, 2, 9, 3, 1, -9 },
  { 457, 9, 7, 10, 1, -7 },
  { 465, 5, 7, 7, 1, -7 },
  { 470, 6, 7, 7, 0, -7 },
  { 476, 5, 10, 7, 1, -7 },
  { 483, 6, 10, 7, 0, -7 },
  { 491, 4, 7, 5, 1, -7 },
  { 495, 5, 7, 5, 0, -7 },
  { 500, 4, 8, 5, 0, -8 },
  { 504, 5, 7, 7, 1, -7 },
  { 509, 6, 7, 6, 0, -7 },
  { 515, 9, 7, 9, 0, -7 },
  { 523, 6, 7, 6, 0, -7 },
  { 529, 6, 10, 6, 0, -7 },
  { 537, 5, 7, 5, 0, -7 },
  { 542, 4, 11, 5, 0, -9 },
  { 548, 2, 12, 5, 2, -9 },
  { 551, 4, 11, 5, 0, -9 },
  { 557, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_Black12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_BLACK12PT7B_H_
