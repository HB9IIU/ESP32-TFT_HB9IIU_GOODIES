#ifndef _NOTOSANS_CONDENSED_BLACK37PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0xFF, 0xFD, 0xF8,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xF7, 0xE3, 0xEF, 0xC7, 0xDF, 0x8F, 0xBF,
  0x1F, 0x7C, 0x3E, 0xF8, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x87, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xF3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x01, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xBC, 0xFD, 0xC2, 0x7E, 0xE0, 0x1F, 0x70, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x77, 0xE0, 0x39, 0xF4, 0x1C, 0xFB, 0x8E, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xFC, 0x03,
  0xE0, 0x1F, 0xF8, 0x1F, 0x00, 0xFF, 0xE0, 0x7C, 0x03, 0xE7, 0xC3, 0xE0,
  0x0F, 0x9F, 0x0F, 0x80, 0x3E, 0x7C, 0x3C, 0x00, 0xF9, 0xF1, 0xF0, 0x03,
  0xE7, 0xC7, 0x80, 0x0F, 0x9F, 0x3E, 0x00, 0x3E, 0x7C, 0xF1, 0xF8, 0xFF,
  0xF7, 0xCF, 0xF1, 0xFF, 0x9F, 0x7F, 0xE7, 0xFE, 0xF9, 0xFF, 0xCF, 0xF3,
  0xE7, 0x9F, 0x0F, 0x1F, 0x3E, 0x7C, 0x00, 0x7C, 0xF9, 0xF0, 0x01, 0xE3,
  0xE3, 0xC0, 0x0F, 0x8F, 0x8F, 0x00, 0x3C, 0x3E, 0x7C, 0x01, 0xF0, 0xF9,
  0xF0, 0x07, 0x81, 0xE7, 0xC0, 0x3E, 0x07, 0xFF, 0x00, 0xF8, 0x1F, 0xF8,
  0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC7,
  0xF0, 0xFF, 0xC3, 0xF0, 0xFF, 0xF3, 0xF8, 0xFF, 0xFD, 0xFC, 0x7E, 0xFF,
  0xFC, 0x7F, 0x3F, 0xFE, 0x3F, 0x8F, 0xFF, 0x1F, 0x87, 0xFF, 0x0F, 0xE1,
  0xFF, 0x87, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3F, 0x1F, 0x87,
  0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F,
  0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x0E, 0x3C, 0x77, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x83, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xF3, 0xF0, 0xF8, 0xF0, 0x18, 0x70, 0x04, 0x20, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFD, 0xFB, 0xFF, 0xFF, 0xCF, 0x80,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF9, 0xFC, 0xFC, 0xFC, 0x7E, 0x7E,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xDF, 0x8F, 0xEF, 0xC7,
  0xF7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x7E, 0xFC, 0xF3, 0xF1, 0x8F, 0xC2,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xF9, 0xE1, 0xFC, 0x60, 0x7E, 0x10, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xF8, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x81,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0xF9,
  0xF8, 0x3E, 0x7E, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0x20, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF1,
  0xFF, 0xF8, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x18, 0x1F, 0x3F,
  0x1F, 0xBF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xEF, 0xC3, 0xF7, 0xE3, 0xFB, 0xF9, 0xFD,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E,
  0x7E, 0x3F, 0x3F, 0xBF, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0x7F, 0x3F, 0x1F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF,
  0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFB, 0xF8, 0xFD, 0xFC, 0x7F, 0xFE, 0x1F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x3F, 0xDF, 0x87, 0xCF, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF0, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0xFD, 0xFF, 0xFF, 0xE7, 0xC0, 0x1C, 0x7E,
  0x7F, 0x7F, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xF3, 0xFF, 0xF7, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xCC, 0x1F, 0x90, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF1, 0xF0, 0x7F, 0x1E, 0x3C, 0x3F,
  0xFB, 0xEF, 0x8F, 0xFE, 0x3D, 0xF3, 0xFF, 0xC7, 0xBC, 0x7C, 0x78, 0xF7,
  0x9F, 0x0F, 0x1F, 0xF3, 0xE1, 0xE3, 0xFE, 0x7C, 0x3C, 0x7F, 0xCF, 0x87,
  0x8F, 0xF9, 0xF1, 0xF1, 0xFF, 0x3E, 0x3E, 0x3F, 0xE7, 0xC7, 0xCF, 0xBC,
  0x7F, 0xFF, 0xE7, 0x8F, 0xFF, 0xF8, 0xF8, 0xFE, 0x7E, 0x0F, 0x03, 0x03,
  0x81, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x03, 0xF8, 0x03, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xFB, 0xFF, 0xF9, 0xFE, 0x0C, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x0B,
  0xFC, 0x39, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xE3, 0xFC, 0xFE, 0x1F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x80, 0x87, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0x7F, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFF, 0xFF, 0xBF,
  0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC,
  0xFE, 0x1F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xBE, 0x1F, 0xFF, 0xF7, 0xC7, 0xDF,
  0xFE, 0xFC, 0xFB, 0xFF, 0xDF, 0x9F, 0x7F, 0xF9, 0xF3, 0xEF, 0xFF, 0x3E,
  0xF9, 0xFF, 0xE7, 0xFF, 0x3F, 0xFC, 0x7F, 0xE7, 0xFF, 0x8F, 0xFC, 0xFF,
  0xF1, 0xFF, 0x1F, 0xFE, 0x3F, 0xE3, 0xFF, 0xC3, 0xFC, 0x7F, 0xF8, 0x7F,
  0x8F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x1F, 0x87, 0xFF,
  0x83, 0xF0, 0xFC, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0x8F, 0xFF, 0x7F, 0x3F,
  0xFC, 0xFC, 0xFF, 0xF3, 0xFB, 0xFF, 0xC7, 0xEF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFC, 0x1F, 0xDF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF7, 0xF0, 0x7F, 0x3F, 0xC7,
  0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x8F, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0x3F, 0xC1, 0xFE, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x0F,
  0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0x7F, 0x07, 0xF1, 0xFE, 0x3F, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0xFE, 0x0F,
  0xE7, 0xE0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8,
  0xFE, 0x1F, 0xCF, 0xE1, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0x03, 0xF0,
  0x0F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE, 0x0E,
  0xFE, 0x02, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xF7,
  0xF9, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0x9F, 0xC0,
  0xFE, 0x7F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xF3, 0xF8, 0x0F,
  0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x7E, 0x07, 0xE0, 0x7F, 0x7E, 0x07,
  0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0x7F, 0x7E, 0x0F, 0xF0, 0x7E, 0x7F, 0x0F,
  0xF0, 0x7E, 0x3F, 0x0F, 0xF0, 0x7E, 0x3F, 0x0F, 0xF8, 0xFE, 0x3F, 0x0F,
  0xF8, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x9F, 0xF8, 0xFC, 0x1F, 0x9F,
  0x78, 0xFC, 0x1F, 0x9F, 0x7D, 0xFC, 0x1F, 0x9F, 0x7D, 0xF8, 0x1F, 0xBE,
  0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x0F, 0xBE, 0x7D, 0xF8, 0x0F, 0xFE,
  0x3D, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07,
  0xF9, 0xFC, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0,
  0x7F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xFB, 0xF8, 0x0F, 0xF0, 0xFE, 0x03,
  0xFB, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xBF, 0x00,
  0xF9, 0xF0, 0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0x7C,
  0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF0, 0xE1, 0xFC, 0x40, 0xFE, 0x00, 0x7F, 0x07, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xF9, 0xF3,
  0xF8, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0xF0, 0xFC, 0xFC, 0x7E, 0xFF, 0x3F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xF7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x7F, 0x9F,
  0x1F, 0x80, 0x01, 0xF0, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xCF,
  0xF7, 0x9F, 0xC1, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xBF, 0x83, 0x7F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x1E, 0x7F,
  0x1F, 0xDF, 0xCF, 0xFB, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0x87, 0xF7, 0xF1, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x3F, 0x3F, 0x03, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF9, 0xFD, 0xF8, 0x7E,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x02, 0x7F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x07, 0xF3, 0xF3,
  0xFE, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F,
  0xFF, 0x87, 0xF7, 0xE1, 0xFD, 0xFC, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFE, 0xFC, 0x7F, 0xFF, 0x0F, 0xDF, 0xC0, 0x07, 0xF0, 0x01, 0xF9, 0x00,
  0x7E, 0x7C, 0x7F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0xF0, 0xFD, 0xFE, 0x7E, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xF0, 0x39, 0xFB, 0xF7, 0xFF, 0xDF, 0x84, 0x00, 0x01, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xC0, 0x03, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0xFC,
  0x1F, 0x80, 0x40, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xCF, 0xF0, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xDF, 0x87, 0xF3, 0xF0, 0xFE,
  0x7E, 0x3F, 0x8F, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0x7F, 0x07, 0xEF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFC, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xFC, 0xFC, 0x3F, 0x9F, 0x83, 0xFB,
  0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x1E, 0x0F, 0x9F, 0xE3, 0xFC, 0xFF, 0xFF, 0x7F,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x3F, 0xC7, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xC1, 0xF8,
  0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF,
  0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F,
  0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F,
  0xFC, 0x1F, 0x87, 0xF0, 0x00, 0x78, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x9F, 0xCF, 0xE7, 0xE1, 0xFD, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF, 0x87, 0xF7, 0xE1, 0xFD, 0xFC,
  0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0x78, 0x7C, 0xFE, 0x3F, 0x7F, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFB, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xBF, 0xCF, 0xCF, 0xC7, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xF3, 0xF3, 0xFE, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87,
  0xF7, 0xE1, 0xFD, 0xFC, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFE, 0xFC,
  0x7F, 0xFF, 0x0F, 0xDF, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x7F, 0xC7, 0xBE, 0x7D, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF,
  0xDF, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0xFF, 0xE7, 0xFF, 0xDF, 0xFE, 0xFF, 0xFB, 0xF0, 0xCF, 0xC0,
  0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F,
  0xE0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x11, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xF3, 0xE3, 0xF1,
  0xF0, 0xFE, 0x07, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF7,
  0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x1F, 0xC1, 0xFB, 0xF0, 0xFF, 0x1F, 0x9F, 0x8F, 0xF8, 0xFC,
  0xFC, 0x7F, 0xC7, 0xE7, 0xE3, 0xFE, 0x3F, 0x1F, 0x9E, 0xF1, 0xF8, 0xFC,
  0xF7, 0x9F, 0x87, 0xEF, 0xBE, 0xFC, 0x3F, 0x7D, 0xF7, 0xE0, 0xFB, 0xEF,
  0xBF, 0x07, 0xDF, 0x7D, 0xF0, 0x3E, 0xF1, 0xEF, 0x81, 0xFF, 0x8F, 0x7C,
  0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFF, 0x0F, 0xEF, 0xE3, 0xF8, 0xFE, 0x7E, 0x1F, 0xDF, 0xC1,
  0xFB, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xEF, 0xC1, 0xFD, 0xFC, 0x3F, 0x9F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F, 0x7F,
  0x07, 0xF0, 0xFE, 0x07, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0x87, 0xE3,
  0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0x8F, 0xF0, 0xFC, 0x0F,
  0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xF8, 0x7F, 0x83,
  0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x08, 0x00, 0xBF, 0xC0, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x03, 0xFC,
};

const GFXglyph NotoSans_Condensed_Black37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 26, 10, 2, -26 },
  { 24, 15, 9, 18, 2, -26 },
  { 41, 20, 26, 21, 1, -26 },
  { 106, 17, 30, 19, 1, -28 },
  { 170, 30, 27, 32, 1, -27 },
  { 272, 25, 27, 26, 1, -27 },
  { 357, 6, 9, 10, 2, -26 },
  { 364, 10, 33, 12, 2, -27 },
  { 406, 11, 33, 12, 0, -27 },
  { 452, 17, 17, 18, 1, -28 },
  { 489, 17, 18, 19, 1, -22 },
  { 528, 8, 10, 11, 1, -5 },
  { 538, 10, 6, 12, 1, -13 },
  { 546, 7, 6, 10, 2, -6 },
  { 552, 16, 27, 16, 0, -27 },
  { 606, 17, 27, 19, 1, -27 },
  { 664, 14, 26, 19, 1, -26 },
  { 710, 17, 27, 19, 1, -27 },
  { 768, 17, 27, 19, 1, -27 },
  { 826, 18, 26, 19, 1, -26 },
  { 885, 16, 26, 19, 2, -26 },
  { 937, 17, 27, 19, 1, -27 },
  { 995, 17, 26, 19, 1, -26 },
  { 1051, 17, 27, 19, 1, -27 },
  { 1109, 17, 27, 19, 1, -27 },
  { 1167, 7, 21, 10, 2, -21 },
  { 1186, 8, 26, 11, 1, -21 },
  { 1212, 17, 19, 19, 1, -23 },
  { 1253, 17, 14, 19, 1, -20 },
  { 1283, 17, 19, 19, 1, -23 },
  { 1324, 15, 27, 16, 0, -27 },
  { 1375, 27, 30, 30, 1, -27 },
  { 1477, 23, 26, 23, 0, -26 },
  { 1552, 18, 26, 22, 2, -26 },
  { 1611, 17, 27, 20, 2, -27 },
  { 1669, 20, 26, 23, 2, -26 },
  { 1734, 14, 26, 18, 2, -26 },
  { 1780, 14, 26, 17, 2, -26 },
  { 1826, 20, 27, 24, 2, -27 },
  { 1894, 20, 26, 24, 2, -26 },
  { 1959, 12, 26, 14, 1, -26 },
  { 1998, 11, 34, 11, -2, -26 },
  { 2045, 20, 26, 22, 2, -26 },
  { 2110, 15, 26, 18, 2, -26 },
  { 2159, 27, 26, 32, 2, -26 },
  { 2247, 22, 26, 26, 2, -26 },
  { 2319, 21, 27, 25, 2, -27 },
  { 2390, 17, 26, 21, 2, -26 },
  { 2446, 22, 33, 25, 2, -27 },
  { 2537, 20, 26, 22, 2, -26 },
  { 2602, 16, 27, 18, 1, -27 },
  { 2656, 17, 26, 18, 1, -26 },
  { 2712, 19, 26, 24, 2, -26 },
  { 2774, 22, 26, 22, 0, -26 },
  { 2846, 32, 26, 33, 0, -26 },
  { 2950, 22, 26, 22, 0, -26 },
  { 3022, 21, 26, 21, 0, -26 },
  { 3091, 17, 26, 19, 1, -26 },
  { 3147, 9, 33, 11, 2, -27 },
  { 3185, 16, 27, 16, 0, -27 },
  { 3239, 9, 33, 11, 1, -27 },
  { 3277, 20, 17, 20, 0, -26 },
  { 3320, 19, 5, 19, 0, 2 },
  { 3332, 11, 6, 13, 1, -28 },
  { 3341, 17, 21, 20, 1, -21 },
  { 3386, 17, 28, 21, 2, -28 },
  { 3446, 15, 21, 17, 1, -21 },
  { 3486, 18, 28, 21, 1, -28 },
  { 3549, 17, 21, 19, 1, -21 },
  { 3594, 14, 28, 13, 0, -28 },
  { 3643, 18, 30, 21, 1, -21 },
  { 3711, 17, 28, 21, 2, -28 },
  { 3771, 7, 29, 10, 2, -29 },
  { 3797, 11, 38, 10, -2, -29 },
  { 3850, 19, 28, 21, 2, -28 },
  { 3917, 6, 28, 10, 2, -28 },
  { 3938, 28, 21, 32, 2, -21 },
  { 4012, 17, 21, 21, 2, -21 },
  { 4057, 18, 21, 20, 1, -21 },
  { 4105, 17, 30, 21, 2, -21 },
  { 4169, 18, 30, 21, 1, -21 },
  { 4237, 13, 21, 15, 2, -21 },
  { 4272, 14, 21, 16, 1, -21 },
  { 4309, 13, 25, 14, 0, -25 },
  { 4350, 17, 20, 21, 2, -20 },
  { 4393, 19, 20, 20, 0, -20 },
  { 4441, 29, 20, 29, 0, -20 },
  { 4514, 19, 20, 19, 0, -20 },
  { 4562, 19, 29, 20, 0, -20 },
  { 4631, 14, 20, 16, 1, -20 },
  { 4666, 12, 33, 14, 1, -27 },
  { 4716, 5, 36, 17, 6, -28 },
  { 4739, 13, 33, 14, 1, -27 },
  { 4793, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_Black37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_BLACK37PT7B_H_
