#ifndef _NOTOSANS_CONDENSED_BLACK36PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x87,
  0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x87, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFD, 0xC6, 0xF9, 0xC0, 0xFD, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xDF, 0x41, 0xDF, 0x71, 0xDF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xF8, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFF, 0x00, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x3F, 0xF8, 0x1E, 0x00,
  0xFB, 0xE0, 0xF8, 0x03, 0xE7, 0xC3, 0xC0, 0x0F, 0x9F, 0x1F, 0x00, 0x3E,
  0x7C, 0x7C, 0x00, 0xF9, 0xF3, 0xE0, 0x03, 0xE7, 0xCF, 0x80, 0x0F, 0x9F,
  0x3C, 0x3C, 0x3E, 0x79, 0xF3, 0xF8, 0x7F, 0xE7, 0x9F, 0xF1, 0xFF, 0x3E,
  0xFF, 0xE3, 0xFC, 0xF3, 0xEF, 0x87, 0xC7, 0xCF, 0x9E, 0x00, 0x1E, 0x3C,
  0x78, 0x00, 0xF8, 0xF1, 0xF0, 0x03, 0xE3, 0xC7, 0xC0, 0x1F, 0x0F, 0x1F,
  0x00, 0x7C, 0x3C, 0x78, 0x01, 0xE0, 0xFB, 0xE0, 0x0F, 0x83, 0xFF, 0x80,
  0x3C, 0x07, 0xFC, 0x01, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xBF, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x1F,
  0xBF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0xFE, 0x3F, 0xF8, 0xFC, 0x7F, 0xFC, 0xFC, 0x7E, 0xFF, 0xFC, 0xFE,
  0xFF, 0xF8, 0xFC, 0x7F, 0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFE,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB,
  0xE0, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x83,
  0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x83,
  0xC2, 0xF3, 0xCE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3E, 0x7C, 0x7E, 0x7E, 0x1C, 0x38, 0x04,
  0x20, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFB, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x7F, 0x1F, 0xBF, 0x8F,
  0xDF, 0xC7, 0xEF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7E, 0xFE,
  0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xF3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFC, 0xFB, 0xF1, 0xCF, 0xC2, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7C, 0xFF, 0x38, 0x7F, 0x20, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0x3F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x38, 0xFF, 0x20,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xBF,
  0x07, 0xDF, 0x87, 0xCF, 0xC3, 0xEF, 0xE3, 0xE7, 0xF1, 0xF3, 0xF9, 0xF1,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xDF,
  0xFF, 0xCC, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0,
  0x00, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x3F, 0x7F, 0x9F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0xFD, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x7F, 0x1F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFE, 0x7E, 0x7F, 0x7E, 0x1F, 0xBF, 0x07, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xFB, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xF3,
  0xFB, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xBE, 0x1F, 0x9F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE3, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFF,
  0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0x3C,
  0x7E, 0x7E, 0x7F, 0x7E, 0x3E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0xF3, 0xFF, 0xF7, 0xFF, 0xE7, 0xFF, 0xEF, 0x1F, 0xC8, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0x81, 0x81, 0xE1, 0xF1,
  0xFF, 0xBE, 0x7C, 0x7F, 0xF3, 0xCF, 0x9F, 0xFE, 0x79, 0xE3, 0xE7, 0xCF,
  0xBC, 0xF8, 0xF9, 0xFF, 0x9F, 0x1F, 0x3F, 0xF3, 0xC3, 0xE7, 0xFE, 0x78,
  0x7C, 0xFF, 0xCF, 0x0F, 0x9E, 0xF9, 0xF1, 0xF3, 0xDF, 0x3E, 0x7E, 0x79,
  0xE7, 0xFF, 0xFE, 0x3C, 0x7F, 0xFF, 0xC7, 0xC7, 0xF7, 0xF0, 0xF8, 0x38,
  0x3C, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x1F, 0xC0, 0x3C, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFC,
  0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0x9F, 0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x8F, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8,
  0xFE, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF3, 0xFC,
  0xF9, 0xFC, 0x09, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x27, 0xF8, 0x73, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0x87,
  0xF7, 0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xEF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0x8F, 0x1F, 0xC0, 0x27, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xF7, 0xF8, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x7F, 0xF0, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF9, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x1F, 0x80, 0xFE, 0x07, 0xFF,
  0xE0, 0xFE, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7D, 0xFF, 0xDF, 0x1F, 0x7F,
  0xF7, 0xC7, 0xFF, 0xFD, 0xF1, 0xEF, 0xFF, 0x7E, 0xFB, 0xFF, 0xCF, 0xBE,
  0xFF, 0xF3, 0xEF, 0xBF, 0xFC, 0xFF, 0xCF, 0xFF, 0x3F, 0xF3, 0xFF, 0xC7,
  0xFC, 0xFF, 0xF1, 0xFF, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0x1F, 0xE3, 0xFF,
  0xC3, 0xF8, 0xFF, 0xF0, 0xFE, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x07, 0xC3,
  0xF0, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFB, 0xF3, 0xFF, 0xDF, 0xDF, 0xFE,
  0x7E, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xDF, 0xFC, 0x7E, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xCF, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x81, 0xFD,
  0xFE, 0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xCF, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xBF, 0x81, 0xFD, 0xFE, 0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFD, 0xFF, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x1F,
  0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x7F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0xC3, 0xF9, 0xF8,
  0x7F, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x3F, 0x87, 0xE7, 0xF0, 0xFE,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0xFE, 0x04, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xF7, 0xF1, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x00, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x7F, 0x03, 0xF1, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1,
  0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8,
  0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFD, 0xF8,
  0x1F, 0x81, 0xFB, 0xF0, 0x7F, 0x03, 0xF7, 0xE0, 0xFE, 0x0F, 0xEF, 0xC1,
  0xFE, 0x1F, 0x9F, 0x83, 0xFC, 0x3F, 0x1F, 0x87, 0xF8, 0x7E, 0x3F, 0x1F,
  0xF0, 0xFC, 0x7E, 0x3F, 0xE3, 0xF8, 0xFC, 0x7F, 0xE7, 0xE1, 0xF8, 0xFF,
  0xCF, 0xC1, 0xF9, 0xEF, 0x9F, 0x83, 0xF7, 0xDF, 0x3F, 0x07, 0xEF, 0x9E,
  0x7E, 0x0F, 0xDF, 0x3D, 0xF8, 0x0F, 0xBE, 0x7F, 0xF0, 0x1F, 0x7C, 0xFF,
  0xE0, 0x3E, 0xF1, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF3, 0xF8,
  0x3F, 0x9F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0,
  0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xBF,
  0x01, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F,
  0x07, 0xF7, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x07,
  0xE7, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF8, 0xFC, 0x1F, 0x9F, 0xC1, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x81, 0xF3, 0xE0,
  0x3E, 0xFC, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x10,
  0x3F, 0x00, 0x3F, 0x01, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0x7F, 0xDF, 0x3F, 0x8F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF9, 0xF0, 0xFD, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xE3, 0xF7, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF,
  0x3E, 0x3E, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF,
  0xCF, 0xE1, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x5F, 0xC1, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0x3F, 0x1F, 0xDF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF3, 0xFB, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7,
  0xC3, 0xF3, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xF7, 0xF3, 0xF0, 0xF9, 0xF8, 0x7D, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x04, 0xFF,
  0x3E, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x80,
  0x3F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xE8, 0x7E, 0x03, 0xF0, 0x3F,
  0xF3, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x8F, 0x8F, 0xE7,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF1, 0xFD, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF7,
  0xE1, 0xF3, 0xF0, 0x01, 0xF8, 0x00, 0xFD, 0x00, 0xFE, 0xFD, 0xFE, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x00, 0x38, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF9, 0xF8, 0xFD, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xE0, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFB, 0xFC, 0x38, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0xFC, 0x3F,
  0xBF, 0x0F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x7F, 0x0F,
  0xDF, 0x83, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFE, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xF0, 0xFE, 0xFC, 0x3F,
  0xBF, 0x07, 0xFF, 0xC1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0xFC, 0x3F, 0x1F, 0x7F, 0xCF, 0xF3, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x9F, 0xFF, 0x8F,
  0xE3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xE0, 0xFF,
  0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E,
  0x0F, 0xFF, 0x0F, 0xC1, 0xFF, 0xE1, 0xF8, 0x3F, 0xFC, 0x3F, 0x07, 0xFF,
  0x87, 0xE0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xF0, 0xF8, 0xFC,
  0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x8F, 0xE7, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0x87,
  0xE7, 0xE1, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xE0, 0xF8, 0xF8, 0x7C, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF7, 0xF1, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0x7F, 0x9F, 0x9F, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x0F, 0x8F, 0x8F, 0xE7, 0xCF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF1, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFD, 0xF8, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF7, 0xE1, 0xF3, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0xF8, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x1F, 0xE0, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFE, 0xF3, 0xF0, 0x4F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x07,
  0xFC, 0x1F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xF7, 0xE3, 0xF1, 0xF0, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE1, 0xFC, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF8, 0xFC, 0x1F, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x1F, 0xC3,
  0xF7, 0xE3, 0xFC, 0x3F, 0x7E, 0x3F, 0xC3, 0xF7, 0xE3, 0xFC, 0x7E, 0x7E,
  0x3F, 0xE7, 0xE7, 0xE3, 0xFE, 0x7E, 0x3F, 0x7F, 0xE7, 0xE3, 0xF7, 0xFE,
  0x7C, 0x3F, 0x7D, 0xE7, 0xC3, 0xF7, 0xDE, 0xFC, 0x1F, 0x79, 0xFF, 0xC1,
  0xF7, 0x9F, 0xFC, 0x1F, 0x79, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x0F, 0xF8,
  0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8,
  0xFC, 0x7E, 0x1F, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F, 0x3F, 0x8F,
  0xE3, 0xF1, 0xF8, 0x7F, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xFF, 0xC1, 0xF9,
  0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE0,
  0xF8, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xC0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xF8,
  0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xFF, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xF1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0x80, 0x3F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFA, 0x00, 0x70,
};

const GFXglyph NotoSans_Condensed_Black36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 26, 10, 1, -26 },
  { 27, 14, 10, 18, 2, -26 },
  { 45, 19, 26, 21, 1, -26 },
  { 107, 16, 29, 19, 1, -27 },
  { 165, 30, 26, 31, 1, -26 },
  { 263, 24, 26, 25, 1, -26 },
  { 341, 6, 10, 10, 2, -26 },
  { 349, 11, 32, 12, 1, -26 },
  { 393, 11, 32, 12, 0, -26 },
  { 437, 16, 16, 18, 1, -27 },
  { 469, 17, 17, 19, 1, -21 },
  { 506, 8, 10, 10, 1, -5 },
  { 516, 10, 5, 12, 1, -12 },
  { 523, 6, 6, 10, 2, -6 },
  { 528, 15, 26, 15, 0, -26 },
  { 577, 17, 26, 19, 1, -26 },
  { 633, 14, 26, 19, 1, -26 },
  { 679, 16, 26, 19, 1, -26 },
  { 731, 16, 26, 19, 1, -26 },
  { 783, 17, 26, 19, 1, -26 },
  { 839, 15, 26, 19, 2, -26 },
  { 888, 17, 26, 19, 1, -26 },
  { 944, 17, 26, 19, 1, -26 },
  { 1000, 17, 26, 19, 1, -26 },
  { 1056, 17, 26, 19, 1, -26 },
  { 1112, 6, 20, 10, 2, -20 },
  { 1127, 8, 25, 10, 1, -20 },
  { 1152, 17, 18, 19, 1, -22 },
  { 1191, 17, 13, 19, 1, -19 },
  { 1219, 17, 18, 19, 1, -22 },
  { 1258, 15, 26, 16, 0, -26 },
  { 1307, 27, 29, 29, 1, -26 },
  { 1405, 22, 26, 22, 0, -26 },
  { 1477, 18, 26, 21, 2, -26 },
  { 1536, 17, 26, 20, 2, -26 },
  { 1592, 19, 26, 23, 2, -26 },
  { 1654, 14, 26, 17, 2, -26 },
  { 1700, 13, 26, 17, 2, -26 },
  { 1743, 19, 26, 23, 2, -26 },
  { 1805, 19, 26, 24, 2, -26 },
  { 1867, 12, 26, 14, 1, -26 },
  { 1906, 11, 34, 11, -2, -26 },
  { 1953, 20, 26, 21, 2, -26 },
  { 2018, 14, 26, 17, 2, -26 },
  { 2064, 26, 26, 31, 2, -26 },
  { 2149, 21, 26, 26, 2, -26 },
  { 2218, 21, 26, 24, 2, -26 },
  { 2287, 17, 26, 20, 2, -26 },
  { 2343, 21, 32, 24, 2, -26 },
  { 2427, 19, 26, 21, 2, -26 },
  { 2489, 16, 26, 18, 1, -26 },
  { 2541, 16, 26, 18, 1, -26 },
  { 2593, 19, 26, 23, 2, -26 },
  { 2655, 22, 26, 22, 0, -26 },
  { 2727, 31, 26, 32, 0, -26 },
  { 2828, 21, 26, 21, 0, -26 },
  { 2897, 20, 26, 20, 0, -26 },
  { 2962, 17, 26, 18, 1, -26 },
  { 3018, 8, 32, 11, 2, -26 },
  { 3050, 15, 26, 15, 0, -26 },
  { 3099, 8, 32, 11, 1, -26 },
  { 3131, 19, 17, 19, 0, -26 },
  { 3172, 18, 5, 18, 0, 2 },
  { 3184, 11, 6, 13, 1, -28 },
  { 3193, 16, 20, 19, 1, -20 },
  { 3233, 17, 27, 20, 2, -27 },
  { 3291, 15, 20, 17, 1, -20 },
  { 3329, 17, 27, 20, 1, -27 },
  { 3387, 17, 20, 19, 1, -20 },
  { 3430, 13, 28, 13, 0, -28 },
  { 3476, 17, 29, 20, 1, -20 },
  { 3538, 17, 27, 21, 2, -27 },
  { 3596, 6, 28, 10, 2, -28 },
  { 3617, 10, 37, 10, -2, -28 },
  { 3664, 18, 27, 20, 2, -27 },
  { 3725, 6, 27, 10, 2, -27 },
  { 3746, 27, 20, 31, 2, -20 },
  { 3814, 17, 20, 21, 2, -20 },
  { 3857, 18, 20, 20, 1, -20 },
  { 3902, 17, 29, 20, 2, -20 },
  { 3964, 17, 29, 20, 1, -20 },
  { 4026, 12, 20, 15, 2, -20 },
  { 4056, 14, 20, 16, 1, -20 },
  { 4091, 13, 24, 14, 0, -24 },
  { 4130, 17, 20, 21, 2, -20 },
  { 4173, 19, 20, 19, 0, -20 },
  { 4221, 28, 20, 28, 0, -20 },
  { 4291, 19, 20, 19, 0, -20 },
  { 4339, 19, 29, 19, 0, -20 },
  { 4408, 14, 20, 15, 1, -20 },
  { 4443, 12, 32, 14, 1, -26 },
  { 4491, 5, 36, 16, 6, -28 },
  { 4514, 12, 32, 14, 1, -26 },
  { 4562, 17, 7, 19, 1, -16 },
};

const GFXfont NotoSans_Condensed_Black36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_BLACK36PT7B_H_
