#ifndef _NOTOSANS_CONDENSED_BLACK11PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black11pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0x24, 0x17, 0xDA, 0xD6, 0x2C, 0xA7, 0xDF, 0x6B, 0xF5, 0x94,
  0x33, 0xF8, 0xE3, 0x95, 0xEE, 0x20, 0x62, 0x7B, 0x3D, 0x1F, 0xF6, 0xA8,
  0xD4, 0x4A, 0x67, 0x38, 0x68, 0x78, 0x38, 0x7E, 0xDE, 0xFC, 0x7F, 0xD4,
  0x36, 0x44, 0xCC, 0x46, 0x63, 0xCD, 0xB6, 0xDB, 0x58, 0x37, 0xCC, 0xF5,
  0x00, 0x31, 0xBF, 0xF3, 0x18, 0x69, 0x60, 0xFC, 0x5C, 0x18, 0x8C, 0x46,
  0x31, 0x18, 0x73, 0xD7, 0xBD, 0xED, 0xEE, 0x1B, 0xFE, 0xB1, 0x8C, 0x63,
  0x77, 0xD6, 0x33, 0x33, 0xFF, 0xF3, 0xC6, 0xE7, 0x8F, 0xFE, 0x18, 0xE3,
  0x9E, 0xDB, 0xF1, 0x86, 0xFF, 0x8F, 0xB3, 0xFE, 0x3B, 0xD1, 0xFF, 0xE5,
  0xEF, 0xFF, 0xC6, 0x33, 0x18, 0xCC, 0x7B, 0xD6, 0xF7, 0xEF, 0x6F, 0x73,
  0xF7, 0xB7, 0x8E, 0xEE, 0xE0, 0xB0, 0x68, 0x06, 0x96, 0x08, 0xDD, 0xE3,
  0x84, 0xFF, 0xC1, 0xF0, 0x87, 0x0E, 0x7E, 0x40, 0xF7, 0xC6, 0x66, 0x01,
  0x8C, 0x1E, 0x63, 0x5D, 0x55, 0xF5, 0xD5, 0x5A, 0x62, 0x1E, 0x38, 0x71,
  0xA3, 0x66, 0xCF, 0xB3, 0x63, 0xF7, 0xF7, 0xEF, 0xEF, 0xFE, 0x3D, 0xE6,
  0x38, 0xC1, 0x87, 0x8E, 0xF7, 0xF7, 0xBD, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFC, 0xCC, 0x3D, 0xF6, 0x3F, 0xDD, 0x97, 0xCF, 0xCF,
  0x3C, 0xFF, 0xFF, 0x3C, 0xF3, 0xF6, 0x66, 0x66, 0x6F, 0x33, 0x33, 0x33,
  0x33, 0x3E, 0xDF, 0x6F, 0x3C, 0xF3, 0xCD, 0xB7, 0xCC, 0xCC, 0xCC, 0xFF,
  0xC7, 0xE7, 0xEF, 0xAF, 0xBB, 0xFB, 0xFB, 0xDB, 0xCF, 0xBE, 0xEF, 0xBE,
  0x79, 0xE3, 0x3C, 0xF9, 0x9F, 0x3E, 0x6C, 0xDF, 0x1E, 0xF7, 0xF7, 0xBF,
  0x63, 0x18, 0x3C, 0xF9, 0x9F, 0x3E, 0x6C, 0xDF, 0x1E, 0x0C, 0x1C, 0xF3,
  0xED, 0xBE, 0xF3, 0xCD, 0xB7, 0x7B, 0xF0, 0xE3, 0x8F, 0xFE, 0xFF, 0xCC,
  0x63, 0x18, 0xC6, 0xDE, 0xF7, 0xBD, 0xEF, 0xEE, 0xCF, 0x99, 0xB3, 0x66,
  0x8F, 0x0E, 0x1C, 0xCC, 0xF3, 0x64, 0xD9, 0xF6, 0x7F, 0x9D, 0xE7, 0x70,
  0xCC, 0xCD, 0xB7, 0x8E, 0x39, 0xE6, 0xF3, 0xCD, 0xB7, 0x9E, 0x30, 0xC3,
  0x0C, 0xFF, 0xC6, 0x63, 0x33, 0xFF, 0xFB, 0x6D, 0xB6, 0xFC, 0xC2, 0x18,
  0xC2, 0x18, 0xC3, 0xED, 0xB6, 0xDB, 0xFC, 0x30, 0xC7, 0x96, 0xCC, 0xFC,
  0xF0, 0x7A, 0xDF, 0xBD, 0xB4, 0x84, 0x2D, 0xB9, 0xCF, 0xF6, 0x7B, 0x71,
  0x86, 0xBC, 0x0C, 0x37, 0xDF, 0xCF, 0x37, 0xDF, 0x7A, 0x7F, 0xF6, 0xBC,
  0x76, 0xF6, 0x66, 0x66, 0x7D, 0xFC, 0xF3, 0x7D, 0xB0, 0x9E, 0x70, 0x84,
  0x2D, 0xBD, 0xCE, 0x73, 0xB2, 0xAA, 0x80, 0x4C, 0x24, 0x92, 0x4B, 0x40,
  0x84, 0x27, 0x6E, 0x7A, 0xD3, 0xFF, 0xF6, 0xFB, 0xDB, 0x9B, 0x9B, 0x9B,
  0xF6, 0xE7, 0x39, 0xCC, 0x79, 0xEC, 0xF3, 0x79, 0xE0, 0xB6, 0xE7, 0x3F,
  0xDA, 0x10, 0x80, 0x7D, 0xFC, 0xF3, 0x7D, 0xB0, 0xC3, 0x0C, 0xBF, 0x49,
  0x00, 0x7D, 0x73, 0xBF, 0x6F, 0x66, 0x67, 0x70, 0x9C, 0xE7, 0x3F, 0xFC,
  0xCD, 0x67, 0x9E, 0x70, 0xC0, 0xDD, 0xEF, 0x97, 0xCE, 0xE7, 0x73, 0xB0,
  0xDD, 0xE7, 0x1C, 0x7B, 0x70, 0xCD, 0x67, 0x9E, 0x30, 0xC3, 0x18, 0x40,
  0xF1, 0x8C, 0xCF, 0xFC, 0x37, 0x66, 0xEE, 0x66, 0x73, 0xFF, 0xC0, 0xCE,
  0x66, 0x77, 0x66, 0xEC, 0x6F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Black11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 5, 3, 5, 0, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 6, 0, -8 },
  { 18, 9, 8, 10, 0, -8 },
  { 27, 8, 8, 8, 0, -8 },
  { 35, 2, 3, 3, 0, -8 },
  { 36, 4, 10, 4, 0, -8 },
  { 41, 3, 10, 4, 0, -8 },
  { 45, 5, 5, 5, 0, -8 },
  { 49, 5, 6, 6, 0, -7 },
  { 53, 3, 4, 3, 0, -2 },
  { 55, 3, 2, 4, 0, -4 },
  { 56, 3, 2, 3, 0, -2 },
  { 57, 5, 8, 5, 0, -8 },
  { 62, 5, 8, 6, 0, -8 },
  { 67, 5, 8, 6, 0, -8 },
  { 72, 5, 8, 6, 0, -8 },
  { 77, 5, 8, 6, 0, -8 },
  { 82, 6, 8, 6, 0, -8 },
  { 88, 4, 8, 6, 1, -8 },
  { 92, 5, 8, 6, 0, -8 },
  { 97, 5, 8, 6, 0, -8 },
  { 102, 5, 8, 6, 0, -8 },
  { 107, 5, 8, 6, 0, -8 },
  { 112, 2, 6, 3, 1, -6 },
  { 114, 3, 8, 3, 0, -6 },
  { 117, 5, 6, 6, 0, -7 },
  { 121, 5, 4, 6, 0, -6 },
  { 124, 5, 6, 6, 0, -7 },
  { 128, 5, 8, 5, 0, -8 },
  { 133, 8, 9, 9, 0, -8 },
  { 142, 7, 8, 7, 0, -8 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 6, 8, 6, 0, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 4, 8, 5, 1, -8 },
  { 169, 4, 8, 5, 1, -8 },
  { 173, 6, 8, 7, 0, -8 },
  { 179, 6, 8, 7, 1, -8 },
  { 185, 4, 8, 4, 0, -8 },
  { 189, 4, 10, 3, -1, -8 },
  { 194, 6, 8, 7, 1, -8 },
  { 200, 4, 8, 5, 1, -8 },
  { 204, 8, 8, 9, 1, -8 },
  { 212, 6, 8, 8, 1, -8 },
  { 218, 7, 8, 7, 0, -8 },
  { 225, 5, 8, 6, 1, -8 },
  { 230, 7, 10, 7, 0, -8 },
  { 239, 6, 8, 6, 1, -8 },
  { 245, 5, 8, 5, 0, -8 },
  { 250, 5, 8, 5, 0, -8 },
  { 255, 5, 8, 7, 1, -8 },
  { 260, 7, 8, 7, 0, -8 },
  { 267, 10, 8, 10, 0, -8 },
  { 277, 6, 8, 6, 0, -8 },
  { 283, 6, 8, 6, 0, -8 },
  { 289, 5, 8, 6, 0, -8 },
  { 294, 3, 10, 3, 0, -8 },
  { 298, 5, 8, 5, 0, -8 },
  { 303, 3, 10, 3, 0, -8 },
  { 307, 6, 5, 6, 0, -8 },
  { 311, 6, 1, 6, 0, 1 },
  { 312, 4, 1, 4, 0, -8 },
  { 313, 5, 6, 6, 0, -6 },
  { 317, 5, 8, 6, 1, -8 },
  { 322, 5, 6, 5, 0, -6 },
  { 326, 6, 8, 6, 0, -8 },
  { 332, 5, 6, 6, 0, -6 },
  { 336, 4, 8, 4, 0, -8 },
  { 340, 6, 9, 6, 0, -6 },
  { 347, 5, 8, 6, 1, -8 },
  { 352, 2, 9, 3, 1, -9 },
  { 355, 3, 12, 3, 0, -9 },
  { 360, 5, 8, 6, 1, -8 },
  { 365, 1, 8, 3, 1, -8 },
  { 366, 8, 6, 9, 1, -6 },
  { 372, 5, 6, 6, 1, -6 },
  { 376, 6, 6, 6, 0, -6 },
  { 381, 5, 9, 6, 1, -6 },
  { 387, 6, 9, 6, 0, -6 },
  { 394, 3, 6, 4, 1, -6 },
  { 397, 4, 6, 5, 0, -6 },
  { 400, 4, 7, 4, 0, -7 },
  { 404, 5, 6, 6, 1, -6 },
  { 408, 6, 6, 6, 0, -6 },
  { 413, 9, 6, 9, 0, -6 },
  { 420, 6, 6, 6, 0, -6 },
  { 425, 6, 9, 6, 0, -6 },
  { 432, 5, 6, 5, 0, -6 },
  { 436, 4, 10, 4, 0, -8 },
  { 441, 1, 10, 5, 2, -8 },
  { 443, 4, 10, 4, 0, -8 },
  { 448, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_Black11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_BLACK11PT7B_H_
