#ifndef _NOTOSANS_CONDENSED_BLACK27PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF0, 0x00, 0xDF, 0xFF,
  0xDE, 0xFB, 0xFF, 0x3F, 0xE7, 0xBC, 0xF7, 0x9E, 0xE3, 0xDC, 0x78, 0x0E,
  0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x73, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07, 0xBC, 0x00, 0x06, 0x00, 0x60,
  0x0F, 0x83, 0xFF, 0x7F, 0xEF, 0xFE, 0xF6, 0x2F, 0x60, 0xFE, 0x0F, 0xE0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x06, 0xF8, 0x6F, 0xF7, 0xFF, 0xFE,
  0xFF, 0xE7, 0xF8, 0x06, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x01, 0xF8,
  0x1E, 0x0F, 0xF0, 0x70, 0x3F, 0xC3, 0xC0, 0xE7, 0x0E, 0x03, 0x9E, 0x78,
  0x0E, 0x79, 0xC0, 0x39, 0xEF, 0x00, 0xE7, 0x38, 0xE3, 0xFD, 0xEF, 0xCF,
  0xF7, 0x3F, 0x9F, 0xBD, 0xEF, 0x08, 0xE7, 0xBC, 0x03, 0x9E, 0xF0, 0x1E,
  0x7B, 0xC0, 0x71, 0xEF, 0x03, 0xC7, 0xBC, 0x0E, 0x0F, 0xE0, 0x78, 0x3F,
  0x81, 0xC0, 0x7C, 0x02, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x7C, 0xF0, 0x1F, 0x3C, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF3, 0xE7, 0xFC, 0xF9, 0xFF, 0x7C, 0xFB, 0xFF, 0x3E, 0xFF, 0xCF, 0x1F,
  0xE3, 0xE3, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0x7F,
  0xFF, 0xFE, 0xF7, 0xB9, 0xC0, 0x1F, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78,
  0x7C, 0x3C, 0x3C, 0x1E, 0x1F, 0xF8, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x78, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x8E, 0x27,
  0xF7, 0x3F, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEF, 0x1F, 0x7C, 0x31,
  0xC0, 0x88, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7B,
  0xDF, 0xFF, 0xFB, 0xDE, 0xFF, 0xFF, 0xFF, 0xF0, 0x37, 0xFF, 0xF7, 0x80,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x06, 0x01, 0xF8, 0x3F, 0xC7, 0xFE,
  0x7F, 0xEF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0x7F, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8,
  0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x7F, 0xFF, 0xF7, 0xBC, 0xCF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x04, 0x03, 0xF8, 0x7F, 0xCF, 0xFE, 0xFF, 0xE6, 0x1F, 0x41, 0xE0, 0x1E,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x07, 0xFC, 0xFF, 0xE7, 0xFE,
  0x77, 0xE4, 0x1F, 0x01, 0xE0, 0x3E, 0x3F, 0xC3, 0xF8, 0x3F, 0xC3, 0xFE,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xFC, 0x3D, 0xF0, 0xE7, 0xC7, 0x9F, 0x3C, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80, 0x7F, 0x07, 0xFC, 0x7F, 0xE7,
  0xFE, 0x23, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFC, 0x7F, 0x80, 0x01, 0xC0, 0xFE, 0x1F, 0xE3, 0xFE, 0x7F, 0x17, 0x80,
  0xF8, 0x0F, 0x38, 0xF7, 0xEF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x9F, 0x7F, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7E, 0x00, 0x02, 0x03, 0xFC, 0x7F, 0xE7, 0xFF, 0xF9, 0xFF, 0x9F, 0xF9,
  0xF7, 0xFE, 0x7F, 0xE3, 0xF8, 0x3F, 0xC7, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0,
  0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x04, 0x03, 0xF8, 0x7F,
  0xC7, 0xFE, 0xFF, 0xEF, 0x9F, 0xF1, 0xFF, 0x1F, 0xF9, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0x3E, 0xF0, 0x8F, 0x01, 0xE0, 0x3E, 0x7F, 0xE7, 0xFC, 0x7F,
  0x87, 0xE0, 0x7F, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFD, 0xE0,
  0x7F, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xF7, 0xBF, 0xFF, 0xF7, 0xBC,
  0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xF7, 0xF8, 0xFE, 0x0F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x0C, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0x0F,
  0xF3, 0xFC, 0xFF, 0x0F, 0xC0, 0xF0, 0x08, 0x00, 0x06, 0x0F, 0xF3, 0xFF,
  0x3F, 0xF7, 0xBE, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C, 0x3C, 0x03,
  0xC7, 0x87, 0x9E, 0x71, 0xFE, 0xE7, 0x3F, 0xEF, 0xF7, 0x9E, 0xFE, 0x79,
  0xE7, 0xE7, 0x1E, 0x7E, 0x71, 0xC7, 0xE7, 0x1C, 0xFE, 0x79, 0xCE, 0xF7,
  0xFF, 0xEF, 0x3F, 0xFC, 0x71, 0xE3, 0x87, 0x80, 0x00, 0x3C, 0x01, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8,
  0x1E, 0x7C, 0x0F, 0x1E, 0x0F, 0x8F, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xFC, 0xF8, 0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xE0,
  0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0xFC, 0x7B, 0xE7, 0xDF,
  0xFE, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xF3, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7,
  0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xE0, 0x01, 0x00, 0x7F, 0xC7, 0xFE,
  0x7F, 0xF7, 0xFF, 0x3E, 0x09, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC2, 0x7F, 0xF1, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF8,
  0xFB, 0xE3, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0xFB, 0xE3, 0xEF, 0x9F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xFE,
  0xFF, 0xBF, 0xEF, 0xFB, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0x8F,
  0xC1, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x07, 0xDF, 0x0F, 0xBF, 0x1F, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xC0, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF7,
  0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xF8, 0x7F, 0xE3, 0xEF, 0x9F, 0xBE, 0x7C,
  0xFB, 0xE3, 0xEF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF8, 0xFB, 0xE3, 0xEF, 0xCF, 0x9F, 0x3E, 0x7E, 0xF8, 0xFB, 0xE3,
  0xEF, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xEF, 0xF7, 0x9D,
  0xFE, 0xF7, 0xBF, 0xDE, 0xF7, 0xF9, 0xDC, 0xFF, 0x3F, 0x9F, 0xE7, 0xF3,
  0xFC, 0xFE, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0xC7,
  0x80, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xE7, 0xFF, 0xCF, 0xF7, 0xDF, 0xEF, 0xBF, 0xCF, 0x7F, 0x9F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xF8, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C,
  0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xFB, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFE,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0x80,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0x7C, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFB, 0xC3, 0xEF,
  0x8F, 0x9F, 0x3E, 0x7C, 0xF9, 0xFB, 0xE3, 0xEF, 0x8F, 0xC0, 0x06, 0x03,
  0xFF, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0x84, 0xF8, 0x0F, 0xC0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x3E, 0x81, 0xFC, 0x3E, 0xFF, 0xEF,
  0xFE, 0xFF, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x8F, 0xBF,
  0xFE, 0x7F, 0xF9, 0xFF, 0xC1, 0xFC, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x3C, 0x1F,
  0xF8, 0x7C, 0x1E, 0x78, 0x7C, 0x3E, 0x78, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E,
  0x7C, 0x7E, 0x3C, 0x3C, 0xFE, 0x3C, 0x3C, 0xFE, 0x7C, 0x3C, 0xFF, 0x7C,
  0x3E, 0xEF, 0x7C, 0x3E, 0xEF, 0x78, 0x1F, 0xE7, 0x78, 0x1F, 0xE7, 0x78,
  0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3E, 0xF8,
  0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7D,
  0xF1, 0xF1, 0xE3, 0xE3, 0xEF, 0x83, 0xDF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xFE, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xEF,
  0x0F, 0x3C, 0x3C, 0x79, 0xE1, 0xE7, 0x83, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x1F, 0xC7, 0xFE, 0x3F,
  0xE3, 0xBF, 0x01, 0xF0, 0x1F, 0x3F, 0xF7, 0xFF, 0xFD, 0xFF, 0x9F, 0xF1,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0x7C, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xEF, 0x9F, 0xFE, 0xFF, 0xF7, 0xFF, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xEF, 0x3E, 0x00, 0x1F, 0xC7, 0xFD, 0xFF, 0x3F, 0xEF,
  0x85, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFF, 0xF7, 0xFE,
  0x7F, 0xC7, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0xFB, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF3,
  0xE7, 0x80, 0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0xDF, 0xF8, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xC6, 0x7F, 0xE3, 0xFE, 0x1F,
  0xE0, 0x07, 0x07, 0xF1, 0xFC, 0xFE, 0x3E, 0x0F, 0x83, 0xFB, 0xFE, 0xFF,
  0xBF, 0xE3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x00, 0x3E, 0x7B, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFC, 0xFB, 0xE0, 0x1F, 0x00, 0xF3, 0x9F, 0x9F, 0xFC, 0xFF,
  0xC7, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xEF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0x80, 0x7F, 0xFE, 0xF3, 0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0x80, 0x1E, 0x7C, 0xF8, 0xF0, 0xC0, 0x0F, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0xFF, 0xFF, 0xFB, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x87, 0xFE, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0xBE, 0x3E,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xF9, 0xF3, 0xE7, 0xCF,
  0x8F, 0xBE, 0x3E, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF3, 0xE3, 0xE7, 0xBF, 0xBF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xCF, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3,
  0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F,
  0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xE0, 0xF3,
  0xE7, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xE0,
  0x1F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3E, 0xFB, 0xE7, 0xFF, 0x1F, 0xF0, 0x7F,
  0x00, 0xF3, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB,
  0xEF, 0x9F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x7B, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0xFB,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF3,
  0xFD, 0xFF, 0xFB, 0xFE, 0xFF, 0xBF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x3F, 0x9F, 0xFF, 0xFB, 0xCE, 0xF8,
  0x3F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFC, 0xFF, 0x1F, 0xC3, 0xF0,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3E, 0xFF, 0xF7, 0xFF, 0xBF, 0xBC, 0xF9,
  0xE0, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0x9F, 0x1E, 0x7C, 0xF8, 0xF3, 0xE3,
  0xCF, 0x0F, 0xBC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0xF8, 0x7B, 0xC7, 0xE7, 0xDE, 0x3F, 0x3E,
  0xF3, 0xF9, 0xE7, 0xDF, 0xCF, 0x3E, 0xEE, 0x78, 0xF7, 0x77, 0xC7, 0xBB,
  0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x00, 0xFC, 0x7D, 0xF3, 0xE3,
  0xCF, 0x8F, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xE0,
  0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x7C, 0xF9, 0xF3, 0xEF, 0x87, 0xC0, 0xF8,
  0x7D, 0xE1, 0xF7, 0x87, 0x9F, 0x1E, 0x3C, 0xF8, 0xF3, 0xE3, 0xEF, 0x07,
  0xBC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x81, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC1, 0xF0,
  0xFC, 0x7F, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE3, 0xF8,
  0xF8, 0x3F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xF0, 0xFC, 0x1F, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x7C, 0x3F, 0x1F, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xC3, 0xF0, 0x78, 0xFC, 0xFC,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC7, 0xE3, 0xF1, 0xF0, 0x80, 0x00,
  0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0,
};

const GFXglyph NotoSans_Condensed_Black27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 11, 7, 13, 1, -19 },
  { 23, 14, 19, 16, 1, -19 },
  { 57, 12, 23, 14, 1, -21 },
  { 92, 22, 20, 24, 1, -20 },
  { 147, 18, 20, 19, 1, -20 },
  { 192, 5, 7, 7, 1, -19 },
  { 197, 8, 24, 9, 1, -20 },
  { 221, 8, 24, 9, 0, -20 },
  { 245, 13, 13, 13, 0, -21 },
  { 267, 12, 13, 14, 1, -16 },
  { 287, 5, 8, 8, 1, -4 },
  { 292, 7, 4, 9, 1, -9 },
  { 296, 5, 5, 8, 1, -5 },
  { 300, 12, 20, 12, 0, -20 },
  { 330, 12, 20, 14, 1, -20 },
  { 360, 10, 19, 14, 1, -19 },
  { 384, 12, 20, 14, 1, -20 },
  { 414, 12, 20, 14, 1, -20 },
  { 444, 14, 19, 14, 0, -19 },
  { 478, 12, 19, 14, 1, -19 },
  { 507, 12, 20, 14, 1, -20 },
  { 537, 12, 19, 14, 1, -19 },
  { 566, 12, 20, 14, 1, -20 },
  { 596, 12, 20, 14, 1, -20 },
  { 626, 5, 15, 8, 1, -15 },
  { 636, 5, 19, 8, 1, -15 },
  { 648, 12, 14, 14, 1, -17 },
  { 669, 12, 9, 14, 1, -14 },
  { 683, 12, 14, 14, 1, -17 },
  { 704, 11, 20, 12, 0, -20 },
  { 732, 20, 22, 22, 1, -20 },
  { 787, 17, 19, 17, 0, -19 },
  { 828, 13, 19, 16, 2, -19 },
  { 859, 13, 20, 15, 1, -20 },
  { 892, 14, 19, 17, 2, -19 },
  { 926, 10, 19, 13, 2, -19 },
  { 950, 10, 19, 13, 2, -19 },
  { 974, 15, 20, 17, 1, -20 },
  { 1012, 14, 19, 18, 2, -19 },
  { 1046, 9, 19, 10, 1, -19 },
  { 1068, 9, 25, 8, -2, -19 },
  { 1097, 14, 19, 16, 2, -19 },
  { 1131, 10, 19, 13, 2, -19 },
  { 1155, 19, 19, 23, 2, -19 },
  { 1201, 15, 19, 19, 2, -19 },
  { 1237, 16, 20, 18, 1, -20 },
  { 1277, 12, 19, 15, 2, -19 },
  { 1306, 16, 25, 18, 1, -20 },
  { 1356, 14, 19, 16, 2, -19 },
  { 1390, 12, 20, 13, 1, -20 },
  { 1420, 12, 19, 13, 1, -19 },
  { 1449, 14, 19, 17, 2, -19 },
  { 1483, 16, 19, 16, 0, -19 },
  { 1521, 24, 19, 24, 0, -19 },
  { 1578, 16, 19, 16, 0, -19 },
  { 1616, 15, 19, 15, 0, -19 },
  { 1652, 12, 19, 14, 1, -19 },
  { 1681, 7, 25, 8, 1, -20 },
  { 1703, 12, 20, 12, 0, -20 },
  { 1733, 6, 25, 8, 1, -20 },
  { 1752, 14, 12, 14, 0, -19 },
  { 1773, 14, 3, 14, 0, 2 },
  { 1779, 8, 5, 10, 1, -21 },
  { 1784, 12, 15, 14, 1, -15 },
  { 1807, 13, 21, 15, 1, -21 },
  { 1842, 11, 15, 13, 1, -15 },
  { 1863, 13, 21, 15, 1, -21 },
  { 1898, 12, 15, 14, 1, -15 },
  { 1921, 10, 21, 10, 0, -21 },
  { 1948, 13, 21, 15, 1, -15 },
  { 1983, 13, 21, 15, 1, -21 },
  { 2018, 5, 21, 8, 1, -21 },
  { 2032, 7, 27, 8, -1, -21 },
  { 2056, 14, 21, 15, 1, -21 },
  { 2093, 5, 21, 8, 1, -21 },
  { 2107, 21, 15, 23, 1, -15 },
  { 2147, 13, 15, 15, 1, -15 },
  { 2172, 13, 15, 15, 1, -15 },
  { 2197, 13, 21, 15, 1, -15 },
  { 2232, 13, 21, 15, 1, -15 },
  { 2267, 10, 15, 11, 1, -15 },
  { 2286, 10, 15, 12, 1, -15 },
  { 2305, 10, 18, 10, 0, -18 },
  { 2328, 13, 15, 15, 1, -15 },
  { 2353, 14, 15, 14, 0, -15 },
  { 2380, 21, 15, 21, 0, -15 },
  { 2420, 14, 15, 14, 0, -15 },
  { 2447, 14, 21, 14, 0, -15 },
  { 2484, 11, 15, 12, 0, -15 },
  { 2505, 10, 25, 10, 0, -20 },
  { 2537, 4, 27, 12, 4, -21 },
  { 2551, 9, 25, 10, 1, -20 },
  { 2580, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_Black27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_BLACK27PT7B_H_
