#ifndef _NOTOSANS_CONDENSED_BLACK69PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF,
  0x3F, 0xF9, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7,
  0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0,
  0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x8F,
  0xFC, 0xFC, 0x1E, 0x3F, 0xF3, 0xF0, 0x18, 0xFF, 0x8F, 0xC0, 0x03, 0xFE,
  0x3F, 0x00, 0x0F, 0xFC, 0xFC, 0x00, 0x3F, 0xFB, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0x7F, 0xF0, 0x00, 0xFC, 0xFF, 0xC0, 0x03, 0xF1, 0xFF, 0x00, 0x0F,
  0xC7, 0xFE, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0xFC, 0xFF, 0xFF, 0x03, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xCF,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xE3, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF1,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F,
  0xE3, 0xFF, 0x1F, 0xF0, 0x3F, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x03,
  0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x07, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE7, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x38, 0x0F, 0xF0, 0x1C, 0x3F, 0x0F, 0xF0, 0x7C, 0x3F, 0xCF, 0xF3,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF,
  0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF3, 0xFF, 0xCF, 0xF8, 0xFF, 0xF1, 0xFC, 0x3F, 0xFC, 0x3E, 0x0F, 0xFF,
  0x07, 0x03, 0xFF, 0xC0, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xFE, 0x0F,
  0xC0, 0x3F, 0xFE, 0x07, 0x80, 0x1F, 0xFE, 0x03, 0x00, 0x1F, 0xFE, 0x02,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0x87,
  0xFF, 0xF0, 0x78, 0x03, 0xFF, 0xE0, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0x9F, 0xFE, 0x00, 0xFF,
  0xC7, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF8, 0x07,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x81,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xBF, 0xF3, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x04, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x7E, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0xE0, 0x7F, 0xF7,
  0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xFE, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8,
  0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xFC,
  0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE,
  0x7F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE,
  0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE,
  0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xFE, 0x1F, 0xFF, 0xE7, 0xFE,
  0x0F, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0x0F, 0xFE,
  0x00, 0x18, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x18, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xFF, 0x3F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xBF, 0xF8, 0xFF, 0x80, 0xF0, 0x01, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF,
  0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF,
  0x87, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0xFE, 0x3E, 0x00, 0xFF, 0xF1,
  0xC0, 0x07, 0xFF, 0x84, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF,
  0xC1, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0xFF, 0xE3, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xC7, 0xFC, 0x0F,
  0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0x9F, 0xE0,
  0xFF, 0xE3, 0xFE, 0x0F, 0xF7, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0xFF,
  0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFB,
  0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x7F, 0x87, 0xFC, 0x07, 0xFC, 0x1F,
  0xEF, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFD, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0x01,
  0xFE, 0x07, 0xFB, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x7F, 0x87, 0xFC,
  0x0F, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF9, 0xFE, 0x0F,
  0xF8, 0x7F, 0xF1, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF0, 0x3F, 0xFF, 0xBF, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00,
  0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x01, 0xFF,
  0xF7, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xFF, 0xEF, 0xFF, 0x81, 0xFF, 0xFB, 0xFF,
  0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xEF,
  0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF,
  0x3F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xF8, 0x3F, 0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFB,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0x83, 0xFF, 0xF0, 0x00, 0xC1, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x08, 0xFF, 0xFC, 0x00, 0x18, 0x7F, 0xFF,
  0x80, 0x7C, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFE,
  0x7F, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x0F, 0xFF, 0xDF, 0xFF, 0x00,
  0x3F, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xBF,
  0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x0F,
  0xFF, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x80,
  0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x07, 0xFF, 0xDF,
  0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F,
  0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF,
  0x80, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF,
  0x80, 0x07, 0x03, 0xFF, 0xF8, 0x00, 0x08, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x1F,
  0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xFF,
  0x00, 0x3F, 0xFC, 0xFF, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0xF8, 0x0F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xFF,
  0x80, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xFF,
  0xE3, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x7F, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80,
  0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xFF, 0xEF,
  0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F,
  0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF,
  0xE0, 0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFC, 0x1F, 0xFB, 0xFF,
  0xFF, 0xF9, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xE3, 0xFE,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFB, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xEF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFB, 0xFF, 0xC1, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xDF, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFF, 0xE3,
  0xFF, 0xF0, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xBF, 0xFE, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x03, 0xFF, 0xEF,
  0xFF, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0xE0,
  0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0xC0,
  0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x9F,
  0xFF, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x07, 0xFF, 0xC7, 0xFF, 0xE0,
  0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x07,
  0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x03,
  0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x7F, 0xFB,
  0xFF, 0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xF7,
  0xFF, 0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x9F, 0xFF, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x07, 0xFF, 0xC7,
  0xFF, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xC7,
  0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF,
  0x8F, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xE0,
  0x0F, 0xFF, 0xDF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x01, 0xF8, 0x7F, 0xF8, 0x00,
  0xE1, 0xFF, 0xE0, 0x00, 0x87, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xF8,
  0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xFE, 0x07, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xDF,
  0xFF, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x03, 0xFF, 0xE7, 0xFF, 0xC0,
  0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF1,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x03,
  0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFD, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xDF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFD, 0xFF,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xDF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF,
  0x0F, 0xFD, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x9F, 0xF0, 0xFF,
  0xE0, 0x07, 0xFF, 0x8F, 0xF9, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xFE, 0x00,
  0x3F, 0xF9, 0xFF, 0x8F, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xF8, 0xFF,
  0x9F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0x8F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF,
  0xDF, 0xF0, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0x07, 0xF9, 0xFF,
  0xC0, 0x01, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x03,
  0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x01, 0xFF, 0xEF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x03, 0xFF, 0xE7,
  0xFF, 0x80, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xC0,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x7F, 0xF9,
  0xFF, 0xF0, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF,
  0xF1, 0xFF, 0xE0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFC, 0x0F, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xDF, 0xF9, 0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0xFC, 0x3F,
  0xE1, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x78, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0xFF, 0xE1, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xF0,
  0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xFE,
  0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE,
  0xFF, 0xFC, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xC3, 0xFF,
  0xE0, 0x08, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x02, 0x7F, 0xFE,
  0x00, 0xE3, 0xFF, 0xF0, 0x7E, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xF0,
  0x3F, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x07, 0xFF,
  0xF7, 0xFF, 0x87, 0xFF, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xBF,
  0xFC, 0x07, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F,
  0xFB, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F,
  0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFB, 0xFF, 0x83, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x07, 0xFE, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0C, 0x3F, 0xFE, 0x00, 0x3C, 0x3F, 0xFF, 0xC3, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFE,
  0x7F, 0xF0, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xDF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0xEF, 0xFF, 0x81, 0xFF, 0xF7, 0xFF,
  0x80, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF,
  0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF,
  0x7F, 0xF8, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF,
  0xEF, 0xFF, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xF1, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE,
  0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFC, 0x03, 0xFE,
  0x1F, 0xFE, 0x00, 0x3C, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC4, 0x00, 0x01, 0xFF, 0xE3, 0xC0,
  0x01, 0xFF, 0xF1, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0x04, 0x03, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE3, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xEC,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x01,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFC,
  0xFF, 0xF0, 0x0F, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0xFF,
  0xF1, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFE, 0x3F,
  0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF,
  0x9F, 0xFE, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x83, 0xFE, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x7F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFD, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF,
  0x9F, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xE0, 0x1F,
  0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F,
  0xF8, 0x07, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF9,
  0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xEF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFC, 0x3F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF,
  0xF8, 0x1F, 0xFE, 0xFF, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xEF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0xE7, 0xFF, 0xE0, 0xFF,
  0xE3, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xE0, 0x3C, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xBF, 0xF8,
  0x7F, 0xFF, 0xDF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x87, 0xFF,
  0xEF, 0xFF, 0x81, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F,
  0xFD, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xBF, 0xFC,
  0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xF7, 0xFF,
  0xC0, 0xFF, 0xFB, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0xF8,
  0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0xFE, 0x1F, 0xFE, 0x00, 0x38, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x5F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0x8F, 0xFE, 0x00, 0xE3, 0xFF,
  0xC0, 0x08, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x87,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE,
  0x3F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xDF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xEF, 0xF0, 0xFF,
  0xE0, 0x3F, 0xF8, 0xFF, 0xBF, 0xC3, 0xFF, 0x80, 0xFF, 0xE3, 0xFC, 0xFF,
  0x8F, 0xFE, 0x03, 0xFF, 0x8F, 0xF3, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x3F, 0xE7, 0xFF, 0x00, 0x7F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xE0,
  0x07, 0xFF, 0x7F, 0xC7, 0xF9, 0xFF, 0x80, 0x1F, 0xFD, 0xFE, 0x1F, 0xF7,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xE1,
  0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F,
  0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xF9,
  0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFE,
  0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF,
  0xEF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F,
  0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0x1F, 0xFE, 0x00, 0x03, 0x3F, 0xFF, 0xC0, 0x07, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x1F,
  0xF0,
};

const GFXglyph NotoSans_Condensed_Black69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 50, 19, 3, -49 },
  { 83, 28, 18, 34, 3, -49 },
  { 146, 38, 49, 40, 1, -49 },
  { 379, 30, 56, 36, 3, -52 },
  { 589, 57, 51, 60, 2, -50 },
  { 953, 46, 51, 48, 2, -50 },
  { 1247, 12, 18, 18, 3, -49 },
  { 1274, 20, 62, 23, 3, -51 },
  { 1429, 19, 62, 23, 1, -51 },
  { 1577, 32, 32, 34, 1, -53 },
  { 1705, 31, 33, 36, 3, -41 },
  { 1833, 14, 20, 20, 2, -10 },
  { 1868, 18, 11, 22, 2, -24 },
  { 1893, 13, 13, 19, 3, -12 },
  { 1915, 30, 51, 30, 0, -50 },
  { 2107, 32, 51, 36, 2, -50 },
  { 2311, 26, 49, 36, 3, -49 },
  { 2471, 32, 50, 36, 1, -50 },
  { 2671, 31, 51, 36, 2, -50 },
  { 2869, 34, 49, 36, 1, -49 },
  { 3078, 30, 50, 36, 3, -49 },
  { 3266, 32, 51, 36, 2, -50 },
  { 3470, 31, 49, 36, 3, -49 },
  { 3660, 32, 51, 36, 2, -50 },
  { 3864, 32, 51, 36, 2, -50 },
  { 4068, 13, 40, 20, 3, -39 },
  { 4133, 14, 49, 20, 2, -39 },
  { 4219, 32, 36, 36, 2, -43 },
  { 4363, 31, 25, 36, 3, -37 },
  { 4460, 31, 36, 36, 3, -43 },
  { 4600, 29, 51, 30, 0, -50 },
  { 4785, 51, 55, 56, 2, -50 },
  { 5136, 43, 49, 43, 0, -49 },
  { 5400, 34, 49, 41, 4, -49 },
  { 5609, 33, 51, 38, 3, -50 },
  { 5820, 37, 49, 44, 4, -49 },
  { 6047, 26, 49, 33, 4, -49 },
  { 6207, 26, 49, 32, 4, -49 },
  { 6367, 37, 51, 44, 3, -50 },
  { 6603, 37, 49, 45, 4, -49 },
  { 6830, 22, 49, 26, 2, -49 },
  { 6965, 22, 64, 21, -5, -49 },
  { 7141, 38, 49, 41, 4, -49 },
  { 7374, 27, 49, 33, 4, -49 },
  { 7540, 51, 49, 59, 4, -49 },
  { 7853, 41, 49, 49, 4, -49 },
  { 8105, 41, 51, 47, 3, -50 },
  { 8367, 32, 49, 38, 4, -49 },
  { 8563, 41, 62, 47, 3, -50 },
  { 8881, 37, 49, 40, 4, -49 },
  { 9108, 30, 51, 34, 2, -50 },
  { 9300, 32, 49, 34, 1, -49 },
  { 9496, 36, 50, 44, 4, -49 },
  { 9721, 41, 49, 41, 0, -49 },
  { 9973, 60, 49, 61, 0, -49 },
  { 10341, 40, 49, 40, 0, -49 },
  { 10586, 39, 49, 39, 0, -49 },
  { 10825, 32, 49, 35, 2, -49 },
  { 11021, 17, 63, 21, 3, -51 },
  { 11155, 29, 51, 30, 0, -50 },
  { 11340, 17, 63, 21, 1, -51 },
  { 11474, 37, 32, 37, 0, -49 },
  { 11622, 35, 9, 35, 0, 4 },
  { 11662, 19, 11, 25, 3, -53 },
  { 11689, 31, 40, 37, 2, -39 },
  { 11844, 32, 53, 39, 4, -52 },
  { 12056, 28, 40, 32, 2, -39 },
  { 12196, 33, 53, 39, 2, -52 },
  { 12415, 32, 40, 36, 2, -39 },
  { 12575, 25, 53, 24, 1, -53 },
  { 12741, 33, 56, 39, 2, -39 },
  { 12972, 32, 52, 39, 4, -52 },
  { 13180, 12, 54, 20, 4, -54 },
  { 13261, 19, 71, 20, -3, -54 },
  { 13430, 35, 52, 39, 4, -52 },
  { 13658, 12, 52, 19, 4, -52 },
  { 13736, 51, 39, 59, 4, -39 },
  { 13985, 32, 39, 39, 4, -39 },
  { 14141, 34, 40, 38, 2, -39 },
  { 14311, 32, 56, 39, 4, -39 },
  { 14535, 33, 56, 39, 2, -39 },
  { 14766, 23, 39, 28, 4, -39 },
  { 14879, 26, 40, 30, 2, -39 },
  { 15009, 24, 47, 27, 1, -46 },
  { 15150, 32, 39, 39, 4, -38 },
  { 15306, 36, 38, 36, 0, -38 },
  { 15477, 54, 38, 54, 0, -38 },
  { 15734, 36, 38, 36, 0, -38 },
  { 15905, 36, 55, 36, 0, -38 },
  { 16153, 27, 38, 30, 1, -38 },
  { 16282, 24, 62, 27, 1, -50 },
  { 16468, 9, 69, 31, 11, -53 },
  { 16546, 23, 62, 27, 2, -50 },
  { 16725, 32, 13, 36, 2, -31 },
};

const GFXfont NotoSans_Condensed_Black69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_BLACK69PT7B_H_
