#ifndef _NOTOSANS_CONDENSED_BLACK64PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0xCF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE3, 0xFC, 0x0F, 0x00,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFE, 0x1F, 0xFB, 0xFF,
  0x07, 0xFE, 0x7F, 0xC1, 0xFF, 0x9F, 0xF0, 0x7F, 0xE7, 0xFC, 0x0F, 0xF9,
  0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F,
  0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xF7, 0xCF, 0xE1, 0xFF, 0x3E, 0x07,
  0x0F, 0xF9, 0xF0, 0x08, 0xFF, 0x8F, 0x80, 0x03, 0xFE, 0x7C, 0x00, 0x1F,
  0xF3, 0xE0, 0x00, 0xFF, 0xDF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0x7C, 0x7F, 0xC0, 0x03, 0xE3,
  0xFE, 0x80, 0x1F, 0x1F, 0xF7, 0x00, 0xF8, 0xFF, 0xBE, 0x07, 0xCF, 0xF9,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0xFF, 0x87, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F,
  0x00, 0xFF, 0x0F, 0xF1, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0x8F, 0xF0,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7,
  0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xE3, 0xFE, 0x7F, 0x81,
  0xFF, 0xE1, 0xFE, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x0F, 0xF1, 0xFF, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x7F,
  0xC3, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0x87,
  0xFF, 0xFF, 0xFD, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x0C, 0x07,
  0xF8, 0x0C, 0x3E, 0x1F, 0xE1, 0xF1, 0xFE, 0x7F, 0x3F, 0xC7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x07, 0xFE,
  0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F,
  0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x87,
  0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFE, 0x3F, 0xC0, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0xFF,
  0xE0, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xF9, 0xFF, 0xC0,
  0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF,
  0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x83, 0xFF, 0x9F, 0xFC,
  0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xE7, 0xFF,
  0x1F, 0xF3, 0xFF, 0x87, 0xF1, 0xFF, 0xC3, 0xF0, 0xFF, 0xE0, 0xF0, 0x7F,
  0xF0, 0x30, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFF, 0x87, 0xF0,
  0x1F, 0xFC, 0x1F, 0x00, 0xFF, 0xF0, 0x60, 0x07, 0xFF, 0x83, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0x80, 0x3F,
  0xFC, 0x10, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xE0,
  0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xE0,
  0x0F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xEF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xE0, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x80, 0x00, 0xFF, 0xEE, 0x00, 0x1F, 0xFE, 0xF8, 0x03,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE3, 0xFE, 0x03, 0xFF, 0x3F, 0xFC, 0x1F, 0xFB, 0xFF, 0xF1, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF3,
  0xFF, 0x87, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0xFF, 0xF3,
  0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF,
  0x03, 0xFF, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFC, 0x3F, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFB, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xBF, 0xFC, 0x1F, 0xFD, 0xFF, 0xC0,
  0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0xFE, 0x3F, 0xFF, 0xBF, 0xF0,
  0xFF, 0xF9, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x01, 0xE0, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x83, 0xFC,
  0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE,
  0x3F, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x7F, 0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xE3, 0xFC, 0x0F, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF9, 0xFF, 0x87, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0xFC, 0x78, 0x03, 0xFF,
  0x8C, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xC0, 0x3F,
  0xC1, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0x83, 0xFC, 0x07, 0xFF, 0xFC, 0x7F,
  0x87, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE,
  0x3F, 0xC1, 0xFF, 0xFF, 0xE1, 0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFD,
  0xFE, 0x0F, 0xF8, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF7,
  0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xEF, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xDF,
  0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xBF, 0xC3,
  0xFE, 0x0F, 0xF8, 0x7F, 0x3F, 0x83, 0xFC, 0x3F, 0xF1, 0xFE, 0x7F, 0x87,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0x03, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xC1, 0xFF, 0xFB, 0xFF, 0x80, 0xFF, 0xF7, 0xFF,
  0x01, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8,
  0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFE, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x01, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE0, 0x0F, 0x0F, 0xFF, 0x00, 0x0C,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x8F, 0xFF, 0x80, 0x0E, 0x3F, 0xFF, 0x81, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF,
  0x80, 0x7F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xEF,
  0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF,
  0xBF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0xFF,
  0xE0, 0x07, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xFB,
  0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x07, 0xFF,
  0xCF, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xFF,
  0xF0, 0x00, 0xE0, 0xFF, 0xF8, 0x00, 0x08, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF8, 0x01, 0xFF,
  0xDF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xF8, 0x07,
  0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x83, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x1F, 0xFE,
  0x7F, 0xF0, 0x07, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F,
  0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC0,
  0x3F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xE7, 0xFF,
  0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC,
  0x7F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x07,
  0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFC,
  0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xCF,
  0xFE, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xDF, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF,
  0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF,
  0xFF, 0xF9, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xF3, 0xFF,
  0xFF, 0xE3, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0x8F, 0xFF,
  0xFF, 0xCF, 0xF8, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFB, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xF7, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xEF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0x9F, 0xFC, 0x3F,
  0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0x9F, 0xFF,
  0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0xFF, 0x83, 0xFF,
  0xBF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x7F,
  0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFF,
  0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F,
  0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0xBF, 0xFC,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFF,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xE0, 0x1F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF3,
  0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF8, 0x0F, 0x8F, 0xFF, 0x00, 0x18, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xEF, 0xC0, 0x1F, 0xFE, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0,
  0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F,
  0xF7, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0xF0, 0x07,
  0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F,
  0xE0, 0x07, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0xE0, 0x03, 0xFF,
  0x3F, 0xE3, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xE3, 0xFC, 0xFF, 0xC0,
  0x03, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC3, 0xFC,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF3, 0xFF,
  0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x8F,
  0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F,
  0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0xF0,
  0x3C, 0x03, 0xFF, 0x80, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xDF, 0xF9, 0xFF, 0xFC, 0x7F, 0xC7, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF, 0x7F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0xBF, 0xFC, 0x1F, 0xFE,
  0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xBF,
  0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F,
  0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xBF, 0xFC, 0x1F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xF9,
  0xFF, 0xF8, 0x3F, 0xE3, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0x87, 0xC7, 0xFF,
  0x80, 0x21, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x5F,
  0xFE, 0x00, 0x27, 0xFF, 0xC0, 0x39, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x03, 0xF8, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC1,
  0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xCF, 0xFC, 0x7F, 0xFF, 0xBF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F,
  0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0,
  0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0x7F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFC, 0x7F, 0xC1,
  0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xDF,
  0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x9F, 0xFE, 0x00,
  0x0C, 0x7F, 0xF8, 0x03, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xC3, 0xFF,
  0xFB, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF,
  0xF7, 0xFF, 0x83, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F,
  0xF7, 0xFF, 0x83, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFB, 0xFF, 0x0F,
  0xFF, 0xEF, 0xFC, 0x3F, 0xFF, 0x7F, 0xF0, 0x7F, 0xF9, 0xFF, 0xC0, 0x7F,
  0xC7, 0xFF, 0x00, 0x30, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x30, 0x00, 0x3F, 0xFC, 0xF8, 0x01, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x1F, 0xF9, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x06, 0x03, 0xFC,
  0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE7, 0xFE,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE,
  0x00, 0x18, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xC7, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0xFF,
  0xCF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xF8,
  0x3F, 0xE3, 0xFF, 0xF1, 0xFF, 0x3F, 0xFF, 0x8F, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xF9, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF,
  0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF8, 0xFF, 0xF8, 0x3F, 0xE7, 0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFE, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF,
  0x00, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0,
  0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF, 0x3F, 0xFE, 0x0F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC0, 0x70, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF0,
  0x7F, 0xFC, 0xFF, 0xC3, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xDF, 0xFC, 0x07,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0,
  0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x83, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0xEF, 0xFC, 0x3F, 0xFF, 0x3F, 0xF0,
  0x7F, 0xF9, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0x00, 0x30, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xF1, 0xF8, 0xFF, 0xC0, 0x38, 0xFF, 0xE0, 0x08,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x10, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFD, 0xFF, 0xE1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xC7, 0xFC, 0x3F,
  0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0x0E, 0x00, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xF9, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0x8F, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE1, 0xFE, 0xFF, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xBF, 0xC7, 0xFE,
  0x03, 0xFF, 0x3F, 0xCF, 0xF1, 0xFF, 0x80, 0xFF, 0xCF, 0xF3, 0xFC, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFC, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0x3F, 0xCF,
  0xFC, 0x01, 0xFF, 0x3F, 0xCF, 0xFB, 0xFF, 0x00, 0x7F, 0xCF, 0xF1, 0xFE,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x7F, 0xBF, 0xE0, 0x07, 0xFF, 0xFE, 0x1F,
  0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x87, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xE1,
  0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x7F, 0xBF, 0xE0, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x9F, 0xFC,
  0x07, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F,
  0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC,
  0x07, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xDF,
  0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF,
  0xE0, 0x00, 0x5F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFD, 0x00,
  0x01, 0xFF, 0x88, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Black64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 47, 18, 3, -46 },
  { 72, 26, 17, 32, 3, -46 },
  { 128, 35, 46, 37, 1, -46 },
  { 330, 29, 53, 33, 2, -49 },
  { 523, 53, 47, 56, 1, -46 },
  { 835, 42, 47, 44, 2, -46 },
  { 1082, 11, 17, 17, 3, -46 },
  { 1106, 18, 57, 22, 3, -47 },
  { 1235, 18, 57, 22, 1, -47 },
  { 1364, 30, 30, 32, 1, -49 },
  { 1477, 29, 31, 34, 2, -38 },
  { 1590, 13, 18, 18, 2, -9 },
  { 1620, 17, 10, 21, 2, -22 },
  { 1642, 12, 12, 18, 3, -11 },
  { 1660, 27, 47, 28, 0, -46 },
  { 1819, 29, 47, 33, 2, -46 },
  { 1990, 25, 46, 33, 2, -46 },
  { 2134, 29, 46, 33, 1, -46 },
  { 2301, 29, 47, 33, 2, -46 },
  { 2472, 32, 46, 33, 1, -46 },
  { 2656, 28, 47, 33, 3, -46 },
  { 2821, 29, 47, 33, 2, -46 },
  { 2992, 29, 46, 33, 2, -46 },
  { 3159, 29, 47, 33, 2, -46 },
  { 3330, 29, 47, 33, 2, -46 },
  { 3501, 12, 37, 18, 3, -36 },
  { 3557, 13, 45, 18, 2, -36 },
  { 3631, 29, 32, 34, 2, -39 },
  { 3747, 29, 23, 34, 2, -34 },
  { 3831, 29, 32, 34, 2, -39 },
  { 3947, 27, 47, 28, 0, -46 },
  { 4106, 47, 51, 52, 2, -46 },
  { 4406, 40, 46, 40, 0, -46 },
  { 4636, 31, 46, 38, 4, -46 },
  { 4815, 30, 47, 35, 3, -46 },
  { 4992, 34, 46, 40, 4, -46 },
  { 5188, 24, 46, 30, 4, -46 },
  { 5326, 24, 46, 30, 4, -46 },
  { 5464, 34, 47, 41, 3, -46 },
  { 5664, 34, 46, 42, 4, -46 },
  { 5860, 21, 46, 24, 2, -46 },
  { 5981, 20, 60, 20, -4, -46 },
  { 6131, 35, 46, 38, 4, -46 },
  { 6333, 25, 46, 30, 4, -46 },
  { 6477, 47, 46, 55, 4, -46 },
  { 6748, 37, 46, 45, 4, -46 },
  { 6961, 37, 47, 43, 3, -46 },
  { 7179, 29, 46, 35, 4, -46 },
  { 7346, 38, 57, 43, 3, -46 },
  { 7617, 34, 46, 37, 4, -46 },
  { 7813, 28, 47, 31, 2, -46 },
  { 7978, 30, 46, 32, 1, -46 },
  { 8151, 33, 47, 41, 4, -46 },
  { 8345, 38, 46, 38, 0, -46 },
  { 8564, 56, 46, 56, 0, -46 },
  { 8886, 37, 46, 37, 0, -46 },
  { 9099, 36, 46, 36, 0, -46 },
  { 9306, 29, 46, 33, 2, -46 },
  { 9473, 16, 58, 20, 3, -47 },
  { 9589, 27, 47, 28, 0, -46 },
  { 9748, 16, 58, 20, 1, -47 },
  { 9864, 34, 30, 34, 0, -46 },
  { 9992, 32, 8, 32, 0, 4 },
  { 10024, 18, 10, 23, 3, -49 },
  { 10047, 29, 37, 34, 2, -36 },
  { 10182, 30, 50, 36, 4, -49 },
  { 10370, 26, 37, 30, 2, -36 },
  { 10491, 30, 50, 36, 2, -49 },
  { 10679, 29, 37, 33, 2, -36 },
  { 10814, 23, 49, 23, 1, -49 },
  { 10955, 30, 51, 36, 2, -36 },
  { 11147, 29, 49, 37, 4, -49 },
  { 11325, 12, 50, 18, 3, -50 },
  { 11400, 18, 65, 18, -3, -50 },
  { 11547, 32, 49, 36, 4, -49 },
  { 11743, 10, 49, 18, 4, -49 },
  { 11805, 47, 36, 55, 4, -36 },
  { 12017, 29, 36, 37, 4, -36 },
  { 12148, 31, 37, 35, 2, -36 },
  { 12292, 30, 51, 36, 4, -36 },
  { 12484, 30, 51, 36, 2, -36 },
  { 12676, 21, 36, 26, 4, -36 },
  { 12771, 24, 37, 28, 2, -36 },
  { 12882, 22, 44, 25, 1, -43 },
  { 13003, 30, 36, 37, 3, -35 },
  { 13138, 34, 35, 34, 0, -35 },
  { 13287, 50, 35, 50, 0, -35 },
  { 13506, 33, 35, 33, 0, -35 },
  { 13651, 34, 50, 34, 0, -35 },
  { 13864, 25, 35, 28, 1, -35 },
  { 13974, 22, 57, 25, 1, -46 },
  { 14131, 9, 63, 29, 10, -49 },
  { 14202, 22, 57, 25, 2, -46 },
  { 14359, 29, 13, 34, 2, -29 },
};

const GFXfont NotoSans_Condensed_Black64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_BLACK64PT7B_H_
