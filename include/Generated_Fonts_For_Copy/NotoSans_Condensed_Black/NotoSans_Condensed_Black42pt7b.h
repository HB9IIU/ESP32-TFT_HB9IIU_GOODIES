#ifndef _NOTOSANS_CONDENSED_BLACK42PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFD, 0xFC,
  0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x9F, 0x0F, 0xC0, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC1, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x83,
  0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x78, 0x4F, 0xDE, 0x03,
  0xF7, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7B,
  0xF0, 0x1E, 0xFE, 0x07, 0xBF, 0xF1, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0xFC, 0x07, 0xC0, 0x0F, 0xFF, 0x81,
  0xF8, 0x01, 0xF9, 0xF0, 0x3E, 0x00, 0x3F, 0x3F, 0x0F, 0xC0, 0x07, 0xC7,
  0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x8F, 0x80, 0x03,
  0xE3, 0xF1, 0xF0, 0x00, 0x7E, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xCF, 0x8F,
  0xE0, 0xFB, 0xF3, 0xF3, 0xFE, 0x1F, 0xFE, 0x7C, 0xFF, 0xE1, 0xFF, 0x9F,
  0x9F, 0xFE, 0x3F, 0xF3, 0xE7, 0xEF, 0xC3, 0xF8, 0xFC, 0xFC, 0xF8, 0x00,
  0x1F, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE3, 0xF0, 0x00, 0xF8, 0x7C, 0x7E,
  0x00, 0x1F, 0x0F, 0x8F, 0xC0, 0x07, 0xE1, 0xF1, 0xF8, 0x00, 0xF8, 0x3E,
  0x3E, 0x00, 0x3F, 0x07, 0xE7, 0xC0, 0x07, 0xC0, 0xFD, 0xF8, 0x01, 0xF8,
  0x0F, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xF0, 0x01,
  0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF1, 0xFE, 0x0F, 0xFE, 0x1F, 0xE1, 0xFF, 0xF1, 0xFC,
  0x3F, 0xFF, 0xBF, 0xC7, 0xFF, 0xFB, 0xFC, 0x7F, 0x3F, 0xFF, 0x8F, 0xF3,
  0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF0, 0xFF, 0x07, 0xFE,
  0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0xE0, 0x7F, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xF9, 0xF0, 0x07,
  0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x04, 0x1F, 0x04, 0xE3, 0xE3, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xEF, 0xC3, 0xF9, 0xFC, 0x3F, 0x1F, 0x81, 0xC3, 0xC0,
  0x18, 0x20, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC,
  0x7E, 0x3F, 0x3F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xE7, 0xF3, 0xF8,
  0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xEF, 0xE1,
  0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3,
  0xF9, 0xFC, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0xFF, 0x3C, 0xFF, 0x18, 0xFF, 0x10, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0x8F, 0xF1, 0xC0,
  0xFE, 0x10, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x86, 0x07, 0xF0, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x1F, 0xBF, 0x81, 0xF3, 0xF8, 0x3F, 0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F,
  0x8F, 0xC3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xEE, 0x01, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFB, 0xFF, 0xFE, 0x39, 0xFF, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x3E, 0x07, 0xE7, 0xF8, 0x7E,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x9F, 0xEF,
  0xF0, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF,
  0x7F, 0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF9, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x0F, 0xE7, 0xF9, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0x9F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x1F,
  0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xF7, 0xF1, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0x7E, 0x1F, 0xE7, 0xE0, 0x7C, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x08, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x04,
  0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF3, 0xFB, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0x83,
  0xFC, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x81, 0xF8,
  0x7E, 0x7E, 0x1F, 0xFC, 0xF9, 0xF0, 0xFF, 0xF1, 0xF7, 0xC7, 0xFF, 0xC7,
  0xFE, 0x3F, 0x9F, 0x1F, 0xF8, 0xFC, 0x7C, 0x7F, 0xE3, 0xE1, 0xF1, 0xFF,
  0x9F, 0x87, 0xC7, 0xFE, 0x7E, 0x1F, 0x1F, 0xF9, 0xF0, 0x7C, 0x7F, 0xE7,
  0xC1, 0xF1, 0xFF, 0x9F, 0x87, 0xC7, 0xFE, 0x7E, 0x3F, 0x1F, 0xF8, 0xF8,
  0xFC, 0xFB, 0xE3, 0xFF, 0xFF, 0xEF, 0x87, 0xFD, 0xFF, 0x3F, 0x1F, 0xF7,
  0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x40, 0x1F, 0xF0, 0x1F, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7,
  0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x1F, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xE3, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE3, 0xFE, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xC1, 0xC7, 0xF8, 0x04,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x27, 0xFC, 0x0E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xE3, 0xFF, 0x3F, 0x83, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0,
  0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF,
  0x81, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F, 0x8F,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFE, 0x03, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFD, 0xFE, 0x07,
  0xF7, 0xF8, 0x1F, 0xDF, 0xF0, 0x7F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xEF, 0xE0, 0x7F, 0xBF, 0x83, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x7F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xEF,
  0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xDF, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0x87,
  0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0xBF, 0x81, 0xFE,
  0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xDF, 0x87, 0xFF, 0xFF,
  0x7E, 0x1F, 0xFF, 0xFD, 0xF8, 0x7D, 0xFF, 0xF7, 0xE1, 0xF7, 0xFF, 0xCF,
  0xCF, 0xDF, 0xFF, 0xBF, 0x3F, 0x7F, 0xFE, 0xFC, 0xF9, 0xFF, 0xFB, 0xFF,
  0xE7, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x9F, 0xFE, 0x7F, 0xFE, 0x7F, 0xF1,
  0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0x8F, 0xFC, 0x7F,
  0xFE, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF,
  0x87, 0xF8, 0x7F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFD, 0xFC, 0x7F, 0xFD,
  0xFC, 0x7F, 0xFC, 0xFE, 0x7F, 0xFC, 0xFE, 0x7F, 0xFC, 0x7F, 0x7F, 0xFC,
  0x7F, 0x7F, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1,
  0xFF, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03,
  0xFB, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80,
  0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC,
  0x07, 0xF9, 0xFE, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x0F,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xBF,
  0xC0, 0x1F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xF9,
  0xFE, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xE3, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x3F, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE0,
  0xFF, 0x3F, 0x83, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7,
  0xF8, 0x79, 0xFC, 0x06, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0,
  0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x03,
  0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0x7F, 0x3F, 0x81,
  0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0xC1, 0xFC,
  0x3F, 0x83, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xF0, 0x7F, 0x0F, 0xE1, 0xFF,
  0xC7, 0xF8, 0x3F, 0x8F, 0xBE, 0x3F, 0x81, 0xFC, 0x7D, 0xF1, 0xFC, 0x0F,
  0xE3, 0xEF, 0x8F, 0xE0, 0x7F, 0x3F, 0x7C, 0x7F, 0x03, 0xF9, 0xFB, 0xF3,
  0xF8, 0x0F, 0xCF, 0xDF, 0xBF, 0x80, 0x7F, 0x7C, 0xFD, 0xFC, 0x03, 0xFB,
  0xE3, 0xEF, 0xE0, 0x1F, 0xFF, 0x1F, 0x7F, 0x00, 0xFF, 0xF8, 0xFB, 0xF8,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFE,
  0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xE7, 0xF8,
  0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xF7, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC1, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE7, 0xF8,
  0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF7,
  0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x78, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x87, 0xF8, 0x40, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xEF, 0xCF, 0xF9, 0xF8, 0xFE,
  0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1C, 0x0F,
  0xE7, 0xF0, 0xFE, 0xFF, 0x8F, 0xEF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0x9F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F, 0xC7, 0xF0, 0x00, 0x30, 0x00,
  0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFC,
  0xF1, 0xFE, 0x04, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x9F,
  0xE0, 0x67, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0x87, 0xF0, 0xFE, 0x7F, 0x1F, 0xF7, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0xFF, 0x7F, 0xDF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xF3, 0xF0, 0x7E, 0x3F, 0x00,
  0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x04, 0x7F, 0xC1, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x01, 0x80, 0x00, 0xFE, 0x3F, 0x1F, 0xF3, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFF, 0x7F,
  0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xF7,
  0xF0, 0xFE, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x40, 0x07, 0xF7, 0x00,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F,
  0xFF, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x0C, 0x0F, 0xE7, 0xF8, 0xFE, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x01, 0x80, 0x7E,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8,
  0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE,
  0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F,
  0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xBF, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C,
  0x01, 0xC0, 0xFC, 0x7F, 0x87, 0xF8, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x0F, 0xF0, 0xFE, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0x0C,
  0x0F, 0xC7, 0xF8, 0xFC, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x00, 0x70,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFD, 0xFC,
  0x1F, 0xEF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xFC, 0x3F, 0x8F, 0xF3, 0xFC,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x0C, 0x0F, 0xC7, 0xF0, 0xFE, 0xFF, 0x8F, 0xEF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x9F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xEF, 0xFC, 0xFE, 0xFF, 0x8F, 0xE3,
  0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x3F, 0x1F, 0xF3, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFF, 0x7F, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xF7, 0xF0,
  0xFE, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0xFB, 0xF3, 0xF7, 0xF7, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0x01, 0xC0, 0x1F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFE, 0x0C, 0xFE, 0x04, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0x3F, 0x0F, 0xE3, 0xF0, 0xFF,
  0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x87,
  0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x3F, 0xBF, 0x87, 0xFC, 0x3F, 0x9F,
  0xC3, 0xFE, 0x1F, 0xCF, 0xE1, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0xC7, 0xF1,
  0xF8, 0xFF, 0xE3, 0xF0, 0xFE, 0x7D, 0xF1, 0xF8, 0x7F, 0x3E, 0xF9, 0xFC,
  0x3F, 0x9F, 0x7C, 0xFE, 0x0F, 0xCF, 0xBE, 0x7F, 0x07, 0xEF, 0xDF, 0xBF,
  0x03, 0xF7, 0xEF, 0xDF, 0x81, 0xFB, 0xE7, 0xEF, 0xC0, 0xFF, 0xF1, 0xFF,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x87, 0xF9, 0xFE, 0x1F, 0xE3, 0xF8, 0xFF, 0x0F, 0xF3,
  0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x7F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xFC, 0x7F, 0x87, 0xF1,
  0xFE, 0x1F, 0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xF7,
  0xF0, 0x3F, 0x9F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x80, 0xFC, 0xFE,
  0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x17,
  0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_Condensed_Black42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 31, 12, 2, -30 },
  { 32, 17, 11, 21, 2, -30 },
  { 56, 23, 30, 24, 1, -30 },
  { 143, 18, 34, 22, 2, -32 },
  { 220, 35, 30, 37, 1, -30 },
  { 352, 28, 30, 29, 1, -30 },
  { 457, 7, 11, 11, 2, -30 },
  { 467, 12, 38, 14, 2, -31 },
  { 524, 12, 38, 14, 0, -31 },
  { 581, 19, 19, 21, 1, -32 },
  { 627, 19, 20, 22, 2, -25 },
  { 675, 9, 12, 12, 1, -6 },
  { 689, 11, 6, 14, 1, -14 },
  { 698, 8, 8, 12, 2, -7 },
  { 706, 18, 30, 18, 0, -30 },
  { 774, 19, 30, 22, 1, -30 },
  { 846, 16, 30, 22, 2, -30 },
  { 906, 19, 30, 22, 1, -30 },
  { 978, 19, 30, 22, 1, -30 },
  { 1050, 20, 30, 22, 1, -30 },
  { 1125, 18, 30, 22, 2, -30 },
  { 1193, 20, 30, 22, 1, -30 },
  { 1268, 18, 30, 22, 2, -30 },
  { 1336, 20, 30, 22, 1, -30 },
  { 1411, 20, 30, 22, 1, -30 },
  { 1486, 8, 25, 12, 2, -24 },
  { 1511, 9, 30, 12, 1, -24 },
  { 1545, 20, 22, 22, 1, -26 },
  { 1600, 19, 15, 22, 2, -22 },
  { 1636, 19, 22, 22, 2, -26 },
  { 1689, 18, 31, 18, 0, -30 },
  { 1759, 30, 33, 34, 2, -30 },
  { 1883, 26, 30, 26, 0, -30 },
  { 1981, 20, 30, 25, 3, -30 },
  { 2056, 20, 30, 23, 2, -30 },
  { 2131, 22, 30, 27, 3, -30 },
  { 2214, 15, 30, 20, 3, -30 },
  { 2271, 15, 30, 20, 3, -30 },
  { 2328, 22, 30, 27, 2, -30 },
  { 2411, 22, 30, 28, 3, -30 },
  { 2494, 14, 30, 16, 1, -30 },
  { 2547, 13, 39, 13, -3, -30 },
  { 2611, 22, 30, 25, 3, -30 },
  { 2694, 16, 30, 20, 3, -30 },
  { 2754, 30, 30, 36, 3, -30 },
  { 2867, 24, 30, 30, 3, -30 },
  { 2957, 25, 30, 28, 2, -30 },
  { 3051, 19, 30, 23, 3, -30 },
  { 3123, 25, 37, 28, 2, -30 },
  { 3239, 22, 30, 25, 3, -30 },
  { 3322, 18, 30, 21, 1, -30 },
  { 3390, 19, 30, 21, 1, -30 },
  { 3462, 21, 30, 27, 3, -30 },
  { 3541, 25, 30, 25, 0, -30 },
  { 3635, 37, 30, 37, 0, -30 },
  { 3774, 24, 30, 24, 0, -30 },
  { 3864, 24, 30, 24, 0, -30 },
  { 3954, 20, 30, 22, 1, -30 },
  { 4029, 10, 38, 13, 2, -31 },
  { 4077, 18, 30, 18, 0, -30 },
  { 4145, 10, 38, 13, 1, -31 },
  { 4193, 23, 20, 23, 0, -30 },
  { 4251, 21, 5, 21, 0, 3 },
  { 4265, 12, 7, 15, 2, -32 },
  { 4276, 19, 24, 22, 1, -24 },
  { 4333, 20, 32, 24, 2, -32 },
  { 4413, 18, 24, 20, 1, -24 },
  { 4467, 20, 32, 24, 1, -32 },
  { 4547, 20, 24, 22, 1, -24 },
  { 4607, 16, 32, 15, 0, -32 },
  { 4671, 20, 34, 24, 1, -24 },
  { 4756, 20, 32, 24, 2, -32 },
  { 4836, 8, 33, 12, 2, -33 },
  { 4869, 12, 43, 12, -2, -33 },
  { 4934, 22, 32, 24, 2, -32 },
  { 5022, 7, 32, 12, 2, -32 },
  { 5050, 32, 24, 36, 2, -24 },
  { 5146, 20, 24, 24, 2, -24 },
  { 5206, 21, 24, 23, 1, -24 },
  { 5269, 20, 34, 24, 2, -24 },
  { 5354, 20, 34, 24, 1, -24 },
  { 5439, 15, 24, 17, 2, -24 },
  { 5484, 16, 24, 18, 1, -24 },
  { 5532, 14, 28, 16, 1, -28 },
  { 5581, 20, 23, 24, 2, -23 },
  { 5639, 22, 23, 22, 0, -23 },
  { 5703, 33, 23, 33, 0, -23 },
  { 5798, 22, 23, 22, 0, -23 },
  { 5862, 22, 33, 22, 0, -23 },
  { 5953, 16, 23, 18, 1, -23 },
  { 5999, 14, 37, 16, 1, -30 },
  { 6064, 6, 41, 19, 6, -32 },
  { 6095, 15, 37, 16, 1, -30 },
  { 6165, 20, 8, 22, 1, -19 },
};

const GFXfont NotoSans_Condensed_Black42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_BLACK42PT7B_H_
