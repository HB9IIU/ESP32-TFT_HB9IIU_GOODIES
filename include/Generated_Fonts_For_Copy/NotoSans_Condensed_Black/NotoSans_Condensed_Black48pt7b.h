#ifndef _NOTOSANS_CONDENSED_BLACK48PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xBF, 0x82, 0x00, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xEF, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC,
  0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F,
  0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x83, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFB, 0xCF, 0x3F, 0x9E, 0x09, 0xFC, 0xF0, 0x0F, 0xE7, 0x80,
  0x7F, 0xBC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0x7F, 0x00, 0x7B, 0xFC, 0x03, 0xCF, 0xF0, 0x1E,
  0xFF, 0xF0, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xFE,
  0x03, 0xF8, 0x00, 0x7E, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x7F, 0x03, 0xF0,
  0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x07, 0xE0, 0x00, 0xFC,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x7F, 0x3F, 0x07, 0xE0,
  0x7E, 0x7E, 0x3F, 0x1F, 0xF0, 0x7F, 0xFE, 0x7F, 0x3F, 0xF8, 0x7F, 0xFE,
  0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7F, 0xFE, 0x1F, 0xF8, 0xFC, 0xFE,
  0xFE, 0x0F, 0xF0, 0xFC, 0xFE, 0x7E, 0x03, 0xC1, 0xF8, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x7F, 0x00, 0x03, 0xF0,
  0xFC, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x7F,
  0x00, 0x0F, 0xE0, 0xFC, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x7E, 0x00, 0x0F,
  0xC0, 0xFE, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x7F,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC3, 0xFE,
  0x0F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0xE7, 0xFC,
  0x7F, 0xFF, 0xF7, 0xFC, 0x7F, 0xDF, 0xFF, 0xF8, 0x7F, 0x8F, 0xFF, 0xF8,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xBF, 0xDF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01,
  0x03, 0xF0, 0x27, 0x0F, 0xC7, 0x9F, 0xBF, 0x7E, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x3F, 0x83,
  0xFC, 0xFF, 0x07, 0xE1, 0xF8, 0x07, 0x87, 0x80, 0x0C, 0x0C, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF9, 0xFE,
  0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFB,
  0xFE, 0x7F, 0x8F, 0xF7, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xDF, 0xE3, 0xFE, 0xFF, 0x1F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFD, 0xFC, 0xFF, 0x3F, 0x3F, 0xC7, 0x8F, 0xF0, 0xC3, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x3E, 0x0F, 0xF8, 0x70, 0x1F, 0xE0, 0x80, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x87, 0xC7, 0xFE, 0x18, 0x07, 0xF8, 0x40, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7E, 0xFF, 0x01, 0xFD, 0xFE, 0x07,
  0xF3, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0x8F, 0xF0, 0x7E, 0x1F, 0xE1, 0xFC,
  0x3F, 0xC3, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xBF, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFC,
  0x04, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x0F, 0x03, 0xFD, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xBF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xE3, 0xFE, 0xFF, 0x87,
  0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xEF, 0xF8, 0x7F, 0x9F, 0xE3, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0x83, 0xFC,
  0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFE, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFD,
  0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFD, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xE7, 0xFC, 0x3F, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xF7, 0xFC, 0x7F, 0x87, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF7, 0xFC,
  0x1F, 0xEF, 0xF8, 0x3F, 0xDF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0xBF, 0xC3,
  0xFF, 0x7F, 0xCF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xDF, 0xC3, 0xFF, 0x3F, 0x81, 0xFC, 0xFF, 0x00, 0x41, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x83,
  0x0F, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x3F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xCF, 0xC1, 0x00, 0x0F, 0x0F, 0xE3, 0xFD, 0xFF, 0x7F, 0xDF, 0xF3,
  0xFC, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xE3, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF1, 0xFF, 0x38, 0x0F, 0xF2, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x3F, 0xC3,
  0xF0, 0xFC, 0x1F, 0xFF, 0x3F, 0x3F, 0x07, 0xFF, 0xE7, 0xE7, 0xE1, 0xFF,
  0xFC, 0x7C, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0x0F, 0xC3, 0xF1, 0xFF, 0xE3,
  0xF8, 0x7E, 0x3F, 0xFC, 0x7E, 0x0F, 0xC7, 0xFF, 0x8F, 0xC1, 0xF8, 0xFF,
  0xF1, 0xF8, 0x3F, 0x1F, 0xFE, 0x3F, 0x07, 0xE3, 0xFF, 0x87, 0xE1, 0xF8,
  0x7F, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0x1F, 0x87, 0xE1, 0xF7, 0xE3, 0xF0,
  0xFC, 0x7E, 0xFC, 0x7F, 0x3F, 0xCF, 0xDF, 0x87, 0xFF, 0xFF, 0xF3, 0xF0,
  0xFF, 0xEF, 0xFC, 0x3F, 0x0F, 0xF9, 0xFF, 0x07, 0xE0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x01, 0x00, 0x40, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x70, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xE7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xEF, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0xFE, 0xFC, 0x3F, 0xF0, 0x18, 0xFF, 0xC0, 0x11, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x11,
  0xFF, 0x80, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F, 0xFE,
  0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0xBF, 0xE3, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0,
  0x06, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xFE, 0x03, 0xFC,
  0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xD1, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x07, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF,
  0x83, 0xFE, 0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE0,
  0xFF, 0x8F, 0xF8, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFC, 0x0F, 0xF9, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0xCF,
  0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F,
  0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xBF, 0xFF,
  0xDF, 0xC7, 0xF7, 0xFF, 0xFB, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0x1F, 0x9F,
  0xFF, 0xE7, 0xE3, 0xF3, 0xFF, 0xFC, 0xFE, 0xFE, 0x7F, 0xFF, 0x9F, 0xDF,
  0xCF, 0xFF, 0xF3, 0xFB, 0xF1, 0xFF, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0x03, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x7F, 0x8F, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF,
  0x3F, 0xCF, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xF1, 0xFE,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0xFC, 0x3F, 0xE0, 0x7F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x3F,
  0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xEF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0xFC, 0x3F, 0xE0, 0x7F, 0xE7, 0xFC,
  0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7,
  0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xE0,
  0x3F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF,
  0x87, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F,
  0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x03, 0xFE, 0x7F, 0x81, 0xFF, 0x3F,
  0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xFD, 0xFF,
  0x03, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFC, 0x00,
  0x7F, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x81, 0xCF, 0xF0, 0x04, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xF0, 0x7F, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF7, 0xF8, 0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0xFF, 0xC0, 0x7F, 0x9F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0xC0,
  0xFF, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xFE, 0x0F, 0xF0,
  0x7F, 0x87, 0xFF, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xEF,
  0xC7, 0xF8, 0x0F, 0xF3, 0xF3, 0xF3, 0xFE, 0x03, 0xFC, 0xFC, 0xFC, 0xFF,
  0x00, 0xFF, 0x3F, 0x3F, 0x3F, 0xC0, 0x3F, 0xDF, 0xCF, 0xCF, 0xF0, 0x07,
  0xF7, 0xF3, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x7E, 0xFE, 0x00, 0x7F, 0x7E,
  0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x07, 0xFF, 0xE1, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xE7, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1,
  0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xF9, 0xFF, 0x01,
  0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC7, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0xE0,
  0x3F, 0xE3, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xEF,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x7E,
  0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xF8, 0xFF, 0xC1, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0x7F, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFD, 0xFC, 0xFF, 0xE3, 0xF0, 0xFF,
  0x0F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x7E, 0x0F, 0xF3, 0xFC, 0x3F, 0xDF, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x8F,
  0xFB, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0x8F,
  0xE7, 0xFE, 0x3F, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFE, 0x0C,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x27, 0xFE, 0x3C, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0x8F, 0xF0, 0xFF, 0x3F, 0xC7, 0xFE, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xF7, 0xF1, 0xFF, 0x9F, 0xC3, 0xFC,
  0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF,
  0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x04, 0x7F, 0xC0, 0x71, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xE1, 0xFC, 0x3F, 0xC7, 0xF1, 0xFF, 0x9F, 0xCF, 0xFF, 0x7F, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xEF, 0xF0, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF6, 0x00, 0x7F,
  0xDF, 0x07, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x7E, 0x0F, 0xF7, 0xFE, 0x3F, 0xBF, 0xFC, 0xFE, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x3C, 0x00,
  0x00, 0x1F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xF8, 0x03, 0xF0, 0x3F, 0xC1,
  0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF,
  0x1F, 0xF0, 0x18, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0x9F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x03,
  0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x8F, 0xFC, 0x3F,
  0xF3, 0xFB, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xF1, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xF0, 0x7F, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xE0,
  0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xF0, 0x7F, 0x80, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0x8F, 0xEF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xC3, 0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x07, 0xFB, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFB, 0xFE, 0x0F,
  0xF3, 0xFC, 0x1F, 0xE7, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFC, 0x1F, 0x83, 0xF8, 0xFF, 0x0F, 0xE7, 0xFE, 0x3F, 0xBF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xCF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFD, 0xFF, 0x8F,
  0xF3, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xE1, 0xFC, 0x3F, 0xC7, 0xF1, 0xFF, 0x9F, 0xCF, 0xFF, 0x7F, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xEF, 0xF0,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xF2, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xF8, 0xFB, 0xFC, 0x04,
  0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF3, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFC, 0xFF, 0xE7, 0xF0, 0xFF,
  0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF,
  0xF0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xDF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFD,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xF8, 0x3F,
  0xDF, 0xE0, 0xFF, 0xC1, 0xFE, 0xFF, 0x07, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F,
  0xF0, 0x7F, 0xBF, 0xC3, 0xFF, 0xC3, 0xF8, 0xFF, 0x1F, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xFC,
  0x7F, 0x07, 0xF3, 0xF7, 0xE3, 0xF8, 0x3F, 0x9F, 0xBF, 0xBF, 0xC1, 0xFE,
  0xFC, 0xFD, 0xFE, 0x0F, 0xF7, 0xE7, 0xEF, 0xF0, 0x3F, 0xBF, 0x3F, 0x7F,
  0x01, 0xFD, 0xF9, 0xFB, 0xF8, 0x0F, 0xFF, 0x8F, 0xDF, 0xC0, 0x7F, 0xFC,
  0x7E, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xBF,
  0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0x87, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0,
  0xFF, 0xBF, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0xC7, 0xFC, 0x7F,
  0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0xBF, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xE7, 0xFC, 0x0F,
  0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF,
  0x3F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x6F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x04, 0xFF,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x80, 0x1F, 0xF2, 0x00, 0x06, 0x00,
};

const GFXglyph NotoSans_Condensed_Black48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 35, 13, 2, -34 },
  { 41, 20, 12, 24, 2, -34 },
  { 71, 26, 34, 28, 1, -34 },
  { 182, 21, 39, 25, 2, -36 },
  { 285, 40, 35, 42, 1, -35 },
  { 460, 32, 35, 33, 1, -35 },
  { 600, 9, 12, 13, 2, -34 },
  { 614, 14, 43, 16, 2, -35 },
  { 690, 14, 43, 16, 0, -35 },
  { 766, 22, 22, 24, 1, -37 },
  { 827, 21, 24, 25, 2, -29 },
  { 890, 10, 14, 14, 1, -7 },
  { 908, 13, 8, 16, 1, -17 },
  { 921, 9, 9, 13, 2, -8 },
  { 932, 21, 35, 21, 0, -35 },
  { 1024, 21, 35, 25, 2, -35 },
  { 1116, 18, 34, 25, 2, -34 },
  { 1193, 22, 35, 25, 1, -35 },
  { 1290, 22, 35, 25, 1, -35 },
  { 1387, 23, 34, 25, 1, -34 },
  { 1485, 21, 34, 25, 2, -34 },
  { 1575, 22, 35, 25, 2, -35 },
  { 1672, 21, 34, 25, 2, -34 },
  { 1762, 23, 35, 25, 1, -35 },
  { 1863, 23, 35, 25, 1, -35 },
  { 1964, 9, 28, 14, 2, -27 },
  { 1996, 10, 34, 14, 1, -27 },
  { 2039, 21, 25, 25, 2, -30 },
  { 2105, 21, 17, 25, 2, -25 },
  { 2150, 22, 25, 25, 2, -30 },
  { 2219, 20, 36, 21, 0, -35 },
  { 2309, 35, 39, 39, 2, -35 },
  { 2480, 30, 34, 30, 0, -34 },
  { 2608, 23, 34, 28, 3, -34 },
  { 2706, 23, 35, 26, 2, -35 },
  { 2807, 25, 34, 30, 3, -34 },
  { 2914, 18, 34, 23, 3, -34 },
  { 2991, 18, 34, 22, 3, -34 },
  { 3068, 26, 35, 31, 2, -35 },
  { 3182, 25, 34, 31, 3, -34 },
  { 3289, 16, 34, 18, 1, -34 },
  { 3357, 15, 45, 15, -3, -34 },
  { 3442, 26, 34, 28, 3, -34 },
  { 3553, 19, 34, 23, 3, -34 },
  { 3634, 35, 34, 41, 3, -34 },
  { 3783, 28, 34, 34, 3, -34 },
  { 3902, 28, 35, 32, 2, -35 },
  { 4025, 22, 34, 27, 3, -34 },
  { 4119, 28, 43, 32, 2, -35 },
  { 4270, 25, 34, 28, 3, -34 },
  { 4377, 20, 35, 24, 2, -35 },
  { 4465, 22, 34, 24, 1, -34 },
  { 4559, 25, 34, 31, 3, -34 },
  { 4666, 29, 34, 29, 0, -34 },
  { 4790, 42, 34, 42, 0, -34 },
  { 4969, 28, 34, 28, 0, -34 },
  { 5088, 27, 34, 27, 0, -34 },
  { 5203, 23, 34, 25, 1, -34 },
  { 5301, 12, 43, 15, 2, -35 },
  { 5366, 21, 35, 21, 0, -35 },
  { 5458, 12, 43, 15, 1, -35 },
  { 5523, 26, 22, 26, 0, -34 },
  { 5595, 24, 6, 24, 0, 3 },
  { 5613, 14, 8, 17, 2, -37 },
  { 5627, 22, 27, 26, 1, -27 },
  { 5702, 22, 36, 27, 3, -36 },
  { 5801, 19, 27, 22, 2, -27 },
  { 5866, 22, 36, 27, 2, -36 },
  { 5965, 22, 27, 25, 2, -27 },
  { 6040, 17, 37, 17, 1, -37 },
  { 6119, 22, 39, 27, 2, -27 },
  { 6227, 22, 36, 27, 3, -36 },
  { 6326, 9, 37, 14, 2, -37 },
  { 6368, 13, 49, 14, -2, -37 },
  { 6448, 24, 36, 27, 3, -36 },
  { 6556, 8, 36, 13, 3, -36 },
  { 6592, 35, 27, 41, 3, -27 },
  { 6711, 22, 27, 27, 3, -27 },
  { 6786, 23, 27, 27, 2, -27 },
  { 6864, 22, 39, 27, 3, -27 },
  { 6972, 22, 39, 27, 2, -27 },
  { 7080, 16, 27, 19, 3, -27 },
  { 7134, 18, 27, 21, 1, -27 },
  { 7195, 16, 32, 19, 1, -32 },
  { 7259, 22, 27, 27, 3, -27 },
  { 7334, 25, 27, 25, 0, -27 },
  { 7419, 37, 27, 38, 0, -27 },
  { 7544, 25, 27, 25, 0, -27 },
  { 7629, 25, 39, 25, 0, -27 },
  { 7751, 19, 27, 21, 1, -27 },
  { 7816, 16, 43, 19, 1, -35 },
  { 7902, 7, 48, 21, 7, -37 },
  { 7944, 17, 43, 19, 1, -35 },
  { 8036, 22, 10, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Black48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_BLACK48PT7B_H_
