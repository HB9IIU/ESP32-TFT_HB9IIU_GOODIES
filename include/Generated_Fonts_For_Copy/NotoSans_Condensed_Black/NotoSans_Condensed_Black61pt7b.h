#ifndef _NOTOSANS_CONDENSED_BLACK61PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x3F, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x3F, 0xE3, 0xFC, 0x07, 0x00, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xBF, 0xF0, 0xFF, 0xDF, 0xF8, 0x7F, 0xEF, 0xFC, 0x3F,
  0xF7, 0xFE, 0x1F, 0xFB, 0xFF, 0x0F, 0xFD, 0xFF, 0x87, 0xFE, 0xFF, 0xC1,
  0xFF, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xF8,
  0x1F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFC,
  0xF0, 0xF9, 0xFF, 0x1E, 0x02, 0x3F, 0xE3, 0xC0, 0x07, 0xFC, 0x78, 0x00,
  0xFF, 0x8F, 0x00, 0x0F, 0xF9, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1E, 0xFF, 0xC0,
  0x03, 0xCF, 0xF8, 0x00, 0x78, 0xFF, 0x00, 0x0F, 0x1F, 0xE8, 0x01, 0xE3,
  0xFD, 0xE0, 0x3C, 0xFF, 0xBF, 0x07, 0xBF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x8F,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xF8, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0,
  0x7C, 0x01, 0xFE, 0x3F, 0xC7, 0xF8, 0x3F, 0xF0, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0x87, 0xF1, 0xFF, 0x3F, 0xC0, 0xFF,
  0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFC,
  0x3F, 0xFF, 0xFF, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x3F, 0xF8, 0x7F, 0xF7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x30, 0x3F, 0xC0, 0xE7, 0xE1, 0xFC, 0x3E, 0x7F, 0x9F,
  0x9F, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xE7, 0xFE, 0x7F,
  0xE7, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0xF1, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x07, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0x9F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F,
  0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF,
  0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xE7, 0xFF,
  0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF7, 0xFF, 0x3F, 0xE7, 0xFF, 0x1F, 0xC7, 0xFF, 0x0F, 0x87, 0xFF, 0x07,
  0x07, 0xFF, 0x02, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFE, 0x1F, 0xFE, 0x1F, 0x80, 0xFF, 0xE0, 0xF0, 0x0F, 0xFE, 0x06,
  0x00, 0x7F, 0xE0, 0x40, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0, 0x7F,
  0xF8, 0x70, 0x07, 0xFF, 0x04, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0x00, 0x7F, 0xDF, 0xFC, 0x03, 0xFE,
  0x7F, 0xF0, 0x0F, 0xF1, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0x01, 0xFE, 0x1F,
  0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0x3F, 0xC1, 0xFF, 0xC1, 0xFF, 0x07, 0xFF,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x88, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x1E, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x7F, 0xC7, 0xFE, 0x07, 0xFC,
  0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xF0,
  0xFF, 0xE3, 0xFF, 0x9F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0,
  0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xBF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFB, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC,
  0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFB, 0xFE, 0x1F, 0xFF, 0xBF, 0xE0,
  0xFF, 0xF3, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x82, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x8F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x3F, 0xCF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xC7, 0xF8, 0x38, 0x00, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x3F, 0xF3, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3,
  0xFF, 0x3F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFC, 0x7F, 0xC7,
  0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xC0,
  0x7F, 0xE1, 0xC0, 0x1F, 0xFC, 0x40, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xFF, 0xFC, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFF, 0xC7, 0xF8, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF,
  0xF0, 0xFE, 0x7F, 0x87, 0xFF, 0xFF, 0x87, 0xFB, 0xFC, 0x3F, 0xE1, 0xFC,
  0x3F, 0xDF, 0xC3, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x1F, 0xE0, 0x7F, 0x07,
  0xF7, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xFF, 0x87, 0xF0, 0x1F, 0xC1, 0xFF,
  0xFC, 0x7F, 0x80, 0xFE, 0x0F, 0xFF, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF,
  0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0xF8, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xC7,
  0xF8, 0x1F, 0xE1, 0xFD, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE,
  0x07, 0xF8, 0x7F, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xF9, 0xFC, 0x3F, 0xE3,
  0xFE, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0x7F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF9, 0xFF,
  0xE0, 0x7F, 0x81, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFE, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x07,
  0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF9, 0xFF,
  0xC0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0xFF,
  0xE0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0x0F, 0xFF, 0x00, 0x30, 0xFF, 0xF0, 0x00,
  0x87, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0x0F, 0xFF, 0x80, 0x78,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xE0, 0x3F,
  0xFC, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F,
  0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F,
  0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7C, 0x0F, 0xFF, 0x80, 0x06, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xF8, 0x03, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x87, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xBF, 0xF8, 0x03, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF,
  0xC7, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x1F,
  0xFC, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03,
  0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xBF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xE0,
  0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0x0F, 0xF3, 0xFF, 0xFF, 0xCF, 0xF8, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0xCF, 0xF9, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFD, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xF7,
  0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xEF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F,
  0xF7, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFC, 0x01,
  0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x80,
  0x7F, 0xF8, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F,
  0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x1F, 0xFE,
  0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x07,
  0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFF,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC,
  0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFE, 0x1F, 0xCF, 0xFF, 0x00, 0xF3, 0xFF,
  0x80, 0x08, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xB8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01,
  0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F,
  0xF0, 0x1F, 0xF8, 0x7F, 0xBF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFD, 0xFE,
  0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0x3F, 0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xF9, 0xFE, 0x7F, 0xF0, 0x07, 0xFE,
  0x7F, 0xCF, 0xF3, 0xFF, 0x00, 0x3F, 0xF3, 0xFC, 0x7F, 0x9F, 0xF8, 0x00,
  0xFF, 0x9F, 0xE3, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x0F, 0xF7, 0xFE,
  0x00, 0x3F, 0xF7, 0xF8, 0x7F, 0xBF, 0xF0, 0x01, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF,
  0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0xFF, 0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07,
  0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0x80, 0xFF, 0xE0, 0xC0, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xF9,
  0xFF, 0xF8, 0xFF, 0x1F, 0xFE, 0x1F, 0xE1, 0xFF, 0x81, 0xFC, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x1F,
  0xC0, 0x7F, 0xF3, 0xFF, 0x83, 0xFF, 0xBF, 0xFE, 0x1F, 0xFB, 0xFF, 0xF8,
  0xFF, 0xDF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0x7F, 0xF8, 0x3F, 0xFB, 0xFF, 0xC0,
  0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xEF, 0xFF, 0x07, 0xFF, 0x7F, 0xFC, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xBF, 0xFF, 0x0F, 0xF8, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x02,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x02, 0x7F, 0xF0, 0x03, 0x3F,
  0xFE, 0x0F, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x1F, 0xE3, 0xFF, 0x83, 0xFF, 0x8F, 0xFC, 0x3F, 0xFE,
  0x7F, 0xE3, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xDF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xBF,
  0xF8, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0xBF, 0xFC, 0x3F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0xFE, 0x1F, 0xFF, 0xBF, 0xF0, 0x7F,
  0xF8, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xDF, 0xFE, 0x7F, 0xF0, 0x7F, 0xE7, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x3F,
  0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x47, 0xFF, 0x80, 0x1C, 0x3F, 0xFF, 0x1F, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xC3, 0xFF, 0xE7, 0xFE, 0x1F, 0xFF,
  0xBF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0x83, 0xFF, 0xDF,
  0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFC,
  0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xFB, 0xFF, 0xC7, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0x7F, 0xE1, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x1F,
  0xF1, 0xFF, 0xC0, 0x0C, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x20, 0x00, 0x1F, 0xF8, 0xC0, 0x01, 0xFF, 0xC7, 0xC0, 0x3F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7D, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x83,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFC, 0x3F, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0x8F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC3, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x70,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F,
  0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0x80, 0xFF, 0xF1, 0xFF,
  0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F,
  0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0x03, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF9, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x3F, 0xFC, 0x3F, 0xE3, 0xFF, 0xF1,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x83,
  0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8,
  0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFD, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xF1,
  0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x3F, 0xF3, 0xFF, 0xE1, 0xFF,
  0xBF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xF7, 0xFF, 0x83, 0xFF,
  0xBF, 0xFC, 0x0F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0x7F, 0xFF, 0x1F, 0xFD, 0xFF, 0xF0, 0xFF, 0xE7, 0xFF, 0x07,
  0xFF, 0x1F, 0xF0, 0x3F, 0xF8, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xC3, 0xFF, 0xE7, 0xFE, 0x1F, 0xFF, 0xBF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0x83, 0xFF, 0xDF, 0xFC,
  0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x07,
  0xFF, 0x7F, 0xF0, 0x7F, 0xFB, 0xFF, 0xC7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0x7F, 0xE1, 0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xF1,
  0xFF, 0xC0, 0x08, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xC5, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xC0, 0xF1, 0xFF, 0x80, 0x23, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x18, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xF1, 0xFF,
  0xFC, 0xFF, 0x0F, 0xFF, 0x8F, 0xF0, 0x7F, 0xE0, 0xFF, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F,
  0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x7F,
  0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x7F,
  0xE0, 0x3F, 0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0x7F, 0xFE, 0x07, 0xFE, 0x3F,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF8, 0xFF, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFE, 0xFF, 0x1F, 0xF8, 0x1F,
  0xF8, 0xFE, 0x7F, 0x1F, 0xF8, 0x0F, 0xF9, 0xFE, 0x7F, 0x9F, 0xF0, 0x0F,
  0xF9, 0xFE, 0x7F, 0x9F, 0xF0, 0x0F, 0xFD, 0xFE, 0x7F, 0x9F, 0xF0, 0x0F,
  0xFD, 0xFE, 0x7F, 0xBF, 0xF0, 0x07, 0xFD, 0xFE, 0x7F, 0xBF, 0xE0, 0x07,
  0xFD, 0xFC, 0x3F, 0xBF, 0xE0, 0x07, 0xFD, 0xFC, 0x3F, 0xBF, 0xE0, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x3F, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xF9,
  0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x11, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x13, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x80, 0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_Condensed_Black61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 45, 17, 2, -44 },
  { 69, 25, 16, 30, 3, -44 },
  { 119, 34, 44, 35, 1, -44 },
  { 306, 27, 50, 32, 2, -46 },
  { 475, 51, 44, 53, 1, -44 },
  { 756, 40, 45, 42, 2, -44 },
  { 981, 10, 16, 16, 3, -44 },
  { 1001, 18, 55, 21, 2, -45 },
  { 1125, 17, 55, 21, 1, -45 },
  { 1242, 28, 27, 30, 1, -46 },
  { 1337, 28, 29, 32, 2, -36 },
  { 1439, 12, 17, 17, 2, -9 },
  { 1465, 16, 9, 20, 2, -21 },
  { 1483, 11, 12, 17, 3, -11 },
  { 1500, 26, 45, 26, 0, -44 },
  { 1647, 28, 45, 32, 2, -44 },
  { 1805, 24, 44, 32, 2, -44 },
  { 1937, 28, 44, 32, 1, -44 },
  { 2091, 27, 45, 32, 2, -44 },
  { 2243, 30, 44, 32, 1, -44 },
  { 2408, 26, 45, 32, 3, -44 },
  { 2555, 28, 45, 32, 2, -44 },
  { 2713, 28, 44, 32, 2, -44 },
  { 2867, 28, 45, 32, 2, -44 },
  { 3025, 28, 45, 32, 2, -44 },
  { 3183, 11, 35, 17, 3, -34 },
  { 3232, 12, 42, 17, 2, -34 },
  { 3295, 28, 32, 32, 2, -38 },
  { 3407, 28, 21, 32, 2, -32 },
  { 3481, 28, 32, 32, 2, -38 },
  { 3593, 26, 45, 26, 0, -44 },
  { 3740, 45, 49, 49, 2, -44 },
  { 4016, 38, 44, 38, 0, -44 },
  { 4225, 29, 44, 36, 4, -44 },
  { 4385, 29, 45, 34, 3, -44 },
  { 4549, 32, 44, 38, 4, -44 },
  { 4725, 22, 44, 29, 4, -44 },
  { 4846, 22, 44, 28, 4, -44 },
  { 4967, 33, 45, 39, 3, -44 },
  { 5153, 32, 44, 40, 4, -44 },
  { 5329, 19, 44, 23, 2, -44 },
  { 5434, 19, 58, 19, -4, -44 },
  { 5572, 33, 44, 36, 4, -44 },
  { 5754, 24, 44, 29, 4, -44 },
  { 5886, 44, 44, 52, 4, -44 },
  { 6128, 35, 44, 43, 4, -44 },
  { 6321, 35, 45, 41, 3, -44 },
  { 6518, 28, 44, 34, 4, -44 },
  { 6672, 36, 54, 41, 3, -44 },
  { 6915, 32, 44, 36, 4, -44 },
  { 7091, 26, 45, 30, 2, -44 },
  { 7238, 28, 44, 30, 1, -44 },
  { 7392, 31, 45, 39, 4, -44 },
  { 7567, 37, 44, 37, 0, -44 },
  { 7771, 53, 44, 54, 0, -44 },
  { 8063, 35, 44, 35, 0, -44 },
  { 8256, 35, 44, 35, 0, -44 },
  { 8449, 29, 44, 31, 1, -44 },
  { 8609, 15, 55, 19, 3, -45 },
  { 8713, 26, 45, 26, 0, -44 },
  { 8860, 15, 55, 19, 1, -45 },
  { 8964, 33, 29, 33, 0, -44 },
  { 9084, 31, 7, 31, 0, 4 },
  { 9112, 18, 10, 22, 2, -47 },
  { 9135, 27, 35, 33, 2, -34 },
  { 9254, 29, 47, 34, 3, -46 },
  { 9425, 25, 35, 28, 2, -34 },
  { 9535, 29, 47, 34, 2, -46 },
  { 9706, 28, 35, 32, 2, -34 },
  { 9829, 22, 47, 22, 1, -47 },
  { 9959, 29, 49, 34, 2, -34 },
  { 10137, 29, 46, 35, 3, -46 },
  { 10304, 11, 47, 17, 3, -47 },
  { 10369, 17, 62, 17, -3, -47 },
  { 10501, 32, 46, 34, 3, -46 },
  { 10685, 11, 46, 17, 3, -46 },
  { 10749, 46, 34, 52, 3, -34 },
  { 10945, 29, 34, 35, 3, -34 },
  { 11069, 29, 35, 34, 2, -34 },
  { 11196, 29, 49, 34, 3, -34 },
  { 11374, 29, 49, 34, 2, -34 },
  { 11552, 21, 34, 25, 3, -34 },
  { 11642, 23, 35, 26, 2, -34 },
  { 11743, 21, 42, 24, 1, -41 },
  { 11854, 28, 35, 35, 3, -34 },
  { 11977, 32, 34, 32, 0, -34 },
  { 12113, 48, 34, 48, 0, -34 },
  { 12317, 31, 34, 32, 0, -34 },
  { 12449, 32, 49, 32, 0, -34 },
  { 12645, 24, 34, 26, 1, -34 },
  { 12747, 21, 54, 24, 1, -44 },
  { 12889, 9, 61, 27, 9, -47 },
  { 12958, 22, 54, 24, 1, -44 },
  { 13107, 28, 11, 32, 2, -27 },
};

const GFXfont NotoSans_Condensed_Black61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_BLACK61PT7B_H_
