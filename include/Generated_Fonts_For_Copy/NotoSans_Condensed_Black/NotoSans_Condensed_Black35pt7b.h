#ifndef _NOTOSANS_CONDENSED_BLACK35PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x00, 0x00, 0x01, 0xE7, 0xEF, 0xFF, 0xBF, 0x7C, 0xFC,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE,
  0x3E, 0xF8, 0xF8, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x79, 0xF0,
  0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3, 0xC0,
  0x3C, 0xF8, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0xF8, 0x3F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0xF9, 0xC4, 0xF9, 0xC0, 0xFD,
  0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xDF, 0x81, 0xDF, 0x61, 0xDF, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFE, 0x03, 0xC0, 0x1F, 0xF0, 0x1E, 0x01,
  0xFF, 0xC1, 0xF0, 0x0F, 0xBE, 0x0F, 0x00, 0x78, 0xF0, 0xF8, 0x03, 0xC7,
  0x87, 0x80, 0x1E, 0x3C, 0x7C, 0x00, 0xF1, 0xE3, 0xC0, 0x07, 0x8F, 0x3E,
  0x00, 0x3E, 0x79, 0xE3, 0xF1, 0xFF, 0xDF, 0x3F, 0xC7, 0xFC, 0xF3, 0xFF,
  0x1F, 0xE7, 0x9F, 0xF8, 0x7E, 0x7D, 0xF3, 0xC0, 0x03, 0xCF, 0x9F, 0x00,
  0x3E, 0x7C, 0xF8, 0x01, 0xE3, 0xE7, 0xC0, 0x1F, 0x1F, 0x3E, 0x00, 0xF0,
  0xF9, 0xF0, 0x0F, 0x87, 0xCF, 0x00, 0x78, 0x1F, 0xF8, 0x07, 0xC0, 0xFF,
  0xC0, 0x3C, 0x03, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE3,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xE3, 0xFF, 0x0F, 0xCF, 0xFF, 0x3F,
  0x9F, 0xFF, 0x7E, 0x7F, 0x7F, 0xFC, 0xFC, 0x7F, 0xF1, 0xF8, 0xFF, 0xE3,
  0xF0, 0xFF, 0xC7, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFE, 0xFF, 0xFF, 0xFE, 0xFB,
  0xEF, 0xBE, 0xF8, 0x07, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3,
  0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xF0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xC3, 0xC6, 0xFB, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E,
  0xF8, 0x7E, 0x7C, 0x3C, 0x78, 0x0C, 0x20, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x7E,
  0xF9, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E,
  0x7E, 0x3E, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF3, 0xFF, 0xFF, 0xFF, 0x7E, 0xFC, 0xF7, 0xF1, 0x9F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x78, 0xFE, 0x30, 0x7E,
  0x20, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x30, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xBF, 0x07, 0xDF, 0x87, 0xCF, 0xC3, 0xE7, 0xE3, 0xE3, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x9F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x60, 0xFD, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7F,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x0F,
  0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0x7E, 0x3F, 0x7C,
  0x3E, 0x7E, 0x7E, 0x7F, 0x7E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE,
  0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xBF, 0x06, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xC0, 0x33, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFE, 0x18, 0xFD, 0xFB, 0xF7, 0xEF, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0xFD, 0xFB, 0xE7,
  0xCF, 0xBF, 0x7C, 0xF8, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xC6, 0x0F, 0xC8, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x03,
  0xC3, 0xE1, 0xFC, 0xF8, 0xF1, 0xFF, 0x9E, 0x7C, 0xFF, 0xE7, 0xDE, 0x3F,
  0x78, 0xF7, 0x9F, 0x1E, 0x3F, 0xE7, 0x87, 0x8F, 0xF9, 0xE1, 0xE3, 0xFC,
  0x78, 0x78, 0xFF, 0x1E, 0x1E, 0x3F, 0xC7, 0x8F, 0x9F, 0xF9, 0xE3, 0xE7,
  0xBE, 0x7D, 0xFF, 0xE7, 0x8F, 0xFF, 0xF1, 0xE3, 0xF9, 0xF8, 0x7C, 0x3C,
  0x3C, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x80, 0x7F, 0x00, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF7, 0xE0, 0x0F, 0xCF,
  0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F,
  0xE7, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFC, 0xFF, 0xF0, 0x7F,
  0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0x7E, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xFF, 0xFB, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFC, 0x19, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x63, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF8, 0xFF, 0x3F,
  0x07, 0xF7, 0xE0, 0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0xFE, 0x7E, 0x7F, 0xCF, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x81, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFE, 0xFC, 0x7F, 0xDF, 0x8F, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF,
  0xE0, 0xFD, 0xFC, 0x1F, 0x9F, 0xC3, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x4F, 0xEF, 0xFD, 0xFF, 0x3F,
  0xE7, 0xF8, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7F, 0x7E,
  0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE7, 0xF0, 0xFC,
  0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xF7, 0xE0,
  0xFE, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFE, 0x3E, 0xFF,
  0xF7, 0xCF, 0xBF, 0xFD, 0xF3, 0xEF, 0xFF, 0x7C, 0xF3, 0xFF, 0xCF, 0xFC,
  0xFF, 0xF3, 0xFF, 0x3F, 0xFC, 0xFF, 0xCF, 0xFF, 0x3F, 0xE3, 0xFF, 0xC7,
  0xF8, 0xFF, 0xF1, 0xFE, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0x1F, 0xC3, 0xFF,
  0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xC0, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0x7E, 0x7F, 0xFB, 0xF3, 0xFF, 0xDF, 0xDF, 0xFE, 0x7E, 0xFF, 0xF3,
  0xF7, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0,
  0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03,
  0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFC, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0x7E, 0x03, 0xFB,
  0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF8, 0x1F, 0xDF,
  0xC0, 0xFC, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC7, 0xE1, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7F, 0x3F, 0x07, 0xE7, 0xE0, 0xFE, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xDF, 0xC3, 0xBF, 0x81, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xDF, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFC, 0x00, 0xFC, 0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xF9, 0xF8, 0x3F,
  0x83, 0xF3, 0xF0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xCF, 0xC1, 0xFC,
  0x3F, 0x1F, 0x87, 0xF8, 0x7E, 0x1F, 0x8F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF1,
  0xF8, 0x7E, 0x3F, 0xE3, 0xF0, 0xFC, 0x7B, 0xC7, 0xC0, 0xF9, 0xF7, 0x9F,
  0x81, 0xF3, 0xEF, 0x3F, 0x03, 0xF7, 0xDF, 0x7E, 0x07, 0xEF, 0xBE, 0xFC,
  0x0F, 0xDE, 0x7D, 0xF0, 0x0F, 0xFC, 0x7B, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1,
  0xFC, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xDF, 0x81, 0xF9, 0xF8, 0x3F, 0x9F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xE7, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7E,
  0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF9, 0xF8, 0x1F, 0x9F, 0x81,
  0xF9, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x03,
  0xE7, 0xC0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F,
  0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x07, 0xC0, 0xF0,
  0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x18, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xDF,
  0x7F, 0xDF, 0x3F, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x70, 0xFD, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9, 0xF8, 0x01, 0xC0,
  0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x7F, 0xF9, 0xFC, 0x67, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x5F, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x0C, 0x3F, 0x1F, 0xDF, 0x9F, 0xEF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF7,
  0xFB, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x9F, 0xEF, 0xC7, 0xE3, 0xE0, 0x03, 0xC0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x02, 0x7F, 0x0E, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x03,
  0xE0, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x07, 0x00, 0x0F, 0xEF, 0xCF,
  0xF7, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFB, 0xFD, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xF7, 0xE3,
  0xF3, 0xF0, 0x01, 0xF8, 0x00, 0xF9, 0x00, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x70, 0xFD,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x7B, 0xFF, 0xFF, 0xFD, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0x70, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x3F, 0xBF, 0x0F,
  0xCF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x7F, 0x0F, 0xDF, 0x83,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFE,
  0xFC, 0x3F, 0x3F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F,
  0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x70, 0x18, 0x3E, 0x7F, 0x1F, 0xCF, 0xBF, 0xEF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFF, 0xF0,
  0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0,
  0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0x00, 0x60, 0xF9, 0xFC, 0xFB, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x01, 0xC0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFB, 0xF0, 0xFD, 0xF8, 0xFC, 0xFE, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x70, 0xF9, 0xFC, 0xFB, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFD, 0xF8, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x07, 0x00, 0x0F, 0xEF, 0xCF, 0xF7, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFB,
  0xFD, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xF7, 0xE3, 0xF3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x7F, 0x9F, 0xFB, 0xFF, 0xBF, 0xFF, 0xEF, 0xFE, 0xFF, 0xAF, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x07, 0x01, 0xFF, 0x9F, 0xFE, 0xFF,
  0xEF, 0xFF, 0x7E, 0x1B, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFC, 0xFF, 0x80, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFE, 0x3F, 0xF1,
  0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x1F, 0x9F, 0xFC, 0x0F, 0xDF, 0x83, 0xF7,
  0xE1, 0xFD, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x1F, 0x3F, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0xFC, 0x3F, 0x87, 0xEF, 0xC7, 0xF8, 0xFD, 0xF8, 0xFF, 0x1F,
  0xBF, 0x1F, 0xE3, 0xE7, 0xE7, 0xFC, 0x7C, 0x7C, 0xFF, 0x9F, 0x8F, 0x9E,
  0xF3, 0xF1, 0xFB, 0xDF, 0x7E, 0x3F, 0x7B, 0xEF, 0x87, 0xEF, 0x7D, 0xF0,
  0x7F, 0xE7, 0xBE, 0x0F, 0xFC, 0xF7, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3,
  0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01,
  0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xDF, 0xC7, 0xE3,
  0xF3, 0xF0, 0xFE, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0x83, 0xFB, 0xF0, 0xFC, 0xFC, 0x7F, 0x3F, 0x9F, 0x87, 0xEF,
  0xE1, 0xFC, 0xFE, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xFD, 0xF8, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0xBF, 0x07, 0xEF,
  0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xF0, 0x00, 0x08, 0x01, 0x7F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_Condensed_Black35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 25, 10, 1, -25 },
  { 23, 14, 9, 17, 2, -25 },
  { 39, 19, 25, 20, 1, -25 },
  { 99, 16, 29, 18, 1, -27 },
  { 157, 29, 25, 31, 1, -25 },
  { 248, 23, 25, 24, 1, -25 },
  { 320, 6, 9, 9, 2, -25 },
  { 327, 10, 32, 12, 1, -26 },
  { 367, 10, 32, 12, 0, -26 },
  { 407, 16, 16, 17, 1, -27 },
  { 439, 16, 17, 18, 1, -21 },
  { 473, 7, 10, 10, 1, -5 },
  { 482, 9, 5, 11, 1, -12 },
  { 488, 6, 6, 10, 2, -6 },
  { 493, 15, 25, 15, 0, -25 },
  { 540, 16, 25, 18, 1, -25 },
  { 590, 14, 25, 18, 1, -25 },
  { 634, 16, 25, 18, 1, -25 },
  { 684, 16, 25, 18, 1, -25 },
  { 734, 17, 25, 18, 1, -25 },
  { 788, 15, 25, 18, 2, -25 },
  { 835, 16, 25, 18, 1, -25 },
  { 885, 16, 25, 18, 1, -25 },
  { 935, 16, 25, 18, 1, -25 },
  { 985, 16, 25, 18, 1, -25 },
  { 1035, 6, 20, 10, 2, -20 },
  { 1050, 7, 25, 10, 1, -20 },
  { 1072, 16, 18, 18, 1, -22 },
  { 1108, 16, 13, 18, 1, -19 },
  { 1134, 16, 18, 18, 1, -22 },
  { 1170, 15, 25, 15, 0, -25 },
  { 1217, 26, 28, 28, 1, -25 },
  { 1308, 22, 25, 22, 0, -25 },
  { 1377, 17, 25, 21, 2, -25 },
  { 1431, 17, 25, 19, 1, -25 },
  { 1485, 19, 25, 22, 2, -25 },
  { 1545, 13, 25, 17, 2, -25 },
  { 1586, 13, 25, 16, 2, -25 },
  { 1627, 19, 25, 22, 1, -25 },
  { 1687, 19, 25, 23, 2, -25 },
  { 1747, 11, 25, 13, 1, -25 },
  { 1782, 11, 33, 11, -2, -25 },
  { 1828, 19, 25, 21, 2, -25 },
  { 1888, 14, 25, 17, 2, -25 },
  { 1932, 26, 25, 30, 2, -25 },
  { 2014, 21, 25, 25, 2, -25 },
  { 2080, 21, 25, 24, 1, -25 },
  { 2146, 16, 25, 19, 2, -25 },
  { 2196, 21, 31, 24, 1, -25 },
  { 2278, 19, 25, 20, 2, -25 },
  { 2338, 15, 25, 17, 1, -25 },
  { 2385, 16, 25, 17, 1, -25 },
  { 2435, 18, 25, 22, 2, -25 },
  { 2492, 21, 25, 21, 0, -25 },
  { 2558, 31, 25, 31, 0, -25 },
  { 2655, 20, 25, 20, 0, -25 },
  { 2718, 20, 25, 20, 0, -25 },
  { 2781, 16, 25, 18, 1, -25 },
  { 2831, 8, 32, 11, 2, -26 },
  { 2863, 15, 25, 15, 0, -25 },
  { 2910, 8, 32, 11, 1, -26 },
  { 2942, 19, 17, 19, 0, -25 },
  { 2983, 18, 4, 18, 0, 2 },
  { 2992, 10, 6, 13, 1, -27 },
  { 3000, 16, 20, 19, 1, -20 },
  { 3040, 16, 27, 20, 2, -27 },
  { 3094, 14, 20, 16, 1, -20 },
  { 3129, 17, 27, 20, 1, -27 },
  { 3187, 16, 20, 18, 1, -20 },
  { 3227, 13, 27, 12, 0, -27 },
  { 3271, 17, 28, 20, 1, -20 },
  { 3331, 16, 27, 20, 2, -27 },
  { 3385, 6, 27, 10, 2, -27 },
  { 3406, 9, 35, 10, -1, -27 },
  { 3446, 18, 27, 20, 2, -27 },
  { 3507, 6, 27, 10, 2, -27 },
  { 3528, 26, 20, 30, 2, -20 },
  { 3593, 16, 20, 20, 2, -20 },
  { 3633, 17, 20, 19, 1, -20 },
  { 3676, 16, 28, 20, 2, -20 },
  { 3732, 17, 28, 20, 1, -20 },
  { 3792, 12, 20, 14, 2, -20 },
  { 3822, 13, 20, 15, 1, -20 },
  { 3855, 13, 23, 14, 0, -23 },
  { 3893, 16, 19, 20, 2, -19 },
  { 3931, 18, 19, 18, 0, -19 },
  { 3974, 27, 19, 28, 0, -19 },
  { 4039, 18, 19, 18, 0, -19 },
  { 4082, 18, 27, 18, 0, -19 },
  { 4143, 13, 19, 15, 1, -19 },
  { 4174, 12, 31, 14, 1, -25 },
  { 4221, 5, 35, 16, 5, -27 },
  { 4243, 12, 31, 14, 1, -25 },
  { 4290, 16, 7, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_Black35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_BLACK35PT7B_H_
