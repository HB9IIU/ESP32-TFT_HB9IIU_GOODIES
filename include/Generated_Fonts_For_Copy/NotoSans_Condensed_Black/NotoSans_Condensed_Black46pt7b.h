#ifndef _NOTOSANS_CONDENSED_BLACK46PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F,
  0xBF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x0C, 0x00, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFD, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7E,
  0x1F, 0xCF, 0xC3, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0xFC,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1,
  0xF8, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0x7C, 0xFC, 0xF0, 0x4F, 0xCF, 0x00, 0xFC,
  0xF0, 0x0F, 0xEF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0x7F, 0x00, 0xF3, 0xF8, 0x0F, 0x3F, 0xE0, 0xF7,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0xFC, 0x00, 0x7F,
  0xFC, 0x03, 0xE0, 0x01, 0xF9, 0xF8, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x7C,
  0x00, 0x3F, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x0F, 0xC0, 0x03, 0xF1,
  0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF9, 0xF8, 0x7F, 0x07, 0xE7,
  0xE7, 0xE3, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0xFC, 0x7F, 0xFC, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE3, 0xF3, 0xFF, 0xE1, 0xFF, 0x1F, 0x9F, 0xDF, 0x83, 0xF8,
  0x7E, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE3,
  0xF0, 0x00, 0x7E, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0xFC, 0x00, 0x3F, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x1F, 0x8F,
  0xC0, 0x07, 0xE0, 0x7E, 0x7F, 0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x00, 0xFC,
  0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0x03, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0x87, 0xF8, 0x3F,
  0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0x7F, 0x87, 0xF9,
  0xFF, 0xFF, 0x1F, 0xF3, 0xFF, 0xFC, 0x3F, 0xC3, 0xFF, 0xF8, 0x7F, 0x83,
  0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x30, 0x7C, 0x39,
  0xF3, 0xE7, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03,
  0xFB, 0xF8, 0x3F, 0x9F, 0xC3, 0xFC, 0x7F, 0x07, 0xC3, 0xE0, 0x0E, 0x0E,
  0x00, 0x20, 0x40, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF9, 0xFE, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xF7, 0xF8, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xEF, 0xF3, 0xE7, 0xF8, 0xE3, 0xFC, 0x21, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xC1, 0xFE, 0x1C, 0x0F, 0xF0,
  0x40, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0x01, 0xFE,
  0x10, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x7F, 0x81, 0xFD, 0xFE, 0x07,
  0xE7, 0xF8, 0x3F, 0x1F, 0xE1, 0xFC, 0x7F, 0x87, 0xE1, 0xFE, 0x3F, 0x87,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF1, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x18, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0x8F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x7C, 0x0F, 0xE7, 0xF8, 0x7F, 0x7F,
  0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xE3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xF7, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F, 0x9F, 0xE1, 0xFE,
  0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0xFF, 0x0F, 0xF7, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xCF, 0xF9,
  0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0x87, 0xFB, 0xFC, 0x1F,
  0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFE, 0x1F, 0xF7,
  0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x87, 0xFE, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC2, 0x07, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x1C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC,
  0xFE, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3F, 0x82, 0x00, 0x0F,
  0x0F, 0xE3, 0xFD, 0xFF, 0x7F, 0xDF, 0xF3, 0xFC, 0xFE, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xE3, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE1, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xCF, 0xF9, 0xC0,
  0xFF, 0x20, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x03, 0xFC, 0x3F, 0x1F, 0x87, 0xFF, 0xCF, 0x9F, 0x87, 0xFF, 0xE7,
  0xEF, 0xC7, 0xFF, 0xF3, 0xF7, 0xC3, 0xFF, 0xF8, 0xFF, 0xE3, 0xF0, 0xFC,
  0x7F, 0xF1, 0xF8, 0x7E, 0x3F, 0xF1, 0xF8, 0x3F, 0x1F, 0xF8, 0xFC, 0x1F,
  0x0F, 0xFC, 0x7E, 0x0F, 0x87, 0xFE, 0x3F, 0x07, 0xC3, 0xFF, 0x1F, 0x83,
  0xE1, 0xFF, 0x8F, 0xC3, 0xF0, 0xFF, 0xC7, 0xE1, 0xF8, 0xFF, 0xE1, 0xF8,
  0xFC, 0x7D, 0xF8, 0xFF, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xFE, 0x7E, 0x1F,
  0xFB, 0xFE, 0x1F, 0x87, 0xF8, 0xFE, 0x0F, 0xC0, 0xF0, 0x1C, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x80, 0x1F,
  0xF8, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x83,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0x80,
  0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F,
  0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xF8,
  0x0C, 0x7F, 0xC0, 0x11, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x09,
  0xFF, 0x80, 0x63, 0xFF, 0xDF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x0F, 0xFC, 0xFF, 0x03,
  0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x07,
  0xFE, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0x18,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF,
  0x80, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0,
  0x7F, 0x9F, 0xE0, 0x7F, 0xCF, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC,
  0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xCF, 0xF8, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFC, 0xFF,
  0x03, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87,
  0xFC, 0x3F, 0xC1, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8,
  0x1F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xDF, 0x83, 0xFF, 0xFF, 0xEF, 0xC1, 0xFB, 0xFF, 0xF7, 0xF0, 0xFD,
  0xFF, 0xFB, 0xF8, 0x7E, 0xFF, 0xFC, 0xFC, 0x7E, 0x7F, 0xFE, 0x7E, 0x3F,
  0x3F, 0xFF, 0x3F, 0x9F, 0x9F, 0xFF, 0x9F, 0xDF, 0xCF, 0xFF, 0xC7, 0xEF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xEF, 0xE1, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xBF, 0xC7, 0xFF, 0xF3,
  0xFC, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF, 0xC7, 0xFB, 0xFF, 0xF8, 0xFF, 0x7F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x00,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x7F,
  0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0x07, 0xFE, 0x7F, 0xC0,
  0x7F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F,
  0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x7F, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF,
  0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8, 0x1E,
  0xFF, 0x00, 0x9F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xC7,
  0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0x81, 0xFE, 0x3F, 0x81, 0xFF, 0x81,
  0xFE, 0x3F, 0x81, 0xFF, 0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x81, 0xFC, 0x3F,
  0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0xC3, 0xFC, 0x1F, 0xC3, 0xFF,
  0xC3, 0xFC, 0x1F, 0xC3, 0xFF, 0xC3, 0xFC, 0x1F, 0xE3, 0xFF, 0xC3, 0xF8,
  0x1F, 0xE3, 0xF7, 0xC3, 0xF8, 0x1F, 0xE3, 0xF7, 0xE7, 0xF8, 0x0F, 0xE7,
  0xF7, 0xE7, 0xF8, 0x0F, 0xE7, 0xE7, 0xE7, 0xF8, 0x0F, 0xE7, 0xE7, 0xE7,
  0xF0, 0x0F, 0xF7, 0xE7, 0xE7, 0xF0, 0x0F, 0xF7, 0xE3, 0xFF, 0xF0, 0x07,
  0xF7, 0xE3, 0xFF, 0xF0, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F,
  0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F,
  0x9F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01,
  0xFE, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x01, 0xFD, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF7, 0xF0,
  0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3C, 0x3F, 0xE1, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0x7F, 0x3F,
  0xF1, 0xF8, 0xFF, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0xF0, 0x3F, 0x9F, 0xE1, 0xFD, 0xFF,
  0x8F, 0xEF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xE7, 0xFE, 0x3F, 0x1F,
  0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFE, 0x04, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x3E, 0x3F, 0xC3, 0xFD, 0xFE, 0x3F, 0xF7, 0xF3, 0xFF, 0xBF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFB, 0xF8, 0xFF, 0x9F, 0xC3, 0xF8, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFE, 0x3F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x05, 0xFF, 0x00,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xC4, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x9F, 0xC7, 0xFE, 0xFE, 0x7F, 0xF7, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F,
  0xF7, 0xF8, 0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xB0, 0x07, 0xFD, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0xF8,
  0x3F, 0x9F, 0xF1, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFE, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF,
  0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0, 0x01,
  0xC0, 0x3F, 0x81, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x3F, 0xC1, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFE,
  0x7F, 0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF7,
  0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x9F, 0xC1, 0xFE, 0x3F, 0x87, 0xF8, 0x7F,
  0x1F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFC, 0xFF, 0x03, 0xFB, 0xFE, 0x07, 0xF7,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x07, 0xF8, 0xFF,
  0x0F, 0xE1, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xFE, 0x7F, 0x03, 0xFC,
  0xFE, 0x07, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x3F, 0x1F, 0xF0, 0xFF,
  0x8F, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF1, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0x83, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xFF,
  0x81, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF,
  0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x83,
  0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x81, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFE, 0x07,
  0xF8, 0x3F, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0x07, 0xE3, 0xFE,
  0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFD, 0xFF, 0xBF,
  0xE1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0x9F, 0xE3, 0xFE, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0xE3, 0xFC, 0x3F, 0xBF, 0xF1,
  0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xDF, 0xFC, 0xFE, 0x7F, 0xC7, 0xF1, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x9F, 0xC7,
  0xFE, 0xFE, 0x7F, 0xF7, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0x7F, 0x1F, 0xF7, 0xF8,
  0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xF0,
  0xF3, 0xFC, 0x08, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE3, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFD, 0xFE, 0x1F, 0xF7,
  0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xDF, 0xC7, 0xFE, 0x7F, 0x0F, 0xF0, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xC1,
  0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xE3,
  0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7,
  0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x03,
  0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xE0, 0xFE, 0x7F, 0x87, 0xFE, 0x0F, 0xE7,
  0xF8, 0x7F, 0xE0, 0xFE, 0x7F, 0x87, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0xF1,
  0xFE, 0x3F, 0x8F, 0xFF, 0x1F, 0xC3, 0xFC, 0xFF, 0xF1, 0xFC, 0x3F, 0xCF,
  0xFF, 0x1F, 0xC1, 0xFC, 0xFD, 0xF3, 0xFC, 0x1F, 0xCF, 0x9F, 0xBF, 0x81,
  0xFD, 0xF9, 0xFB, 0xF8, 0x1F, 0xDF, 0x9F, 0xBF, 0x80, 0xFD, 0xF9, 0xFB,
  0xF8, 0x0F, 0xDF, 0x9F, 0xBF, 0x80, 0xFF, 0xF9, 0xFB, 0xF0, 0x0F, 0xFF,
  0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x7F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xE7, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xE7, 0xF8, 0x3F, 0xE7, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC,
  0x7F, 0x83, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFC,
  0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xE3, 0xF8,
  0x0F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF0, 0x07, 0xF7, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x0B,
  0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF8, 0x0F, 0xFE, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Black46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 34, 13, 2, -33 },
  { 40, 19, 12, 23, 2, -33 },
  { 69, 25, 33, 27, 1, -33 },
  { 173, 20, 38, 24, 2, -35 },
  { 268, 38, 33, 40, 1, -33 },
  { 425, 31, 33, 32, 1, -33 },
  { 553, 8, 12, 12, 2, -33 },
  { 565, 13, 41, 15, 2, -34 },
  { 632, 14, 41, 15, 0, -34 },
  { 704, 21, 21, 23, 1, -35 },
  { 760, 20, 22, 24, 2, -27 },
  { 815, 10, 13, 13, 1, -7 },
  { 832, 13, 7, 15, 1, -16 },
  { 844, 9, 9, 13, 2, -8 },
  { 855, 20, 33, 20, 0, -33 },
  { 938, 20, 33, 24, 2, -33 },
  { 1021, 17, 33, 24, 2, -33 },
  { 1092, 21, 33, 24, 1, -33 },
  { 1179, 21, 33, 24, 1, -33 },
  { 1266, 22, 33, 24, 1, -33 },
  { 1357, 20, 33, 24, 2, -33 },
  { 1440, 21, 33, 24, 2, -33 },
  { 1527, 20, 33, 24, 2, -33 },
  { 1610, 22, 33, 24, 1, -33 },
  { 1701, 22, 33, 24, 1, -33 },
  { 1792, 9, 27, 13, 2, -26 },
  { 1823, 10, 32, 13, 1, -26 },
  { 1863, 20, 23, 24, 2, -28 },
  { 1921, 20, 16, 24, 2, -24 },
  { 1961, 21, 23, 24, 2, -28 },
  { 2022, 19, 34, 20, 0, -33 },
  { 2103, 33, 36, 37, 2, -33 },
  { 2252, 29, 33, 29, 0, -33 },
  { 2372, 22, 33, 27, 3, -33 },
  { 2463, 22, 33, 25, 2, -33 },
  { 2554, 24, 33, 29, 3, -33 },
  { 2653, 17, 33, 22, 3, -33 },
  { 2724, 17, 33, 21, 3, -33 },
  { 2795, 25, 33, 29, 2, -33 },
  { 2899, 24, 33, 30, 3, -33 },
  { 2998, 15, 33, 17, 1, -33 },
  { 3060, 14, 43, 14, -3, -33 },
  { 3136, 25, 33, 27, 3, -33 },
  { 3240, 18, 33, 22, 3, -33 },
  { 3315, 33, 33, 39, 3, -33 },
  { 3452, 27, 33, 33, 3, -33 },
  { 3564, 27, 33, 31, 2, -33 },
  { 3676, 21, 33, 25, 3, -33 },
  { 3763, 27, 41, 31, 2, -33 },
  { 3902, 24, 33, 27, 3, -33 },
  { 4001, 19, 33, 23, 2, -33 },
  { 4080, 21, 33, 23, 1, -33 },
  { 4167, 24, 33, 29, 3, -33 },
  { 4266, 28, 33, 28, 0, -33 },
  { 4382, 40, 33, 40, 0, -33 },
  { 4547, 27, 33, 27, 0, -33 },
  { 4659, 26, 33, 26, 0, -33 },
  { 4767, 22, 33, 24, 1, -33 },
  { 4858, 11, 42, 14, 2, -34 },
  { 4916, 20, 33, 20, 0, -33 },
  { 4999, 11, 42, 14, 1, -34 },
  { 5057, 25, 22, 25, 0, -33 },
  { 5126, 23, 6, 23, 0, 3 },
  { 5144, 13, 7, 17, 2, -35 },
  { 5156, 21, 26, 25, 1, -26 },
  { 5225, 21, 35, 26, 3, -35 },
  { 5317, 18, 26, 21, 2, -26 },
  { 5376, 21, 35, 26, 2, -35 },
  { 5468, 21, 26, 24, 2, -26 },
  { 5537, 17, 35, 16, 0, -35 },
  { 5612, 21, 37, 26, 2, -26 },
  { 5710, 21, 35, 26, 3, -35 },
  { 5802, 9, 36, 13, 2, -36 },
  { 5843, 13, 47, 13, -2, -36 },
  { 5920, 23, 35, 26, 3, -35 },
  { 6021, 7, 35, 13, 3, -35 },
  { 6052, 34, 26, 39, 3, -26 },
  { 6163, 21, 26, 26, 3, -26 },
  { 6232, 22, 26, 25, 2, -26 },
  { 6304, 21, 37, 26, 3, -26 },
  { 6402, 21, 37, 26, 2, -26 },
  { 6500, 15, 26, 19, 3, -26 },
  { 6549, 18, 26, 20, 1, -26 },
  { 6608, 16, 31, 18, 1, -31 },
  { 6670, 22, 25, 26, 2, -25 },
  { 6739, 24, 25, 24, 0, -25 },
  { 6814, 36, 25, 36, 0, -25 },
  { 6927, 24, 25, 24, 0, -25 },
  { 7002, 24, 36, 24, 0, -25 },
  { 7110, 18, 25, 20, 1, -25 },
  { 7167, 16, 41, 18, 1, -33 },
  { 7249, 6, 45, 21, 7, -35 },
  { 7283, 16, 41, 18, 1, -33 },
  { 7365, 21, 9, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Black46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_BLACK46PT7B_H_
