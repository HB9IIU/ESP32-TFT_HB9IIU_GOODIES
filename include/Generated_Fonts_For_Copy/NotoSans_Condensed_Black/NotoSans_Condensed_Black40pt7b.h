#ifndef _NOTOSANS_CONDENSED_BLACK40PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF1, 0xF0, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFC, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x83,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xF9, 0xC2, 0x7C, 0xE0, 0x3E, 0x70, 0x1F, 0xB8, 0x0F, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3B, 0xF0, 0x1C, 0xFC, 0x0E, 0x7F, 0x07, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0x80, 0xFE, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xE0, 0x07,
  0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x0F, 0xFE, 0x03, 0xE0, 0x0F, 0xFF, 0x03,
  0xF0, 0x07, 0xEF, 0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0xF8, 0x01, 0xF1, 0xF0,
  0xF8, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x3E, 0x00, 0x1F, 0x1F, 0x3E, 0x0C, 0x0F, 0xCF, 0x9F, 0x1F, 0xC3, 0xFF,
  0x9F, 0x1F, 0xF1, 0xFF, 0xCF, 0x9F, 0xFC, 0x7F, 0xEF, 0xDF, 0xFE, 0x3F,
  0xE7, 0xCF, 0xDF, 0x07, 0xC3, 0xE7, 0xCF, 0xC0, 0x03, 0xE3, 0xE3, 0xE0,
  0x01, 0xF1, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x7C,
  0x00, 0xF8, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x3F, 0x00, 0x7C, 0x0F, 0xDF,
  0x00, 0x3E, 0x03, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x7F,
  0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x04, 0x0F, 0xFC, 0x7F, 0x07, 0xFF, 0x0F, 0xE1, 0xFF, 0xF1, 0xFC, 0x7F,
  0xFF, 0x7F, 0x8F, 0xEF, 0xFF, 0xE3, 0xF9, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF,
  0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xBF, 0xE0, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xBF, 0x7E, 0xFC, 0xF9, 0xF0, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x61, 0xE1, 0xBF, 0x7B,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xC0, 0x7F, 0x80,
  0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xDF, 0xC7, 0xF3, 0xF8, 0xF8, 0xF8, 0x0E,
  0x1C, 0x01, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x7F, 0x7F, 0x1F, 0xDF, 0xC7, 0xF7, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xF7, 0xE1, 0xFD, 0xFC, 0x7F, 0x7F, 0x1F, 0xDF, 0xC7, 0xF7,
  0xF1, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0xF3,
  0xF9, 0xE7, 0xF1, 0x8F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x03,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xE7, 0xC3, 0xF8, 0xE0, 0xFE, 0x10, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0x83, 0xF8, 0x40, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3E,
  0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x20, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0xF0,
  0x3F, 0x7F, 0x87, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0x1F, 0xDF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF7, 0xE0, 0xFE,
  0xFE, 0x1F, 0x9F, 0xC7, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFF, 0x7F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3,
  0xF0, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xF7, 0xF1, 0xFC, 0x7F, 0x7F, 0x0F,
  0xEF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xCF, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F,
  0x7F, 0x0F, 0xFF, 0xE1, 0xFE, 0xFE, 0x7F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFD, 0xF8, 0x3F, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE1, 0x0F, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0x80, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xE0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0xFE,
  0x40, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0xF8, 0x7C, 0x3E, 0x0F, 0xFC, 0xF8, 0xF8, 0xFF, 0xF3,
  0xE7, 0xC7, 0xFF, 0xC7, 0x9F, 0x1F, 0x9F, 0x1F, 0x7C, 0xFC, 0x7C, 0x7D,
  0xF3, 0xE1, 0xF1, 0xF7, 0x8F, 0x87, 0xC7, 0xFE, 0x3E, 0x1F, 0x1F, 0xF8,
  0xF8, 0x7C, 0x7F, 0xE3, 0xE1, 0xF1, 0xEF, 0x8F, 0x87, 0xC7, 0x9E, 0x3E,
  0x3F, 0x3E, 0x7C, 0xFF, 0xFF, 0xF1, 0xF1, 0xFF, 0xFF, 0xC7, 0xC7, 0xFD,
  0xFE, 0x1F, 0x87, 0xE3, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x10, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xDF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x8F, 0xF7, 0xF0,
  0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x7F, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xC3,
  0xFB, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xF0, 0xE3, 0xFC, 0x04, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x33, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF0,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFB, 0xFF, 0x9F, 0xC3, 0xFC, 0xFE, 0x0F, 0xF7,
  0xF0, 0x7F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x0F, 0xF3, 0xF8, 0xFF,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF9, 0xFF, 0x83, 0x8F, 0xF0, 0x04, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFE, 0x0F, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x7F, 0x00, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE,
  0x7F, 0x0F, 0xE3, 0xF8, 0xFF, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF7,
  0xF8, 0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xDF,
  0xC1, 0xFC, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xFD, 0xFC, 0x1F,
  0xEF, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xDF, 0x0F, 0xBF, 0xFE, 0xFC,
  0x7D, 0xFF, 0xF7, 0xE7, 0xEF, 0xFF, 0x9F, 0x3E, 0x7F, 0xFC, 0xFD, 0xF3,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF8, 0xFF, 0xC7, 0xFF,
  0xC7, 0xFE, 0x3F, 0xFE, 0x3F, 0xF1, 0xFF, 0xF1, 0xFF, 0x8F, 0xFF, 0x87,
  0xF8, 0x7F, 0xFC, 0x3F, 0xC3, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0x0F, 0xF0,
  0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xC1, 0xF8, 0x3F, 0x80, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0xCF, 0xFF, 0xBF,
  0x9F, 0xFF, 0x3F, 0xBF, 0xFE, 0x7F, 0x7F, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F,
  0x9F, 0xE0, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0xBF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F,
  0xC1, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xE0, 0xFF, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xF9, 0xFF, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x8F, 0xE7, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xEF, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF8, 0xF3, 0xFC, 0x0C, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xEF, 0x03, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xFE, 0x1F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0xFE,
  0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0,
  0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFD, 0xF8, 0x0F, 0xE0,
  0x3F, 0xBF, 0x81, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x81, 0xFC, 0xFE, 0x07,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0xE0, 0xFE, 0x3F,
  0x87, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x87, 0xF0, 0xFE, 0x3F, 0xF8, 0xFE,
  0x1F, 0xC7, 0xDF, 0x1F, 0xC1, 0xF8, 0xFB, 0xE3, 0xF0, 0x3F, 0x1F, 0x7C,
  0x7E, 0x07, 0xF3, 0xEF, 0x9F, 0xC0, 0xFE, 0xFD, 0xFB, 0xF8, 0x0F, 0xDF,
  0xBF, 0x7F, 0x01, 0xFB, 0xF3, 0xEF, 0xC0, 0x3F, 0x7C, 0x7D, 0xF8, 0x07,
  0xEF, 0x8F, 0xBF, 0x00, 0xFD, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0xFE, 0x07,
  0xF9, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xFB,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x0F,
  0xF3, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xF9, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x83,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xFF,
  0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0x20,
  0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF0,
  0xC1, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC1, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xF9, 0xF1,
  0xFC, 0x7C, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x40, 0xFE, 0x7E, 0x1F,
  0xDF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x3F, 0xBF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF,
  0xBF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xCF, 0xF1, 0xF8,
  0xFC, 0x00, 0x00, 0x20, 0x01, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF1, 0xFE, 0x18, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x01, 0x3F, 0xE7, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x08, 0x7F, 0x0F, 0xEF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x3F,
  0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F,
  0x7F, 0x9F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0x7E,
  0x1F, 0xC7, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x02, 0x7F, 0x81, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x87, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0x00, 0x01, 0xFC, 0xFC,
  0x7F, 0xDF, 0x9F, 0xFB, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xE7, 0xFB,
  0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF,
  0xF3, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0x7E, 0x3F, 0xDF, 0xC3,
  0xF3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE8, 0x01, 0xFD, 0xE0, 0x7F, 0xBF,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x40, 0xFE, 0x7F, 0x1F,
  0xDF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0xCE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x0F, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xE7,
  0xF8, 0x38, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0x8F, 0xE3,
  0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xDF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFD, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F,
  0x87, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x7F, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x08, 0x01, 0x03, 0xF3, 0xFC, 0x3F, 0x8F, 0xDF, 0xF9, 0xFF,
  0x3F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x3F, 0xFF, 0xC7, 0xF8, 0x7F, 0xFE, 0x1F, 0xE1, 0xFF, 0xF8,
  0x3F, 0x87, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x0F,
  0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0,
  0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF,
  0xE0, 0xFC, 0x1F, 0xC0, 0x00, 0x08, 0x1F, 0x8F, 0xE3, 0xF7, 0xFE, 0x7E,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x00,
  0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x08, 0x1F,
  0x8F, 0xC3, 0xF3, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xC7, 0xF7, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF,
  0x1F, 0xFF, 0xF7, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFD,
  0xFE, 0x3F, 0x9F, 0x87, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFC, 0xFC, 0x7F, 0xDF, 0x9F,
  0xFB, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xE7, 0xFB, 0xF8, 0x7F, 0x7F,
  0x0F, 0xEF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xDF, 0x83, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xF3, 0xFD, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0x7E, 0x3F, 0xDF, 0xC3, 0xF3, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0x13, 0xF1, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x3F, 0xF0, 0xFF, 0xFB, 0xFF, 0xE7,
  0xFF, 0xDF, 0xFF, 0xBF, 0x82, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFC, 0x00,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x33, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFB, 0xF3,
  0xFE, 0x7E, 0x3F, 0x8F, 0xC0, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC1,
  0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xF7, 0xF0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0xFE, 0xFC, 0x1F, 0xE1, 0xFD, 0xFC,
  0x7F, 0xC3, 0xFB, 0xF8, 0xFF, 0x87, 0xE7, 0xF1, 0xFF, 0x8F, 0xC7, 0xE3,
  0xFF, 0x3F, 0x8F, 0xC7, 0xFE, 0x7F, 0x1F, 0x9F, 0x7C, 0xFE, 0x3F, 0xBE,
  0xF9, 0xF8, 0x7F, 0x7D, 0xF3, 0xF0, 0x7E, 0xFB, 0xF7, 0xE0, 0xFD, 0xF3,
  0xEF, 0xC1, 0xFB, 0xE7, 0xFF, 0x03, 0xF7, 0x8F, 0xFE, 0x03, 0xFF, 0x1F,
  0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF3, 0xFC, 0x7F, 0x8F, 0xE3,
  0xF8, 0x7F, 0x3F, 0xC1, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0xFF,
  0x7F, 0x83, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC1, 0xFC, 0xFE,
  0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x3F, 0x83, 0xF1, 0xFC,
  0x1F, 0x8F, 0xC0, 0xFE, 0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x3F,
  0xF0, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0x81, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x2F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x1F, 0xF4, 0x00, 0x70,
};

const GFXglyph NotoSans_Condensed_Black40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 16, 11, 20, 2, -29 },
  { 49, 22, 29, 23, 1, -29 },
  { 129, 17, 32, 21, 2, -30 },
  { 197, 33, 29, 35, 1, -29 },
  { 317, 27, 29, 28, 1, -29 },
  { 415, 7, 11, 11, 2, -29 },
  { 425, 11, 35, 13, 2, -29 },
  { 474, 12, 35, 13, 0, -29 },
  { 527, 18, 18, 20, 1, -30 },
  { 568, 19, 20, 21, 1, -24 },
  { 616, 8, 12, 11, 1, -6 },
  { 628, 11, 6, 13, 1, -14 },
  { 637, 7, 7, 11, 2, -7 },
  { 644, 17, 29, 17, 0, -29 },
  { 706, 18, 29, 21, 1, -29 },
  { 772, 15, 29, 21, 2, -29 },
  { 827, 18, 29, 21, 1, -29 },
  { 893, 18, 29, 21, 1, -29 },
  { 959, 19, 29, 21, 1, -29 },
  { 1028, 17, 29, 21, 2, -29 },
  { 1090, 19, 29, 21, 1, -29 },
  { 1159, 18, 29, 21, 1, -29 },
  { 1225, 19, 29, 21, 1, -29 },
  { 1294, 19, 29, 21, 1, -29 },
  { 1363, 7, 22, 11, 2, -22 },
  { 1383, 8, 28, 11, 1, -22 },
  { 1411, 19, 21, 21, 1, -25 },
  { 1461, 19, 14, 21, 1, -21 },
  { 1495, 19, 21, 21, 1, -25 },
  { 1545, 17, 29, 17, 0, -29 },
  { 1607, 30, 32, 32, 1, -29 },
  { 1727, 25, 29, 25, 0, -29 },
  { 1818, 19, 29, 24, 3, -29 },
  { 1887, 19, 29, 22, 2, -29 },
  { 1956, 21, 29, 25, 3, -29 },
  { 2033, 14, 29, 19, 3, -29 },
  { 2084, 14, 29, 19, 3, -29 },
  { 2135, 21, 29, 25, 2, -29 },
  { 2212, 21, 29, 26, 3, -29 },
  { 2289, 13, 29, 15, 1, -29 },
  { 2337, 13, 38, 12, -3, -29 },
  { 2399, 21, 29, 24, 3, -29 },
  { 2476, 15, 29, 19, 3, -29 },
  { 2531, 29, 29, 34, 3, -29 },
  { 2637, 23, 29, 28, 3, -29 },
  { 2721, 23, 29, 27, 2, -29 },
  { 2805, 18, 29, 22, 3, -29 },
  { 2871, 23, 36, 27, 2, -29 },
  { 2975, 21, 29, 23, 3, -29 },
  { 3052, 18, 29, 20, 1, -29 },
  { 3118, 18, 29, 20, 1, -29 },
  { 3184, 21, 29, 26, 2, -29 },
  { 3261, 24, 29, 24, 0, -29 },
  { 3348, 35, 29, 35, 0, -29 },
  { 3475, 23, 29, 23, 0, -29 },
  { 3559, 23, 29, 23, 0, -29 },
  { 3643, 19, 29, 21, 1, -29 },
  { 3712, 10, 36, 12, 2, -29 },
  { 3757, 17, 29, 17, 0, -29 },
  { 3819, 10, 36, 12, 1, -29 },
  { 3864, 21, 19, 21, 0, -29 },
  { 3914, 20, 4, 20, 0, 3 },
  { 3924, 11, 7, 15, 2, -31 },
  { 3934, 18, 23, 21, 1, -23 },
  { 3986, 19, 30, 22, 2, -30 },
  { 4058, 17, 23, 19, 1, -23 },
  { 4107, 19, 30, 22, 1, -30 },
  { 4179, 19, 22, 21, 1, -22 },
  { 4232, 15, 31, 14, 0, -31 },
  { 4291, 19, 33, 22, 1, -23 },
  { 4370, 19, 30, 23, 2, -30 },
  { 4442, 7, 31, 11, 2, -31 },
  { 4470, 11, 41, 11, -2, -31 },
  { 4527, 21, 30, 22, 2, -30 },
  { 4606, 7, 30, 11, 2, -30 },
  { 4633, 30, 23, 34, 2, -23 },
  { 4720, 19, 23, 23, 2, -23 },
  { 4775, 20, 23, 22, 1, -23 },
  { 4833, 19, 33, 22, 2, -23 },
  { 4912, 19, 33, 22, 1, -23 },
  { 4991, 14, 23, 16, 2, -23 },
  { 5032, 15, 23, 17, 1, -23 },
  { 5076, 14, 27, 15, 1, -27 },
  { 5124, 19, 22, 23, 2, -22 },
  { 5177, 21, 22, 21, 0, -22 },
  { 5235, 31, 22, 32, 0, -22 },
  { 5321, 21, 22, 21, 0, -22 },
  { 5379, 21, 32, 21, 0, -22 },
  { 5463, 15, 22, 17, 1, -22 },
  { 5505, 14, 36, 15, 1, -29 },
  { 5568, 6, 40, 18, 6, -31 },
  { 5598, 14, 36, 15, 1, -29 },
  { 5661, 19, 8, 21, 1, -18 },
};

const GFXfont NotoSans_Condensed_Black40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_BLACK40PT7B_H_
