#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Condensed_Black
// Headers: 67

#include "NotoSans_Condensed_Black6pt7b.h"
#include "NotoSans_Condensed_Black7pt7b.h"
#include "NotoSans_Condensed_Black8pt7b.h"
#include "NotoSans_Condensed_Black9pt7b.h"
#include "NotoSans_Condensed_Black10pt7b.h"
#include "NotoSans_Condensed_Black11pt7b.h"
#include "NotoSans_Condensed_Black12pt7b.h"
#include "NotoSans_Condensed_Black13pt7b.h"
#include "NotoSans_Condensed_Black14pt7b.h"
#include "NotoSans_Condensed_Black15pt7b.h"
#include "NotoSans_Condensed_Black16pt7b.h"
#include "NotoSans_Condensed_Black17pt7b.h"
#include "NotoSans_Condensed_Black18pt7b.h"
#include "NotoSans_Condensed_Black19pt7b.h"
#include "NotoSans_Condensed_Black20pt7b.h"
#include "NotoSans_Condensed_Black21pt7b.h"
#include "NotoSans_Condensed_Black22pt7b.h"
#include "NotoSans_Condensed_Black23pt7b.h"
#include "NotoSans_Condensed_Black24pt7b.h"
#include "NotoSans_Condensed_Black25pt7b.h"
#include "NotoSans_Condensed_Black26pt7b.h"
#include "NotoSans_Condensed_Black27pt7b.h"
#include "NotoSans_Condensed_Black28pt7b.h"
#include "NotoSans_Condensed_Black29pt7b.h"
#include "NotoSans_Condensed_Black30pt7b.h"
#include "NotoSans_Condensed_Black31pt7b.h"
#include "NotoSans_Condensed_Black32pt7b.h"
#include "NotoSans_Condensed_Black33pt7b.h"
#include "NotoSans_Condensed_Black34pt7b.h"
#include "NotoSans_Condensed_Black35pt7b.h"
#include "NotoSans_Condensed_Black36pt7b.h"
#include "NotoSans_Condensed_Black37pt7b.h"
#include "NotoSans_Condensed_Black38pt7b.h"
#include "NotoSans_Condensed_Black39pt7b.h"
#include "NotoSans_Condensed_Black40pt7b.h"
#include "NotoSans_Condensed_Black41pt7b.h"
#include "NotoSans_Condensed_Black42pt7b.h"
#include "NotoSans_Condensed_Black43pt7b.h"
#include "NotoSans_Condensed_Black44pt7b.h"
#include "NotoSans_Condensed_Black45pt7b.h"
#include "NotoSans_Condensed_Black46pt7b.h"
#include "NotoSans_Condensed_Black47pt7b.h"
#include "NotoSans_Condensed_Black48pt7b.h"
#include "NotoSans_Condensed_Black49pt7b.h"
#include "NotoSans_Condensed_Black50pt7b.h"
#include "NotoSans_Condensed_Black51pt7b.h"
#include "NotoSans_Condensed_Black52pt7b.h"
#include "NotoSans_Condensed_Black53pt7b.h"
#include "NotoSans_Condensed_Black54pt7b.h"
#include "NotoSans_Condensed_Black55pt7b.h"
#include "NotoSans_Condensed_Black56pt7b.h"
#include "NotoSans_Condensed_Black57pt7b.h"
#include "NotoSans_Condensed_Black58pt7b.h"
#include "NotoSans_Condensed_Black59pt7b.h"
#include "NotoSans_Condensed_Black60pt7b.h"
#include "NotoSans_Condensed_Black61pt7b.h"
#include "NotoSans_Condensed_Black62pt7b.h"
#include "NotoSans_Condensed_Black63pt7b.h"
#include "NotoSans_Condensed_Black64pt7b.h"
#include "NotoSans_Condensed_Black65pt7b.h"
#include "NotoSans_Condensed_Black66pt7b.h"
#include "NotoSans_Condensed_Black67pt7b.h"
#include "NotoSans_Condensed_Black68pt7b.h"
#include "NotoSans_Condensed_Black69pt7b.h"
#include "NotoSans_Condensed_Black70pt7b.h"
#include "NotoSans_Condensed_Black71pt7b.h"
#include "NotoSans_Condensed_Black72pt7b.h"
