#ifndef _NOTOSANS_CONDENSED_BLACK56PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xFE, 0x7F, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF1, 0xFC, 0x06, 0x00, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xF9, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xCF, 0xF9, 0xE1, 0xC7, 0xF8, 0xF0, 0x23, 0xFC, 0x78, 0x01, 0xFE,
  0x3C, 0x00, 0xFF, 0x9E, 0x00, 0x3F, 0xEF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xEF, 0xF8, 0x00, 0xF3, 0xFC, 0x00, 0x79,
  0xFE, 0x80, 0x3C, 0xFF, 0x70, 0x1E, 0x7F, 0xBF, 0x0F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F,
  0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC3,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xF1, 0xFC, 0x00, 0x00, 0xFF, 0x1F,
  0xE3, 0xF8, 0x1E, 0x00, 0xFE, 0x3F, 0x8F, 0xE0, 0xFF, 0x81, 0xFC, 0x7F,
  0x1F, 0xC7, 0xFF, 0x83, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF, 0x83, 0xFF, 0xF8,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0xC7,
  0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xE3, 0xF9, 0xFE, 0x07, 0xFC, 0x3F,
  0x8F, 0xF1, 0xFC, 0x00, 0xC0, 0x7F, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC,
  0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83,
  0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0xCF, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0x83, 0xFF, 0xFF,
  0xE7, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xC1,
  0xFF, 0x8F, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xF3, 0xF8, 0x01, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x06, 0x07, 0xF0, 0x11, 0xF0, 0xFC,
  0x3C, 0x7F, 0x3F, 0x7F, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xDF, 0xF0, 0x1F, 0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0xFE,
  0x1F, 0xC0, 0x1F, 0x07, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x20, 0x10, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF1, 0xFE, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x07, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB,
  0xFF, 0x7F, 0xC7, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0x7F, 0xCF, 0xF8,
  0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFE, 0x0F, 0xFD, 0xFF, 0x07,
  0xFC, 0xFF, 0xC3, 0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xE7,
  0xFC, 0xFF, 0x3F, 0xE3, 0xF1, 0xFF, 0x0F, 0x0F, 0xF8, 0x30, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0xE1, 0xF0, 0x1F, 0xF8, 0x38, 0x07, 0xFE,
  0x04, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0x03, 0xFF, 0x86, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFB, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xF3, 0xFE, 0x00, 0xFF,
  0x3F, 0xE0, 0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE,
  0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x10, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0xF0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xDE, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x38, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x9F, 0xFC, 0x3F, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F,
  0xFB, 0xFF, 0x87, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xFC,
  0x0F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF,
  0xFC, 0x0F, 0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xFC, 0x1F, 0xFB,
  0xFF, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xBF, 0xF0, 0x7F, 0xDF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0x8F, 0xFF, 0x7F, 0xC1, 0xFE,
  0x3F, 0xE0, 0x1C, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x1E, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x8F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x87, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xF8, 0x30, 0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x3F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x3F, 0xE7, 0xFD, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3,
  0xFE, 0x7F, 0x8F, 0xF3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7C, 0x0F,
  0xFC, 0x60, 0x0F, 0xF8, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0x87, 0xF8, 0x3F, 0xFF, 0xCF, 0xE3, 0xF8,
  0x3F, 0xFF, 0xE7, 0xF1, 0xFC, 0x3F, 0xFF, 0xF1, 0xF9, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFE, 0xFE, 0x1F, 0xE1, 0xF8, 0x7F, 0x7F, 0x1F, 0xE1, 0xFC, 0x3F,
  0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xFF, 0xC7,
  0xF8, 0x3F, 0x87, 0xFF, 0xE3, 0xF8, 0x1F, 0xC3, 0xFF, 0xF1, 0xFC, 0x0F,
  0xE1, 0xFF, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0xBF, 0x87,
  0xF0, 0xFF, 0x1F, 0xDF, 0xC3, 0xFC, 0x7F, 0x8F, 0xEF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0xFF, 0xF0,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0,
  0x18, 0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB,
  0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81,
  0xFF, 0xBF, 0xF0, 0x7F, 0xE7, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFE, 0x1F, 0xFE, 0xFF,
  0xC0, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xC0, 0xF0, 0xFF, 0xE0, 0x06, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x06, 0x3F, 0xFE, 0x03, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFE, 0x0F, 0xFF, 0x3F, 0xF0, 0x3F, 0xFD, 0xFF, 0x80, 0xFF, 0xEF, 0xFC,
  0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x07, 0xFF,
  0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0x07, 0xFF, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xE0, 0xFF, 0xF0, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0xE0, 0xFF,
  0xFE, 0xFF, 0xC1, 0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xCF, 0xFE, 0x01, 0xFF,
  0x9F, 0xFE, 0x03, 0xFF, 0x3F, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x1C,
  0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x03,
  0xFF, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF,
  0x8F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x80, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xBF, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x7F,
  0x81, 0xFF, 0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0x7F, 0x81, 0xFD,
  0xFF, 0xFF, 0x7F, 0xC3, 0xFD, 0xFF, 0xFF, 0xBF, 0xC3, 0xFD, 0xFF, 0xFF,
  0xBF, 0xC3, 0xFD, 0xFF, 0xFF, 0xBF, 0xC3, 0xF9, 0xFF, 0xFF, 0x9F, 0xE7,
  0xF9, 0xFF, 0xFF, 0x9F, 0xE7, 0xF9, 0xFF, 0xFF, 0x9F, 0xE7, 0xF1, 0xFF,
  0xFF, 0x9F, 0xE7, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x7F, 0xC1,
  0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0x3F, 0xF1,
  0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0x9F, 0xF9,
  0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0x87, 0xFD,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x1F, 0xFD, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F,
  0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F,
  0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0x83, 0xFF,
  0x8F, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFE, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1,
  0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x3F, 0xFB, 0xFF,
  0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xE0, 0xFC,
  0xFF, 0xC0, 0x1C, 0xFF, 0xC0, 0x04, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF,
  0x80, 0xFF, 0xEF, 0xFF, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF,
  0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xBF,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xCF,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE,
  0x1F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0x83, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFE, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0x7F, 0x0F,
  0xFC, 0x07, 0xFC, 0x3F, 0xBF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xDF, 0xC3,
  0xFE, 0x01, 0xFF, 0x1F, 0xEF, 0xF1, 0xFF, 0x00, 0xFF, 0xCF, 0xF3, 0xF9,
  0xFF, 0x80, 0x3F, 0xE7, 0xF9, 0xFC, 0xFF, 0xC0, 0x1F, 0xF3, 0xF8, 0xFE,
  0x7F, 0xC0, 0x0F, 0xF9, 0xFC, 0x7F, 0x3F, 0xE0, 0x07, 0xFD, 0xFE, 0x3F,
  0x9F, 0xF0, 0x01, 0xFE, 0xFF, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0x87,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF,
  0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07,
  0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0x83, 0xFF, 0x82, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFB, 0xFF, 0xF3,
  0xFC, 0xFF, 0xF1, 0xFE, 0x3F, 0xE0, 0x7F, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x02, 0x00, 0xFF, 0xC7, 0xF8, 0x3F, 0xE3, 0xFF, 0x0F, 0xF9, 0xFF, 0xE3,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xBF, 0xFE,
  0x3F, 0xC7, 0xFF, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF8,
  0xFF, 0xE0, 0x21, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x01, 0x3F, 0xF0, 0x0E, 0x7F, 0xFD, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0x01, 0xFF,
  0x03, 0xFC, 0x7F, 0xC3, 0xFF, 0x9F, 0xF1, 0xFF, 0xF7, 0xFC, 0x7F, 0xFD,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF7,
  0xFE, 0x0F, 0xFD, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0x3F, 0xC3, 0xFF,
  0x8F, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x7F, 0xC0,
  0xFF, 0x9F, 0xF0, 0x3F, 0xEF, 0xFC, 0x07, 0xFB, 0xFF, 0x01, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x11, 0xFF,
  0xC0, 0x3C, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF,
  0xE3, 0xFC, 0x7F, 0xFC, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x7F, 0xC7, 0xFF, 0xDF, 0xF0, 0xFF, 0xE7, 0xFC, 0x0F, 0xF1, 0xFF,
  0x00, 0x40, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFD, 0x00, 0x03,
  0xFF, 0x78, 0x01, 0xFF, 0x9F, 0xF7, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0x00, 0xFF, 0x8F,
  0xF8, 0x3F, 0xE7, 0xFF, 0x8F, 0xFB, 0xFF, 0xF3, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFC, 0x7F, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF,
  0x9F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7,
  0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xBF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF7, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE3,
  0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE,
  0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x3F, 0xC3, 0xFF, 0x03, 0xFE, 0x0F, 0xF1,
  0xFF, 0xE1, 0xFF, 0xE3, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x80, 0x3F, 0xC3, 0xFE, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC, 0xFF,
  0xFC, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF1, 0xFF, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x3F,
  0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xF0,
  0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFF, 0xC3, 0xFE, 0x7F,
  0xF8, 0xFF, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xBF, 0xFF, 0x3F, 0xEF,
  0xFF, 0x8F, 0xF9, 0xFF, 0xC3, 0xFF, 0x1F, 0xE0, 0xFF, 0xC1, 0x80, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0xE3,
  0xFC, 0x3F, 0xFC, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0x7F, 0xC7, 0xFF, 0xDF, 0xF0, 0xFF, 0xE7, 0xFC, 0x0F, 0xF1, 0xFF, 0x00,
  0x40, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x9F, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xF1, 0x7F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0x81, 0xC7, 0xFC, 0x02,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xFC, 0x3F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x82, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0x3F, 0xC7, 0xFF, 0x8F, 0xF0, 0x7F, 0xC3,
  0xFC, 0x01, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF,
  0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0x1F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF,
  0x9F, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F,
  0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xF0,
  0x3F, 0xE7, 0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x7F, 0xE0, 0xFF, 0xF0, 0x3F,
  0xE3, 0xFE, 0x0F, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF,
  0x1F, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0x3F,
  0xBF, 0xCF, 0xF8, 0x1F, 0xF3, 0xF9, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0x9F,
  0xCF, 0xF8, 0x0F, 0xF3, 0xF9, 0xFC, 0xFF, 0x00, 0xFF, 0xBF, 0x9F, 0xCF,
  0xF0, 0x0F, 0xFB, 0xF9, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xFB, 0xFF, 0x83, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF7,
  0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x01,
  0xFF, 0xBF, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x3F, 0xF0, 0x1F,
  0xFB, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF,
  0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x5F, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xA0, 0x01, 0xFF,
  0x88, 0x00, 0x06, 0x00,
};

const GFXglyph NotoSans_Condensed_Black56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 41, 16, 2, -40 },
  { 58, 22, 14, 28, 3, -40 },
  { 97, 31, 40, 32, 1, -40 },
  { 252, 25, 46, 29, 2, -43 },
  { 396, 47, 41, 49, 1, -41 },
  { 637, 38, 41, 39, 1, -40 },
  { 832, 9, 14, 15, 3, -40 },
  { 848, 16, 50, 19, 2, -41 },
  { 948, 17, 50, 19, 0, -41 },
  { 1055, 26, 26, 28, 1, -43 },
  { 1140, 25, 27, 29, 2, -33 },
  { 1225, 11, 16, 16, 2, -8 },
  { 1247, 15, 8, 18, 2, -19 },
  { 1262, 11, 11, 16, 2, -10 },
  { 1278, 24, 42, 24, 0, -41 },
  { 1404, 25, 42, 29, 2, -41 },
  { 1536, 21, 40, 29, 2, -40 },
  { 1641, 26, 41, 29, 1, -41 },
  { 1775, 25, 42, 29, 2, -41 },
  { 1907, 28, 40, 29, 1, -40 },
  { 2047, 24, 41, 29, 3, -40 },
  { 2170, 26, 42, 29, 2, -41 },
  { 2307, 25, 40, 29, 2, -40 },
  { 2432, 26, 42, 29, 2, -41 },
  { 2569, 25, 42, 29, 2, -41 },
  { 2701, 10, 32, 16, 3, -31 },
  { 2741, 11, 39, 16, 2, -31 },
  { 2795, 25, 29, 29, 2, -35 },
  { 2886, 25, 20, 29, 2, -30 },
  { 2949, 26, 29, 29, 2, -35 },
  { 3044, 23, 42, 24, 0, -41 },
  { 3165, 41, 44, 45, 2, -40 },
  { 3391, 35, 40, 35, 0, -40 },
  { 3566, 27, 40, 33, 4, -40 },
  { 3701, 27, 42, 31, 2, -41 },
  { 3843, 29, 40, 35, 4, -40 },
  { 3988, 20, 40, 27, 4, -40 },
  { 4088, 20, 40, 26, 4, -40 },
  { 4188, 31, 42, 36, 2, -41 },
  { 4351, 29, 40, 37, 4, -40 },
  { 4496, 18, 40, 21, 2, -40 },
  { 4586, 18, 53, 17, -4, -40 },
  { 4706, 30, 40, 33, 4, -40 },
  { 4856, 21, 40, 27, 4, -40 },
  { 4961, 40, 40, 48, 4, -40 },
  { 5161, 32, 40, 40, 4, -40 },
  { 5321, 33, 42, 38, 2, -41 },
  { 5495, 25, 40, 31, 4, -40 },
  { 5620, 34, 51, 38, 2, -41 },
  { 5837, 29, 40, 33, 4, -40 },
  { 5982, 24, 42, 28, 2, -41 },
  { 6108, 26, 40, 28, 1, -40 },
  { 6238, 29, 41, 36, 3, -40 },
  { 6387, 34, 40, 34, 0, -40 },
  { 6557, 49, 40, 49, 0, -40 },
  { 6802, 33, 40, 33, 0, -40 },
  { 6967, 32, 40, 32, 0, -40 },
  { 7127, 27, 40, 29, 1, -40 },
  { 7262, 13, 50, 17, 3, -41 },
  { 7344, 24, 42, 24, 0, -41 },
  { 7470, 14, 50, 17, 1, -41 },
  { 7558, 30, 26, 30, 0, -40 },
  { 7656, 28, 6, 28, 0, 4 },
  { 7677, 16, 9, 20, 2, -43 },
  { 7695, 25, 33, 30, 2, -32 },
  { 7799, 26, 44, 31, 3, -43 },
  { 7942, 23, 33, 26, 2, -32 },
  { 8037, 26, 44, 31, 2, -43 },
  { 8180, 26, 32, 29, 2, -31 },
  { 8284, 20, 43, 20, 1, -43 },
  { 8392, 26, 45, 31, 2, -32 },
  { 8539, 26, 43, 32, 3, -43 },
  { 8679, 10, 43, 16, 3, -43 },
  { 8733, 15, 56, 16, -2, -43 },
  { 8838, 29, 43, 31, 3, -43 },
  { 8994, 10, 43, 16, 3, -43 },
  { 9048, 42, 32, 48, 3, -32 },
  { 9216, 26, 32, 32, 3, -32 },
  { 9320, 27, 33, 31, 2, -32 },
  { 9432, 26, 45, 31, 3, -32 },
  { 9579, 26, 45, 31, 2, -32 },
  { 9726, 19, 32, 23, 3, -32 },
  { 9802, 21, 33, 24, 2, -32 },
  { 9889, 19, 38, 22, 1, -37 },
  { 9980, 26, 32, 32, 3, -31 },
  { 10084, 29, 31, 30, 0, -31 },
  { 10197, 44, 31, 44, 0, -31 },
  { 10368, 29, 31, 29, 0, -31 },
  { 10481, 29, 44, 30, 0, -31 },
  { 10641, 22, 31, 24, 1, -31 },
  { 10727, 19, 50, 22, 1, -41 },
  { 10846, 7, 56, 25, 9, -43 },
  { 10895, 20, 50, 22, 1, -41 },
  { 11020, 26, 11, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_Black56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_BLACK56PT7B_H_
