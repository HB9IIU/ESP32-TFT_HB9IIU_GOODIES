#ifndef _NOTOSANS_CONDENSED_BLACK72PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0xF8, 0x3F,
  0xF1, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF9, 0xFF, 0xC3, 0xFE, 0x01, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF,
  0x07, 0xFF, 0xBF, 0xF8, 0x3F, 0xFD, 0xFF, 0xC1, 0xFF, 0xEF, 0xFE, 0x07,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE,
  0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x3F, 0xF8, 0x1F, 0xF9, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE7, 0xE1, 0xF8, 0xFF, 0xC7, 0xE0,
  0x30, 0xFF, 0xC7, 0xE0, 0x10, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0xC7, 0xE0,
  0x00, 0xFF, 0xE7, 0xE0, 0x00, 0xFF, 0xF7, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xE7, 0xFF, 0x00, 0x07, 0xE7,
  0xFF, 0x00, 0x07, 0xE3, 0xFF, 0x80, 0x07, 0xE3, 0xFF, 0xE0, 0x07, 0xE3,
  0xFF, 0xF8, 0x07, 0xE7, 0xFE, 0xFF, 0x07, 0xEF, 0xFE, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xE7, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x80, 0x78, 0x01,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x3F, 0xFF, 0x03, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x38, 0x0F, 0xF8, 0x07, 0x1F, 0x83, 0xFC, 0x1F, 0x8F, 0xF1, 0xFE,
  0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE, 0xFF,
  0xF8, 0x1F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF,
  0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF9, 0xFF, 0xE7, 0xFE, 0x3F, 0xFC,
  0x7F, 0xCF, 0xFF, 0x87, 0xF1, 0xFF, 0xF0, 0x7C, 0x3F, 0xFE, 0x07, 0x07,
  0xFF, 0xC0, 0x40, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xE0, 0x7F, 0xFE, 0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0x00, 0x3F, 0xFE,
  0x0E, 0x00, 0x1F, 0xFE, 0x06, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0x81, 0xF0, 0x07, 0xFF, 0xC0, 0xE0, 0x01,
  0xFF, 0xE0, 0x20, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xFC,
  0x00, 0x1F, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xF3,
  0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x0F,
  0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xCF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x0C, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x01, 0x81, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xE0, 0x0F, 0xFE,
  0x3F, 0xFC, 0x07, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xBF, 0xFF, 0xE1, 0xFF,
  0xDF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xDF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F,
  0xFB, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF8, 0x1F,
  0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0x80, 0xFF,
  0xF1, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0xDF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F,
  0xFE, 0x0F, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xDF, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xE7,
  0xFF, 0xC1, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xE0, 0x3F, 0xFD,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xDF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0xEF, 0xFF, 0x07, 0xFF,
  0xE7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0x81, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x1F, 0xE0, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x07,
  0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x9F,
  0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0x1E, 0x00, 0x3F, 0xFC, 0x20, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFE,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x1F, 0xF7, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0x7F, 0xC1, 0xFF, 0xC3, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0xFF, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xEF, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFE, 0xFF, 0x83, 0xFF,
  0x3F, 0xFE, 0x7F, 0xCF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xF7, 0xFF, 0xF0, 0x7F,
  0xC0, 0xFF, 0xFE, 0x7F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xDF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE7,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xF7, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F,
  0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xFD, 0xFF, 0xE0,
  0x0F, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFC, 0xFF,
  0xF0, 0x0F, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xE0, 0x7F, 0xFF,
  0x3F, 0xFC, 0x03, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xF0, 0x07,
  0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xBF,
  0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0x81, 0xFF, 0xF8, 0x00, 0x70, 0x7F, 0xFE, 0x00, 0x04, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0C, 0x3F, 0xFF, 0xC0, 0x07, 0x83, 0xFF, 0xFE, 0x07,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0xDF, 0xFE,
  0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xEF,
  0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F,
  0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x1F, 0x01, 0xFF, 0xFC, 0x00, 0x06, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF8,
  0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0xFF,
  0xF7, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFF,
  0xC0, 0x07, 0xFF, 0x9F, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0xBF, 0xFC, 0x00,
  0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F,
  0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xFE, 0x00, 0xFF,
  0xF1, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFE,
  0x00, 0x3F, 0xFD, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x03, 0xFF,
  0xDF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xF0,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xF8,
  0xFF, 0xF0, 0x07, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0xCF, 0xFF, 0x00,
  0x3F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xFB,
  0xFF, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x03, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0xEF, 0xFE, 0x07, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0xE7, 0xFE, 0x07,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xF9, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0x9F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xF9, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0x9F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xFF, 0xF9, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x03,
  0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x01,
  0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0xFF, 0xFD, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x80, 0x07, 0xFF, 0xE3, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFC, 0x3F, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xF7,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xF7, 0xFF, 0x81, 0xFF,
  0xFB, 0xFF, 0xC1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE3, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x01,
  0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xEF, 0xFF, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xBF,
  0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x7F,
  0xFD, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x01, 0xFF, 0xF7,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xCF, 0xFF,
  0x80, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x05, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x03, 0xFF, 0xC7,
  0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F,
  0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x03,
  0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xC7, 0xFF,
  0xC0, 0x0F, 0x0F, 0xFF, 0x80, 0x06, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF9, 0xFF,
  0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0xFF, 0x9F, 0xFF, 0x80, 0x7F,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xFD, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xFF, 0xE1,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xE3, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xDF,
  0xFE, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC7, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x3F, 0xEF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xDF, 0xF0,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xBF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF,
  0xC3, 0xFF, 0x7F, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFE, 0x7F, 0xC3,
  0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xC7, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xF9,
  0xFF, 0x8F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x0F, 0xF9, 0xFF,
  0xE0, 0x00, 0xFF, 0xE7, 0xFE, 0x1F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF,
  0xF8, 0x3F, 0xEF, 0xFF, 0x00, 0x03, 0xFF, 0xDF, 0xF0, 0x7F, 0xDF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xFF, 0xE1,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0x00, 0x07,
  0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xBF, 0xFE, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x80, 0x0F, 0xFF, 0xC7, 0xFF,
  0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x0F,
  0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x1F, 0xFF, 0x01, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFB, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x40, 0x03, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFC,
  0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xFF,
  0xEF, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x07,
  0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0xFF,
  0xFB, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0x9F, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x07, 0x87, 0xFF, 0xC0, 0x0C, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0x7F, 0xFE, 0x00, 0x39, 0xFF, 0xF8, 0x07,
  0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x60, 0x1F, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0xFD, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF7, 0xFF, 0xC1, 0xFF, 0xFB, 0xFF,
  0xF9, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xFE,
  0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x04, 0x7F, 0xFC, 0x00, 0x0C, 0x7F, 0xFE, 0x00, 0x7C,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xFF, 0xDF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xBF, 0xFC, 0x3F, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x80, 0x1E, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFA, 0x00, 0x00, 0x7F,
  0xFD, 0xE0, 0x00, 0x7F, 0xFC, 0xFE, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x10, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF9, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x87, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFF, 0x3F,
  0xFC, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC0,
  0x3F, 0xFC, 0x7F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F,
  0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF7,
  0xFF, 0xE0, 0x3F, 0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0x80, 0x7F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF,
  0xCF, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xBF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFE, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xEF, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF,
  0xBF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0x9F, 0xFE, 0x03, 0xFF,
  0xE7, 0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF,
  0xF8, 0x3F, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF,
  0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0xE0, 0x1F, 0xFE,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0xFF, 0x03, 0xFF, 0xEF,
  0xFF, 0xC1, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F,
  0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0xDF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0xFC,
  0x3F, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0x87, 0xFF,
  0x80, 0x1E, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x08, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xC0, 0x7C, 0x7F, 0xF8, 0x03, 0x8F, 0xFF, 0x00, 0x11, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x04, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0xFF, 0x8F, 0xFC, 0x1F,
  0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xF7, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF7, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFE, 0x1F, 0xF7, 0xFC, 0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF7, 0xFC,
  0x7F, 0xF8, 0x0F, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0xF0, 0x0F, 0xFF, 0x3F,
  0xE7, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xE7, 0xFE, 0x7F, 0xF0, 0x07,
  0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xE3, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC3,
  0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0xE0, 0x03, 0xFF,
  0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F,
  0xFF, 0x80, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF,
  0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F,
  0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0xF0,
  0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFD,
  0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFF, 0x00,
  0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xC3,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F,
  0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x87, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x8F, 0xFF, 0xC0, 0x00, 0x4F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC8, 0x00, 0x01, 0xFF, 0xC4, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Black72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 52, 20, 3, -51 },
  { 92, 29, 18, 36, 3, -51 },
  { 158, 40, 51, 42, 1, -51 },
  { 413, 32, 59, 37, 3, -55 },
  { 649, 59, 53, 63, 2, -52 },
  { 1040, 48, 53, 50, 2, -52 },
  { 1358, 13, 18, 19, 3, -51 },
  { 1388, 20, 64, 24, 3, -53 },
  { 1548, 20, 64, 24, 1, -53 },
  { 1708, 33, 33, 36, 1, -55 },
  { 1845, 32, 35, 38, 3, -43 },
  { 1985, 15, 21, 20, 2, -11 },
  { 2025, 19, 11, 23, 2, -25 },
  { 2052, 14, 14, 20, 3, -13 },
  { 2077, 31, 53, 31, 0, -52 },
  { 2283, 32, 53, 38, 3, -52 },
  { 2495, 27, 51, 38, 3, -51 },
  { 2668, 32, 52, 38, 2, -52 },
  { 2876, 33, 53, 38, 2, -52 },
  { 3095, 36, 51, 38, 1, -51 },
  { 3325, 30, 52, 38, 4, -51 },
  { 3520, 33, 53, 38, 2, -52 },
  { 3739, 32, 51, 38, 3, -51 },
  { 3943, 33, 53, 38, 2, -52 },
  { 4162, 33, 53, 38, 2, -52 },
  { 4381, 14, 41, 20, 3, -40 },
  { 4453, 15, 50, 21, 2, -40 },
  { 4547, 33, 36, 38, 2, -44 },
  { 4696, 32, 25, 38, 3, -38 },
  { 4796, 32, 36, 38, 3, -44 },
  { 4940, 30, 53, 31, 0, -52 },
  { 5139, 52, 57, 58, 3, -52 },
  { 5510, 45, 51, 45, 0, -51 },
  { 5797, 35, 51, 43, 5, -51 },
  { 6021, 35, 53, 40, 3, -52 },
  { 6253, 37, 51, 45, 5, -51 },
  { 6489, 26, 51, 34, 5, -51 },
  { 6655, 26, 51, 34, 5, -51 },
  { 6821, 39, 53, 46, 3, -52 },
  { 7080, 38, 51, 47, 5, -51 },
  { 7323, 23, 51, 27, 2, -51 },
  { 7470, 23, 67, 22, -5, -51 },
  { 7663, 38, 51, 43, 5, -51 },
  { 7906, 28, 51, 34, 5, -51 },
  { 8085, 52, 51, 62, 5, -51 },
  { 8417, 41, 51, 51, 5, -51 },
  { 8679, 42, 53, 49, 3, -52 },
  { 8958, 33, 51, 40, 5, -51 },
  { 9169, 43, 64, 49, 3, -52 },
  { 9513, 38, 51, 42, 5, -51 },
  { 9756, 31, 53, 35, 2, -52 },
  { 9962, 34, 51, 36, 1, -51 },
  { 10179, 38, 52, 46, 4, -51 },
  { 10426, 43, 51, 43, 0, -51 },
  { 10701, 63, 51, 63, 0, -51 },
  { 11103, 42, 51, 42, 0, -51 },
  { 11371, 41, 51, 41, 0, -51 },
  { 11633, 33, 51, 37, 2, -51 },
  { 11844, 18, 65, 22, 3, -53 },
  { 11991, 31, 53, 31, 0, -52 },
  { 12197, 18, 65, 22, 1, -53 },
  { 12344, 39, 34, 39, 0, -51 },
  { 12510, 36, 8, 36, 0, 5 },
  { 12546, 20, 11, 26, 3, -55 },
  { 12574, 32, 42, 38, 2, -41 },
  { 12742, 34, 56, 40, 4, -55 },
  { 12980, 29, 42, 33, 3, -41 },
  { 13133, 33, 56, 40, 3, -55 },
  { 13364, 32, 41, 38, 3, -40 },
  { 13528, 26, 55, 25, 1, -55 },
  { 13707, 33, 58, 40, 3, -41 },
  { 13947, 33, 55, 41, 4, -55 },
  { 14174, 13, 56, 20, 4, -56 },
  { 14265, 20, 73, 20, -3, -56 },
  { 14448, 37, 55, 40, 4, -55 },
  { 14703, 12, 55, 20, 4, -55 },
  { 14786, 54, 41, 61, 4, -41 },
  { 15063, 33, 41, 41, 4, -41 },
  { 15233, 34, 42, 40, 3, -41 },
  { 15412, 34, 58, 40, 4, -41 },
  { 15659, 33, 58, 40, 3, -41 },
  { 15899, 24, 41, 29, 4, -41 },
  { 16022, 27, 42, 31, 2, -41 },
  { 16164, 25, 49, 28, 1, -48 },
  { 16318, 33, 41, 41, 4, -40 },
  { 16488, 38, 40, 38, 0, -40 },
  { 16678, 56, 40, 57, 0, -40 },
  { 16958, 37, 40, 38, 0, -40 },
  { 17143, 38, 57, 38, 0, -40 },
  { 17414, 29, 40, 31, 1, -40 },
  { 17559, 25, 64, 28, 1, -52 },
  { 17759, 10, 71, 32, 11, -55 },
  { 17848, 25, 64, 28, 2, -52 },
  { 18048, 33, 14, 38, 2, -32 },
};

const GFXfont NotoSans_Condensed_Black72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_BLACK72PT7B_H_
