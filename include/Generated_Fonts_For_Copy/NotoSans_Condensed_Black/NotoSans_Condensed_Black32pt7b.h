#ifndef _NOTOSANS_CONDENSED_BLACK32PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x00, 0x00, 0x21, 0xF7, 0xEF, 0xCF, 0x9F, 0x00, 0xFC, 0xFB,
  0xE7, 0xDF, 0x3E, 0xF9, 0xF7, 0xCF, 0xBE, 0x7D, 0xF3, 0xEF, 0x1F, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xC0, 0x79, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x8E, 0x03, 0xCF,
  0x01, 0xE7, 0x87, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x1E,
  0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0xFF, 0x0F, 0xFF, 0x7F, 0xFD, 0xFF, 0xEF, 0xB9,
  0xBE, 0xE0, 0xFB, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBE, 0x0E, 0xF7, 0x3F, 0xDF, 0xFF, 0x7F,
  0xF9, 0xFF, 0xC1, 0xFC, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0x00,
  0xF0, 0x1F, 0xE0, 0x7C, 0x07, 0xF8, 0x1E, 0x03, 0xFF, 0x07, 0x80, 0xF3,
  0xC3, 0xC0, 0x3C, 0xF0, 0xF0, 0x0F, 0x3C, 0x78, 0x03, 0xCF, 0x1E, 0x00,
  0xF3, 0xCF, 0x00, 0x3C, 0xF3, 0xCF, 0x8F, 0xFD, 0xE7, 0xF1, 0xFE, 0x7B,
  0xFE, 0x7F, 0xBE, 0xFF, 0xCF, 0xCF, 0x3C, 0xF0, 0x03, 0xCF, 0x3C, 0x01,
  0xE3, 0xCF, 0x00, 0x78, 0xF3, 0xC0, 0x3C, 0x3C, 0xF0, 0x0F, 0x0F, 0x3C,
  0x07, 0x83, 0xDF, 0x01, 0xE0, 0xFF, 0x80, 0xF0, 0x1F, 0xE0, 0x3C, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFC, 0xFC, 0x7F, 0xC7, 0xE7, 0xFF, 0x3F, 0x3F,
  0xFF, 0xF3, 0xF7, 0xFF, 0x9F, 0x9F, 0xFC, 0xFC, 0x7F, 0xC7, 0xE1, 0xFE,
  0x3F, 0xBF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0x8F, 0xE0, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x80,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0x1E, 0x37, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xF3, 0xE1, 0xE7,
  0x81, 0x84, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0xF9, 0xF3, 0xE7,
  0xCF, 0xBE, 0x7C, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x11, 0xFF, 0xFF,
  0x7D, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0xCF, 0x9F, 0x9F, 0x1F, 0x7E, 0x3E, 0xFC, 0x7D,
  0xF8, 0xFB, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0x7E,
  0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xFB, 0xF3, 0xFF, 0xC3, 0xFF, 0x83, 0xFE,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF,
  0x7F, 0xFF, 0xDF, 0x3D, 0xF3, 0x9F, 0x11, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFD, 0xC3,
  0xF2, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x7F, 0xFC, 0x83, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x7F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC7, 0xFC, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x1E, 0xF8, 0x7F, 0xF0, 0xF7, 0xE3, 0xEF, 0xC7, 0x9F,
  0x9E, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xC7, 0xFF,
  0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF3, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xFC, 0xCF, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF, 0xDF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7E, 0xF8, 0xFD, 0xFB, 0xF3, 0xFF, 0xE3,
  0xFF, 0x83, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xCF,
  0x8F, 0x9F, 0x1F, 0x3E, 0x7E, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0xBF, 0x3F, 0x7E, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xDF, 0x8F, 0xBF, 0x1F, 0x7C,
  0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0x8F, 0xDF, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF1, 0x0F, 0xE3, 0xFF, 0x87,
  0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x38, 0xF9, 0xF7, 0xF7, 0xC7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x8F, 0x9F, 0x7F, 0x7C, 0xF8, 0x38, 0xF9,
  0xFB, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x3E,
  0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7E, 0x07, 0xFC, 0x3F, 0xE3, 0xFF, 0x0F, 0xF8, 0x1F,
  0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x1F, 0xC3, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF7, 0xFF, 0x90, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x3F, 0x81,
  0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0x3C, 0x3C, 0x7F, 0xDE, 0x78, 0xFF, 0xDE, 0x79, 0xFF, 0xCE,
  0x71, 0xE3, 0xCF, 0xF3, 0xC3, 0x8F, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8F,
  0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x9E, 0xF1, 0xFF, 0xFC,
  0x79, 0xFD, 0xFC, 0x78, 0xF8, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF9,
  0xF0, 0x1F, 0x9F, 0x01, 0xF9, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7,
  0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xF0, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x7E,
  0xFC, 0x7E, 0xFC, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFC, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x04, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x02, 0x3F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE3, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xC0, 0x47, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xF7, 0xC0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xC3, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xEF,
  0xFB, 0xFC, 0xFF, 0x3F, 0x00, 0xFC, 0x1F, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF,
  0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xE3, 0xF7, 0xF1, 0xFB, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xEF,
  0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0x8F,
  0x7F, 0xEF, 0x9E, 0xFF, 0xDF, 0x3D, 0xFF, 0xBE, 0xFB, 0xFF, 0x3D, 0xE7,
  0xFE, 0x7F, 0xCF, 0xFC, 0xFF, 0x9F, 0xF8, 0xFF, 0x3F, 0xF1, 0xFC, 0x7F,
  0xE3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFF, 0x87, 0xE3, 0xFF, 0x0F, 0x87, 0xFE,
  0x1F, 0x0F, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xFF, 0x7C, 0xFF, 0xEF, 0xDF, 0xFC, 0xFB, 0xFF, 0x9F, 0xBF, 0xF3, 0xF7,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x1F,
  0x9F, 0x83, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0xE1, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xDF, 0x9F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF7, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xF8, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01,
  0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xE1, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8,
  0xFC, 0xFC, 0x7E, 0x7E, 0x7F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xF7, 0xC1, 0xFB, 0xF0, 0xFC, 0xF8, 0x7E, 0x7E, 0x3F, 0x1F,
  0x9F, 0x8F, 0xCF, 0xC7, 0xF7, 0xE1, 0xFB, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF,
  0xF7, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB, 0xF0, 0x6F, 0xC0, 0x3F, 0x00, 0xFF,
  0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0xFC, 0x1F, 0x7E, 0x1F, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xC0, 0xFC, 0x07, 0xFF, 0x80,
  0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x8F, 0x83,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0xCF,
  0x81, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0xFC, 0x0F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0x7C, 0x1F,
  0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xE1, 0xFC, 0x7E,
  0x7E, 0x3F, 0xC7, 0xE3, 0xE3, 0xFC, 0x7C, 0x3E, 0x3F, 0xC7, 0xC3, 0xE3,
  0xFC, 0x7C, 0x3F, 0x3F, 0xCF, 0xC3, 0xF7, 0xDE, 0xFC, 0x1F, 0x79, 0xEF,
  0x81, 0xF7, 0x9E, 0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xF7, 0x9E, 0xF8, 0x0F,
  0x79, 0xEF, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0xFC, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x9F, 0x83, 0xF3, 0xF0,
  0x3F, 0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xE0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x1F, 0xBF, 0x03, 0xF8, 0xFC, 0x0F, 0xDF, 0x03, 0xF7,
  0xE1, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0x0F, 0xCF, 0xC1, 0xF3, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1E, 0xF0, 0x1F, 0x7C,
  0x0F, 0x1E, 0x0F, 0x8F, 0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0xE1, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x18,
  0xFC, 0x01, 0xF0, 0x07, 0xC7, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0xC7, 0xFF,
  0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBC, 0xFC, 0xF0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x78, 0x7D, 0xFC, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xE3, 0xEF, 0x87,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xF7,
  0xE7, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0x79, 0xF8, 0x07, 0xE0, 0xFF,
  0xCF, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0x0B, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xBF, 0x1D, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF8, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC3, 0xCF, 0x9F, 0xDF, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE3, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF1, 0xFB, 0xF3, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xEF, 0x8F, 0x8F,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0xBF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC1, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF1,
  0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0x03, 0xF0, 0x3F, 0xE7, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0x3E,
  0x7F, 0x7C, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xEF, 0xCF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xBE, 0x3E, 0x7C, 0x00, 0xF8, 0x03, 0xF6,
  0x07, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0x0F, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x7C,
  0x7D, 0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xE3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0x77, 0xFF, 0xFF, 0x90,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x04, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3F, 0xFF, 0xFF, 0xFE, 0xFC, 0xF0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8,
  0x7E, 0xF8, 0xFC, 0xF8, 0xFC, 0xF9, 0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFD, 0xF8, 0xF8,
  0xFC, 0xF8, 0xFC, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xF0, 0xF8, 0xF3, 0xF9, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F,
  0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F,
  0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F,
  0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF1, 0xF1, 0xE7, 0xF3, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7E, 0xFE, 0x7C, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xE0, 0xF1, 0xE1, 0xF7, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF,
  0xFF, 0xDF, 0x8F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0xC7, 0xDF, 0xDF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFB, 0xF9,
  0xF3, 0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x3E, 0x7F, 0x7C, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xEF, 0xCF, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F,
  0xBE, 0x3E, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF1, 0xFE, 0x7F, 0xFF, 0x7F, 0xEF,
  0xFD, 0xFF, 0xBF, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x1F, 0x87, 0xFF, 0x7F, 0xEF,
  0xFE, 0xF8, 0xEF, 0x80, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0x7F, 0x83, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x93,
  0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xBE, 0x7E, 0x7C, 0xFC, 0x1F, 0xFE, 0x0F, 0x9F, 0x07, 0xCF, 0x87,
  0xE7, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xFC, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x7F, 0x0F, 0xFE, 0x3F,
  0x8F, 0xDF, 0x1F, 0xC7, 0xCF, 0x8F, 0xE3, 0xE7, 0xC7, 0xF1, 0xF3, 0xF3,
  0xBC, 0xF8, 0xFB, 0xDE, 0xFC, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7, 0xBE, 0x1F,
  0x7B, 0xDF, 0x07, 0xBD, 0xEF, 0x83, 0xDE, 0x7F, 0x81, 0xFE, 0x3F, 0xC0,
  0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE1, 0xF8,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x3F, 0x1F, 0x9F, 0x9F, 0x87, 0xEF,
  0xC3, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xE0, 0xFD, 0xF8,
  0xFC, 0xFC, 0x7E, 0x3F, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F, 0xFE, 0x0F, 0x9F,
  0x07, 0xCF, 0xC7, 0xE7, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7E, 0xFC,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x8F, 0xE1,
  0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xFE, 0x1F, 0xC1, 0xF8, 0xFF, 0x1F,
  0x87, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7C, 0x00, 0x7F, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xD0, 0x0E, 0x00,
};

const GFXglyph NotoSans_Condensed_Black32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 23, 9, 1, -23 },
  { 22, 13, 8, 16, 1, -23 },
  { 35, 17, 23, 19, 1, -23 },
  { 84, 14, 26, 17, 1, -24 },
  { 130, 26, 23, 28, 1, -23 },
  { 205, 21, 23, 22, 1, -23 },
  { 266, 6, 8, 8, 1, -23 },
  { 272, 9, 28, 11, 1, -23 },
  { 304, 9, 28, 11, 0, -23 },
  { 336, 15, 14, 16, 0, -24 },
  { 363, 15, 15, 17, 1, -19 },
  { 392, 7, 9, 9, 1, -5 },
  { 400, 8, 5, 10, 1, -11 },
  { 405, 6, 6, 9, 1, -6 },
  { 410, 14, 23, 14, 0, -23 },
  { 451, 15, 23, 17, 1, -23 },
  { 495, 12, 23, 17, 1, -23 },
  { 530, 14, 23, 17, 1, -23 },
  { 571, 14, 23, 17, 1, -23 },
  { 612, 15, 23, 17, 1, -23 },
  { 656, 13, 23, 17, 2, -23 },
  { 694, 15, 23, 17, 1, -23 },
  { 738, 15, 23, 17, 1, -23 },
  { 782, 15, 23, 17, 1, -23 },
  { 826, 15, 23, 17, 1, -23 },
  { 870, 7, 18, 9, 1, -18 },
  { 886, 7, 22, 9, 1, -18 },
  { 906, 15, 17, 17, 1, -20 },
  { 938, 15, 11, 17, 1, -17 },
  { 959, 15, 17, 17, 1, -20 },
  { 991, 13, 23, 14, 0, -23 },
  { 1029, 24, 25, 26, 1, -23 },
  { 1104, 20, 23, 20, 0, -23 },
  { 1162, 16, 23, 19, 2, -23 },
  { 1208, 16, 23, 18, 1, -23 },
  { 1254, 17, 23, 20, 2, -23 },
  { 1303, 12, 23, 15, 2, -23 },
  { 1338, 12, 23, 15, 2, -23 },
  { 1373, 18, 23, 20, 1, -23 },
  { 1425, 17, 23, 21, 2, -23 },
  { 1474, 10, 23, 12, 1, -23 },
  { 1503, 10, 30, 10, -2, -23 },
  { 1541, 17, 23, 19, 2, -23 },
  { 1590, 13, 23, 15, 2, -23 },
  { 1628, 23, 23, 27, 2, -23 },
  { 1695, 19, 23, 23, 2, -23 },
  { 1750, 19, 23, 22, 1, -23 },
  { 1805, 15, 23, 18, 2, -23 },
  { 1849, 19, 28, 22, 1, -23 },
  { 1916, 17, 23, 19, 2, -23 },
  { 1965, 14, 23, 16, 1, -23 },
  { 2006, 14, 23, 16, 1, -23 },
  { 2047, 17, 23, 20, 2, -23 },
  { 2096, 19, 23, 19, 0, -23 },
  { 2151, 28, 23, 28, 0, -23 },
  { 2232, 19, 23, 19, 0, -23 },
  { 2287, 18, 23, 18, 0, -23 },
  { 2339, 15, 23, 16, 1, -23 },
  { 2383, 8, 28, 10, 1, -23 },
  { 2411, 14, 23, 14, 0, -23 },
  { 2452, 7, 28, 10, 1, -23 },
  { 2477, 17, 15, 17, 0, -23 },
  { 2509, 16, 4, 16, 0, 2 },
  { 2517, 9, 6, 12, 1, -25 },
  { 2524, 14, 18, 17, 1, -18 },
  { 2556, 15, 24, 18, 2, -24 },
  { 2601, 13, 18, 15, 1, -18 },
  { 2631, 15, 24, 18, 1, -24 },
  { 2676, 15, 18, 17, 1, -18 },
  { 2710, 12, 24, 11, 0, -24 },
  { 2746, 15, 26, 18, 1, -18 },
  { 2795, 15, 24, 18, 2, -24 },
  { 2840, 5, 25, 9, 2, -25 },
  { 2856, 8, 33, 9, -1, -25 },
  { 2889, 16, 24, 18, 2, -24 },
  { 2937, 5, 24, 9, 2, -24 },
  { 2952, 24, 18, 27, 2, -18 },
  { 3006, 15, 18, 18, 2, -18 },
  { 3040, 16, 18, 18, 1, -18 },
  { 3076, 15, 26, 18, 2, -18 },
  { 3125, 15, 26, 18, 1, -18 },
  { 3174, 11, 18, 13, 2, -18 },
  { 3199, 12, 18, 14, 1, -18 },
  { 3226, 12, 21, 12, 0, -21 },
  { 3258, 15, 18, 18, 2, -18 },
  { 3292, 17, 18, 17, 0, -18 },
  { 3331, 25, 18, 25, 0, -18 },
  { 3388, 17, 18, 17, 0, -18 },
  { 3427, 17, 26, 17, 0, -18 },
  { 3483, 12, 18, 14, 1, -18 },
  { 3510, 11, 28, 12, 1, -23 },
  { 3549, 4, 32, 14, 5, -25 },
  { 3565, 11, 28, 12, 1, -23 },
  { 3604, 15, 6, 17, 1, -14 },
};

const GFXfont NotoSans_Condensed_Black32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_BLACK32PT7B_H_
