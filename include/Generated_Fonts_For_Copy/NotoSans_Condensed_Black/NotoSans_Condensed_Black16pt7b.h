#ifndef _NOTOSANS_CONDENSED_BLACK16PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xB0, 0xDF, 0x80, 0xFF, 0x3C, 0xF3, 0x1B, 0x0D, 0x86,
  0xCF, 0xF7, 0xF9, 0xB3, 0xFF, 0xFF, 0x36, 0x13, 0x1B, 0x00, 0x10, 0xFB,
  0xF6, 0xAD, 0x1F, 0x1F, 0x0F, 0x97, 0xFF, 0xF1, 0x81, 0x00, 0x30, 0x21,
  0xE3, 0x07, 0x8C, 0x33, 0x60, 0xCD, 0x81, 0xED, 0xC7, 0xB7, 0x8D, 0xB6,
  0x06, 0xDC, 0x3B, 0x70, 0xC7, 0x87, 0x1E, 0x08, 0x07, 0xC0, 0xDC, 0x3B,
  0x83, 0xE0, 0x7C, 0x5F, 0x33, 0xFE, 0xE7, 0xDE, 0xF1, 0xFF, 0x1F, 0xF0,
  0xFB, 0x60, 0x36, 0x6E, 0xCC, 0xCC, 0xCC, 0xEE, 0x67, 0x30, 0xE3, 0x1C,
  0x63, 0x1C, 0xE7, 0x39, 0xCC, 0x67, 0x33, 0x80, 0x18, 0x99, 0x7E, 0xFF,
  0x3C, 0x7E, 0x24, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x76, 0x6E,
  0xFF, 0xFE, 0xDF, 0x80, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0E, 0x18, 0x70,
  0xC1, 0x87, 0x00, 0x30, 0xFB, 0xF7, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xDB,
  0xF3, 0xC0, 0x3D, 0xFF, 0xF7, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x18,
  0x7E, 0xFE, 0x46, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0x18,
  0x7E, 0x7E, 0x46, 0x0E, 0x3C, 0x3E, 0x0E, 0x07, 0x8F, 0xFE, 0xFC, 0x0E,
  0x1E, 0x1E, 0x3E, 0x7E, 0x6E, 0xEE, 0xFF, 0xFF, 0x0E, 0x0E, 0xFD, 0xFB,
  0x87, 0x0F, 0xDF, 0x83, 0x87, 0x9F, 0xFB, 0xE0, 0x0C, 0xF9, 0xF7, 0x0D,
  0x9F, 0xBF, 0xE7, 0xCF, 0xDF, 0xF3, 0xC0, 0xFF, 0xFC, 0x30, 0xE1, 0xC3,
  0x0E, 0x1C, 0x70, 0xE3, 0xC0, 0x18, 0x7E, 0x7E, 0x67, 0x7E, 0x3E, 0x3E,
  0x7E, 0xE7, 0x67, 0x7F, 0x3E, 0x18, 0x7E, 0x7E, 0x67, 0xE7, 0x67, 0x7F,
  0x7F, 0x06, 0x0E, 0x7C, 0x78, 0xDF, 0x00, 0x37, 0xE0, 0x67, 0x60, 0x00,
  0x07, 0x66, 0xE0, 0x02, 0x1C, 0xFF, 0x8E, 0x0F, 0x87, 0x83, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x81, 0x83, 0xE1, 0xF1, 0xEF, 0xBC, 0x40, 0x31, 0xFB,
  0xFC, 0x70, 0xC3, 0x8E, 0x18, 0x00, 0x60, 0xE1, 0x80, 0x06, 0x07, 0xF1,
  0xC3, 0x73, 0x3D, 0xF7, 0xB6, 0xF6, 0xDF, 0xDB, 0xDB, 0x7B, 0xBB, 0x80,
  0x38, 0xC3, 0xF8, 0x1E, 0x07, 0x83, 0xF0, 0xFC, 0x33, 0x1C, 0xC7, 0xF9,
  0xFE, 0x7F, 0xB8, 0x7E, 0x1C, 0xFE, 0xFE, 0xE7, 0xE6, 0xFE, 0xFE, 0xE7,
  0xE7, 0xEF, 0xFE, 0xFC, 0x18, 0xFD, 0xFF, 0x1E, 0x1C, 0x38, 0x70, 0xE1,
  0xE5, 0xF9, 0xF0, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF,
  0xFE, 0xFC, 0xFF, 0xFE, 0x38, 0xFF, 0xFE, 0x38, 0xE3, 0xFF, 0xC0, 0xFF,
  0xFE, 0x38, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x00, 0x0C, 0x3F, 0x7F, 0xE0,
  0xE0, 0xEF, 0xEF, 0xEF, 0xE3, 0xF3, 0x7F, 0x3F, 0xE3, 0xE3, 0xE3, 0xE3,
  0xFF, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFD, 0xE3, 0x0C, 0x30, 0xC3,
  0x0C, 0x33, 0xFF, 0xC0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F,
  0xFB, 0x00, 0xE7, 0xF7, 0xBB, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xDC, 0xEE,
  0x73, 0xB9, 0xE0, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xC0,
  0xF0, 0xFF, 0x1F, 0xF9, 0xFF, 0x9F, 0xFB, 0xFF, 0xB7, 0xFF, 0x7E, 0xF7,
  0xEF, 0x7E, 0xE7, 0xEE, 0x70, 0xF1, 0xF8, 0xFE, 0x7F, 0x3F, 0xDF, 0xEF,
  0xBF, 0xDF, 0xE7, 0xF3, 0xF8, 0xE0, 0x18, 0x3F, 0xBF, 0xDC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xC7, 0xC0, 0xFD, 0xFF, 0xBF, 0x3E,
  0xFF, 0xFF, 0x70, 0xE1, 0xC3, 0x80, 0x18, 0x3F, 0xBF, 0xDC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xC7, 0xC0, 0x70, 0x38, 0x0E, 0xFE,
  0xFE, 0xEE, 0xE6, 0xEE, 0xFC, 0xFC, 0xEE, 0xEE, 0xE7, 0xE7, 0x33, 0xFF,
  0xF1, 0xE3, 0xE7, 0xCF, 0x0E, 0x7F, 0xFE, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0x7F, 0x3E, 0xE3, 0xD8, 0xE7, 0x39, 0xCE, 0x77, 0x0D,
  0xC3, 0xF0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0xE3, 0x1F, 0x9E, 0x76, 0x79,
  0x9D, 0xEE, 0x77, 0xB9, 0xDE, 0xE3, 0xFF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x00, 0xF3, 0xBB, 0x8D, 0xC7, 0xC1, 0xE0, 0xE0, 0xF8, 0x7C,
  0x77, 0x3B, 0xB8, 0xE0, 0xE3, 0xBB, 0x9D, 0xC6, 0xC3, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF, 0xFF, 0x0E, 0x0E, 0x1C, 0x38, 0x38,
  0x70, 0x70, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0,
  0xC1, 0xC1, 0x83, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x70, 0xFF,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x18, 0x0E, 0x0F, 0x06, 0xC7,
  0x63, 0x3B, 0x8E, 0xFF, 0xFF, 0xE7, 0x3C, 0x7E, 0x27, 0x1F, 0x7F, 0x67,
  0xE7, 0x7F, 0x7B, 0xE1, 0xC3, 0x87, 0xEF, 0xFD, 0xF9, 0xF3, 0xE7, 0xDF,
  0xFE, 0xE0, 0x7F, 0xFE, 0x70, 0xC3, 0x0E, 0x7F, 0x7C, 0x0E, 0x1C, 0x3B,
  0xFF, 0xFD, 0xF3, 0xE7, 0xCF, 0xDF, 0xFB, 0xB0, 0x79, 0xFB, 0xBE, 0x7F,
  0xF8, 0x38, 0xFE, 0x7C, 0x3D, 0xF7, 0x1F, 0xFD, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x77, 0xFF, 0xBE, 0x7C, 0xF9, 0xFB, 0xFF, 0x7E, 0x1F, 0x7F, 0xE7,
  0x80, 0xE1, 0xC3, 0x87, 0xEF, 0xFD, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x30,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x39, 0xC0, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0xFF, 0xDC, 0xE0, 0xE0, 0xE0, 0xE7, 0xEE, 0xFC, 0xFC, 0xFC, 0xFC,
  0xEE, 0xEE, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xDC, 0xEF, 0xFF, 0xEF,
  0x7E, 0xE7, 0xEE, 0x7E, 0xE7, 0xEE, 0x7E, 0xE7, 0xEE, 0x70, 0xDD, 0xFF,
  0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE6, 0x79, 0xFB, 0xBE, 0x7C, 0xF9, 0xFB,
  0xFF, 0x7C, 0xDD, 0xFF, 0xBF, 0x3E, 0x7C, 0xFB, 0xFF, 0xFD, 0xC3, 0x87,
  0x0E, 0x00, 0x77, 0xFF, 0xBE, 0x7C, 0xF9, 0xFB, 0xFF, 0x7E, 0x1C, 0x38,
  0x70, 0xE0, 0xDE, 0xFF, 0xCE, 0x73, 0x9C, 0xE0, 0x3D, 0xFE, 0x5C, 0x7C,
  0x78, 0xFF, 0xFC, 0x30, 0xC7, 0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xF3, 0xC0,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7D, 0xFB, 0xFF, 0x76, 0xE7, 0xE7, 0x67, 0x76,
  0x76, 0x3E, 0x3C, 0x3C, 0x1C, 0xE7, 0x3F, 0x39, 0x9B, 0xDC, 0xDE, 0xE7,
  0xDF, 0x3E, 0xF0, 0xF7, 0x87, 0x3C, 0x39, 0xE0, 0xE7, 0x76, 0x7E, 0x3C,
  0x3C, 0x3C, 0x7E, 0x76, 0xE7, 0xE7, 0xE7, 0x67, 0x76, 0x76, 0x3E, 0x3C,
  0x3C, 0x1C, 0x1C, 0x78, 0x78, 0x70, 0xFD, 0xF8, 0x70, 0xC3, 0x8E, 0x1C,
  0x7F, 0xFE, 0x0C, 0xF3, 0xCC, 0x30, 0xCF, 0x38, 0xF0, 0xC3, 0x0C, 0x38,
  0xF0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xCF, 0x0C, 0x30,
  0xC3, 0xC7, 0x3C, 0xC3, 0x0C, 0x73, 0xCC, 0x00, 0xF3, 0xFE, 0x70,
};

const GFXglyph NotoSans_Condensed_Black16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 4, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 7, 13, 8, 1, -12 },
  { 34, 14, 12, 14, 0, -12 },
  { 55, 11, 12, 11, 0, -12 },
  { 72, 3, 4, 4, 1, -11 },
  { 74, 4, 15, 5, 1, -12 },
  { 82, 5, 15, 5, 0, -12 },
  { 92, 8, 7, 8, 0, -12 },
  { 99, 7, 8, 8, 1, -10 },
  { 106, 4, 4, 5, 0, -2 },
  { 108, 5, 3, 5, 0, -6 },
  { 110, 3, 3, 4, 1, -3 },
  { 112, 7, 12, 7, 0, -12 },
  { 123, 7, 12, 8, 1, -12 },
  { 134, 6, 11, 8, 1, -11 },
  { 143, 8, 12, 8, 0, -12 },
  { 155, 8, 12, 8, 0, -12 },
  { 167, 8, 11, 8, 0, -11 },
  { 178, 7, 11, 8, 1, -11 },
  { 188, 7, 12, 8, 1, -12 },
  { 199, 7, 11, 8, 1, -11 },
  { 209, 8, 12, 8, 0, -12 },
  { 221, 8, 12, 8, 0, -12 },
  { 233, 3, 9, 5, 1, -9 },
  { 237, 4, 11, 5, 0, -9 },
  { 243, 7, 8, 8, 1, -10 },
  { 250, 7, 5, 8, 1, -8 },
  { 255, 7, 8, 8, 1, -10 },
  { 262, 7, 12, 7, 0, -12 },
  { 273, 11, 13, 13, 1, -12 },
  { 291, 10, 11, 10, 0, -11 },
  { 305, 8, 11, 9, 1, -11 },
  { 316, 7, 12, 9, 1, -12 },
  { 327, 8, 11, 10, 1, -11 },
  { 338, 6, 11, 8, 1, -11 },
  { 347, 6, 11, 7, 1, -11 },
  { 356, 8, 12, 10, 1, -12 },
  { 368, 8, 11, 11, 1, -11 },
  { 379, 6, 11, 6, 0, -11 },
  { 388, 5, 15, 5, -1, -11 },
  { 398, 9, 11, 9, 1, -11 },
  { 411, 6, 11, 8, 1, -11 },
  { 420, 12, 11, 14, 1, -11 },
  { 437, 9, 11, 11, 1, -11 },
  { 450, 9, 12, 11, 1, -12 },
  { 464, 7, 11, 9, 1, -11 },
  { 474, 9, 15, 11, 1, -12 },
  { 491, 8, 11, 9, 1, -11 },
  { 502, 6, 12, 8, 1, -12 },
  { 511, 8, 11, 8, 0, -11 },
  { 522, 8, 11, 10, 1, -11 },
  { 533, 10, 11, 10, 0, -11 },
  { 547, 14, 11, 14, 0, -11 },
  { 567, 9, 11, 9, 0, -11 },
  { 580, 9, 11, 9, 0, -11 },
  { 593, 8, 11, 8, 0, -11 },
  { 604, 4, 15, 5, 1, -12 },
  { 612, 7, 12, 7, 0, -12 },
  { 623, 4, 15, 5, 0, -12 },
  { 631, 9, 7, 9, 0, -11 },
  { 639, 8, 2, 8, 0, 1 },
  { 641, 4, 2, 6, 1, -12 },
  { 642, 8, 9, 9, 0, -9 },
  { 651, 7, 12, 9, 1, -12 },
  { 662, 6, 9, 7, 1, -9 },
  { 669, 7, 12, 9, 1, -12 },
  { 680, 7, 9, 8, 1, -9 },
  { 688, 6, 12, 6, 0, -12 },
  { 697, 7, 13, 9, 1, -9 },
  { 709, 7, 12, 9, 1, -12 },
  { 720, 3, 12, 5, 1, -12 },
  { 725, 5, 16, 5, -1, -12 },
  { 735, 8, 12, 9, 1, -12 },
  { 747, 3, 12, 5, 1, -12 },
  { 752, 12, 9, 14, 1, -9 },
  { 766, 7, 9, 9, 1, -9 },
  { 774, 7, 9, 9, 1, -9 },
  { 782, 7, 13, 9, 1, -9 },
  { 794, 7, 13, 9, 1, -9 },
  { 806, 5, 9, 6, 1, -9 },
  { 812, 6, 9, 7, 0, -9 },
  { 819, 6, 11, 6, 0, -11 },
  { 828, 7, 9, 9, 1, -9 },
  { 836, 8, 9, 8, 0, -9 },
  { 845, 13, 9, 13, 0, -9 },
  { 860, 8, 9, 8, 0, -9 },
  { 869, 8, 13, 8, 0, -9 },
  { 882, 7, 9, 7, 0, -9 },
  { 890, 6, 15, 6, 0, -12 },
  { 902, 3, 16, 7, 2, -12 },
  { 908, 6, 15, 6, 0, -12 },
  { 920, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Black16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_BLACK16PT7B_H_
