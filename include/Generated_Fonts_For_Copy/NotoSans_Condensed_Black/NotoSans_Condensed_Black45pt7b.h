#ifndef _NOTOSANS_CONDENSED_BLACK45PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFC,
  0xFC, 0x08, 0x00, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0xFF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0xDF,
  0x87, 0xF7, 0xE1, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF1,
  0xF8, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xE3,
  0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xEF, 0x1C, 0xFC, 0xF0, 0x4F, 0xCF, 0x00, 0xFE, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xF7, 0xF0, 0x0F, 0x7F, 0x80, 0xF7, 0xFE, 0x0F, 0x7F, 0xFC, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x7E, 0x00,
  0x3F, 0xFE, 0x03, 0xF0, 0x03, 0xF1, 0xF0, 0x3F, 0x00, 0x1F, 0x8F, 0xC1,
  0xF8, 0x00, 0xFC, 0x7E, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x3F,
  0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE3, 0xE0,
  0x00, 0x7E, 0x3F, 0x3F, 0x07, 0x83, 0xF1, 0xF9, 0xF8, 0xFF, 0x0F, 0xDF,
  0x9F, 0x9F, 0xFC, 0x7F, 0xFC, 0xFC, 0xFF, 0xF1, 0xFF, 0xCF, 0xCF, 0xFF,
  0x8F, 0xFE, 0x7E, 0x7E, 0xFC, 0x1F, 0xC3, 0xE3, 0xF3, 0xF0, 0x10, 0x3F,
  0x3F, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC7, 0xE0,
  0x00, 0xF8, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x00, 0x7E, 0x1F,
  0x8F, 0xC0, 0x07, 0xE0, 0x7C, 0x7E, 0x00, 0x3F, 0x03, 0xF3, 0xF0, 0x03,
  0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xF8, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF,
  0x0F, 0xF8, 0x7F, 0xFE, 0x3F, 0xC3, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xBF, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF7, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x04, 0x1F, 0x82,
  0x38, 0xFC, 0x71, 0xFB, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xE0, 0xF8, 0x7E, 0x03, 0xC3,
  0xC0, 0x04, 0x0C, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0x8F, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xE1, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF9,
  0xFE, 0xFF, 0x1F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0xFF, 0x0F, 0xE7, 0xF1, 0xFE, 0x7F, 0x9F,
  0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xEF, 0xCF, 0xF3, 0xC7, 0xF8, 0xC3, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF1, 0xFF, 0x3C, 0x0F, 0xF1, 0x80,
  0xFF, 0x10, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0x83, 0xFE, 0x10, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x0F, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xDF, 0xE0, 0x7F, 0x7F, 0x81, 0xF9, 0xFE, 0x0F, 0xC7, 0xF8, 0x3F, 0x1F,
  0xE1, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x07, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xCF, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0xC0, 0x1F, 0xEF, 0x87, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x3F, 0xBF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0x83, 0xFD,
  0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0xCF, 0xF3,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0x7F, 0x87,
  0xF3, 0xFC, 0x3F, 0x9F, 0xE3, 0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFD, 0xFF, 0x3F, 0xC7, 0xFD, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xF1,
  0xFE, 0x7F, 0x8F, 0xF7, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xEF, 0xF1, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xF7, 0xF1, 0xFF, 0x3F, 0x83,
  0xF3, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF,
  0xFF, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x1F, 0xDF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFE, 0x7E, 0x04,
  0x00, 0x1F, 0x0F, 0xE7, 0xF9, 0xFF, 0x7F, 0xDF, 0xE3, 0xF8, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7E, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xE0, 0xFF, 0x30,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0x83, 0xFF, 0x1F, 0x1F, 0x87, 0xFF, 0xCF, 0xCF, 0xC7,
  0xFF, 0xE3, 0xE7, 0xC3, 0xFF, 0xF1, 0xF7, 0xE3, 0xF8, 0xF8, 0xFB, 0xF1,
  0xF8, 0xFC, 0x7F, 0xF1, 0xF8, 0x7E, 0x3F, 0xF8, 0xFC, 0x3F, 0x1F, 0xFC,
  0x7E, 0x1F, 0x8F, 0xFE, 0x3E, 0x0F, 0xC7, 0xFF, 0x1F, 0x07, 0xE3, 0xEF,
  0x8F, 0xC3, 0xF1, 0xF7, 0xC7, 0xE1, 0xF8, 0xFB, 0xE3, 0xF1, 0xFC, 0xFD,
  0xF0, 0xFF, 0xFF, 0xFC, 0xFC, 0x7F, 0xFF, 0xFE, 0x7E, 0x1F, 0xF7, 0xFE,
  0x1F, 0x07, 0xF9, 0xFE, 0x0F, 0xC0, 0xF0, 0x3C, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x1F, 0xF0, 0x1F,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x9F, 0xC0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE7,
  0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC,
  0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC3, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xF3, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFC, 0x3C,
  0x7F, 0xC0, 0x31, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x43, 0xFF, 0x8F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x83, 0xFE, 0xFF, 0x03, 0xFD, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0x7F, 0x83, 0xFE, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xF8,
  0x7C, 0x7F, 0xE0, 0x04, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xE0, 0xFF, 0x3F, 0xF9, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xC3, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xEF, 0xC3, 0xFF, 0xFF, 0xF7, 0xE1, 0xFB, 0xFF,
  0xFB, 0xF8, 0xFD, 0xFF, 0xFD, 0xFC, 0x7E, 0xFF, 0xFE, 0x7E, 0x7E, 0x7F,
  0xFF, 0x3F, 0x3F, 0x3F, 0xFF, 0x9F, 0xDF, 0x9F, 0xFF, 0xC7, 0xEF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xF8, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0x0F, 0xFC,
  0x3F, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFC, 0x0F,
  0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xFE, 0x1F, 0xFF, 0xBF, 0xC7, 0xFF,
  0xEF, 0xF1, 0xFF, 0xF9, 0xFE, 0x7F, 0xFE, 0x7F, 0x9F, 0xFF, 0x8F, 0xF7,
  0xFF, 0xE3, 0xFD, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFE,
  0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFD, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x3F, 0xE3, 0xFF,
  0xBF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F,
  0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F,
  0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x7F,
  0xBF, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x8F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xEF, 0xFE, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0x3F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFC,
  0x7C, 0x7F, 0x80, 0xC7, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xDF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0,
  0x1F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0x03, 0xFD, 0xFC, 0x03,
  0xFC, 0x07, 0xFB, 0xFC, 0x07, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xF0, 0x1F,
  0xCF, 0xF0, 0x3F, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0xC0, 0xFF, 0x1F, 0xC0,
  0xFF, 0xC1, 0xFE, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x7F, 0x87, 0xFF, 0x07,
  0xF0, 0xFF, 0x0F, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xFC, 0x3F, 0xC1, 0xFC,
  0x3F, 0xFC, 0x7F, 0x83, 0xF8, 0x7D, 0xF8, 0xFF, 0x07, 0xF9, 0xFB, 0xF1,
  0xFC, 0x0F, 0xF3, 0xF7, 0xE3, 0xF8, 0x0F, 0xE7, 0xE7, 0xCF, 0xF0, 0x1F,
  0xCF, 0xCF, 0xDF, 0xE0, 0x3F, 0x9F, 0x9F, 0xBF, 0xC0, 0x7F, 0x7F, 0x3F,
  0x7F, 0x00, 0xFF, 0xFC, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0xFD, 0xFC, 0x01,
  0xFF, 0xF0, 0xFB, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0xC3,
  0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07,
  0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x3F,
  0xDF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF,
  0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE7, 0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xDF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3,
  0xFC, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F,
  0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x30, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xEF, 0xE7,
  0xFE, 0x7F, 0x1F, 0xE1, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x7E, 0x0F, 0xF7, 0xFC, 0x3F,
  0xDF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xF3,
  0xFE, 0xFF, 0x87, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xF8, 0x7F, 0xBF, 0xE3, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFE, 0x7F, 0xC3,
  0xF8, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF8, 0x33, 0xFC, 0x04, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x2F, 0xF8, 0x39, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x3F, 0xC7, 0xFD, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x1F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFD, 0xFE, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x67, 0xFE, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0xFF, 0x9F, 0xCF, 0xFE, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFE,
  0xFF, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE6,
  0x00, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x3F,
  0xDF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xC0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x1C, 0x00,
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x87, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F,
  0x9F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x3F, 0xC1,
  0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xBF, 0xC3, 0xFE, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x9F, 0xE0,
  0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xC1, 0xFC, 0x3F, 0x9F, 0xF8, 0xFF, 0xCF, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE7, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0x87, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFC, 0x1F,
  0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0x83, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF,
  0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x83,
  0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x3F,
  0x87, 0xF3, 0xFF, 0x3F, 0xBF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xDF, 0xE3, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x1F,
  0x83, 0xF9, 0xFF, 0x0F, 0xE7, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC,
  0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0x07, 0xFB, 0xFE, 0x1F, 0xEF,
  0xFC, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xDF, 0xF0, 0xFF, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE3, 0xF8, 0xFF, 0x9F, 0xCF, 0xFE, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFE, 0xFF, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFD, 0xFB, 0xFC, 0x19, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF1, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x3F, 0xDF, 0xE3, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xF7, 0xE3, 0xFF, 0x3F, 0x0F, 0xF1, 0xF8, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x83, 0xFD, 0xFC,
  0x1F, 0xF8, 0x7F, 0xBF, 0xC3, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0xE1, 0xFC,
  0x7F, 0x1F, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF, 0x8F, 0xF1, 0xFC, 0x7F, 0xF1,
  0xFC, 0x3F, 0x8F, 0xBF, 0x3F, 0x87, 0xF9, 0xF7, 0xE7, 0xF0, 0x7F, 0x7E,
  0xFC, 0xFE, 0x0F, 0xEF, 0xDF, 0x9F, 0xC1, 0xFD, 0xFB, 0xF7, 0xF0, 0x3F,
  0xBF, 0x3E, 0xFE, 0x03, 0xF7, 0xC7, 0xFF, 0xC0, 0x7E, 0xF8, 0xFF, 0xF8,
  0x0F, 0xDF, 0x1F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFD, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF,
  0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xC1,
  0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x01, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xE7,
  0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x02, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFE, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x80, 0x00, 0x1F, 0xC0, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFC,
};

const GFXglyph NotoSans_Condensed_Black45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 33, 12, 2, -32 },
  { 39, 18, 11, 22, 2, -32 },
  { 64, 24, 32, 26, 1, -32 },
  { 160, 20, 37, 23, 2, -34 },
  { 253, 37, 33, 39, 1, -33 },
  { 406, 30, 33, 31, 1, -33 },
  { 530, 8, 11, 12, 2, -32 },
  { 541, 13, 40, 15, 2, -33 },
  { 606, 13, 40, 15, 0, -33 },
  { 671, 21, 20, 22, 1, -34 },
  { 724, 20, 22, 24, 2, -27 },
  { 779, 10, 13, 13, 1, -7 },
  { 796, 12, 6, 15, 1, -15 },
  { 805, 8, 9, 13, 2, -8 },
  { 814, 19, 33, 19, 0, -33 },
  { 893, 20, 33, 23, 2, -33 },
  { 976, 17, 32, 23, 2, -32 },
  { 1044, 20, 33, 23, 1, -33 },
  { 1127, 21, 33, 23, 1, -33 },
  { 1214, 22, 32, 23, 1, -32 },
  { 1302, 20, 32, 23, 2, -32 },
  { 1382, 21, 33, 23, 1, -33 },
  { 1469, 20, 32, 23, 2, -32 },
  { 1549, 21, 33, 23, 1, -33 },
  { 1636, 21, 33, 23, 1, -33 },
  { 1723, 9, 26, 13, 2, -25 },
  { 1753, 10, 31, 13, 1, -25 },
  { 1792, 20, 23, 24, 2, -28 },
  { 1850, 20, 16, 24, 2, -24 },
  { 1890, 20, 23, 24, 2, -28 },
  { 1948, 19, 34, 19, 0, -33 },
  { 2029, 33, 36, 36, 2, -33 },
  { 2178, 28, 32, 28, 0, -32 },
  { 2290, 22, 32, 27, 3, -32 },
  { 2378, 22, 33, 25, 2, -33 },
  { 2469, 23, 32, 28, 3, -32 },
  { 2561, 16, 32, 21, 3, -32 },
  { 2625, 16, 32, 21, 3, -32 },
  { 2689, 24, 33, 29, 2, -33 },
  { 2788, 24, 32, 30, 3, -32 },
  { 2884, 15, 32, 17, 1, -32 },
  { 2944, 14, 42, 14, -3, -32 },
  { 3018, 24, 32, 27, 3, -32 },
  { 3114, 17, 32, 21, 3, -32 },
  { 3182, 33, 32, 38, 3, -32 },
  { 3314, 26, 32, 32, 3, -32 },
  { 3418, 26, 33, 30, 2, -33 },
  { 3526, 21, 32, 25, 3, -32 },
  { 3610, 27, 41, 30, 2, -33 },
  { 3749, 24, 32, 26, 3, -32 },
  { 3845, 20, 33, 22, 1, -33 },
  { 3928, 21, 32, 22, 1, -32 },
  { 4012, 23, 32, 29, 3, -32 },
  { 4104, 27, 32, 27, 0, -32 },
  { 4212, 39, 32, 40, 0, -32 },
  { 4368, 26, 32, 26, 0, -32 },
  { 4472, 26, 32, 26, 0, -32 },
  { 4576, 21, 32, 23, 1, -32 },
  { 4660, 11, 41, 14, 2, -33 },
  { 4717, 19, 33, 19, 0, -33 },
  { 4796, 11, 41, 14, 1, -33 },
  { 4853, 24, 21, 24, 0, -32 },
  { 4916, 23, 5, 23, 0, 3 },
  { 4931, 13, 7, 16, 2, -34 },
  { 4943, 21, 25, 24, 1, -25 },
  { 5009, 22, 34, 25, 2, -34 },
  { 5103, 18, 25, 21, 2, -25 },
  { 5160, 21, 34, 25, 2, -34 },
  { 5250, 20, 25, 24, 2, -25 },
  { 5313, 17, 34, 16, 0, -34 },
  { 5386, 21, 36, 25, 2, -25 },
  { 5481, 21, 34, 26, 2, -34 },
  { 5571, 8, 35, 13, 2, -35 },
  { 5606, 12, 46, 13, -2, -35 },
  { 5675, 23, 34, 25, 2, -34 },
  { 5773, 8, 34, 13, 2, -34 },
  { 5807, 34, 25, 38, 2, -25 },
  { 5914, 21, 25, 26, 2, -25 },
  { 5980, 21, 25, 25, 2, -25 },
  { 6046, 22, 36, 25, 2, -25 },
  { 6145, 21, 36, 25, 2, -25 },
  { 6240, 16, 25, 18, 2, -25 },
  { 6290, 17, 25, 19, 1, -25 },
  { 6344, 15, 30, 17, 1, -30 },
  { 6401, 21, 25, 26, 2, -25 },
  { 6467, 24, 25, 24, 0, -25 },
  { 6542, 35, 25, 35, 0, -25 },
  { 6652, 23, 25, 23, 0, -25 },
  { 6724, 24, 36, 24, 0, -25 },
  { 6832, 18, 25, 19, 1, -25 },
  { 6889, 15, 41, 17, 1, -33 },
  { 6966, 6, 45, 20, 7, -35 },
  { 7000, 16, 41, 17, 1, -33 },
  { 7082, 21, 8, 24, 1, -20 },
};

const GFXfont NotoSans_Condensed_Black45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_BLACK45PT7B_H_
