#ifndef _NOTOSANS_CONDENSED_BLACK31PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFD, 0xF0, 0xFC, 0xFB, 0xE7, 0xDF, 0x3E, 0xF9,
  0xF7, 0x8F, 0xBC, 0x7D, 0xE3, 0xCF, 0x1E, 0x07, 0x9E, 0x03, 0x8E, 0x01,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x0F, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07,
  0xFC, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0xBE, 0xC4, 0xFB, 0x03, 0xEC, 0x07,
  0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0x3E,
  0x0C, 0xFE, 0x37, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xC1, 0xFC, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x3F, 0x01, 0xE0, 0x3F, 0xC0, 0xF0, 0x3F, 0xE0,
  0xF0, 0x1E, 0xF8, 0x78, 0x0F, 0x3C, 0x78, 0x07, 0x9E, 0x3C, 0x03, 0xCF,
  0x3C, 0x01, 0xE7, 0x9E, 0x00, 0xF3, 0xCF, 0x18, 0x79, 0xEF, 0x3F, 0x3F,
  0xE7, 0xBF, 0xCF, 0xF7, 0x9F, 0xF3, 0xF3, 0xDE, 0x78, 0x03, 0xCF, 0x3C,
  0x01, 0xE7, 0x9E, 0x01, 0xE3, 0xCF, 0x00, 0xF1, 0xE7, 0x80, 0xF0, 0xF3,
  0xC0, 0x78, 0x7D, 0xE0, 0x3C, 0x1F, 0xF0, 0x3C, 0x07, 0xF0, 0x3E, 0x01,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x87, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFF, 0x7E, 0x7E,
  0xFF, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0x7F, 0x87, 0xE3, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0xFD,
  0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x0F, 0x87, 0x87, 0xC7, 0xC3, 0xE1, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1,
  0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x07, 0x39, 0xCF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC3, 0xE7, 0xC1, 0x8E, 0x01,
  0x10, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x7D, 0xF7, 0xDF, 0x7D, 0xEF, 0xBE,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x1F, 0xFE, 0x7C, 0xF9, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x3F, 0x7C, 0xFD, 0xF3, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0x3F,
  0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xF7,
  0xDF, 0x39, 0xF1, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x1F, 0xC1,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x79, 0xF8, 0x83, 0xE2, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x31, 0xF8, 0x83, 0xE0,
  0x0F, 0x80, 0x7E, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xFC, 0x1F, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x87, 0xFF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF1, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1E, 0xFC,
  0x3E, 0xFC, 0x3C, 0xFC, 0x78, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F,
  0x60, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xE0, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x81, 0xFF, 0x1F, 0xBF, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xC0,
  0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x38, 0xFB, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF1,
  0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7D, 0xFB, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFE, 0x7C, 0xFD, 0xF1, 0xF7, 0xCF, 0x9F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC1,
  0xFE, 0x0F, 0xFC, 0x7F, 0xFB, 0xF3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xF1, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0xF8, 0x7F, 0x80, 0x1F, 0xC0, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFE, 0xFC, 0xFB, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0xFD, 0xF0, 0xC7, 0xC0,
  0x3E, 0x00, 0xF8, 0x0F, 0xE7, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00,
  0x7D, 0xFF, 0xDF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xDF,
  0x7C, 0x7D, 0xFF, 0xDF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xF7,
  0xDF, 0x7D, 0xEF, 0xBE, 0xF0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F,
  0x0F, 0xFC, 0xFF, 0xCF, 0xF8, 0x3F, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0xF3, 0xFE,
  0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x3F, 0xE7, 0xFF,
  0xBF, 0xFC, 0xFF, 0xF7, 0x1F, 0xA0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x87,
  0x87, 0xC7, 0x9E, 0x3F, 0xEF, 0x3C, 0xFF, 0xCF, 0x71, 0xE7, 0x9F, 0xE7,
  0x8F, 0x3F, 0xCF, 0x1E, 0x7F, 0x9E, 0x3C, 0xFF, 0x3C, 0x79, 0xFE, 0x78,
  0xF3, 0xFC, 0xF3, 0xE7, 0x79, 0xFF, 0xFE, 0x71, 0xFF, 0xF8, 0xF1, 0xF3,
  0xE1, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x0C, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0x9F, 0x03, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF,
  0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0xEF, 0xFF, 0xDF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF,
  0xE3, 0xF9, 0xCF, 0xC0, 0x9F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E,
  0x02, 0xFF, 0x38, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xF8, 0x63, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFD, 0xF0, 0x3E, 0xFC, 0x1F, 0x7E, 0x0F, 0x9F, 0xCF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xF8, 0x3E, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0xFE,
  0x1F, 0xBF, 0x1F, 0x9F, 0x8F, 0xCF, 0xCF, 0xC7, 0xEF, 0xC3, 0xF7, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xF7, 0xE1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x3E, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC3, 0xF7, 0xE1, 0xFC, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0x9F, 0xFF, 0xEF, 0x3D,
  0xFF, 0xDF, 0x7B, 0xFF, 0xBE, 0xF7, 0xFF, 0x3F, 0xEF, 0xFE, 0x7F, 0x9F,
  0xFC, 0xFF, 0x3F, 0xF9, 0xFE, 0x7F, 0xF1, 0xFC, 0xFF, 0xE3, 0xF1, 0xFF,
  0xC7, 0xE3, 0xFF, 0x87, 0xC7, 0xFF, 0x0F, 0x8F, 0xC0, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE, 0xF9, 0xFF, 0xBF, 0x7F, 0xE7, 0xDF,
  0xF9, 0xF7, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xF8, 0xFC,
  0x1F, 0x9F, 0x83, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xC7, 0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x83, 0xF3,
  0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xC7,
  0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF9, 0xFC, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF9, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xF9, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC,
  0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x3F, 0x1F, 0xF1, 0xFF, 0xDF,
  0xFE, 0xFF, 0xFF, 0xEF, 0x7E, 0x0B, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xFF, 0x81, 0xF9,
  0xF0, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01,
  0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x1F, 0x03, 0xFF, 0x83, 0xE0, 0xFD, 0xF0, 0x7C, 0x1F, 0xBE, 0x0F,
  0xC3, 0xE7, 0xC3, 0xF8, 0x7C, 0xFC, 0x7F, 0x0F, 0x8F, 0x8F, 0xE3, 0xF1,
  0xF1, 0xFC, 0x7E, 0x3E, 0x7F, 0xCF, 0x87, 0xCF, 0x79, 0xF0, 0xF9, 0xEF,
  0x3E, 0x0F, 0xBD, 0xE7, 0xC1, 0xF7, 0xBD, 0xF8, 0x3E, 0xF3, 0xFE, 0x07,
  0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0x9F, 0x87, 0xE3, 0xE3, 0xF0, 0xFC, 0xFC,
  0x1F, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0x7E,
  0x7E, 0x1F, 0xBF, 0x03, 0xF0, 0xFC, 0x0F, 0xDF, 0x07, 0xE7, 0xE1, 0xF0,
  0xF8, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0x81, 0xF7, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7C, 0x1F, 0x1E,
  0x0F, 0x0F, 0x8F, 0x83, 0xC7, 0x81, 0xF7, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x1F,
  0xF1, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x10, 0xFC, 0x01, 0xF0, 0xFF, 0xCF,
  0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xDF, 0x3E, 0x3C, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xFF, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3C, 0xF8, 0x0F,
  0xF1, 0xFF, 0xCF, 0xFC, 0xFF, 0xE7, 0xE2, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x17, 0xE3, 0x3F, 0xF9, 0xFF, 0xC7,
  0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x8F, 0xBF, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFB, 0xE3, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xEF, 0x8F, 0x9F,
  0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7C, 0x7F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7C, 0x09, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE3, 0xF0, 0x3F, 0x03, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x3E, 0x7F, 0x7D, 0xFF, 0xFB,
  0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF,
  0x1F, 0x7E, 0x00, 0xFC, 0x01, 0xF3, 0x07, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F,
  0xFC, 0x3F, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x3F, 0xFF, 0xFE, 0xFE, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7E, 0xF8,
  0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0xF9, 0xF8, 0xF8,
  0xFC, 0xF8, 0xFC, 0xF8, 0x7E, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF1,
  0xF9, 0xEF, 0xF7, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xE7,
  0xFF, 0x1F, 0x8F, 0xFE, 0x1F, 0x1F, 0xFC, 0x3E, 0x3F, 0xF8, 0x7C, 0x7F,
  0xF0, 0xF8, 0xFF, 0xE1, 0xF1, 0xFF, 0xC3, 0xE3, 0xFF, 0x87, 0xC7, 0xFF,
  0x0F, 0x8F, 0xFE, 0x1F, 0x1F, 0xFC, 0x3E, 0x3F, 0xF8, 0x7C, 0x7E, 0xF3,
  0xF3, 0xDF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7C, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF,
  0xE7, 0xC7, 0xDF, 0x8F, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xE3, 0xF7, 0xC7, 0xCF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F,
  0xE0, 0xF3, 0xF3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFB, 0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x3E, 0x7F, 0x7D, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F,
  0xFF, 0x1F, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0xF3, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x00, 0x3F, 0xC7, 0xFE, 0xFF, 0xEF, 0xFC, 0xF8, 0x4F, 0xC0, 0xFF,
  0x07, 0xFC, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x3F, 0xC3, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFC, 0xFF, 0x80, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x27, 0xFC, 0x7F, 0x8F, 0xF0, 0xFE, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xEF, 0x3F, 0x3C, 0xFC, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E,
  0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x7E, 0x1F, 0x7C, 0x7F, 0x1F, 0x7C, 0x7F, 0x1F, 0x7C, 0x7F,
  0x3E, 0x7C, 0xFF, 0x3E, 0x3E, 0xFF, 0x3E, 0x3E, 0xFF, 0x3E, 0x3E, 0xF7,
  0xBC, 0x3E, 0xF7, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F, 0xE7,
  0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3,
  0xF8, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x7E, 0x7E, 0x3E, 0x7E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x7E, 0x7E, 0x7E, 0x3E,
  0xFC, 0x3F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7E, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x07, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF3, 0xF8, 0xFE, 0x3E, 0x0F, 0xE3, 0xF8,
  0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7F, 0x1F, 0xC3,
  0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0x0F, 0xE3, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7F, 0x1F, 0xC1, 0xF1,
  0xFC, 0x7F, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE3, 0xF8,
  0xFE, 0x3F, 0x0F, 0x80, 0x3C, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFE, 0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_Black31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 22, 9, 1, -22 },
  { 18, 13, 8, 15, 1, -22 },
  { 31, 17, 22, 18, 1, -22 },
  { 78, 14, 26, 16, 1, -24 },
  { 124, 25, 22, 27, 1, -22 },
  { 193, 21, 22, 21, 1, -22 },
  { 251, 6, 8, 8, 1, -22 },
  { 257, 9, 28, 10, 1, -23 },
  { 289, 9, 28, 10, 0, -23 },
  { 321, 15, 15, 15, 0, -24 },
  { 350, 14, 16, 16, 1, -19 },
  { 378, 6, 9, 9, 1, -5 },
  { 385, 8, 5, 10, 1, -11 },
  { 390, 6, 5, 9, 1, -5 },
  { 394, 13, 22, 13, 0, -22 },
  { 430, 14, 22, 16, 1, -22 },
  { 469, 12, 22, 16, 1, -22 },
  { 502, 14, 22, 16, 1, -22 },
  { 541, 14, 22, 16, 1, -22 },
  { 580, 16, 22, 16, 0, -22 },
  { 624, 13, 22, 16, 2, -22 },
  { 660, 14, 22, 16, 1, -22 },
  { 699, 14, 22, 16, 1, -22 },
  { 738, 14, 22, 16, 1, -22 },
  { 777, 14, 22, 16, 1, -22 },
  { 816, 6, 17, 9, 1, -17 },
  { 829, 6, 21, 9, 1, -17 },
  { 845, 14, 16, 16, 1, -19 },
  { 873, 14, 11, 16, 1, -16 },
  { 893, 14, 16, 16, 1, -19 },
  { 921, 13, 22, 13, 0, -22 },
  { 957, 23, 24, 25, 1, -22 },
  { 1026, 19, 22, 19, 0, -22 },
  { 1079, 15, 22, 18, 2, -22 },
  { 1121, 15, 22, 17, 1, -22 },
  { 1163, 16, 22, 20, 2, -22 },
  { 1207, 11, 22, 15, 2, -22 },
  { 1238, 11, 22, 14, 2, -22 },
  { 1269, 17, 22, 20, 1, -22 },
  { 1316, 16, 22, 20, 2, -22 },
  { 1360, 10, 22, 12, 1, -22 },
  { 1388, 10, 29, 10, -2, -22 },
  { 1425, 17, 22, 18, 2, -22 },
  { 1472, 12, 22, 15, 2, -22 },
  { 1505, 23, 22, 27, 2, -22 },
  { 1569, 18, 22, 22, 2, -22 },
  { 1619, 19, 22, 21, 1, -22 },
  { 1672, 14, 22, 17, 2, -22 },
  { 1711, 19, 27, 21, 1, -22 },
  { 1776, 16, 22, 18, 2, -22 },
  { 1820, 13, 22, 15, 1, -22 },
  { 1856, 14, 22, 15, 1, -22 },
  { 1895, 16, 22, 20, 2, -22 },
  { 1939, 19, 22, 19, 0, -22 },
  { 1992, 27, 22, 27, 0, -22 },
  { 2067, 18, 22, 18, 0, -22 },
  { 2117, 18, 22, 18, 0, -22 },
  { 2167, 14, 22, 16, 1, -22 },
  { 2206, 8, 28, 10, 1, -23 },
  { 2234, 13, 22, 13, 0, -22 },
  { 2270, 7, 28, 10, 1, -23 },
  { 2295, 17, 14, 17, 0, -22 },
  { 2325, 16, 4, 16, 0, 2 },
  { 2333, 9, 5, 11, 1, -24 },
  { 2339, 14, 17, 17, 1, -17 },
  { 2369, 14, 24, 17, 2, -24 },
  { 2411, 13, 17, 14, 1, -17 },
  { 2439, 15, 24, 17, 1, -24 },
  { 2484, 14, 17, 16, 1, -17 },
  { 2514, 12, 24, 11, 0, -24 },
  { 2550, 15, 24, 17, 1, -17 },
  { 2595, 14, 24, 18, 2, -24 },
  { 2637, 5, 24, 9, 2, -24 },
  { 2652, 8, 31, 9, -1, -24 },
  { 2683, 16, 24, 17, 2, -24 },
  { 2731, 5, 24, 9, 2, -24 },
  { 2746, 23, 17, 26, 2, -17 },
  { 2795, 14, 17, 18, 2, -17 },
  { 2825, 15, 17, 17, 1, -17 },
  { 2857, 14, 24, 17, 2, -17 },
  { 2899, 15, 24, 17, 1, -17 },
  { 2944, 10, 17, 13, 2, -17 },
  { 2966, 12, 17, 13, 1, -17 },
  { 2992, 11, 21, 12, 0, -21 },
  { 3021, 14, 17, 18, 2, -17 },
  { 3051, 16, 17, 16, 0, -17 },
  { 3085, 24, 17, 24, 0, -17 },
  { 3136, 16, 17, 16, 0, -17 },
  { 3170, 16, 24, 16, 0, -17 },
  { 3218, 12, 17, 13, 1, -17 },
  { 3244, 10, 27, 12, 1, -22 },
  { 3278, 4, 31, 14, 5, -24 },
  { 3294, 10, 27, 12, 1, -22 },
  { 3328, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Black31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_BLACK31PT7B_H_
