#ifndef _NOTOSANS_CONDENSED_BLACK28PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x1C, 0xFB, 0xFF, 0x9E, 0xF9, 0xFF, 0x9F, 0xF9, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x0F, 0x38, 0x1E, 0xF0, 0x39, 0xE0, 0x73, 0xC0, 0xE7,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xE0, 0x73, 0x87,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x1C, 0xF0, 0x39, 0xE0, 0x73,
  0x80, 0xE7, 0x03, 0xCE, 0x00, 0x06, 0x00, 0x30, 0x0F, 0xF8, 0xFF, 0xE7,
  0xFF, 0x7F, 0x73, 0xD8, 0x1E, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0x7F, 0x03, 0x78, 0x19, 0xF8, 0xDE, 0xFF, 0xF7, 0xFF, 0xBF, 0xF8,
  0x7F, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x3E, 0x03, 0x80, 0xFE, 0x0F,
  0x03, 0xFC, 0x1C, 0x07, 0xBC, 0x78, 0x0E, 0x78, 0xE0, 0x1C, 0xF3, 0xC0,
  0x39, 0xE7, 0x80, 0x73, 0xCE, 0x00, 0xF7, 0xBD, 0xF9, 0xFE, 0x73, 0xF9,
  0xFD, 0xEF, 0xF1, 0xF3, 0x9C, 0xE0, 0x0F, 0x39, 0xE0, 0x1C, 0xF3, 0xC0,
  0x78, 0xE7, 0x80, 0xE1, 0xCF, 0x03, 0xC3, 0x9C, 0x07, 0x87, 0xF8, 0x0E,
  0x07, 0xF0, 0x3C, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xE0, 0x4F, 0xF3, 0xE7, 0xFC, 0xFB, 0xFF, 0xBE, 0xFB, 0xFF, 0xBE, 0x7F,
  0xCF, 0x8F, 0xF3, 0xE1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0x3F, 0xFF, 0xFE, 0xF7, 0xBD, 0xE0, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0xF8, 0x78, 0x7C, 0x3C,
  0x3E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0xEF, 0x77, 0xFF, 0xBF, 0xFF, 0xFF, 0xE1, 0xF8, 0x1F, 0xE1,
  0xFF, 0x8F, 0x3C, 0x31, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7D, 0xE7, 0x9E, 0xFB, 0xCF, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0x1F, 0x81, 0xFE, 0x1F, 0xF8, 0xFF, 0xE7, 0x9F, 0x7C, 0xFB, 0xE3,
  0xDF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7B,
  0xE7, 0xCF, 0x3E, 0x7F, 0xF3, 0xFF, 0x0F, 0xF8, 0x3F, 0x00, 0x03, 0xE0,
  0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFE, 0xFB, 0xDF, 0x33, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3F, 0x87, 0xFE, 0xFF, 0xEF, 0xFF, 0x71, 0xF2, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xCF, 0xFE, 0xFF,
  0xF7, 0xFF, 0x61, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x3F, 0xC3, 0xF0, 0x3F,
  0xE3, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xF7, 0xC3, 0x9F, 0x1E, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xF8, 0x07, 0xF0, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE7, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x7C, 0xF7, 0xF7, 0xFF, 0xBF,
  0xFD, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x3F, 0x7F, 0xF3, 0xFF,
  0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x00, 0x1F, 0xC3, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x8F, 0x7C, 0x79, 0xF7,
  0xCF, 0xFC, 0x3F, 0xE0, 0xFC, 0x0F, 0xF8, 0xFF, 0xEF, 0x9F, 0x7C, 0x7F,
  0xC3, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x1F, 0x81,
  0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0x9F, 0x7C, 0x7B, 0xE3, 0xFF, 0x1F, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xEF, 0x00, 0x78, 0x07, 0xC0, 0x7E,
  0x7F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFE, 0x00, 0x31, 0xEF, 0xFF, 0x78, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x7B, 0xFF, 0xDE, 0x31, 0xEF, 0xFF, 0x78, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x7D, 0xE7, 0x9E, 0xFB, 0xCF, 0x3C, 0x00, 0x18,
  0x03, 0xC0, 0x7E, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x7F, 0x0F, 0xF3, 0xFE, 0x3F, 0xC1, 0xF8, 0x0E, 0x00, 0x40,
  0x00, 0x3F, 0x8F, 0xFE, 0xFF, 0xE7, 0xFF, 0x61, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xF0, 0x3C, 0x07, 0xC3, 0xC0, 0x0E, 0x3C, 0x7F, 0x79, 0xC7,
  0xF9, 0xCE, 0x7F, 0xCE, 0xF3, 0x8E, 0x7F, 0xBC, 0x73, 0xF9, 0xE3, 0x9F,
  0xCF, 0x3C, 0xEE, 0x79, 0xE7, 0x7B, 0xCF, 0x3B, 0xCF, 0xFF, 0x8E, 0x7E,
  0xFC, 0x78, 0xE1, 0x83, 0xC0, 0x00, 0x0F, 0x80, 0x60, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x3C,
  0x0F, 0x9F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7C, 0x1F, 0x3E, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xF0,
  0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x3E, 0xFF, 0xF7, 0xFE, 0x3F, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0xF3, 0xFF, 0x8F, 0xFE, 0x7E, 0x19, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x86, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0xFF, 0x83, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFE, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7E,
  0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xFC, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xE0, 0xCF, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xC1, 0xEF, 0x83, 0xDF,
  0x07, 0xBF, 0x0F, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xF0, 0xFF, 0xFF, 0xFF, 0xEF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0xFF, 0xFD, 0xFE, 0xFE, 0x7E, 0x00, 0xF8, 0x7F, 0xF0, 0xFB, 0xE3, 0xE7,
  0xCF, 0xCF, 0x9F, 0x1F, 0x7E, 0x3E, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x7E, 0x3E, 0x7C, 0x7C, 0xFC,
  0xF8, 0xF9, 0xF1, 0xFB, 0xE1, 0xF7, 0xC3, 0xF0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0E, 0xFF, 0x79, 0xEF, 0xF7, 0x9F, 0xFF, 0x79,
  0xFF, 0xF7, 0x9D, 0xFF, 0x3F, 0xDF, 0xF3, 0xFD, 0xFF, 0x3F, 0xDF, 0xF3,
  0xF9, 0xFF, 0x1F, 0x9F, 0xF1, 0xF9, 0xFF, 0x1F, 0x9F, 0xF1, 0xF1, 0xFF,
  0x0F, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0x9F, 0xF7, 0xDF, 0xF7, 0xCF, 0xF3, 0xEF,
  0xF3, 0xEF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xFB, 0xF0, 0x7D, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xE0, 0xF9,
  0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0x7C, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF9, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xFB, 0xF0,
  0x7D, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xFB, 0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0xFE, 0x1F, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F,
  0x9F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF9, 0xF1, 0xFF, 0xE3, 0xFF,
  0x87, 0xFE, 0x0F, 0xFE, 0x1F, 0x7C, 0x3E, 0xFC, 0x7C, 0xF8, 0xF9, 0xF9,
  0xF1, 0xF3, 0xE3, 0xF7, 0xC3, 0xF0, 0x1F, 0xE3, 0xFF, 0x7F, 0xFF, 0xFE,
  0xF8, 0x6F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0xFF,
  0x03, 0xF0, 0x1F, 0x81, 0xFE, 0x3F, 0xFF, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFD,
  0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0xF8, 0x1F, 0xFE, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C,
  0x0F, 0x3E, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0x78, 0x3E, 0x1F, 0x7C, 0x7E, 0x1F,
  0x7C, 0x7E, 0x1F, 0x7C, 0x7E, 0x1E, 0x7C, 0x7F, 0x3E, 0x3C, 0x7F, 0x3E,
  0x3E, 0xFF, 0x3E, 0x3E, 0xF7, 0x3E, 0x3E, 0xF7, 0x3C, 0x1E, 0xF7, 0xFC,
  0x1E, 0xE7, 0xFC, 0x1E, 0xE7, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xF8,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF0,
  0xFC, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x3E,
  0x7C, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3F, 0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0x78, 0x78,
  0xF1, 0xE0, 0xF3, 0xC1, 0xEF, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xFE, 0x7F, 0xF3, 0xFF, 0x31,
  0xF0, 0x0F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF7, 0xE7, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x79, 0xC3, 0xDF, 0x9F, 0xFC, 0xFF, 0xF7, 0xCF, 0xBE, 0x3D, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF9, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xCF, 0x7C, 0x00, 0x07, 0x83, 0xFC, 0xFF, 0xBF, 0xF7, 0xC5, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x17, 0xFE, 0xFF, 0xCF,
  0xF8, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x8E, 0x7C,
  0xFF, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFB, 0xFF, 0xDF, 0xFE, 0xFE, 0xF3, 0xE7,
  0x80, 0x07, 0x01, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0x8F, 0x7C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x27, 0xEF, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFC, 0x0F, 0xC7, 0xF3, 0xFC, 0xFD, 0x3E, 0x0F, 0x87, 0xFF,
  0xFF, 0xFF, 0xCF, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x1C, 0x01, 0xFB, 0xDF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE7, 0xDF, 0x00, 0xF8, 0x07, 0xD8,
  0x7E, 0xFF, 0xE7, 0xFF, 0x3F, 0xF0, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x79, 0xE3, 0xDF, 0x9F, 0xFE, 0xFF, 0xF7, 0xEF,
  0xBE, 0x7D, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x80, 0x31, 0xEF, 0xDE, 0x78, 0x00,
  0x1E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x0C, 0x1E, 0x3F, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E,
  0xBE, 0xFE, 0xFE, 0xFC, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x0F, 0xBC, 0x7C, 0xF3, 0xF3, 0xCF, 0x8F, 0x7C,
  0x3D, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0xF3, 0xE3, 0xC7,
  0xCF, 0x1F, 0xBC, 0x3E, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC3, 0xCF, 0x7E, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFD, 0xFF, 0x9F, 0x9F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x03, 0xC7, 0xBF,
  0x3F, 0xFD, 0xFF, 0xEF, 0xDF, 0x7C, 0x7B, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0x07,
  0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xCF, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0x83,
  0xF8, 0x03, 0x87, 0xBF, 0x3F, 0xF9, 0xFF, 0xEF, 0x9F, 0x7C, 0x7B, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF3, 0xEF, 0xFF, 0x7F, 0xFB,
  0xDF, 0x9E, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1C, 0x01, 0xFB, 0xDF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE7, 0xDF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x01, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1E,
  0x1F, 0xFF, 0xFF, 0xFE, 0xF0, 0xBE, 0x0F, 0xE1, 0xFE, 0x7F, 0xC7, 0xF0,
  0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x0E, 0x07, 0x81, 0xE0, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xFF, 0x3F, 0xC7, 0xF0, 0xFC, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x70, 0xF8, 0x7E, 0xF0, 0xF9, 0xF1, 0xF3,
  0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x0F, 0xBE, 0x0F, 0x78, 0x1E, 0xF0, 0x3F,
  0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xF8,
  0xFC, 0x7D, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9F, 0x3F, 0x3E, 0x7D, 0xFE,
  0xF8, 0xF7, 0xFB, 0xE3, 0xDF, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0,
  0xF7, 0x3B, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E,
  0x1F, 0x80, 0xF8, 0x7C, 0x00, 0xFC, 0x7D, 0xF3, 0xE3, 0xEF, 0x8F, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xBE, 0x7C, 0xF9, 0xF1, 0xFF, 0xC7, 0xC0, 0xF8, 0x3E, 0xF8, 0xF9,
  0xF1, 0xF3, 0xE3, 0xC3, 0xC7, 0x87, 0xDF, 0x0F, 0xBE, 0x0F, 0x78, 0x1E,
  0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0xBF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xCF, 0xF3, 0xF8, 0xFC, 0x3F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x0F, 0x03, 0xF0, 0xFC, 0x1F, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7E, 0x3F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0xE3,
  0xF0, 0xF8, 0xFC, 0xFC, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC7, 0xE3,
  0xF1, 0xF0, 0xC0, 0x00, 0x10, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xC0, 0xF0,
};

const GFXglyph NotoSans_Condensed_Black28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 20, 8, 1, -20 },
  { 16, 12, 7, 14, 1, -20 },
  { 27, 15, 20, 16, 1, -20 },
  { 65, 13, 23, 15, 1, -21 },
  { 103, 23, 20, 24, 1, -20 },
  { 161, 18, 20, 19, 1, -20 },
  { 206, 5, 7, 7, 1, -20 },
  { 211, 8, 25, 9, 1, -21 },
  { 236, 8, 25, 9, 0, -21 },
  { 261, 13, 12, 14, 0, -21 },
  { 281, 13, 14, 15, 1, -17 },
  { 304, 6, 8, 8, 1, -4 },
  { 310, 7, 5, 9, 1, -10 },
  { 315, 6, 5, 8, 1, -5 },
  { 319, 12, 20, 12, 0, -20 },
  { 349, 13, 20, 15, 1, -20 },
  { 382, 11, 20, 15, 1, -20 },
  { 410, 12, 20, 15, 1, -20 },
  { 440, 12, 20, 15, 1, -20 },
  { 470, 14, 20, 15, 0, -20 },
  { 505, 12, 20, 15, 1, -20 },
  { 535, 13, 20, 15, 1, -20 },
  { 568, 13, 20, 15, 1, -20 },
  { 601, 13, 20, 15, 1, -20 },
  { 634, 13, 20, 15, 1, -20 },
  { 667, 6, 16, 8, 1, -16 },
  { 679, 6, 20, 8, 1, -16 },
  { 694, 13, 14, 15, 1, -17 },
  { 717, 13, 10, 15, 1, -15 },
  { 734, 13, 14, 15, 1, -17 },
  { 757, 12, 20, 12, 0, -20 },
  { 787, 21, 22, 23, 1, -20 },
  { 845, 17, 20, 17, 0, -20 },
  { 888, 13, 20, 17, 2, -20 },
  { 921, 14, 20, 15, 1, -20 },
  { 956, 14, 20, 18, 2, -20 },
  { 991, 10, 20, 13, 2, -20 },
  { 1016, 10, 20, 13, 2, -20 },
  { 1041, 15, 20, 18, 1, -20 },
  { 1079, 15, 20, 18, 2, -20 },
  { 1117, 9, 20, 11, 1, -20 },
  { 1140, 9, 26, 9, -2, -20 },
  { 1170, 15, 20, 17, 2, -20 },
  { 1208, 11, 20, 13, 2, -20 },
  { 1236, 20, 20, 24, 2, -20 },
  { 1286, 16, 20, 20, 2, -20 },
  { 1326, 17, 20, 19, 1, -20 },
  { 1369, 13, 20, 16, 2, -20 },
  { 1402, 17, 25, 19, 1, -20 },
  { 1456, 15, 20, 16, 2, -20 },
  { 1494, 12, 20, 14, 1, -20 },
  { 1524, 12, 20, 14, 1, -20 },
  { 1554, 14, 20, 18, 2, -20 },
  { 1589, 17, 20, 17, 0, -20 },
  { 1632, 24, 20, 25, 0, -20 },
  { 1692, 16, 20, 16, 0, -20 },
  { 1732, 16, 20, 16, 0, -20 },
  { 1772, 13, 20, 14, 1, -20 },
  { 1805, 7, 26, 9, 1, -21 },
  { 1828, 12, 20, 12, 0, -20 },
  { 1858, 6, 26, 9, 1, -21 },
  { 1878, 15, 13, 15, 0, -20 },
  { 1903, 14, 3, 14, 0, 2 },
  { 1909, 8, 4, 10, 1, -21 },
  { 1913, 12, 16, 15, 1, -16 },
  { 1937, 13, 21, 16, 2, -21 },
  { 1972, 11, 16, 13, 1, -16 },
  { 1994, 13, 21, 16, 1, -21 },
  { 2029, 13, 16, 15, 1, -16 },
  { 2055, 10, 21, 10, 0, -21 },
  { 2082, 13, 23, 16, 1, -16 },
  { 2120, 13, 21, 16, 2, -21 },
  { 2155, 6, 22, 8, 1, -22 },
  { 2172, 8, 29, 8, -1, -22 },
  { 2201, 14, 21, 16, 2, -21 },
  { 2238, 4, 21, 8, 2, -21 },
  { 2249, 20, 16, 24, 2, -16 },
  { 2289, 13, 16, 16, 2, -16 },
  { 2315, 13, 16, 15, 1, -16 },
  { 2341, 13, 23, 16, 2, -16 },
  { 2379, 13, 23, 16, 1, -16 },
  { 2417, 9, 16, 11, 2, -16 },
  { 2435, 10, 16, 12, 1, -16 },
  { 2455, 10, 19, 11, 0, -19 },
  { 2479, 12, 15, 16, 2, -15 },
  { 2502, 15, 15, 15, 0, -15 },
  { 2531, 22, 15, 22, 0, -15 },
  { 2573, 14, 15, 15, 0, -15 },
  { 2600, 15, 22, 15, 0, -15 },
  { 2642, 12, 15, 12, 0, -15 },
  { 2665, 10, 25, 11, 0, -20 },
  { 2697, 4, 28, 12, 4, -22 },
  { 2711, 9, 25, 11, 1, -20 },
  { 2740, 13, 6, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Black28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_BLACK28PT7B_H_
