#ifndef _NOTOSANS_CONDENSED_BLACK17PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0xEF, 0xDF, 0xB6, 0x60, 0x1B, 0x86,
  0xC1, 0xB1, 0xFF, 0x7F, 0xCC, 0xC3, 0x73, 0xFE, 0xFF, 0x8D, 0x83, 0x61,
  0xD8, 0x10, 0x7B, 0xFF, 0xFD, 0x1E, 0x3F, 0x1F, 0x1F, 0x2F, 0xFF, 0xE1,
  0x02, 0x00, 0x78, 0x61, 0xF3, 0x0E, 0xCC, 0x3B, 0x70, 0xED, 0x81, 0xFE,
  0xF7, 0xB6, 0xC0, 0xDB, 0x06, 0x6C, 0x19, 0xB0, 0xC7, 0xC3, 0x0E, 0x3E,
  0x03, 0xF0, 0x33, 0x03, 0xF0, 0x3F, 0x03, 0xEE, 0x7E, 0xE7, 0xFE, 0xE7,
  0xC7, 0x7C, 0x7F, 0xE3, 0xEF, 0xFF, 0xE0, 0x7B, 0x39, 0xCE, 0x63, 0x18,
  0xC7, 0x39, 0xC6, 0x38, 0xE0, 0xE3, 0x8C, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x67, 0x33, 0x80, 0x18, 0x18, 0x7B, 0xFF, 0x1C, 0x3E, 0x76, 0x24, 0x38,
  0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0xFF, 0x60, 0xFF, 0xFE, 0xFF, 0x80,
  0x0E, 0x1C, 0x30, 0xE1, 0x83, 0x0E, 0x18, 0x70, 0xE1, 0x87, 0x00, 0x7D,
  0xFB, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xF3, 0xE0, 0x1C, 0xF7,
  0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3E, 0xFF, 0x67, 0x47, 0x07,
  0x0E, 0x1E, 0x3C, 0x38, 0x7F, 0xFF, 0xFF, 0xFD, 0xFE, 0x38, 0x71, 0xCF,
  0x1F, 0x07, 0x0F, 0x3F, 0xFF, 0xE0, 0x0E, 0x07, 0x07, 0x87, 0xC3, 0x63,
  0xF1, 0xB9, 0xFF, 0xFF, 0xFF, 0xC3, 0x81, 0xC0, 0xFD, 0xFB, 0x87, 0x0F,
  0xDF, 0x97, 0x87, 0x0F, 0x3F, 0xFF, 0xE0, 0x3E, 0xFF, 0xC7, 0x0D, 0xDF,
  0xFB, 0xF7, 0xEF, 0xDF, 0xFB, 0xE0, 0xFF, 0xFC, 0x38, 0x71, 0xC3, 0x87,
  0x1C, 0x38, 0xF1, 0xC3, 0x80, 0x7D, 0xFF, 0xBF, 0x7F, 0xCF, 0x3F, 0x77,
  0xC7, 0xDF, 0xFB, 0xE0, 0x7D, 0xFF, 0xBE, 0x7C, 0xFD, 0xFF, 0xBB, 0x0E,
  0x3B, 0xF7, 0xC0, 0x5F, 0xA0, 0x07, 0xFC, 0x27, 0x72, 0x00, 0x00, 0x77,
  0x6E, 0x06, 0x3D, 0xF7, 0x8F, 0x0F, 0xC3, 0x81, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0xC1, 0xE1, 0xF0, 0xF1, 0xFF, 0x38, 0x40, 0x7D, 0xFD, 0x38,
  0x71, 0xE7, 0x8E, 0x18, 0x00, 0x60, 0xE1, 0xC0, 0x1F, 0x83, 0x9E, 0x60,
  0x6C, 0xFB, 0xDD, 0xBD, 0x9B, 0xD9, 0xBD, 0xBB, 0xDF, 0xEC, 0xEE, 0xE0,
  0x07, 0x9C, 0x3F, 0xC0, 0x1E, 0x03, 0xE0, 0x7C, 0x1D, 0x83, 0xB8, 0x77,
  0x1C, 0xE3, 0xFC, 0x7F, 0xCF, 0xFB, 0xC7, 0x70, 0xF0, 0xFE, 0xFF, 0xE7,
  0xE7, 0xEF, 0xFE, 0xFF, 0xE7, 0xE7, 0xEF, 0xFF, 0xFE, 0x3F, 0x7F, 0xF2,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF2, 0x7E, 0x3E, 0xFE, 0x7F, 0xBB,
  0xDC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xFF, 0xBF, 0x9F, 0x80, 0xFF,
  0xFE, 0x38, 0xFF, 0xFF, 0xF8, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xE3,
  0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0x3F, 0xBF, 0xBC, 0x5C, 0x0E, 0x07, 0x7F,
  0xBF, 0xC7, 0xE3, 0xF9, 0xDF, 0xE7, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0xFF, 0xF3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xEF, 0xFF, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0xFF, 0xDC, 0xE3, 0xF3, 0xBB, 0xDD, 0xCF, 0xE7, 0xE3, 0xF9,
  0xFC, 0xEF, 0x73, 0xB9, 0xDC, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xFF, 0xFF, 0xF0, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF9,
  0xBF, 0xDB, 0xED, 0xBE, 0xFB, 0xEF, 0x3E, 0xF3, 0xE7, 0x3E, 0x73, 0xF1,
  0xFC, 0x7F, 0x9F, 0xE7, 0xFD, 0xFF, 0x7E, 0xFF, 0xBF, 0xE7, 0xF9, 0xFE,
  0x3F, 0x8F, 0x3F, 0x1F, 0xEF, 0x3B, 0x8E, 0xE3, 0xF8, 0x7E, 0x1F, 0x8F,
  0xE3, 0xBD, 0xE7, 0xF8, 0xF8, 0xFC, 0xFE, 0xEF, 0xE7, 0xE7, 0xFF, 0xFE,
  0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x1F, 0xEF, 0x3B, 0x8E, 0xE3, 0xF8,
  0x7E, 0x1F, 0x8F, 0xE3, 0xBD, 0xE7, 0xF8, 0xF8, 0x07, 0x01, 0xE0, 0x3C,
  0xFE, 0x7F, 0xBB, 0xDC, 0xEE, 0x77, 0xF3, 0xF9, 0xDC, 0xEE, 0x73, 0xB9,
  0xDC, 0xF0, 0x7F, 0xFF, 0x97, 0x0F, 0x1F, 0x9F, 0x0F, 0x8F, 0xFF, 0xF7,
  0xC0, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB,
  0xDF, 0xC7, 0xC0, 0xE1, 0xFC, 0x77, 0x39, 0xCE, 0x73, 0x8C, 0xE3, 0xF0,
  0xFC, 0x3F, 0x07, 0xC1, 0xE0, 0x78, 0xE3, 0x8F, 0xC7, 0x1D, 0x8E, 0x73,
  0xBC, 0xE7, 0x6D, 0xCE, 0xDB, 0x9D, 0xB6, 0x1B, 0x6C, 0x36, 0xF8, 0x7D,
  0xF0, 0xF1, 0xE1, 0xE3, 0x80, 0xF3, 0xDC, 0xE7, 0x70, 0xFC, 0x3E, 0x07,
  0x81, 0xE0, 0xF8, 0x3F, 0x1D, 0xE7, 0x3B, 0x8F, 0xE3, 0xDC, 0xE7, 0x30,
  0xFC, 0x3F, 0x0F, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF,
  0xFF, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0xC1, 0xC3, 0x83, 0x07,
  0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0xF0, 0x1C, 0x0E, 0x07, 0x06, 0xC3, 0x63, 0xB9, 0x8D, 0xC7, 0xFF,
  0xFF, 0xC0, 0xE7, 0x30, 0x0C, 0x7E, 0x3F, 0x07, 0x3F, 0x7F, 0x67, 0xE7,
  0x7F, 0x7B, 0xE0, 0xE0, 0xE0, 0xEC, 0xFE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFE, 0xDE, 0x18, 0xFF, 0xF7, 0x0E, 0x1C, 0x38, 0x72, 0xFC, 0xF8,
  0x07, 0x07, 0x07, 0x27, 0x7F, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF,
  0x77, 0x10, 0xFB, 0xFF, 0x3F, 0xFF, 0xF0, 0x71, 0xFE, 0xFC, 0x3C, 0xF7,
  0x1C, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x20, 0x7F, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0x07, 0x8E, 0xFE, 0xFC, 0xE0, 0xE0,
  0xE0, 0xEC, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFD,
  0x0F, 0xFF, 0xFF, 0xFE, 0x39, 0xCC, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9E, 0xFF, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x77, 0x73, 0xF1, 0xF8,
  0xFC, 0x7F, 0x3B, 0x9C, 0xEE, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0C,
  0x66, 0xF7, 0xBF, 0xFD, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7,
  0xE7, 0x3F, 0x39, 0xC0, 0x0C, 0xDE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x18, 0x7C, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0xFE, 0x7C,
  0x0C, 0xFE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFE, 0xFE, 0xE0, 0xE0,
  0xE0, 0xE0, 0x20, 0x7F, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x7F, 0xFD, 0xE3, 0x8E, 0x38, 0xE3, 0x80,
  0x33, 0xFF, 0xB8, 0xF1, 0xE3, 0xE7, 0xFF, 0xE0, 0x30, 0xCF, 0xFF, 0x71,
  0xC7, 0x1C, 0x75, 0xF3, 0xC0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF,
  0xFF, 0x7F, 0xE3, 0xB3, 0x9D, 0xCE, 0xE3, 0x61, 0xB0, 0xF8, 0x78, 0x1C,
  0x00, 0xE7, 0xBB, 0x3D, 0xDD, 0xEE, 0xFB, 0x67, 0xDB, 0x3E, 0xF8, 0xF7,
  0xC7, 0x9C, 0x3C, 0xE0, 0xF7, 0xBB, 0x8F, 0x87, 0xC3, 0xC1, 0xF1, 0xFC,
  0xEE, 0xE7, 0x80, 0xE3, 0xBB, 0x9D, 0xCE, 0xE3, 0x61, 0xF0, 0xF8, 0x38,
  0x1C, 0x0E, 0x2F, 0x0F, 0x07, 0x00, 0xFF, 0xFC, 0x70, 0xE3, 0x8E, 0x1C,
  0x7F, 0xFE, 0x1C, 0xF3, 0x8E, 0x38, 0xEF, 0x3C, 0x78, 0xE3, 0x8E, 0x38,
  0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xC3, 0x0C, 0x30, 0xE3,
  0xC7, 0x3C, 0xC3, 0x0C, 0x73, 0xCE, 0x00, 0x43, 0xFF, 0xFC, 0x60,
};

const GFXglyph NotoSans_Condensed_Black17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 7, 4, 8, 1, -12 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 7, 14, 9, 1, -13 },
  { 38, 14, 12, 15, 0, -12 },
  { 59, 12, 12, 12, 0, -12 },
  { 77, 3, 4, 4, 1, -12 },
  { 79, 5, 15, 6, 1, -12 },
  { 89, 5, 15, 6, 0, -12 },
  { 99, 8, 8, 8, 0, -13 },
  { 107, 7, 8, 9, 1, -10 },
  { 114, 3, 4, 5, 1, -2 },
  { 116, 5, 3, 5, 0, -6 },
  { 118, 3, 3, 5, 1, -3 },
  { 120, 7, 12, 7, 0, -12 },
  { 131, 7, 12, 9, 1, -12 },
  { 142, 6, 12, 9, 1, -12 },
  { 151, 8, 12, 9, 0, -12 },
  { 163, 7, 12, 9, 1, -12 },
  { 174, 9, 12, 9, 0, -12 },
  { 188, 7, 12, 9, 1, -12 },
  { 199, 7, 12, 9, 1, -12 },
  { 210, 7, 12, 9, 1, -12 },
  { 221, 7, 12, 9, 1, -12 },
  { 232, 7, 12, 9, 1, -12 },
  { 243, 3, 10, 5, 1, -10 },
  { 247, 4, 12, 5, 0, -10 },
  { 253, 7, 8, 9, 1, -10 },
  { 260, 7, 6, 9, 1, -9 },
  { 266, 7, 8, 9, 1, -10 },
  { 273, 7, 12, 7, 0, -12 },
  { 284, 12, 13, 14, 1, -12 },
  { 304, 11, 12, 11, 0, -12 },
  { 321, 8, 12, 10, 1, -12 },
  { 333, 8, 12, 9, 1, -12 },
  { 345, 9, 12, 11, 1, -12 },
  { 359, 6, 12, 8, 1, -12 },
  { 368, 6, 12, 8, 1, -12 },
  { 377, 9, 12, 11, 1, -12 },
  { 391, 9, 12, 11, 1, -12 },
  { 405, 6, 12, 6, 0, -12 },
  { 414, 5, 16, 5, -1, -12 },
  { 424, 9, 12, 10, 1, -12 },
  { 438, 7, 12, 8, 1, -12 },
  { 449, 12, 12, 15, 1, -12 },
  { 467, 10, 12, 12, 1, -12 },
  { 482, 10, 12, 11, 1, -12 },
  { 497, 8, 12, 9, 1, -12 },
  { 509, 10, 15, 11, 1, -12 },
  { 528, 9, 12, 10, 1, -12 },
  { 542, 7, 12, 8, 1, -12 },
  { 553, 8, 12, 8, 0, -12 },
  { 565, 9, 12, 11, 1, -12 },
  { 579, 10, 12, 10, 0, -12 },
  { 594, 15, 12, 15, 0, -12 },
  { 617, 10, 12, 10, 0, -12 },
  { 632, 10, 12, 10, 0, -12 },
  { 647, 8, 12, 9, 0, -12 },
  { 659, 4, 15, 5, 1, -12 },
  { 667, 7, 12, 7, 0, -12 },
  { 678, 4, 15, 5, 0, -12 },
  { 686, 9, 8, 9, 0, -12 },
  { 695, 9, 2, 9, 0, 1 },
  { 698, 4, 3, 6, 1, -13 },
  { 700, 8, 10, 9, 0, -10 },
  { 710, 8, 13, 10, 1, -13 },
  { 723, 7, 10, 8, 1, -10 },
  { 732, 8, 13, 10, 1, -13 },
  { 745, 7, 10, 9, 1, -10 },
  { 754, 6, 13, 6, 0, -13 },
  { 764, 8, 14, 10, 1, -10 },
  { 778, 8, 13, 10, 1, -13 },
  { 791, 3, 13, 5, 1, -13 },
  { 796, 5, 17, 5, -1, -13 },
  { 807, 9, 13, 10, 1, -13 },
  { 822, 3, 13, 5, 1, -13 },
  { 827, 13, 10, 14, 1, -10 },
  { 844, 8, 10, 10, 1, -10 },
  { 854, 8, 10, 9, 1, -10 },
  { 864, 8, 14, 10, 1, -10 },
  { 878, 8, 14, 10, 1, -10 },
  { 892, 6, 10, 7, 1, -10 },
  { 900, 6, 10, 7, 1, -10 },
  { 908, 6, 11, 7, 0, -11 },
  { 917, 8, 9, 10, 1, -9 },
  { 926, 9, 9, 9, 0, -9 },
  { 937, 13, 9, 13, 0, -9 },
  { 952, 9, 9, 9, 0, -9 },
  { 963, 9, 13, 9, 0, -9 },
  { 978, 7, 9, 7, 0, -9 },
  { 986, 6, 15, 7, 0, -12 },
  { 998, 2, 17, 8, 3, -13 },
  { 1003, 6, 15, 7, 0, -12 },
  { 1015, 7, 4, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Black17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_BLACK17PT7B_H_
