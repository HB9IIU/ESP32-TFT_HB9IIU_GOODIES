#ifndef _NOTOSANS_CONDENSED_BLACK34PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x00, 0x00, 0x00, 0xF3, 0xF7, 0xFF, 0xDF, 0xBE, 0xF9, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xF8, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x87, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x0F, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x7E, 0xC6, 0xF9, 0x81,
  0xF3, 0x01, 0xF6, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x03, 0x7C, 0x06, 0x7A, 0x0D, 0xF7, 0xDF, 0xEF, 0xFF,
  0xDF, 0xFF, 0x3F, 0xFC, 0x1F, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0xF8, 0x07, 0xFC,
  0x0F, 0x00, 0xFB, 0xE1, 0xF0, 0x0F, 0x3E, 0x1E, 0x00, 0xF1, 0xE3, 0xE0,
  0x0F, 0x1E, 0x3C, 0x00, 0xF1, 0xE3, 0xC0, 0x0F, 0x1E, 0x78, 0x00, 0xF3,
  0xE7, 0x8F, 0x0F, 0xBE, 0xFB, 0xFC, 0x7F, 0xCF, 0x3F, 0xE7, 0xFD, 0xF7,
  0xFE, 0x3F, 0x9E, 0x79, 0xE0, 0xC3, 0xE7, 0x9F, 0x00, 0x3C, 0x79, 0xF0,
  0x03, 0xC7, 0x9F, 0x00, 0x78, 0x79, 0xF0, 0x07, 0x87, 0x9F, 0x00, 0xF0,
  0x79, 0xF0, 0x0F, 0x07, 0xFE, 0x01, 0xF0, 0x3F, 0xE0, 0x1E, 0x03, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x9F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xCF, 0xE1, 0xFF, 0x1F, 0x87, 0xFF, 0x3F, 0x1F, 0xFF, 0x7E, 0x7F,
  0xFF, 0xF8, 0xFC, 0xFF, 0xF1, 0xF8, 0xFF, 0xE3, 0xF0, 0xFF, 0x87, 0xE0,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC3,
  0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0,
  0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7E,
  0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0E, 0x78, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F, 0xC1, 0xF7,
  0xC7, 0xEF, 0xC7, 0x8F, 0x07, 0x1C, 0x04, 0x20, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x7C, 0xF9,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFD, 0xFF, 0xF7, 0xEF,
  0x80, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x03, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE,
  0x7E, 0x7E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x7E,
  0x7C, 0x7E, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x9F, 0xFD,
  0xFF, 0xFF, 0xFF, 0x3D, 0xF8, 0xCF, 0xC4, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0x80, 0x3F, 0xE1, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xCF, 0xFF, 0xDC, 0x1F, 0x90, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xC7, 0xBF, 0xC8, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x7F,
  0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFC, 0x7F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1E, 0xFC, 0x3E,
  0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0xF8, 0xFC, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFC, 0x87, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0x38, 0x03,
  0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xC2, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7D, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E,
  0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x01,
  0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C,
  0x7E, 0x7C, 0x7E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7E, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF0, 0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFE,
  0xFE, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xBE, 0x0F, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F,
  0xE0, 0x7F, 0x80, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7,
  0xDF, 0x3E, 0x7C, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFD, 0xF7, 0xF2, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x80,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0xF8,
  0x00, 0xF0, 0xF8, 0x10, 0x7C, 0x78, 0x7F, 0xDE, 0x7C, 0x7F, 0xE7, 0xBC,
  0x7F, 0xF3, 0xDE, 0x7C, 0xF9, 0xFF, 0x3C, 0x7C, 0xFF, 0x1E, 0x3E, 0x7F,
  0x9F, 0x1F, 0x3F, 0xCF, 0x8F, 0x1F, 0xE7, 0xC7, 0x8F, 0xF1, 0xE3, 0xC7,
  0xFC, 0xFB, 0xF7, 0x9E, 0x7F, 0xFF, 0xCF, 0x1F, 0xDF, 0xC7, 0xC7, 0xC7,
  0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E,
  0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xCF,
  0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x60, 0x01, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0x08, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x63,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x0F,
  0xEF, 0xC1, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xBF, 0x0F, 0xEF, 0xC7, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x18, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xE0, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xDF, 0x8F, 0xFB, 0xF1,
  0xFF, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xFC, 0x1F, 0x9F, 0xC3, 0xF3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFB, 0xFF,
  0xFE, 0xFF, 0xBF, 0xCF, 0xE1, 0xC0, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC3,
  0xFB, 0xF0, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xF7, 0xF0,
  0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFB, 0xF0, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0xBF, 0x07, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xF7, 0x83, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xF7, 0xFF, 0xBE, 0x7B, 0xFF, 0xDF, 0x7D, 0xFF, 0xEF, 0xBE, 0xFF, 0xF7,
  0xDE, 0x7F, 0xF9, 0xFF, 0x3F, 0xFC, 0xFF, 0x9F, 0xFE, 0x7F, 0xCF, 0xFF,
  0x1F, 0xC7, 0xFF, 0x8F, 0xE3, 0xFF, 0xC7, 0xF1, 0xFF, 0xE3, 0xF8, 0xFF,
  0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x3F, 0xFD, 0xF3, 0xFF, 0xDF, 0xBF,
  0xFD, 0xFB, 0xFF, 0xCF, 0xDF, 0xFC, 0xFD, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFD, 0xFE, 0x7F, 0x07, 0xF7,
  0xF0, 0x7F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xF8, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xEF,
  0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F,
  0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xF9, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0xC1, 0xFC, 0x7F,
  0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x1F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF7, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0,
  0x7F, 0x01, 0x80, 0x3F, 0xF0, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF,
  0xBF, 0x02, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFF, 0x87, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x07, 0xEF, 0xE1, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xE0, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0,
  0x7E, 0x7F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x80,
  0xF9, 0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F, 0x07, 0xE7, 0xE0,
  0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x7E, 0x7E, 0x1F, 0xC1, 0xF9, 0xF8, 0x7F,
  0x87, 0xE3, 0xE1, 0xFE, 0x1F, 0x0F, 0x87, 0xF8, 0xFC, 0x3F, 0x1F, 0xE3,
  0xF0, 0xFC, 0xFF, 0x8F, 0xC3, 0xF3, 0xFF, 0x3F, 0x07, 0xCF, 0xFC, 0xF8,
  0x1F, 0x3C, 0xF7, 0xE0, 0x7C, 0xF3, 0xDF, 0x81, 0xFF, 0xCF, 0x7E, 0x07,
  0xFF, 0x3D, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF,
  0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE1,
  0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE7,
  0xE0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0x1F, 0x9F, 0x81, 0xFB, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0x9F, 0x83, 0xF9, 0xF8, 0x3F,
  0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF,
  0xC1, 0xFD, 0xF8, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x3F, 0x3F, 0x07,
  0xEF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x0F,
  0x9F, 0x03, 0xE7, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0x0F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF1, 0xEF, 0xE2, 0x0F, 0xC0, 0x1F,
  0x83, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0x3C, 0xFC, 0x78, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0xF0, 0xFF, 0xFC, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC,
  0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB,
  0xFC, 0xF9, 0xF8, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xCF, 0xFE, 0x7F, 0xF9,
  0xF8, 0x2F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x27, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x0F, 0xBF, 0x3F, 0xFF, 0x3F, 0xDF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x02, 0x7F, 0x0E, 0x7F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xF0, 0x7F, 0xC7, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xC0, 0x7C, 0x07, 0xFE, 0x7F, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x00, 0x0F, 0x9F, 0x3F, 0xDF, 0x3F, 0xDF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x40, 0x3F, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xF8,
  0xFB, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFB, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x7F, 0xFC, 0x3F, 0x7E, 0x3F, 0x3F, 0x3F, 0x9F, 0x9F,
  0x8F, 0xDF, 0x87, 0xEF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF9,
  0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF1, 0xF8, 0x7E, 0x7D, 0xFE, 0x7F, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0xFF, 0xF1, 0xFC,
  0x7F, 0xF8, 0x7E, 0x3F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F,
  0x87, 0xFF, 0x87, 0xC3, 0xFF, 0xC3, 0xE1, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0,
  0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF,
  0x0F, 0x87, 0xE0, 0xF1, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x3E, 0xFC, 0x1F,
  0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xEF, 0xC3, 0xF3, 0xF1, 0xF9, 0xFD,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF9, 0xF0,
  0xFB, 0xFC, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFD, 0xF8,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xDF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0xFF,
  0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x00, 0x1F, 0xC1, 0xFF, 0xDF, 0xFD, 0xFF, 0xEF, 0xCE, 0x7E, 0x13, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x3F, 0x1F, 0xFC, 0x0F, 0xFF,
  0x07, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x8F, 0x87, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x3F, 0x87, 0xEF, 0x87, 0xF0, 0xF9, 0xF0,
  0xFE, 0x3F, 0x3F, 0x3F, 0xC7, 0xE7, 0xE7, 0xFC, 0xFC, 0xFC, 0xFF, 0x9F,
  0x0F, 0x9E, 0xF3, 0xE1, 0xF3, 0xDE, 0xFC, 0x3E, 0x7B, 0xDF, 0x87, 0xFF,
  0x7B, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0x9F,
  0x8F, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xF7, 0xE0, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F,
  0x8F, 0xEF, 0xE1, 0xFC, 0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xE1, 0xF9, 0xF8,
  0x7E, 0x7E, 0x1F, 0x8F, 0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0x3E,
  0x07, 0xEF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x60, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF1, 0xFE, 0x3F, 0x87, 0xC0, 0xFE, 0x1F,
  0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0,
  0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x1F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xC0, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0x80, 0xFC,
};

const GFXglyph NotoSans_Condensed_Black34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 24, 9, 1, -24 },
  { 22, 13, 9, 17, 2, -24 },
  { 37, 18, 24, 20, 1, -24 },
  { 91, 15, 28, 18, 1, -26 },
  { 144, 28, 25, 30, 1, -25 },
  { 232, 23, 25, 23, 1, -25 },
  { 304, 5, 9, 9, 2, -24 },
  { 310, 10, 30, 11, 1, -25 },
  { 348, 10, 30, 11, 0, -25 },
  { 386, 15, 16, 17, 1, -26 },
  { 416, 16, 16, 18, 1, -20 },
  { 448, 7, 10, 10, 1, -5 },
  { 457, 9, 5, 11, 1, -12 },
  { 463, 7, 6, 9, 1, -6 },
  { 469, 15, 25, 15, 0, -25 },
  { 516, 16, 25, 18, 1, -25 },
  { 566, 13, 24, 18, 1, -24 },
  { 605, 15, 25, 18, 1, -25 },
  { 652, 15, 25, 18, 1, -25 },
  { 699, 16, 24, 18, 1, -24 },
  { 747, 14, 24, 18, 2, -24 },
  { 789, 16, 25, 18, 1, -25 },
  { 839, 16, 24, 18, 1, -24 },
  { 887, 16, 25, 18, 1, -25 },
  { 937, 16, 25, 18, 1, -25 },
  { 987, 6, 19, 10, 2, -19 },
  { 1002, 7, 24, 10, 1, -19 },
  { 1023, 16, 17, 18, 1, -21 },
  { 1057, 16, 12, 18, 1, -18 },
  { 1081, 16, 17, 18, 1, -21 },
  { 1115, 14, 25, 15, 0, -25 },
  { 1159, 25, 28, 27, 1, -25 },
  { 1247, 21, 24, 21, 0, -24 },
  { 1310, 17, 24, 20, 2, -24 },
  { 1361, 17, 25, 19, 1, -25 },
  { 1415, 18, 24, 21, 2, -24 },
  { 1469, 13, 24, 16, 2, -24 },
  { 1508, 13, 24, 16, 2, -24 },
  { 1547, 19, 25, 22, 1, -25 },
  { 1607, 18, 24, 22, 2, -24 },
  { 1661, 11, 24, 13, 1, -24 },
  { 1694, 10, 32, 11, -2, -24 },
  { 1734, 18, 24, 20, 2, -24 },
  { 1788, 13, 24, 16, 2, -24 },
  { 1827, 25, 24, 29, 2, -24 },
  { 1902, 20, 24, 24, 2, -24 },
  { 1962, 20, 25, 23, 1, -25 },
  { 2025, 16, 24, 19, 2, -24 },
  { 2073, 21, 31, 23, 1, -25 },
  { 2155, 18, 24, 20, 2, -24 },
  { 2209, 15, 25, 17, 1, -25 },
  { 2256, 15, 24, 17, 1, -24 },
  { 2301, 18, 24, 22, 2, -24 },
  { 2355, 20, 24, 20, 0, -24 },
  { 2415, 30, 24, 30, 0, -24 },
  { 2505, 20, 24, 20, 0, -24 },
  { 2565, 19, 24, 19, 0, -24 },
  { 2622, 16, 24, 17, 1, -24 },
  { 2670, 8, 31, 11, 2, -25 },
  { 2701, 15, 25, 15, 0, -25 },
  { 2748, 8, 31, 11, 1, -25 },
  { 2779, 18, 16, 18, 0, -24 },
  { 2815, 17, 4, 17, 0, 2 },
  { 2824, 10, 5, 12, 1, -26 },
  { 2831, 15, 19, 18, 1, -19 },
  { 2867, 16, 26, 19, 2, -26 },
  { 2919, 14, 19, 16, 1, -19 },
  { 2953, 16, 26, 19, 1, -26 },
  { 3005, 16, 19, 18, 1, -19 },
  { 3043, 13, 26, 12, 0, -26 },
  { 3086, 16, 27, 19, 1, -19 },
  { 3140, 16, 26, 19, 2, -26 },
  { 3192, 6, 26, 10, 2, -26 },
  { 3212, 9, 34, 10, -1, -26 },
  { 3251, 17, 26, 19, 2, -26 },
  { 3307, 6, 26, 10, 2, -26 },
  { 3327, 25, 19, 29, 2, -19 },
  { 3387, 16, 19, 19, 2, -19 },
  { 3425, 17, 19, 19, 1, -19 },
  { 3466, 16, 27, 19, 2, -19 },
  { 3520, 16, 27, 19, 1, -19 },
  { 3574, 11, 19, 14, 2, -19 },
  { 3601, 13, 19, 15, 1, -19 },
  { 3632, 12, 23, 13, 0, -23 },
  { 3667, 16, 19, 19, 2, -19 },
  { 3705, 18, 19, 18, 0, -19 },
  { 3748, 27, 19, 27, 0, -19 },
  { 3813, 18, 19, 18, 0, -19 },
  { 3856, 18, 27, 18, 0, -19 },
  { 3917, 13, 19, 15, 1, -19 },
  { 3948, 11, 31, 13, 1, -25 },
  { 3991, 5, 34, 15, 5, -26 },
  { 4013, 12, 31, 13, 1, -25 },
  { 4060, 16, 6, 18, 1, -15 },
};

const GFXfont NotoSans_Condensed_Black34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_BLACK34PT7B_H_
