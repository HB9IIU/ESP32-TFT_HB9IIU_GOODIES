#ifndef _NOTOSANS_CONDENSED_BLACK24PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0x9C, 0x00, 0x3B, 0xFF, 0xF0,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0x9C, 0xE0, 0x07, 0x70, 0x39, 0xC0,
  0xE7, 0x03, 0x98, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC7, 0x38, 0x1C, 0xE0,
  0x73, 0x8F, 0xFF, 0xBF, 0xFE, 0x1D, 0xC0, 0x67, 0x03, 0x9C, 0x0E, 0x70,
  0x3B, 0x80, 0x0C, 0x01, 0xC1, 0xFF, 0x3F, 0xEF, 0xFD, 0xD8, 0xBF, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0xDF, 0x9B, 0xBF, 0xF7, 0xFE,
  0x7F, 0x01, 0x80, 0x30, 0x00, 0x7C, 0x1E, 0x1F, 0xC3, 0x83, 0xB8, 0x70,
  0x77, 0x1C, 0x0E, 0xF3, 0x81, 0xDC, 0xE0, 0x3B, 0x9C, 0x47, 0x77, 0x3E,
  0xFE, 0xEF, 0xEF, 0xB9, 0xDC, 0x07, 0x7B, 0x80, 0xEF, 0x70, 0x39, 0xEE,
  0x07, 0x1D, 0xC1, 0xC3, 0xF8, 0x38, 0x7F, 0x0E, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0x9E, 0x7F, 0x3E, 0xFF, 0xBC, 0xF7, 0xFC, 0xF3, 0xFC, 0xF1, 0xF8,
  0xF9, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xBF, 0xFF, 0xFF, 0xF7, 0x1E,
  0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3,
  0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF3,
  0xC7, 0x9E, 0x00, 0x0F, 0x00, 0xF0, 0x4E, 0x27, 0xFE, 0x7F, 0xEF, 0xFF,
  0x1F, 0x83, 0xF8, 0x7B, 0xE3, 0x98, 0x09, 0x00, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00,
  0x7B, 0xFD, 0xEF, 0x7B, 0x80, 0xFF, 0xFF, 0xC0, 0x77, 0xFF, 0xE0, 0x03,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x3F, 0x0F, 0xF1,
  0xFF, 0x7D, 0xEF, 0x3D, 0xE7, 0xBC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3C, 0xF7, 0x9F, 0xF1, 0xFC, 0x1F, 0x00, 0x07, 0x87, 0xC7,
  0xE7, 0xF7, 0xFF, 0xBD, 0xDE, 0x4F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x1F, 0x8F, 0xFB, 0xFF, 0xBD, 0xF2, 0x1E,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xFF,
  0xDF, 0xFB, 0xFF, 0x7F, 0xE0, 0x7F, 0x1F, 0xF3, 0xFF, 0x31, 0xE0, 0x3C,
  0x07, 0x87, 0xE1, 0xF8, 0x3F, 0x07, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x8F,
  0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC3, 0xBC, 0x7B, 0xC7, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7F, 0xDF, 0xF7, 0xFD, 0xE0,
  0x70, 0x1C, 0x07, 0xF3, 0xFE, 0xFF, 0xD1, 0xF0, 0x3C, 0x0F, 0x03, 0xF9,
  0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x0F, 0xC7, 0xF9, 0xFF, 0x3E, 0x0F, 0x01,
  0xE0, 0x3F, 0xE7, 0xFE, 0xFF, 0xDF, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF7,
  0x9F, 0xF3, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x3F, 0x8F, 0xFB, 0xFF, 0x79, 0xEF, 0x3D,
  0xF7, 0x9F, 0xF1, 0xFC, 0x3F, 0x8F, 0xFB, 0xEF, 0x78, 0xFF, 0x1F, 0xE3,
  0xFF, 0xF3, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xF3, 0xFF, 0x79, 0xEF, 0x3D,
  0xE7, 0xFC, 0xFF, 0x9F, 0xFF, 0xEF, 0xFD, 0xF7, 0x00, 0xE0, 0x3C, 0x0F,
  0x9F, 0xE3, 0xF8, 0x7E, 0x00, 0xF7, 0xFE, 0xE0, 0x00, 0x00, 0x03, 0xBF,
  0xF7, 0x00, 0xF7, 0xFE, 0xE0, 0x00, 0x00, 0x03, 0xDF, 0xEF, 0x7B, 0xDC,
  0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xF9, 0xF8, 0x3E, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xF8, 0x7F, 0x7F, 0x1F, 0x83, 0xC0, 0x60, 0x00, 0x7F,
  0x3F, 0xE7, 0xFD, 0x8F, 0x03, 0xC0, 0xF0, 0x78, 0x3E, 0x1E, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xF8, 0x1C, 0x00, 0x07, 0xF8, 0x0F,
  0xFF, 0x0F, 0x83, 0xC7, 0x00, 0xE7, 0x1F, 0xBB, 0x9F, 0xDF, 0x9E, 0xEF,
  0xCE, 0x73, 0xEE, 0x39, 0xF7, 0x1C, 0xFB, 0x8E, 0xFD, 0xEF, 0x7E, 0x7F,
  0xF7, 0x9E, 0xF1, 0xC0, 0x00, 0xF0, 0x08, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEE, 0x03,
  0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0x78, 0x78, 0xF0, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0xCF, 0xFF, 0x9E, 0x0F, 0x7C, 0x1E, 0xF8, 0x3E, 0xFF, 0x9F,
  0xFB, 0xFF, 0xF9, 0xFF, 0x1F, 0xE7, 0xFD, 0xF7, 0xFC, 0xFF, 0xDF, 0xFF,
  0xC7, 0xF8, 0xFF, 0x1F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x0F, 0xF3,
  0xFE, 0x3F, 0xE7, 0xC6, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xEE, 0x7F, 0xE3, 0xFE, 0x0F, 0xC0,
  0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x7E, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x0F, 0xF8, 0xFF, 0x8F, 0xFC, 0xFC, 0x67, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0xBF, 0x7C, 0xFF,
  0xE7, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFB, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xBF, 0xFF, 0xFE, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1F, 0x1F, 0xFE, 0xFE, 0xFC, 0xF1, 0xFF, 0x1F, 0xF3, 0xEF,
  0x3C, 0xF7, 0xCF, 0x78, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F,
  0x7C, 0xF3, 0xCF, 0x3E, 0xF1, 0xEF, 0x1F, 0xF1, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xB9, 0xFF, 0xDC, 0xEF, 0xEF, 0x77,
  0xF7, 0xBB, 0xF9, 0xFD, 0xFC, 0xFC, 0xFE, 0x7E, 0x7F, 0x1F, 0x3F, 0x8F,
  0x9F, 0xC7, 0x8F, 0xE3, 0xC7, 0x80, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x1F, 0xBC, 0xFD, 0xE7, 0xEF, 0xBF, 0x3D, 0xF9, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xF8, 0x1F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x9F, 0x3E, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0x78, 0x7D, 0xFF, 0xE7, 0xFF,
  0x8F, 0xFC, 0x0F, 0xE0, 0xFF, 0x1F, 0xF3, 0xFF, 0x7B, 0xEF, 0x3D, 0xE7,
  0xFC, 0xF7, 0xBE, 0xFF, 0xDF, 0xF3, 0xFC, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0x3E, 0xF8,
  0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE,
  0x1F, 0x78, 0x7D, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0x7E, 0xF3,
  0xEF, 0x3E, 0xF3, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFF, 0x8F, 0x78, 0xF7,
  0xCF, 0x3C, 0xF3, 0xEF, 0x1E, 0xF1, 0xF0, 0x3F, 0x9F, 0xFF, 0xFF, 0xE6,
  0xF0, 0x3E, 0x0F, 0xC1, 0xFC, 0x7F, 0x87, 0xF0, 0xFC, 0x0F, 0x83, 0xFF,
  0xFF, 0xFB, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xF7, 0x8F, 0xBE, 0xFD, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0xF8,
  0x3F, 0xE1, 0xF7, 0x87, 0xDE, 0x1E, 0x7C, 0x78, 0xF1, 0xE3, 0xCF, 0x8F,
  0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0xF0, 0x70, 0x7F, 0xC7, 0xC7, 0xDE, 0x3E,
  0x3C, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F, 0x3C, 0x7C, 0x79, 0xE7, 0x73, 0xC7,
  0xBB, 0xBC, 0x3D, 0xDD, 0xE1, 0xEE, 0xEF, 0x0F, 0x77, 0x78, 0x3F, 0xBF,
  0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F,
  0x8F, 0xC0, 0xF8, 0x79, 0xE3, 0xE3, 0xCF, 0x0F, 0x7C, 0x1F, 0xE0, 0x7F,
  0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF8, 0x3F,
  0xF0, 0xF3, 0xC7, 0xCF, 0x9E, 0x1E, 0xF8, 0x7C, 0xF8, 0x7D, 0xE1, 0xE7,
  0x8F, 0x0F, 0x3C, 0x3D, 0xF0, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xF0, 0xF0, 0x1C, 0x07, 0x81, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0E, 0xE0, 0xF7, 0x87, 0x1C, 0x78,
  0xF3, 0x83, 0xBC, 0x1E, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x78, 0x04, 0x0F,
  0xF1, 0xFF, 0x1F, 0xE2, 0x3C, 0x07, 0xDF, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFB, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF1, 0x0F, 0x7C, 0xFF, 0xEF, 0xFE, 0xF9, 0xEF, 0x9E, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x9E, 0xF9, 0xEF, 0xFE, 0xFF, 0xCF, 0x78, 0x04, 0x0F, 0xF7,
  0xF9, 0xFE, 0xF8, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x89, 0xFE,
  0x7F, 0x8F, 0xE0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF1, 0x1E, 0x7B, 0xDF,
  0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFE, 0xFF,
  0xFF, 0x7F, 0xE7, 0x9C, 0x3F, 0x8F, 0xF9, 0xFF, 0x78, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x09, 0xFF, 0x3F, 0xE1, 0xFC, 0x1F, 0x9F,
  0xCF, 0xC7, 0x83, 0xC3, 0xFB, 0xFD, 0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x08, 0x07, 0xBD, 0xFF, 0xFF,
  0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xFF, 0xF7,
  0xFE, 0x7B, 0xC0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x11, 0xEF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF,
  0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3C,
  0x67, 0xBF, 0xE0, 0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC,
  0x18, 0x78, 0xF9, 0xE0, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xDF, 0xBF, 0x7C, 0xF0, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0xFB, 0xC7, 0x9E, 0x78, 0xF7,
  0xC7, 0xBC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0x7D, 0xE3, 0xCF, 0x9E, 0x3C,
  0xF1, 0xF7, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x02, 0x3D, 0xF3, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF3,
  0xFE, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF,
  0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xF0, 0x01, 0x1E, 0xFB,
  0xFF, 0xFF, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0x04, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xE7, 0xBF, 0xE3, 0xFC, 0x3F,
  0x00, 0x01, 0x0F, 0x7C, 0xFF, 0xEF, 0xFE, 0xF9, 0xEF, 0x9E, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x9E, 0xF9, 0xEF, 0xFE, 0xFF, 0xCF, 0x7C, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x08, 0x07, 0xBD, 0xFF, 0xFF,
  0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xFF, 0xF7,
  0xFE, 0x7B, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x01,
  0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x08, 0x3F, 0xFF, 0xDF, 0xEF, 0x17, 0xC3, 0xF8, 0xFE, 0x3F, 0x07,
  0xE1, 0xFF, 0xEF, 0xF7, 0xF0, 0x1C, 0x0E, 0x0F, 0x0F, 0xFF, 0xFF, 0xFC,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC9, 0xFC, 0xFE, 0x3F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF,
  0x7D, 0xFF, 0xBF, 0x73, 0xEE, 0xF0, 0xFB, 0xC7, 0x9E, 0x3C, 0xF3, 0xC3,
  0x9E, 0x1E, 0xF0, 0xF7, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x00, 0xF1, 0xF1, 0xEF, 0x3E, 0x79, 0xE7, 0xCF, 0x3D, 0xD9,
  0xE7, 0xBB, 0xBC, 0xF7, 0x77, 0x0E, 0xEE, 0xE1, 0xDD, 0xFC, 0x3F, 0xBF,
  0x87, 0xE7, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0xF9, 0xF7,
  0xDE, 0x3D, 0xE3, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0xC3,
  0xFE, 0x7D, 0xE7, 0x9F, 0xF8, 0xF0, 0xF8, 0xFB, 0xC7, 0x9E, 0x3C, 0xF3,
  0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x1E,
  0x00, 0x7F, 0xDF, 0xF7, 0xFC, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3C,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x8F, 0xC7, 0xE3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3E, 0x7E, 0x3E, 0x1F, 0x83, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xE1, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0xF8, 0xF8, 0x78, 0x38, 0x38, 0x38, 0x38, 0x3E,
  0x3F, 0x0F, 0x3F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF8, 0xF8, 0xF0,
  0x30, 0x3F, 0xCF, 0xFF, 0xEF, 0xF8, 0x3C,
};

const GFXglyph NotoSans_Condensed_Black24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 17, 7, 1, -17 },
  { 12, 10, 6, 12, 1, -17 },
  { 20, 14, 17, 14, 0, -17 },
  { 50, 11, 19, 12, 1, -18 },
  { 77, 19, 17, 21, 1, -17 },
  { 118, 16, 17, 17, 1, -17 },
  { 152, 4, 6, 6, 1, -17 },
  { 155, 7, 22, 8, 1, -18 },
  { 175, 7, 22, 8, 0, -18 },
  { 195, 12, 11, 12, 0, -18 },
  { 212, 11, 11, 13, 1, -14 },
  { 228, 5, 7, 7, 1, -4 },
  { 233, 6, 3, 8, 1, -8 },
  { 236, 5, 4, 7, 1, -4 },
  { 239, 10, 17, 10, 0, -17 },
  { 261, 11, 17, 13, 1, -17 },
  { 285, 9, 17, 13, 1, -17 },
  { 305, 11, 17, 13, 0, -17 },
  { 329, 11, 17, 13, 1, -17 },
  { 353, 12, 17, 13, 0, -17 },
  { 379, 10, 17, 13, 1, -17 },
  { 401, 11, 17, 13, 1, -17 },
  { 425, 11, 17, 13, 1, -17 },
  { 449, 11, 17, 13, 1, -17 },
  { 473, 11, 17, 13, 1, -17 },
  { 497, 5, 13, 7, 1, -13 },
  { 506, 5, 16, 7, 1, -13 },
  { 516, 11, 12, 13, 1, -15 },
  { 533, 11, 9, 13, 1, -13 },
  { 546, 11, 12, 13, 1, -15 },
  { 563, 10, 17, 10, 0, -17 },
  { 585, 17, 19, 19, 1, -17 },
  { 626, 15, 17, 15, 0, -17 },
  { 658, 11, 17, 14, 2, -17 },
  { 682, 12, 17, 13, 1, -17 },
  { 708, 12, 17, 15, 2, -17 },
  { 734, 8, 17, 11, 2, -17 },
  { 751, 8, 17, 11, 2, -17 },
  { 768, 13, 17, 15, 1, -17 },
  { 796, 12, 17, 16, 2, -17 },
  { 822, 7, 17, 9, 1, -17 },
  { 837, 8, 22, 7, -2, -17 },
  { 859, 12, 17, 14, 2, -17 },
  { 885, 9, 17, 11, 2, -17 },
  { 905, 17, 17, 21, 2, -17 },
  { 942, 13, 17, 17, 2, -17 },
  { 970, 14, 17, 16, 1, -17 },
  { 1000, 11, 17, 13, 2, -17 },
  { 1024, 14, 21, 16, 1, -17 },
  { 1061, 12, 17, 14, 2, -17 },
  { 1087, 10, 17, 12, 1, -17 },
  { 1109, 12, 17, 12, 0, -17 },
  { 1135, 13, 17, 15, 1, -17 },
  { 1163, 14, 17, 14, 0, -17 },
  { 1193, 21, 17, 21, 0, -17 },
  { 1238, 14, 17, 14, 0, -17 },
  { 1268, 14, 17, 14, 0, -17 },
  { 1298, 11, 17, 12, 1, -17 },
  { 1322, 6, 22, 7, 1, -18 },
  { 1339, 10, 17, 10, 0, -17 },
  { 1361, 6, 22, 7, 0, -18 },
  { 1378, 13, 11, 13, 0, -17 },
  { 1396, 12, 2, 12, 0, 2 },
  { 1399, 7, 3, 9, 1, -18 },
  { 1402, 11, 14, 13, 1, -14 },
  { 1422, 12, 18, 13, 1, -18 },
  { 1449, 10, 14, 11, 1, -14 },
  { 1467, 11, 18, 13, 1, -18 },
  { 1492, 11, 13, 13, 1, -13 },
  { 1510, 9, 18, 8, 0, -18 },
  { 1531, 11, 20, 13, 1, -14 },
  { 1559, 11, 18, 14, 1, -18 },
  { 1584, 5, 19, 7, 1, -19 },
  { 1596, 7, 25, 7, -1, -19 },
  { 1618, 13, 18, 13, 1, -18 },
  { 1648, 4, 18, 7, 1, -18 },
  { 1657, 18, 14, 20, 1, -14 },
  { 1689, 11, 14, 14, 1, -14 },
  { 1709, 11, 14, 13, 1, -14 },
  { 1729, 12, 20, 13, 1, -14 },
  { 1759, 11, 20, 13, 1, -14 },
  { 1787, 8, 14, 10, 1, -14 },
  { 1801, 9, 14, 10, 1, -14 },
  { 1817, 9, 16, 9, 0, -16 },
  { 1835, 11, 13, 14, 1, -13 },
  { 1853, 13, 13, 13, 0, -13 },
  { 1875, 19, 13, 19, 0, -13 },
  { 1906, 12, 13, 13, 0, -13 },
  { 1926, 13, 19, 13, 0, -13 },
  { 1957, 10, 13, 10, 0, -13 },
  { 1974, 9, 21, 9, 0, -17 },
  { 1998, 3, 23, 11, 4, -18 },
  { 2007, 8, 21, 9, 1, -17 },
  { 2028, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_Black24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_BLACK24PT7B_H_
