#ifndef _NOTOSANS_CONDENSED_BLACK43PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFE,
  0xFC, 0x7F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xE0, 0x01, 0xF9, 0xF8,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC1, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x83, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x3F, 0x00,
  0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0x9C, 0x73, 0xF3, 0x82, 0x7E, 0x70, 0x0F, 0xCE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x39, 0xF8, 0x07, 0x3F,
  0xC0, 0xE7, 0xFE, 0x1D, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0xFC, 0x00, 0x7F,
  0xF8, 0x0F, 0x80, 0x0F, 0xCF, 0xC0, 0xF8, 0x00, 0xFC, 0xFC, 0x1F, 0x80,
  0x0F, 0xC7, 0xC1, 0xF0, 0x00, 0xFC, 0x7C, 0x3F, 0x00, 0x0F, 0xC7, 0xC3,
  0xE0, 0x00, 0xFC, 0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xC7, 0xC0, 0x00, 0xFC,
  0xFC, 0xFC, 0x3E, 0x0F, 0xCF, 0xCF, 0x8F, 0xF0, 0x7F, 0xF9, 0xF9, 0xFF,
  0x87, 0xFF, 0x9F, 0x1F, 0xFC, 0x3F, 0xF1, 0xF3, 0xFF, 0xE1, 0xFF, 0x3F,
  0x3F, 0x7E, 0x0F, 0xC3, 0xE3, 0xE3, 0xE0, 0x00, 0x7E, 0x7E, 0x3E, 0x00,
  0x07, 0xC7, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE3,
  0xE0, 0x01, 0xF8, 0x7E, 0x3E, 0x00, 0x1F, 0x07, 0xE3, 0xE0, 0x03, 0xF0,
  0x3E, 0x7E, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0xFC, 0x00,
  0x7E, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x08, 0x1F, 0xFC, 0x3F, 0x83, 0xFF, 0xC3, 0xFC, 0x3F,
  0xFF, 0x1F, 0xE1, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F,
  0xFF, 0x8F, 0xF1, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC,
  0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xDF, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0x7E, 0xFD, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7E, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x06, 0x1F, 0x0C, 0x7D, 0xF7,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xBF, 0x03, 0xFB, 0xF8, 0x7F,
  0x1F, 0xC1, 0xF1, 0xF0, 0x0E, 0x0E, 0x00, 0x20, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x9F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xDF,
  0xE7, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xF7, 0xF0,
  0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7,
  0xF0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0x9F, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7E,
  0xFF, 0x3C, 0xFF, 0x18, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xCF, 0xF9, 0xE0, 0xFF, 0x18, 0x1F,
  0xE2, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3E, 0x3F, 0xE1, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xDF, 0xE0,
  0xFC, 0xFF, 0x07, 0xE7, 0xF8, 0x7E, 0x3F, 0xC3, 0xF1, 0xFE, 0x3F, 0x0F,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC2, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF4, 0x01, 0xFE, 0xE0, 0x7F, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x7E, 0xFF, 0xC7, 0xEF, 0xFC, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0xFF, 0x7F,
  0x8F, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x8F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0x9F, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF9, 0xFE, 0x7F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF7, 0xF9, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x7F, 0x9F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF7,
  0xF0, 0xFE, 0x7F, 0x03, 0x87, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x1F, 0x1F, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF3, 0xF9, 0xFD, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xC3, 0xFC, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x7C, 0x3E, 0x0F, 0xFC, 0xFC, 0xFC, 0x3F, 0xFC, 0xF9, 0xF0, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0x8F, 0xE3, 0xE3, 0xFF, 0x1F, 0x87, 0xC7,
  0xFE, 0x3E, 0x1F, 0x8F, 0xFC, 0x7C, 0x3F, 0x1F, 0xF9, 0xF8, 0x7E, 0x3F,
  0xF3, 0xF0, 0xFC, 0x7F, 0xE7, 0xE1, 0xF8, 0xFF, 0xC7, 0xC3, 0xF1, 0xFF,
  0x8F, 0x87, 0xE7, 0xDF, 0x1F, 0x9F, 0xCF, 0xBE, 0x3F, 0xFF, 0xFE, 0x7E,
  0x3F, 0xFF, 0xFC, 0xFC, 0x3F, 0xCF, 0xF0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x18, 0x03, 0xFE,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xF8, 0xFF, 0xE8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF8, 0xFF, 0xDF, 0xC1, 0xFE,
  0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFC, 0x3F, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0x87, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFE, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xF3, 0xE7, 0xFC, 0x06, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x02, 0x7F, 0xE0, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0x83, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0xBF, 0x83,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFE, 0x3E, 0x3F, 0xE0, 0x08, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0xE0, 0x7F, 0x7F, 0xE0, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x87, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0x38, 0x00, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFB, 0xF8, 0x1F, 0xF7, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x1F, 0xC1,
  0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFC, 0xFF,
  0x03, 0xF9, 0xFE, 0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F,
  0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8,
  0x3F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0xDF, 0xC0, 0x7F, 0xBF, 0x80,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF7,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xEF, 0xFF, 0xDF,
  0x8F, 0xDF, 0xFF, 0xBF, 0x1F, 0xBF, 0xFF, 0x7E, 0x3E, 0x7F, 0xFE, 0xFC,
  0xFC, 0xFF, 0xFC, 0xFD, 0xF9, 0xFF, 0xF9, 0xFB, 0xF3, 0xFF, 0xF3, 0xF7,
  0xC7, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0x8F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xF8, 0x7F, 0xFE, 0x3F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE1,
  0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xE1, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x3F, 0x80, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x87, 0xFF, 0xDF,
  0xE3, 0xFF, 0xF7, 0xF1, 0xFF, 0xFB, 0xFC, 0xFF, 0xFC, 0xFE, 0x7F, 0xFE,
  0x7F, 0x3F, 0xFF, 0x3F, 0xDF, 0xFF, 0x8F, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0xFF, 0x83, 0xFE, 0x7F,
  0x80, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFC, 0xFF, 0x83,
  0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0xFF,
  0x83, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFD, 0xFE, 0x03,
  0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xE7, 0xFE, 0x3F, 0x87, 0xFC, 0xFE, 0x0F,
  0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x1F, 0xE3,
  0xF8, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F, 0x83, 0xF8, 0xFE,
  0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0xCF,
  0xE0, 0xFF, 0x3F, 0x83, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xF8, 0x0C, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0,
  0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xDF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x81, 0xFE,
  0x7F, 0x01, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F,
  0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xFF, 0x07, 0xF0,
  0xFE, 0x0F, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xF0, 0xFE, 0x07, 0xF1, 0xFF,
  0xC3, 0xF8, 0x1F, 0xC7, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xFE, 0x3F, 0x81,
  0xFC, 0x7D, 0xF9, 0xFE, 0x07, 0xF1, 0xF7, 0xE7, 0xF0, 0x0F, 0xCF, 0xCF,
  0x9F, 0xC0, 0x3F, 0xBF, 0x3E, 0x7F, 0x00, 0xFE, 0xFC, 0xFD, 0xFC, 0x03,
  0xFB, 0xF3, 0xF7, 0xF0, 0x0F, 0xEF, 0x8F, 0xFF, 0x80, 0x1F, 0xBE, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x3F, 0xC0, 0xFF, 0x8F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC7, 0xF8, 0x1F, 0xF3, 0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00,
  0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xE3, 0xF8, 0x0F, 0xE7,
  0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0x7F, 0x00,
  0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F,
  0x01, 0xF8, 0xFE, 0x03, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFB, 0xFE, 0x0C, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFE, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0x7F, 0x3F, 0xF3,
  0xF1, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF9, 0xF8, 0x3F, 0xDF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xF1, 0xFE, 0xFF, 0x0F, 0xF7,
  0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xBF,
  0xE3, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xDF, 0xF8, 0xFC, 0x3F, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFC, 0x31, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x5F, 0xE0, 0x67, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0x3F, 0xC3, 0xFD, 0xFE, 0x3F, 0xF7, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xF1, 0xFF, 0x7F, 0x87, 0xFB, 0xF8, 0x3F, 0xDF,
  0xC1, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F,
  0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xEF, 0xE3, 0xFF, 0x7F,
  0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE3, 0xFD, 0xFE, 0x7F, 0x87, 0xF7, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x02,
  0x7F, 0xC1, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xFE, 0x3F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xE3, 0xF8,
  0x7F, 0x9F, 0xC7, 0xFE, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFE, 0x3F, 0xEF, 0xF0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F,
  0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xFC, 0x3F, 0xDF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xDF, 0xE0, 0xFC, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xD0, 0x01, 0xFC, 0x60, 0x1F, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF3, 0xF0, 0xFE, 0x7F, 0xCF, 0xEF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xF0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1,
  0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0xCF, 0xF0,
  0xFF, 0x7F, 0x83, 0xFD, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFE, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x83, 0xF8,
  0xFC, 0xFF, 0xC7, 0xFC, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF,
  0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F,
  0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F,
  0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F,
  0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F,
  0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F,
  0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F, 0xFC, 0x3F, 0x0F, 0xC7,
  0xFC, 0xFE, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9,
  0xFE, 0x1F, 0xCF, 0xF0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF,
  0xE0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0xFC,
  0x3F, 0x07, 0xF3, 0xFC, 0x3F, 0xBF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x07, 0xF7, 0xF8,
  0x3F, 0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xFC, 0x7F, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x7F, 0xE3, 0xFD, 0xFF, 0x1F,
  0xE7, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x7F, 0x9F, 0xC7, 0xFE,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x3F, 0xEF,
  0xF0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F,
  0x07, 0xFB, 0xFC, 0x3F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFD, 0xFC, 0x7F, 0xDF, 0xE0, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFC,
  0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xFE,
  0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0x3E, 0xFE, 0x04, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x3F, 0xF3,
  0xF0, 0xFE, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF3,
  0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0x7E,
  0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x07, 0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0xC3,
  0xF9, 0xFC, 0x3F, 0xF0, 0xFE, 0x7F, 0x0F, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF,
  0x1F, 0xC3, 0xF8, 0xFF, 0xC7, 0xF0, 0xFE, 0x7F, 0xF1, 0xFC, 0x3F, 0x9F,
  0xFE, 0x7F, 0x0F, 0xE7, 0xDF, 0x9F, 0x81, 0xF9, 0xF7, 0xE7, 0xE0, 0x7F,
  0x7C, 0xFB, 0xF8, 0x1F, 0xFF, 0x3E, 0xFE, 0x07, 0xFF, 0xCF, 0xBF, 0x80,
  0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFD, 0xFE, 0x1F, 0xE3,
  0xF8, 0x7F, 0x8F, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0xBF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0xFE, 0x0F, 0xF3,
  0xFC, 0x3F, 0xC7, 0xF1, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xBF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0xFE,
  0xFE, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0xC0, 0x17, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x7F, 0xE8, 0x00, 0xFC,
};

const GFXglyph NotoSans_Condensed_Black43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 17, 11, 21, 2, -31 },
  { 57, 23, 31, 25, 1, -31 },
  { 147, 19, 36, 22, 2, -33 },
  { 233, 36, 31, 38, 1, -31 },
  { 373, 29, 31, 30, 1, -31 },
  { 486, 7, 11, 11, 2, -31 },
  { 496, 12, 39, 14, 2, -32 },
  { 555, 13, 39, 14, 0, -32 },
  { 619, 20, 20, 21, 1, -33 },
  { 669, 19, 21, 23, 2, -26 },
  { 719, 9, 12, 12, 1, -6 },
  { 733, 12, 7, 14, 1, -15 },
  { 744, 8, 9, 12, 2, -8 },
  { 753, 18, 31, 18, 0, -31 },
  { 823, 20, 31, 22, 1, -31 },
  { 901, 16, 31, 22, 2, -31 },
  { 963, 19, 31, 22, 1, -31 },
  { 1037, 20, 31, 22, 1, -31 },
  { 1115, 21, 31, 22, 1, -31 },
  { 1197, 19, 31, 22, 2, -31 },
  { 1271, 20, 31, 22, 1, -31 },
  { 1349, 19, 31, 22, 2, -31 },
  { 1423, 20, 31, 22, 1, -31 },
  { 1501, 20, 31, 22, 1, -31 },
  { 1579, 8, 25, 12, 2, -24 },
  { 1604, 9, 30, 12, 1, -24 },
  { 1638, 20, 22, 23, 1, -27 },
  { 1693, 19, 15, 23, 2, -23 },
  { 1729, 19, 22, 23, 2, -27 },
  { 1782, 18, 32, 19, 0, -31 },
  { 1854, 31, 34, 35, 2, -31 },
  { 1986, 27, 31, 27, 0, -31 },
  { 2091, 21, 31, 26, 3, -31 },
  { 2173, 20, 31, 24, 2, -31 },
  { 2251, 22, 31, 27, 3, -31 },
  { 2337, 16, 31, 20, 3, -31 },
  { 2399, 15, 31, 20, 3, -31 },
  { 2458, 23, 31, 27, 2, -31 },
  { 2548, 22, 31, 28, 3, -31 },
  { 2634, 14, 31, 16, 1, -31 },
  { 2689, 13, 41, 13, -3, -31 },
  { 2756, 23, 31, 25, 3, -31 },
  { 2846, 17, 31, 20, 3, -31 },
  { 2912, 31, 31, 37, 3, -31 },
  { 3033, 25, 31, 30, 3, -31 },
  { 3130, 25, 31, 29, 2, -31 },
  { 3227, 19, 31, 24, 3, -31 },
  { 3301, 25, 38, 29, 2, -31 },
  { 3420, 22, 31, 25, 3, -31 },
  { 3506, 19, 31, 21, 1, -31 },
  { 3580, 20, 31, 21, 1, -31 },
  { 3658, 22, 31, 27, 3, -31 },
  { 3744, 26, 31, 26, 0, -31 },
  { 3845, 38, 31, 38, 0, -31 },
  { 3993, 25, 31, 25, 0, -31 },
  { 4090, 24, 31, 24, 0, -31 },
  { 4183, 20, 31, 22, 1, -31 },
  { 4261, 10, 39, 13, 2, -32 },
  { 4310, 18, 31, 18, 0, -31 },
  { 4380, 10, 39, 13, 1, -32 },
  { 4429, 23, 21, 23, 0, -31 },
  { 4490, 22, 5, 22, 0, 3 },
  { 4504, 12, 7, 16, 2, -33 },
  { 4515, 20, 24, 23, 1, -24 },
  { 4575, 21, 33, 24, 2, -33 },
  { 4662, 18, 24, 20, 1, -24 },
  { 4716, 21, 33, 24, 1, -33 },
  { 4803, 20, 24, 22, 1, -24 },
  { 4863, 16, 33, 15, 0, -33 },
  { 4929, 21, 34, 24, 1, -24 },
  { 5019, 20, 33, 25, 2, -33 },
  { 5102, 8, 33, 12, 2, -33 },
  { 5135, 12, 43, 12, -2, -33 },
  { 5200, 22, 33, 24, 2, -33 },
  { 5291, 8, 33, 12, 2, -33 },
  { 5324, 32, 24, 37, 2, -24 },
  { 5420, 20, 24, 25, 2, -24 },
  { 5480, 21, 24, 24, 1, -24 },
  { 5543, 21, 34, 24, 2, -24 },
  { 5633, 21, 34, 24, 1, -24 },
  { 5723, 15, 24, 17, 2, -24 },
  { 5768, 16, 24, 19, 1, -24 },
  { 5816, 15, 29, 17, 1, -29 },
  { 5871, 20, 24, 25, 2, -24 },
  { 5931, 23, 24, 23, 0, -24 },
  { 6000, 34, 24, 34, 0, -24 },
  { 6102, 22, 24, 22, 0, -24 },
  { 6168, 23, 34, 23, 0, -24 },
  { 6266, 17, 24, 18, 1, -24 },
  { 6317, 15, 38, 17, 1, -31 },
  { 6389, 6, 43, 19, 7, -33 },
  { 6422, 15, 38, 17, 1, -31 },
  { 6494, 20, 8, 23, 1, -19 },
};

const GFXfont NotoSans_Condensed_Black43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_BLACK43PT7B_H_
