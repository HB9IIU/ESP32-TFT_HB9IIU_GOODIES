#ifndef _NOTOSANS_CONDENSED_BLACK29PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xF9, 0xFF, 0x9F, 0xF9, 0xF7, 0x9F, 0x79,
  0xF7, 0x9F, 0x78, 0xF7, 0x8F, 0x07, 0x3C, 0x1E, 0x70, 0x3C, 0xE0, 0x79,
  0xC0, 0xE7, 0x81, 0xCF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xE0,
  0x7B, 0xC0, 0xE7, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x70, 0x3C,
  0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xCF, 0x07, 0x9C, 0x00, 0x07, 0x00, 0x38,
  0x07, 0xF8, 0x7F, 0xF7, 0xFF, 0x7F, 0xFB, 0xDC, 0x5E, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xEF, 0xC7,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xC3, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x3E, 0x03, 0xC0, 0x7F, 0x03, 0xC0, 0xFF, 0x07, 0x80, 0xF7, 0x87, 0x80,
  0xF7, 0x87, 0x00, 0xE7, 0x8F, 0x00, 0xE7, 0x8E, 0x00, 0xE7, 0x9E, 0x00,
  0xF7, 0x9C, 0x70, 0xF7, 0xBC, 0xFC, 0xFF, 0x3D, 0xFE, 0x7F, 0x7B, 0xFE,
  0x3E, 0x7B, 0xCE, 0x00, 0xF3, 0xCF, 0x00, 0xF3, 0xCF, 0x00, 0xE3, 0xCF,
  0x01, 0xE3, 0xCE, 0x01, 0xC3, 0xDE, 0x03, 0xC1, 0xFE, 0x03, 0x81, 0xFC,
  0x07, 0x80, 0xF8, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0xF8, 0xFF, 0x1F, 0x3F, 0xF7, 0xEF, 0xFF, 0xF9, 0xF3, 0xFF,
  0x3E, 0x7F, 0xE7, 0xC7, 0xF8, 0xF8, 0x7E, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFC, 0xFE, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x0F, 0x1E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0x0F,
  0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x19,
  0xE6, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3,
  0xEF, 0x87, 0x3C, 0x0C, 0x40, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0xF8, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xF8, 0xFF, 0xE7, 0xDF, 0x7C, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0x7D, 0xF3, 0xFF, 0x8F, 0xFC, 0x7F, 0xC1, 0xFC,
  0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFF, 0xFB, 0xDF,
  0x33, 0xE2, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x83, 0xFF, 0x3F, 0xF9, 0xFF,
  0xE7, 0xBF, 0x30, 0xF8, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xFF, 0xE7,
  0x3F, 0x20, 0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0xE0, 0xFF, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xBF, 0xFD,
  0xFF, 0xC7, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1E, 0xF8, 0x3D, 0xF0, 0xF3,
  0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x3E, 0x01, 0xF0, 0x0F, 0x60, 0x7F, 0xE3, 0xFF,
  0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xC1, 0xFF,
  0xFF, 0xBF, 0xFD, 0xFF, 0xC7, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x87, 0xFC,
  0x7F, 0xE7, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x38, 0xFF, 0xE7, 0xFF, 0xBF,
  0xFF, 0xFB, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0x7C, 0xFB, 0xFF,
  0xDF, 0xFC, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF,
  0x8F, 0xFC, 0x7D, 0xE3, 0xEF, 0xBE, 0x3F, 0xF1, 0xFF, 0x07, 0xF0, 0x7F,
  0xC7, 0xFF, 0x7C, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xDF, 0xFE,
  0xFF, 0xE1, 0xFC, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0xDF,
  0x7C, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xF7,
  0xFF, 0x9F, 0x7C, 0x03, 0xE0, 0x1E, 0x03, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF,
  0x87, 0xF0, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x7F, 0xFF, 0xDE, 0x7B, 0xFF, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0x3C, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07,
  0xF0, 0xFF, 0x9F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x03, 0xF8, 0xFF, 0x9F, 0xF1, 0xFE, 0x0F, 0x80, 0x70, 0x02, 0x00,
  0x00, 0x1F, 0x87, 0xFE, 0xFF, 0xE7, 0xFF, 0x71, 0xF4, 0x1F, 0x01, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xC0, 0x0F, 0x1E, 0x3E,
  0x39, 0xE3, 0xFD, 0xEE, 0x3F, 0xE7, 0xF3, 0xCF, 0x3F, 0x9C, 0x79, 0xFD,
  0xE3, 0xCF, 0xEF, 0x1E, 0x7F, 0x78, 0xF3, 0xFB, 0xC7, 0x9F, 0xCF, 0x7D,
  0xFE, 0x7F, 0xFE, 0x71, 0xFB, 0xE3, 0xC7, 0x06, 0x1F, 0x00, 0x00, 0x7C,
  0x01, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C,
  0xF8, 0x3E, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0x03,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF9, 0xFF, 0xE3, 0xFF, 0x8F, 0xBE, 0x3E,
  0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE3, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x03,
  0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F, 0x39, 0xF8, 0x27, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7F, 0x18, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x07, 0xF8,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xDF, 0x1F, 0xBE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7E, 0xFB, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x07, 0xC0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00,
  0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x9C, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x7F, 0x1F, 0x3F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xFF,
  0xFF, 0xEF, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xF8, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7F,
  0xFF, 0xFF, 0x7F, 0xBF, 0x84, 0x00, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xF7,
  0xC7, 0xEF, 0x9F, 0x9F, 0x3E, 0x3E, 0xFC, 0x7D, 0xF0, 0xFF, 0xE1, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x7C, 0x7C, 0xFC,
  0xF8, 0xF9, 0xF1, 0xFB, 0xE1, 0xF7, 0xC3, 0xFF, 0x87, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFE, 0xF1, 0xFF,
  0xF7, 0x8F, 0xFF, 0xBC, 0x77, 0xFF, 0xF7, 0xBF, 0xF7, 0xBD, 0xFF, 0xBD,
  0xEF, 0xFD, 0xFE, 0x7F, 0xEF, 0xF3, 0xFF, 0x3F, 0x9F, 0xF9, 0xFC, 0xFF,
  0xCF, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0x80, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xF7, 0xCF, 0xFB, 0xE7, 0xFE, 0xFB, 0xFF, 0x7D,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xF8, 0x07, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xF7, 0xF3, 0xF0, 0xFD, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF,
  0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF,
  0xEF, 0xFE, 0x7F, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xF7, 0xF3, 0xF0, 0xFD, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x7E,
  0xF8, 0x3F, 0x7E, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0xBF, 0x9F, 0x1F, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE,
  0x1F, 0x7C, 0x3E, 0xFC, 0x7C, 0xF8, 0xF9, 0xF9, 0xF1, 0xF3, 0xE3, 0xF7,
  0xC3, 0xEF, 0x87, 0xE0, 0x0F, 0xC3, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xEF,
  0x82, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0x7D, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF,
  0xC1, 0xFE, 0x00, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xF7,
  0xC1, 0xF3, 0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xEF, 0x81, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0xF8, 0x1E, 0x0F, 0xFC, 0x1F, 0x07, 0xDF, 0x0F, 0x83, 0xEF, 0x87, 0xE1,
  0xF7, 0xC3, 0xF1, 0xF3, 0xE3, 0xF8, 0xF9, 0xF1, 0xFC, 0x7C, 0x78, 0xFE,
  0x3E, 0x3E, 0x7F, 0x9F, 0x1F, 0x3F, 0xCF, 0x0F, 0xBD, 0xEF, 0x87, 0xDE,
  0xF7, 0xC1, 0xEF, 0x7B, 0xE0, 0xF7, 0x9D, 0xF0, 0x7F, 0xCF, 0xF0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x3E, 0x1F, 0x9F, 0x8F,
  0x87, 0xCF, 0xC3, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3E, 0xF8, 0x3F, 0x7C, 0x1F, 0x1F, 0x1F, 0x8F, 0xCF, 0x87,
  0xEF, 0xC1, 0xF8, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E,
  0x7E, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3F, 0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0xFF, 0xFF, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x3C,
  0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x3E, 0x1E, 0x0F, 0x1F, 0xE3, 0xFF, 0x8F, 0xFC, 0x7F, 0xF2, 0x0F,
  0x80, 0x7C, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFD, 0xE7, 0xCF, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xCF, 0x9E, 0xFE, 0xFF, 0xF7, 0xFF, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xEF, 0x7F, 0x79, 0xF0, 0x0F, 0xE3, 0xFF, 0x7F, 0xE7, 0xFE,
  0xFC, 0x2F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC2,
  0x7F, 0xE7, 0xFE, 0x3F, 0xE1, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF1, 0xE7, 0xCF, 0xDF, 0x7F, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7C, 0xF0, 0x1F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xFB, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3E, 0x01, 0xF0, 0x17, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F,
  0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xE0, 0x7C, 0x0F, 0xF7, 0xFE, 0xFF, 0xDF,
  0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x7C, 0xFD, 0xF7, 0xFF, 0xDF,
  0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFF, 0x3F, 0x7F, 0xFD, 0xFF, 0xF3, 0xF7, 0xC7, 0x9F, 0x00, 0x7C,
  0x03, 0xE6, 0x1F, 0x9F, 0xFE, 0x7F, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xCF, 0x9E, 0xFE,
  0xFF, 0xF7, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7C, 0x11,
  0xEF, 0xDF, 0x78, 0x00, 0x1F, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xC0, 0x04, 0x1E, 0x3F, 0x3F, 0x1E, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x8F, 0xFE,
  0x3E, 0xF9, 0xF3, 0xEF, 0xCF, 0xBE, 0x3D, 0xF0, 0xF7, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xE7, 0xCF, 0x9F, 0xBE, 0x3E, 0xF8, 0xFF,
  0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF7, 0xE3, 0xE7, 0xFF, 0xBF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xCF, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F,
  0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF,
  0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF3, 0xE7,
  0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFB, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDF, 0x3E, 0x7F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x03, 0xF0, 0xF3, 0xE7, 0xBF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFB, 0xDF, 0xDE, 0x7C, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x7C, 0xFD, 0xF7, 0xFF, 0xDF,
  0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFF, 0x3F, 0x7F, 0xFD, 0xFF, 0xF3, 0xF7, 0xC7, 0x9F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0xF3,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x3F, 0x8F, 0xFF, 0xFF, 0x7D, 0xEF, 0x85,
  0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF7, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0xEF, 0xFD, 0xFF, 0xBF,
  0xF1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xFF, 0x3F, 0xE3, 0xFC, 0x3F, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0xE7, 0xCF, 0xF8, 0x3E, 0xF8, 0x7D,
  0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xC7, 0x8F, 0x8F, 0xBE, 0x1F, 0x7C, 0x1E,
  0xF8, 0x3D, 0xE0, 0x7B, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0xF8, 0x7C, 0x3E, 0xF1, 0xFC, 0x79, 0xF3, 0xF9, 0xF3, 0xE7,
  0xF3, 0xE7, 0xCF, 0xE7, 0xCF, 0x9D, 0xCF, 0x0F, 0x7B, 0x9E, 0x1E, 0xF7,
  0xFC, 0x3F, 0xEF, 0xF8, 0x7F, 0xDF, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0,
  0xFC, 0x7E, 0xF8, 0xF8, 0xFB, 0xF1, 0xF7, 0xC1, 0xFF, 0x83, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xF7, 0xC3, 0xEF,
  0x8F, 0xDF, 0x9F, 0x1F, 0x7E, 0x3F, 0xF8, 0x3E, 0xF8, 0x7D, 0xF1, 0xF3,
  0xE3, 0xE3, 0xC7, 0xC7, 0xCF, 0x8F, 0xBE, 0x0F, 0x7C, 0x1E, 0xF8, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC3, 0xF1, 0xFC, 0x7F, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xE3, 0xF8, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xFC, 0x7F, 0x0F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xF0, 0x7F, 0x0F, 0xC3, 0xF1, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x8F, 0xC3, 0xF0, 0xFC, 0x38, 0x00, 0x7C, 0x0F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x20,
};

const GFXglyph NotoSans_Condensed_Black29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 12, 8, 14, 1, -21 },
  { 29, 15, 21, 17, 1, -21 },
  { 69, 13, 24, 15, 1, -22 },
  { 108, 24, 21, 25, 1, -21 },
  { 171, 19, 21, 20, 1, -21 },
  { 221, 5, 8, 8, 1, -21 },
  { 226, 8, 26, 10, 1, -21 },
  { 252, 9, 26, 10, 0, -21 },
  { 282, 14, 13, 14, 0, -22 },
  { 305, 13, 14, 15, 1, -17 },
  { 328, 6, 8, 8, 1, -4 },
  { 334, 8, 4, 9, 1, -10 },
  { 338, 6, 5, 8, 1, -5 },
  { 342, 12, 21, 12, 0, -21 },
  { 374, 13, 21, 15, 1, -21 },
  { 409, 11, 21, 15, 1, -21 },
  { 438, 13, 21, 15, 1, -21 },
  { 473, 13, 21, 15, 1, -21 },
  { 508, 15, 21, 15, 0, -21 },
  { 548, 13, 21, 15, 1, -21 },
  { 583, 13, 21, 15, 1, -21 },
  { 618, 13, 21, 15, 1, -21 },
  { 653, 13, 21, 15, 1, -21 },
  { 688, 13, 21, 15, 1, -21 },
  { 723, 6, 16, 8, 1, -16 },
  { 735, 6, 20, 8, 1, -16 },
  { 750, 13, 15, 15, 1, -18 },
  { 775, 13, 10, 15, 1, -15 },
  { 792, 13, 15, 15, 1, -18 },
  { 817, 12, 21, 13, 0, -21 },
  { 849, 21, 23, 23, 1, -21 },
  { 910, 18, 21, 18, 0, -21 },
  { 958, 14, 21, 17, 2, -21 },
  { 995, 14, 21, 16, 1, -21 },
  { 1032, 15, 21, 18, 2, -21 },
  { 1072, 11, 21, 14, 2, -21 },
  { 1101, 10, 21, 14, 2, -21 },
  { 1128, 16, 21, 18, 1, -21 },
  { 1170, 15, 21, 19, 2, -21 },
  { 1210, 9, 21, 11, 1, -21 },
  { 1234, 9, 28, 9, -2, -21 },
  { 1266, 15, 21, 17, 2, -21 },
  { 1306, 11, 21, 14, 2, -21 },
  { 1335, 21, 21, 25, 2, -21 },
  { 1391, 17, 21, 21, 2, -21 },
  { 1436, 17, 21, 20, 1, -21 },
  { 1481, 13, 21, 16, 2, -21 },
  { 1516, 17, 26, 20, 1, -21 },
  { 1572, 15, 21, 17, 2, -21 },
  { 1612, 12, 21, 14, 1, -21 },
  { 1644, 13, 21, 14, 1, -21 },
  { 1679, 15, 21, 19, 2, -21 },
  { 1719, 17, 21, 17, 0, -21 },
  { 1764, 25, 21, 25, 0, -21 },
  { 1830, 17, 21, 17, 0, -21 },
  { 1875, 16, 21, 16, 0, -21 },
  { 1917, 13, 21, 15, 1, -21 },
  { 1952, 7, 26, 9, 1, -21 },
  { 1975, 12, 21, 12, 0, -21 },
  { 2007, 7, 26, 9, 1, -21 },
  { 2030, 16, 14, 16, 0, -21 },
  { 2058, 15, 3, 15, 0, 2 },
  { 2064, 8, 4, 11, 1, -22 },
  { 2068, 13, 16, 15, 1, -16 },
  { 2094, 13, 22, 16, 2, -22 },
  { 2130, 12, 16, 13, 1, -16 },
  { 2154, 14, 22, 16, 1, -22 },
  { 2193, 13, 16, 15, 1, -16 },
  { 2219, 11, 22, 10, 0, -22 },
  { 2250, 14, 23, 16, 1, -16 },
  { 2291, 13, 22, 17, 2, -22 },
  { 2327, 6, 23, 8, 1, -23 },
  { 2345, 8, 30, 8, -1, -23 },
  { 2375, 14, 22, 16, 2, -22 },
  { 2414, 5, 22, 8, 2, -22 },
  { 2428, 21, 16, 25, 2, -16 },
  { 2470, 13, 16, 17, 2, -16 },
  { 2496, 14, 16, 16, 1, -16 },
  { 2524, 13, 23, 16, 2, -16 },
  { 2562, 14, 23, 16, 1, -16 },
  { 2603, 9, 16, 12, 2, -16 },
  { 2621, 11, 16, 13, 1, -16 },
  { 2643, 11, 19, 11, 0, -19 },
  { 2670, 13, 16, 17, 2, -16 },
  { 2696, 15, 16, 15, 0, -16 },
  { 2726, 23, 16, 23, 0, -16 },
  { 2772, 15, 16, 15, 0, -16 },
  { 2802, 15, 23, 15, 0, -16 },
  { 2846, 11, 16, 12, 1, -16 },
  { 2868, 10, 26, 11, 1, -21 },
  { 2901, 4, 29, 13, 4, -22 },
  { 2916, 10, 26, 11, 1, -21 },
  { 2949, 13, 6, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Black29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_BLACK29PT7B_H_
