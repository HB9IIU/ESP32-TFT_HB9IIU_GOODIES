#ifndef _NOTOSANS_CONDENSED_BLACK21PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0xFF, 0xF0, 0xF7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xDC, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF1, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE3, 0xB8, 0x3B, 0x83, 0x30, 0x33,
  0x00, 0x08, 0x06, 0x1F, 0xFF, 0xFE, 0x97, 0x43, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC2, 0xF1, 0x7E, 0xFF, 0xFB, 0xF8, 0x10, 0x08, 0x00, 0x3C, 0x1C, 0x1F,
  0x86, 0x07, 0xE3, 0x81, 0x98, 0xC0, 0xE6, 0x70, 0x19, 0x98, 0x06, 0xEE,
  0xF1, 0xFB, 0x7E, 0x3D, 0xDD, 0xC0, 0x77, 0x70, 0x39, 0xDC, 0x0E, 0x77,
  0x03, 0x1D, 0xC1, 0xC3, 0xE0, 0xE0, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xB8,
  0x1C, 0xE0, 0x7B, 0x81, 0xFE, 0x03, 0xF0, 0x1F, 0x9E, 0xFF, 0x73, 0xBF,
  0xCE, 0x7F, 0x38, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xF7, 0xC0, 0xFE, 0xEE,
  0xE0, 0x3C, 0xE7, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0xC7,
  0x1C, 0x38, 0xF0, 0xF1, 0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0xF3, 0x8E, 0x73, 0xC0, 0x0E, 0x03, 0x84, 0xC9, 0xFF, 0xFF, 0xC7,
  0x83, 0xF1, 0xEE, 0x33, 0x04, 0x80, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF,
  0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF, 0xEE, 0xEE, 0xFF, 0xFE,
  0x6F, 0xFF, 0x03, 0x83, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x83, 0x80, 0x3E, 0x3F, 0xBF, 0xDE, 0xFF,
  0x7F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFD, 0xFE, 0xF7, 0xF3, 0xF8, 0xF8,
  0x0F, 0x1F, 0x3F, 0x7F, 0xFF, 0x6F, 0x4F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x3F, 0x1F, 0xEF, 0xF9, 0x8F, 0x23, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x7F, 0xDF, 0xF7, 0xFC, 0x7E, 0x7F,
  0xBF, 0xE8, 0xF0, 0x78, 0x78, 0xF8, 0x7C, 0x3F, 0x03, 0xC1, 0xF0, 0xFF,
  0xFF, 0xFB, 0xF8, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x37, 0x0E,
  0xE3, 0x9C, 0x73, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00, 0xE0,
  0x7F, 0x3F, 0x9F, 0xDE, 0x0F, 0x07, 0xF3, 0xFD, 0xFF, 0x47, 0x83, 0xC1,
  0xF0, 0xFF, 0xFF, 0xFB, 0xF8, 0x1F, 0x9F, 0xDF, 0xEE, 0x0E, 0x07, 0x7B,
  0xFF, 0xFF, 0xF7, 0xF1, 0xF8, 0xFE, 0xFF, 0xFB, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x07, 0x83,
  0xC3, 0xC1, 0xE0, 0x3E, 0x3F, 0xBF, 0xFE, 0xFF, 0x7B, 0xF9, 0xFC, 0x7C,
  0xFF, 0x7B, 0xF8, 0xFC, 0x7F, 0xFF, 0xFD, 0xFC, 0x3E, 0x3F, 0xBF, 0xFC,
  0xFE, 0x3F, 0x1F, 0xDF, 0xFF, 0xFF, 0xBD, 0xC1, 0xE0, 0xEF, 0xF7, 0xF3,
  0xF0, 0x6F, 0xFF, 0x00, 0x00, 0x6F, 0xFF, 0x6F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0xEE, 0xE0, 0x00, 0x81, 0xC3, 0xE7, 0xEF, 0xC7, 0x83, 0xF0, 0x7F,
  0x0F, 0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x80, 0x70, 0x3E, 0x0F, 0xC1, 0xF8, 0x3C, 0x7F, 0xFC, 0xF8, 0x70, 0x20,
  0x00, 0x7E, 0x7F, 0x9F, 0xE8, 0xF0, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x1C,
  0x00, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x0F, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3,
  0x80, 0x66, 0x7E, 0xFD, 0xFC, 0xFB, 0x99, 0xE6, 0x73, 0xCC, 0xE7, 0x99,
  0xDF, 0x3B, 0xBF, 0x7D, 0xEE, 0x31, 0x0E, 0x01, 0x0F, 0xFC, 0x0F, 0xF8,
  0x03, 0x80, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0,
  0xF7, 0x87, 0xBC, 0x38, 0xE3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x8F, 0x78,
  0x3F, 0xC1, 0xE0, 0xFF, 0x1F, 0xFB, 0xFF, 0x79, 0xEF, 0x3D, 0xE7, 0xBF,
  0xE7, 0xFC, 0xFF, 0xDE, 0x3B, 0xC7, 0xF9, 0xEF, 0xFD, 0xFF, 0x3F, 0xC0,
  0x1F, 0x8F, 0xF7, 0xF9, 0xE2, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xE1, 0x7F, 0x8F, 0xE1, 0xF8, 0xFF, 0x1F, 0xF3, 0xFF, 0x79,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF9, 0xEF,
  0xFD, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0xC7,
  0xFD, 0xFF, 0x3C, 0x2F, 0x01, 0xE0, 0x3C, 0xFF, 0x9F, 0xF3, 0xFE, 0x1F,
  0xC3, 0xBC, 0x77, 0xFE, 0x7F, 0xC7, 0xF8, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x38, 0xFF, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x7B, 0xFF, 0xC0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0xBF, 0xEF, 0xB8, 0xF1, 0xFF, 0x1E, 0xF3, 0xCF,
  0x3C, 0xF7, 0x8F, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0xF3, 0x8F,
  0x3C, 0xF3, 0xCF, 0x1E, 0xF1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFE, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x6F, 0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xE7, 0xFF, 0x3F, 0xFD, 0xFE, 0xEF, 0xF7, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xE0, 0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0x9F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9F,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x3F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xFE, 0xFF, 0xBF, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xE3, 0xFC, 0x1F, 0xC0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0x79, 0xEF, 0x3D,
  0xE7, 0xBD, 0xF7, 0xFC, 0xFF, 0x1E, 0xE3, 0xDE, 0x79, 0xEF, 0x3D, 0xE3,
  0xFC, 0x78, 0x3F, 0x3F, 0xFF, 0xDE, 0x2F, 0x07, 0xC3, 0xF0, 0xFE, 0x3F,
  0x07, 0xC1, 0xF0, 0xFF, 0xF7, 0xFB, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7, 0xFE, 0xFF, 0x87, 0xE0, 0xF0,
  0x7F, 0x87, 0x9E, 0x3C, 0xF1, 0xE7, 0x8E, 0x1C, 0xF0, 0xE7, 0x87, 0xBC,
  0x3D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0xE1, 0xFC, 0x78, 0xF7, 0x1E, 0x3D, 0xC7, 0x8F, 0x79, 0xF3, 0x9E,
  0x7C, 0xE7, 0xBF, 0x78, 0xEE, 0xDE, 0x3B, 0xB7, 0x8E, 0xEF, 0xC3, 0xB3,
  0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0xF0, 0xF7,
  0x9E, 0x79, 0xE3, 0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x1F, 0x81,
  0xF8, 0x3F, 0xC3, 0xFC, 0x79, 0xE7, 0x9E, 0xF0, 0xF0, 0xF0, 0xF7, 0x1E,
  0x79, 0xE3, 0x9C, 0x3F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0xDF, 0xF7, 0xFC,
  0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xFF, 0xFE, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0E, 0xFF, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x77, 0x0E, 0x73, 0x8E, 0x70, 0xFC,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE3, 0xC0, 0x3E, 0x3F, 0x9F,
  0xE8, 0xF0, 0x7B, 0xFF, 0xFF, 0xCF, 0xE7, 0xFF, 0xFF, 0xEF, 0x70, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF7, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFF, 0xFF, 0xFB, 0xBC, 0x1E, 0x7F, 0x7F, 0xF1, 0xF0,
  0xE0, 0xE0, 0xE0, 0xF1, 0xFF, 0x7F, 0x3E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x3B, 0xDF, 0xFF, 0xFF, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3, 0xFF,
  0xF7, 0xFD, 0xE7, 0x1C, 0x3F, 0xBF, 0xFE, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0,
  0xF0, 0x7F, 0xDF, 0xE7, 0xE0, 0x1F, 0x3F, 0x3E, 0x38, 0x7E, 0xFE, 0xFE,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3B, 0xDF, 0xFF,
  0xFF, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3, 0xFF, 0xF7, 0xFD, 0xEF,
  0x03, 0xE0, 0xEF, 0xFB, 0xFC, 0x7E, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF7, 0x3F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C,
  0xF3, 0xC0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xFF, 0xFE, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x1F, 0xE7, 0xBD,
  0xE7, 0xBC, 0xFF, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0x79, 0xE7, 0xBC, 0xF7,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x1C, 0xEF,
  0xBE, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xE7, 0x3B, 0xEF,
  0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0x1E, 0x1F, 0xC7, 0xFB, 0xCE, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3, 0xFF,
  0xE7, 0xF8, 0xF8, 0xE7, 0x3B, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x3B, 0xDF, 0xFF, 0xFF, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3,
  0xFF, 0xF7, 0xFD, 0xEF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE7,
  0xDF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x3D, 0xFF,
  0xFF, 0x1F, 0x1F, 0x9F, 0x8F, 0x8F, 0xFF, 0xFF, 0xE0, 0x18, 0x38, 0x3F,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0xF7,
  0xFD, 0xF7, 0xF1, 0xFE, 0x3D, 0xC7, 0x38, 0xE7, 0xBC, 0x77, 0x0E, 0xE1,
  0xDC, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0x80, 0xF3, 0xC7, 0xF3, 0xE7, 0x73,
  0xE7, 0x73, 0xEF, 0x77, 0xEE, 0x7F, 0x6E, 0x3F, 0x6E, 0x3F, 0x7E, 0x3E,
  0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x3C, 0xF1, 0xEF, 0x79, 0xEF, 0x1F,
  0xC3, 0xF8, 0x3E, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0x79, 0xEF, 0x78, 0xF0,
  0xF1, 0xFE, 0x3D, 0xC7, 0x3C, 0xE7, 0xBC, 0x77, 0x0E, 0xE1, 0xFC, 0x1F,
  0x83, 0xE0, 0x7C, 0x07, 0x80, 0xE0, 0x3C, 0x1F, 0x83, 0xE0, 0x78, 0x00,
  0x7F, 0x3F, 0x9F, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF8,
  0xFC, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x1F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x3C,
  0x3C, 0x1F, 0x1F, 0x3F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xC0,
  0xF8, 0xFF, 0xE7, 0xF0, 0x60,
};

const GFXglyph NotoSans_Condensed_Black21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 8, 5, 10, 1, -15 },
  { 14, 12, 15, 12, 0, -15 },
  { 37, 9, 17, 11, 1, -16 },
  { 57, 18, 15, 18, 0, -15 },
  { 91, 14, 15, 14, 1, -15 },
  { 118, 4, 5, 6, 1, -15 },
  { 121, 6, 18, 7, 1, -15 },
  { 135, 6, 18, 7, 0, -15 },
  { 149, 10, 10, 10, 0, -16 },
  { 162, 9, 11, 11, 1, -13 },
  { 175, 4, 6, 6, 1, -3 },
  { 178, 5, 3, 7, 1, -7 },
  { 180, 4, 4, 6, 1, -4 },
  { 182, 9, 15, 9, 0, -15 },
  { 199, 9, 15, 11, 1, -15 },
  { 216, 8, 15, 11, 1, -15 },
  { 231, 10, 15, 11, 0, -15 },
  { 250, 9, 15, 11, 1, -15 },
  { 267, 11, 15, 11, 0, -15 },
  { 288, 9, 15, 11, 1, -15 },
  { 305, 9, 15, 11, 1, -15 },
  { 322, 9, 15, 11, 1, -15 },
  { 339, 9, 15, 11, 1, -15 },
  { 356, 9, 15, 11, 1, -15 },
  { 373, 4, 12, 6, 1, -12 },
  { 379, 4, 15, 6, 1, -12 },
  { 387, 9, 11, 11, 1, -13 },
  { 400, 9, 7, 11, 1, -11 },
  { 408, 9, 11, 11, 1, -13 },
  { 421, 9, 15, 9, 0, -15 },
  { 438, 15, 17, 17, 1, -15 },
  { 470, 13, 15, 13, 0, -15 },
  { 495, 11, 15, 12, 1, -15 },
  { 516, 10, 15, 12, 1, -15 },
  { 535, 11, 15, 13, 1, -15 },
  { 556, 8, 15, 10, 1, -15 },
  { 571, 8, 15, 10, 1, -15 },
  { 586, 11, 15, 13, 1, -15 },
  { 607, 11, 15, 14, 1, -15 },
  { 628, 6, 15, 8, 1, -15 },
  { 640, 6, 20, 6, -1, -15 },
  { 655, 12, 15, 12, 1, -15 },
  { 678, 9, 15, 10, 1, -15 },
  { 695, 16, 15, 18, 1, -15 },
  { 725, 13, 15, 15, 1, -15 },
  { 750, 12, 15, 14, 1, -15 },
  { 773, 10, 15, 12, 1, -15 },
  { 792, 12, 19, 14, 1, -15 },
  { 821, 11, 15, 12, 1, -15 },
  { 842, 9, 15, 10, 1, -15 },
  { 859, 10, 15, 10, 0, -15 },
  { 878, 11, 15, 13, 1, -15 },
  { 899, 13, 15, 13, 0, -15 },
  { 924, 18, 15, 18, 0, -15 },
  { 958, 12, 15, 12, 0, -15 },
  { 981, 12, 15, 12, 0, -15 },
  { 1004, 10, 15, 11, 0, -15 },
  { 1023, 5, 19, 6, 1, -15 },
  { 1035, 9, 15, 9, 0, -15 },
  { 1052, 6, 19, 6, 0, -15 },
  { 1067, 11, 10, 11, 0, -15 },
  { 1081, 11, 3, 11, 0, 1 },
  { 1086, 6, 3, 8, 1, -16 },
  { 1089, 9, 12, 11, 1, -12 },
  { 1103, 10, 16, 12, 1, -16 },
  { 1123, 8, 12, 10, 1, -12 },
  { 1135, 10, 16, 12, 1, -16 },
  { 1155, 9, 12, 11, 1, -12 },
  { 1169, 8, 16, 7, 0, -16 },
  { 1185, 10, 17, 12, 1, -12 },
  { 1207, 10, 16, 12, 1, -16 },
  { 1227, 4, 16, 6, 1, -16 },
  { 1235, 6, 21, 6, -1, -16 },
  { 1251, 11, 16, 12, 1, -16 },
  { 1273, 4, 16, 6, 1, -16 },
  { 1281, 16, 12, 18, 1, -12 },
  { 1305, 10, 12, 12, 1, -12 },
  { 1320, 10, 12, 12, 1, -12 },
  { 1335, 10, 17, 12, 1, -12 },
  { 1357, 10, 17, 12, 1, -12 },
  { 1379, 7, 12, 8, 1, -12 },
  { 1390, 7, 12, 9, 1, -12 },
  { 1401, 8, 14, 8, 0, -14 },
  { 1415, 10, 12, 12, 1, -12 },
  { 1430, 11, 12, 11, 0, -12 },
  { 1447, 16, 12, 17, 0, -12 },
  { 1471, 11, 12, 11, 0, -12 },
  { 1488, 11, 17, 11, 0, -12 },
  { 1512, 9, 12, 9, 0, -12 },
  { 1526, 8, 19, 8, 0, -15 },
  { 1545, 3, 21, 9, 3, -16 },
  { 1553, 8, 19, 8, 0, -15 },
  { 1572, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_Black21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_BLACK21PT7B_H_
