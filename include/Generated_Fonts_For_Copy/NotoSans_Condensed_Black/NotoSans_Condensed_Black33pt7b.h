#ifndef _NOTOSANS_CONDENSED_BLACK33PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x00, 0x00, 0xE3, 0xEF, 0xFF, 0xDF, 0x3E, 0xFC, 0xFD,
  0xF3, 0xF7, 0xCF, 0xDF, 0x3F, 0x7C, 0xFD, 0xF1, 0xF7, 0xC7, 0x9F, 0x1E,
  0x7C, 0x78, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x0F, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xE7, 0x80, 0xF1, 0xE0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1F, 0x80, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x7D, 0xC4, 0xFB,
  0x81, 0xF7, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0x01, 0xFF, 0x03, 0xBE, 0x07, 0x7D, 0x0E, 0xFB, 0xDF, 0xF7, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFE, 0x0F, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x78, 0x07, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x7F, 0xE0, 0xF0,
  0x0F, 0x3C, 0x1E, 0x01, 0xE7, 0xC7, 0x80, 0x3C, 0xF8, 0xF0, 0x07, 0x9F,
  0x3E, 0x00, 0xF3, 0xE7, 0x80, 0x1E, 0x7D, 0xF0, 0x83, 0xCF, 0x3C, 0xFE,
  0x7F, 0xE7, 0xBF, 0xE7, 0xFD, 0xE7, 0xFC, 0x7F, 0x3D, 0xF7, 0xC7, 0x8F,
  0x3E, 0xF8, 0x01, 0xE7, 0x8F, 0x00, 0x7C, 0xF1, 0xE0, 0x0F, 0x1E, 0x3C,
  0x03, 0xE3, 0xC7, 0x80, 0x78, 0x7D, 0xF0, 0x1F, 0x07, 0xBC, 0x03, 0xC0,
  0xFF, 0x80, 0x78, 0x0F, 0xE0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x7E, 0x3F, 0xF1, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF,
  0xFF, 0x3F, 0x3F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC3, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFC, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x0F, 0xC3, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x43, 0xC2, 0x7B, 0xDE, 0x7F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7C, 0x3E,
  0x7C, 0x0E, 0x38, 0x04, 0x20, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x7E,
  0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x38, 0xF9, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0xCF,
  0xDF, 0x9F, 0x1F, 0x7E, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7E, 0xF8, 0xFD,
  0xF1, 0xF3, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7D, 0xF9, 0xCF, 0xC4, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xCF,
  0x1F, 0x8C, 0x3F, 0x10, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC0, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xC6, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFF, 0xF9, 0x8F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE,
  0x1F, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0xE1, 0xFB, 0xF3, 0xEF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFD,
  0xF1, 0xFB, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0x8F, 0xDF, 0x1F, 0xBE, 0x3E, 0x7E,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xBF,
  0x7E, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xEF,
  0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xDF, 0x8F, 0xBF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xEF, 0x8F, 0x9F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF2, 0x3F, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xC0, 0x23, 0xEF, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xCF, 0xBF, 0xFF, 0xFF, 0x80, 0x10, 0xF9, 0xFB, 0xF7, 0xEF, 0x86, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7C, 0xF9, 0xF3, 0xEF, 0x9F,
  0x3E, 0x78, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFE,
  0x07, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFD,
  0xC3, 0xF4, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xF3, 0xF8, 0x1F, 0x80, 0x7C,
  0x1E, 0x00, 0x3E, 0x3C, 0x1F, 0x9E, 0x7C, 0x7F, 0xCF, 0x78, 0xFF, 0xCF,
  0x79, 0xF3, 0xCF, 0x79, 0xE3, 0xCF, 0xF3, 0xE3, 0xCF, 0xF3, 0xC3, 0xCF,
  0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xE7, 0xCF, 0xF1, 0xE7, 0xCF,
  0xF9, 0xFF, 0xFE, 0x78, 0xFF, 0xFC, 0x78, 0x7C, 0xF8, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0xFD, 0xF0, 0x0F,
  0xDF, 0x00, 0xF9, 0xF8, 0x0F, 0x9F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x81,
  0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xF8, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFE, 0x3F, 0x86, 0x7F, 0x02, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x02, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF7, 0xE7, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xE0, 0xC7, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xF7, 0xE7, 0xFD, 0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x81, 0xF7, 0xF0,
  0x7C, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFC,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFB,
  0xFF, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC3,
  0xFB, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF7, 0xF0,
  0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7F,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFB, 0xC3, 0xDF, 0xFB, 0xE3, 0xDF, 0xFB, 0xE7, 0xDF,
  0xFB, 0xE7, 0xDF, 0xF9, 0xE7, 0x9F, 0xF9, 0xF7, 0x9F, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F,
  0xF8, 0xFF, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0x7C, 0x7F, 0xEF, 0xCF, 0xFC, 0xF9, 0xFF, 0x9F, 0xBF, 0xF3, 0xF7,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xF8, 0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xF7, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0xFE,
  0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0x3F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xFB, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0xF3, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFB, 0xF8, 0xEF, 0xC0, 0xBF, 0x00, 0xFE, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE,
  0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x87, 0xEF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1,
  0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F,
  0xBF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xDF, 0x03, 0xE0, 0x7C, 0xF8,
  0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0x3F, 0x3F, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F,
  0x0F, 0xC7, 0xC3, 0xF8, 0x7C, 0x3E, 0x3F, 0xE3, 0xE1, 0xF1, 0xEF, 0x3F,
  0x0F, 0xCF, 0x79, 0xF8, 0x7E, 0x7B, 0xCF, 0xC1, 0xF3, 0xDE, 0x7C, 0x0F,
  0xBE, 0xFB, 0xE0, 0x7D, 0xF7, 0xDF, 0x03, 0xEF, 0x1F, 0xF8, 0x1F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7F, 0x1F, 0x8F,
  0xC3, 0xF3, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x83, 0xF7, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8,
  0x7E, 0x3E, 0x07, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0x7C, 0x07, 0xCF, 0x81, 0xE3,
  0xE0, 0xF8, 0x7C, 0x3C, 0x1F, 0x1F, 0x03, 0xC7, 0xC0, 0xFB, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x80, 0x3F, 0xE0, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC2, 0x0F, 0xC0, 0x1F, 0x81, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x7C, 0xFC, 0x78, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x18, 0x7C, 0xFC, 0xFB, 0xF9, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7D,
  0xFC, 0xF9, 0xF0, 0x00, 0x80, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF9,
  0xF8, 0x47, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF8, 0x27, 0xF7, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x04, 0x3F, 0x1F, 0xBF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E,
  0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xDF, 0x1F, 0x9F, 0x01, 0x00, 0x1F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF,
  0xCF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x83, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xE0, 0x07, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0x91, 0xF0,
  0x1F, 0x03, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x06, 0x00, 0x1F, 0x9F, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7F, 0x7F,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x3E, 0x60,
  0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xC0, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x10,
  0x7D, 0xFC, 0xFB, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7E, 0x33, 0xEF,
  0xFF, 0xF9, 0xE0, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x06, 0x0F, 0x87, 0xE3, 0xF1, 0xF0,
  0x70, 0x00, 0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE3, 0xF7, 0xFB, 0xFD, 0xFE, 0xFE, 0x7C, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x7E, 0xF8, 0x7E, 0x7C, 0x7F, 0x3E, 0x3F, 0x1F, 0x3F, 0x0F, 0x9F,
  0x07, 0xDF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7, 0xC3, 0xF3, 0xE1, 0xF9, 0xF0, 0x7E,
  0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x20, 0xF3, 0xF8,
  0xFC, 0xFF, 0xFD, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0x00, 0x41, 0xE7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xF8, 0x00, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x41, 0xF3, 0xF3, 0xEF, 0xE7,
  0xFF, 0xEF, 0xFF, 0xDF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFD, 0xF7, 0xF3, 0xE7, 0xC7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x1F,
  0x9F, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x7E, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x5E, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x02, 0x03, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0x82, 0xFC, 0x0F, 0xF0, 0x7F, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF,
  0x03, 0xF8, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xFB, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xBE, 0x7E, 0x3C, 0xFC, 0x1F, 0xBE, 0x0F, 0xDF, 0x87,
  0xEF, 0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7E, 0x7C, 0x1F,
  0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x3F, 0x0F,
  0xDF, 0x1F, 0xE3, 0xE7, 0xC7, 0xF8, 0xF9, 0xF9, 0xFE, 0x3E, 0x7E, 0x7F,
  0x9F, 0x8F, 0x9F, 0xE7, 0xC3, 0xE7, 0xF9, 0xF0, 0xFB, 0xFF, 0x7C, 0x3E,
  0xF3, 0xDF, 0x0F, 0xBC, 0xF7, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xF3, 0xFE, 0x07, 0xF8, 0xFF, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xBF, 0x1F,
  0x8F, 0xDF, 0x87, 0xEF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFB, 0xF0, 0xFD, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0xBE, 0x0F, 0xDF, 0x87, 0xCF, 0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF8,
  0xFC, 0xF8, 0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x8F, 0xF1, 0xFC, 0x3F, 0x07, 0xF0, 0xFF,
  0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xFC, 0x7F, 0x87, 0xF0, 0x7E, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0x7E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFC, 0x3F, 0xC1, 0xF8,
  0x7F, 0x1F, 0xE3, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x3F, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0x80, 0x00, 0x1C, 0x02, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xA0, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Black33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 24, 9, 1, -24 },
  { 22, 14, 9, 16, 1, -24 },
  { 38, 18, 24, 19, 1, -24 },
  { 92, 15, 27, 17, 1, -25 },
  { 143, 27, 24, 29, 1, -24 },
  { 224, 22, 24, 23, 1, -24 },
  { 290, 6, 9, 9, 1, -24 },
  { 297, 10, 29, 11, 1, -24 },
  { 334, 10, 29, 11, 0, -24 },
  { 371, 16, 15, 16, 0, -25 },
  { 401, 15, 16, 17, 1, -20 },
  { 431, 7, 10, 9, 1, -5 },
  { 440, 9, 5, 11, 1, -11 },
  { 446, 7, 6, 9, 1, -6 },
  { 452, 14, 24, 14, 0, -24 },
  { 494, 15, 24, 17, 1, -24 },
  { 539, 13, 24, 17, 1, -24 },
  { 578, 15, 24, 17, 1, -24 },
  { 623, 15, 24, 17, 1, -24 },
  { 668, 16, 24, 17, 1, -24 },
  { 716, 14, 24, 17, 2, -24 },
  { 758, 15, 24, 17, 1, -24 },
  { 803, 15, 24, 17, 1, -24 },
  { 848, 15, 24, 17, 1, -24 },
  { 893, 15, 24, 17, 1, -24 },
  { 938, 6, 19, 9, 2, -19 },
  { 953, 7, 24, 9, 1, -19 },
  { 974, 15, 17, 17, 1, -20 },
  { 1006, 15, 11, 17, 1, -17 },
  { 1027, 15, 17, 17, 1, -20 },
  { 1059, 14, 24, 14, 0, -24 },
  { 1101, 24, 26, 27, 1, -24 },
  { 1179, 20, 24, 20, 0, -24 },
  { 1239, 16, 24, 20, 2, -24 },
  { 1287, 16, 24, 18, 1, -24 },
  { 1335, 17, 24, 21, 2, -24 },
  { 1386, 12, 24, 16, 2, -24 },
  { 1422, 12, 24, 15, 2, -24 },
  { 1458, 18, 24, 21, 1, -24 },
  { 1512, 18, 24, 22, 2, -24 },
  { 1566, 11, 24, 13, 1, -24 },
  { 1599, 10, 31, 10, -2, -24 },
  { 1638, 18, 24, 20, 2, -24 },
  { 1692, 13, 24, 16, 2, -24 },
  { 1731, 24, 24, 28, 2, -24 },
  { 1803, 19, 24, 23, 2, -24 },
  { 1860, 20, 24, 22, 1, -24 },
  { 1920, 15, 24, 18, 2, -24 },
  { 1965, 20, 30, 22, 1, -24 },
  { 2040, 18, 24, 19, 2, -24 },
  { 2094, 14, 24, 16, 1, -24 },
  { 2136, 15, 24, 16, 1, -24 },
  { 2181, 17, 24, 21, 2, -24 },
  { 2232, 20, 24, 20, 0, -24 },
  { 2292, 29, 24, 29, 0, -24 },
  { 2379, 19, 24, 19, 0, -24 },
  { 2436, 19, 24, 19, 0, -24 },
  { 2493, 15, 24, 17, 1, -24 },
  { 2538, 8, 30, 10, 2, -24 },
  { 2568, 14, 24, 14, 0, -24 },
  { 2610, 8, 30, 10, 1, -24 },
  { 2640, 18, 16, 18, 0, -24 },
  { 2676, 17, 4, 17, 0, 2 },
  { 2685, 10, 5, 12, 1, -25 },
  { 2692, 15, 19, 18, 1, -19 },
  { 2728, 15, 25, 18, 2, -25 },
  { 2775, 14, 19, 15, 1, -19 },
  { 2809, 16, 25, 18, 1, -25 },
  { 2859, 15, 19, 17, 1, -19 },
  { 2895, 12, 25, 12, 0, -25 },
  { 2933, 16, 27, 18, 1, -19 },
  { 2987, 15, 25, 19, 2, -25 },
  { 3034, 6, 26, 9, 2, -26 },
  { 3054, 9, 34, 9, -1, -26 },
  { 3093, 17, 25, 19, 2, -25 },
  { 3147, 5, 25, 9, 2, -25 },
  { 3163, 24, 19, 28, 2, -19 },
  { 3220, 15, 19, 19, 2, -19 },
  { 3256, 16, 19, 18, 1, -19 },
  { 3294, 15, 27, 18, 2, -19 },
  { 3345, 16, 27, 18, 1, -19 },
  { 3399, 11, 19, 13, 2, -19 },
  { 3426, 12, 19, 14, 1, -19 },
  { 3455, 12, 22, 13, 0, -22 },
  { 3488, 15, 18, 19, 2, -18 },
  { 3522, 17, 18, 17, 0, -18 },
  { 3561, 26, 18, 26, 0, -18 },
  { 3620, 17, 18, 17, 0, -18 },
  { 3659, 17, 26, 17, 0, -18 },
  { 3715, 13, 18, 14, 1, -18 },
  { 3745, 11, 30, 13, 1, -24 },
  { 3787, 5, 32, 15, 5, -25 },
  { 3807, 11, 30, 13, 1, -24 },
  { 3849, 15, 7, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Black33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_BLACK33PT7B_H_
