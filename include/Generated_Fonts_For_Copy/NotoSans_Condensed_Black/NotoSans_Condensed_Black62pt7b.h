#ifndef _NOTOSANS_CONDENSED_BLACK62PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x7F, 0xCF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x7F, 0xC3, 0xFC, 0x0E, 0x00, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0x83, 0xFE, 0xFF, 0xC1,
  0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC,
  0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xEF, 0xBF, 0x87, 0xFC, 0xF8, 0x38, 0xFF, 0x8F, 0x80, 0x8F, 0xF8,
  0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x07, 0xFC, 0xF8, 0x00, 0x7F, 0xEF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xBF, 0xF0, 0x00, 0xF9, 0xFF, 0x00, 0x0F,
  0x9F, 0xF4, 0x00, 0xF9, 0xFF, 0x60, 0x0F, 0x9F, 0xF7, 0x80, 0xF9, 0xFF,
  0x7F, 0x0F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF,
  0x87, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x00,
  0x00, 0xFF, 0x87, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0x8F, 0xF0,
  0x00, 0x00, 0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0xFF, 0x0F,
  0xE0, 0xFF, 0xE0, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0xFF,
  0x1F, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x3F, 0xCF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xE0, 0x0F, 0xC0, 0xFF, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xC1,
  0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0x00, 0x00,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFE, 0x1F, 0xFF, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xDF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC7,
  0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x80, 0x7F, 0x00, 0x87, 0x83, 0xF8,
  0x3C, 0x7F, 0x1F, 0xCF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0,
  0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFC, 0xFF, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xDF, 0xFC, 0x3F, 0xF0, 0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0x7F, 0xF0,
  0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xF7, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFE, 0x07,
  0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xE7,
  0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0x1F, 0xE7, 0xFF, 0x1F, 0xC7, 0xFF,
  0x0F, 0x87, 0xFF, 0x07, 0x07, 0xFF, 0x02, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0xF0,
  0xF0, 0x07, 0xFF, 0x0E, 0x00, 0x7F, 0xF0, 0x40, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0xFE, 0x1E, 0x01,
  0xFF, 0xE0, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xA0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFB,
  0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0xFF, 0x1F,
  0xFC, 0x03, 0xFE, 0x3F, 0xF8, 0x07, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x83, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x0C, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xD8, 0x00,
  0x3F, 0xFB, 0xC0, 0x0F, 0xFF, 0x7F, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0x40, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xF0, 0x02, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x06, 0x00, 0x7F,
  0xC3, 0xFC, 0x07, 0xFC, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0x8F, 0xFD, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFE,
  0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFD,
  0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF,
  0x9F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF0, 0xFF, 0xEF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFF, 0xF0,
  0xFF, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFB,
  0xFF, 0x07, 0xFF, 0x3F, 0xF0, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x30, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xE0, 0x07, 0x80,
  0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF1, 0xFF, 0x87, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0,
  0xFF, 0xF1, 0xE0, 0x1F, 0xFC, 0x60, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7C, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF,
  0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0x1F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFC,
  0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0x83, 0xFF, 0xFF, 0xC3,
  0xF9, 0xFE, 0x1F, 0xFC, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F,
  0xDF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFD,
  0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xFF,
  0xC3, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xFF, 0xFC,
  0x3F, 0x80, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0xBF, 0xC3,
  0xF8, 0x0F, 0xE0, 0xFE, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFB, 0xFC, 0x3F,
  0xC1, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0x1F, 0xC3, 0xFE,
  0x3F, 0xF3, 0xFC, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xFF, 0x7F, 0xFC, 0x1F, 0xE0, 0x7F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x80, 0xFC, 0x01,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x07,
  0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3,
  0xFF, 0xFB, 0xFF, 0x81, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFE, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF,
  0xBF, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0x83, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE,
  0xFF, 0x0F, 0xFF, 0x80, 0x78, 0x7F, 0xF8, 0x00, 0xC7, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0C, 0x7F, 0xFC, 0x03, 0xE3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE,
  0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFC,
  0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0xC0, 0x0F, 0x07, 0xFF, 0xC0, 0x01, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF8,
  0x03, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF,
  0xE0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x83, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xCF, 0xFE,
  0x01, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x07,
  0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xDF, 0xFE, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE,
  0x03, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF9, 0xFF,
  0xC0, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0xBF,
  0xF8, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFB, 0xFF, 0xFF, 0xDF, 0xE0, 0x3F, 0xDF, 0xFF, 0xFE, 0xFF, 0x83, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0xCF, 0xFF,
  0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF,
  0xC7, 0xFC, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xEF, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0x7F, 0x87, 0xFF, 0xFF, 0x8F, 0xFB, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFD, 0xFF, 0x83,
  0xFF, 0xFF, 0xDF, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xF3, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF, 0xFC, 0x3F, 0xFB,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xC7,
  0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF8,
  0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFF,
  0xC7, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F,
  0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF,
  0xC3, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x81, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF,
  0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFE,
  0x7F, 0xF0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xDF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xC0, 0x7C, 0x7F, 0xF8, 0x01, 0x8F, 0xFE, 0x00, 0x11, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0x81, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF8, 0x1F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xE7,
  0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x7F, 0xBF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFE, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x8F, 0xFB, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xEF,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0x3F, 0xC7, 0xFF, 0x00, 0x7F, 0xE3,
  0xFC, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xF3, 0xFE, 0x7F, 0xE0, 0x07,
  0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x1F, 0xE7, 0xFE,
  0x00, 0x3F, 0xF7, 0xFC, 0x7F, 0x9F, 0xF8, 0x00, 0xFF, 0xDF, 0xE1, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0x87, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFE,
  0x0F, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x03,
  0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F,
  0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xEF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xE1, 0xFF, 0xE0, 0x70, 0x0F,
  0xFE, 0x04, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0x3F, 0xFF, 0x9F, 0xF1, 0xFF, 0xE0,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x7F, 0xF1, 0xFF, 0x83, 0xFF,
  0x9F, 0xFE, 0x1F, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFC, 0xFF, 0xF8, 0x7F, 0xE3, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFE, 0x0F, 0x1F, 0xFE, 0x00,
  0x8F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0x3F, 0xFC, 0x01, 0x9F,
  0xFF, 0x07, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xC1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x1F, 0xFE,
  0x7F, 0xE1, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFC, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x1F,
  0xFD, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0x83, 0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x7F, 0xE7, 0xFF, 0x03, 0xFF,
  0x7F, 0xE0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x06, 0x7F, 0xF8, 0x01, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFE, 0x10, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x7F,
  0xC1, 0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xC3, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F,
  0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB,
  0xFF, 0x81, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFB,
  0xFF, 0x0F, 0xFF, 0xDF, 0xF8, 0x3F, 0xFC, 0xFF, 0xC0, 0xFF, 0x87, 0xFE,
  0x00, 0x60, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0x00,
  0x00, 0xFF, 0xE6, 0x00, 0x0F, 0xFF, 0x3E, 0x00, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x7F, 0xF1, 0xFF, 0x83, 0xFF, 0xBF,
  0xFF, 0x1F, 0xF9, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x8F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE3,
  0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x01, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFB, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF7,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE3, 0xFF, 0xF1, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07,
  0xFE, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0x7F, 0xF0,
  0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0xE1, 0xFF, 0x9F, 0xFF, 0x8F, 0xFD, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0x87, 0xFF, 0x3F, 0xF8, 0x3F, 0xF8,
  0xFF, 0x81, 0xFF, 0xC0, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0x9F, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xC3, 0xFF, 0xDF, 0xFC, 0x0F,
  0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0x9F, 0xF8, 0x3F, 0xFC, 0xFF,
  0xC0, 0xFF, 0x87, 0xFE, 0x00, 0x60, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xE1, 0xF9, 0xFF, 0x80, 0x63,
  0xFF, 0x00, 0x47, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x1C, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF, 0x8F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC0, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xF8,
  0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x3F, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F,
  0x7F, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0x7F, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF,
  0x7F, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0x7F, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF,
  0x7F, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0x7F, 0x9F, 0xF8, 0x0F, 0xFD, 0xFE,
  0x7F, 0x9F, 0xF8, 0x0F, 0xFD, 0xFE, 0x7F, 0x9F, 0xF8, 0x0F, 0xFD, 0xFE,
  0x3F, 0xDF, 0xF0, 0x07, 0xFD, 0xFE, 0x3F, 0xDF, 0xF0, 0x07, 0xFD, 0xFE,
  0x3F, 0xDF, 0xF0, 0x07, 0xFD, 0xFC, 0x3F, 0xDF, 0xF0, 0x07, 0xFD, 0xFC,
  0x3F, 0xDF, 0xE0, 0x03, 0xFD, 0xFC, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xBF,
  0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE3, 0xFF,
  0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x21, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x08, 0xFF, 0xE0,
  0x00, 0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xB0, 0x00, 0xFF, 0xF1, 0x00, 0x00,
  0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_Black62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 45, 17, 3, -44 },
  { 69, 25, 16, 31, 3, -44 },
  { 119, 34, 44, 36, 1, -44 },
  { 306, 28, 51, 32, 2, -47 },
  { 485, 52, 46, 54, 1, -45 },
  { 784, 41, 46, 43, 2, -45 },
  { 1020, 11, 16, 16, 3, -44 },
  { 1042, 17, 56, 21, 3, -46 },
  { 1161, 17, 56, 21, 1, -46 },
  { 1280, 29, 28, 31, 1, -47 },
  { 1382, 28, 30, 33, 2, -37 },
  { 1487, 13, 18, 18, 2, -9 },
  { 1517, 16, 9, 20, 2, -21 },
  { 1535, 11, 12, 17, 3, -11 },
  { 1552, 27, 46, 27, 0, -45 },
  { 1708, 28, 46, 32, 2, -45 },
  { 1869, 24, 44, 32, 2, -44 },
  { 2001, 28, 45, 32, 1, -45 },
  { 2159, 28, 46, 32, 2, -45 },
  { 2320, 31, 44, 32, 1, -44 },
  { 2491, 27, 45, 32, 3, -44 },
  { 2643, 28, 46, 32, 2, -45 },
  { 2804, 28, 44, 32, 2, -44 },
  { 2958, 28, 46, 32, 2, -45 },
  { 3119, 28, 46, 32, 2, -45 },
  { 3280, 12, 36, 18, 3, -35 },
  { 3334, 13, 44, 18, 2, -35 },
  { 3406, 28, 31, 33, 2, -38 },
  { 3515, 28, 22, 33, 2, -33 },
  { 3592, 28, 31, 33, 2, -38 },
  { 3701, 26, 46, 27, 0, -45 },
  { 3851, 46, 50, 50, 2, -45 },
  { 4139, 38, 44, 38, 0, -44 },
  { 4348, 30, 44, 37, 4, -44 },
  { 4513, 29, 46, 34, 3, -45 },
  { 4680, 32, 44, 39, 4, -44 },
  { 4856, 23, 44, 29, 4, -44 },
  { 4983, 23, 44, 29, 4, -44 },
  { 5110, 33, 46, 40, 3, -45 },
  { 5300, 33, 44, 41, 4, -44 },
  { 5482, 20, 44, 24, 2, -44 },
  { 5592, 19, 58, 19, -4, -44 },
  { 5730, 33, 44, 37, 4, -44 },
  { 5912, 24, 44, 29, 4, -44 },
  { 6044, 45, 44, 53, 4, -44 },
  { 6292, 36, 44, 44, 4, -44 },
  { 6490, 36, 46, 42, 3, -45 },
  { 6697, 28, 44, 34, 4, -44 },
  { 6851, 36, 56, 42, 3, -45 },
  { 7103, 33, 44, 36, 4, -44 },
  { 7285, 27, 46, 30, 2, -45 },
  { 7441, 29, 44, 31, 1, -44 },
  { 7601, 32, 45, 40, 4, -44 },
  { 7781, 37, 44, 37, 0, -44 },
  { 7985, 54, 44, 55, 0, -44 },
  { 8282, 36, 44, 36, 0, -44 },
  { 8480, 35, 44, 35, 0, -44 },
  { 8673, 29, 44, 32, 1, -44 },
  { 8833, 15, 56, 19, 3, -46 },
  { 8938, 26, 46, 27, 0, -45 },
  { 9088, 15, 56, 19, 1, -46 },
  { 9193, 33, 29, 33, 0, -44 },
  { 9313, 31, 7, 31, 0, 4 },
  { 9341, 18, 9, 23, 2, -47 },
  { 9362, 28, 36, 33, 2, -35 },
  { 9488, 29, 48, 35, 3, -47 },
  { 9662, 25, 36, 29, 2, -35 },
  { 9775, 29, 48, 35, 2, -47 },
  { 9949, 28, 36, 32, 2, -35 },
  { 10075, 22, 47, 22, 1, -47 },
  { 10205, 29, 50, 35, 2, -35 },
  { 10387, 29, 47, 35, 3, -47 },
  { 10558, 11, 48, 18, 3, -48 },
  { 10624, 17, 63, 18, -3, -48 },
  { 10758, 32, 47, 35, 3, -47 },
  { 10946, 11, 47, 17, 3, -47 },
  { 11011, 47, 35, 53, 3, -35 },
  { 11217, 29, 35, 35, 3, -35 },
  { 11344, 30, 36, 34, 2, -35 },
  { 11479, 29, 50, 35, 3, -35 },
  { 11661, 29, 50, 35, 2, -35 },
  { 11843, 21, 35, 25, 3, -35 },
  { 11935, 23, 36, 27, 2, -35 },
  { 12039, 22, 42, 24, 1, -41 },
  { 12155, 29, 35, 35, 3, -34 },
  { 12282, 33, 34, 33, 0, -34 },
  { 12423, 48, 34, 49, 0, -34 },
  { 12627, 32, 34, 32, 0, -34 },
  { 12763, 33, 49, 33, 0, -34 },
  { 12966, 24, 34, 27, 1, -34 },
  { 13068, 22, 55, 24, 1, -45 },
  { 13220, 8, 62, 28, 10, -48 },
  { 13282, 22, 55, 24, 1, -45 },
  { 13434, 29, 12, 33, 2, -28 },
};

const GFXfont NotoSans_Condensed_Black62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_BLACK62PT7B_H_
