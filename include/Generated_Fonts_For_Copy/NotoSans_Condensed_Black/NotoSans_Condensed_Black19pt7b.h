#ifndef _NOTOSANS_CONDENSED_BLACK19PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xEE, 0xEE, 0xEE, 0xE6,
  0x0D, 0xC1, 0xB0, 0x76, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0xE0, 0xD8, 0xFF,
  0xDF, 0xF8, 0xCC, 0x19, 0x83, 0x70, 0x6E, 0x00, 0x18, 0x7E, 0xFF, 0xFA,
  0xD8, 0xF8, 0xFC, 0x3E, 0x1F, 0x1B, 0x9F, 0xFF, 0xFE, 0x18, 0x18, 0x38,
  0x38, 0x7C, 0x30, 0x6C, 0x70, 0xEE, 0x60, 0xEE, 0xE0, 0xEE, 0xC0, 0x6D,
  0xDE, 0x7D, 0xBF, 0x3B, 0xB3, 0x03, 0x33, 0x03, 0x33, 0x07, 0x37, 0x06,
  0x3F, 0x0E, 0x1E, 0x0E, 0x01, 0xFC, 0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x1F,
  0xC0, 0x7D, 0xE7, 0xEE, 0x77, 0x73, 0xBF, 0xBC, 0xF8, 0xFF, 0xC7, 0xFF,
  0x1F, 0xBC, 0xFF, 0xFE, 0x3B, 0x9C, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x39, 0xCE, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0xE3, 0x87, 0x1C, 0x73, 0xCE,
  0x38, 0xE7, 0x1C, 0xE0, 0x1C, 0x46, 0x5F, 0xFF, 0xF1, 0xC1, 0xF1, 0xDC,
  0x64, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0x38, 0x7E, 0xFE, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0x0E, 0x3C, 0xFB,
  0xFF, 0xED, 0xD3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x1C, 0x3F,
  0xBF, 0xEC, 0xF2, 0x78, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0xF7,
  0xFB, 0xFC, 0x3C, 0xFE, 0xFF, 0x4F, 0x07, 0x0E, 0x7C, 0x7E, 0x1F, 0x07,
  0x07, 0xFF, 0xFE, 0xFC, 0x07, 0x01, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3,
  0x71, 0xDC, 0xE7, 0x3F, 0xFF, 0xFC, 0x1C, 0x07, 0x01, 0xC0, 0x7E, 0xFE,
  0xFE, 0xE0, 0xE0, 0xFC, 0xFE, 0xFF, 0x0F, 0x07, 0x07, 0xFF, 0xFE, 0xFC,
  0x0F, 0x3F, 0x7F, 0xF0, 0xE0, 0xFE, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF,
  0x7F, 0x3E, 0xFF, 0xFF, 0xFF, 0x07, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7, 0xFE, 0x7E, 0x7E,
  0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E, 0x38, 0x7E, 0xFF, 0xE7, 0xE7, 0xE7,
  0xEF, 0xFF, 0x7F, 0x07, 0x07, 0xFE, 0xFC, 0xF8, 0x7F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0x03, 0x0F, 0x3E, 0xF8,
  0xF0, 0x7C, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x3E, 0xF8, 0xE0, 0x80, 0x3C, 0xFE,
  0xFF, 0x47, 0x07, 0x0F, 0x1E, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38,
  0x07, 0x80, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0xE7, 0xDB, 0x3F, 0x7D, 0xCD,
  0xF7, 0x37, 0xDD, 0xDB, 0x77, 0x6C, 0xFF, 0xB9, 0x9C, 0x70, 0x00, 0xF7,
  0x81, 0xFE, 0x00, 0x0F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xB8,
  0x39, 0xC3, 0x9C, 0x79, 0xC7, 0xFE, 0x7F, 0xE7, 0x0E, 0xF0, 0xEF, 0x0F,
  0xFC, 0x7F, 0xBF, 0xFE, 0x7F, 0x3F, 0xBF, 0xFD, 0xFE, 0xF7, 0xF9, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x1F, 0xDF, 0xCE, 0x2F, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x78, 0x3C, 0x2F, 0xE7, 0xF1, 0xF8, 0xF8, 0x3F, 0xCF, 0xFB,
  0xDF, 0xF3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFF, 0x3F, 0xFE, 0xFF,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xE3,
  0xC7, 0x8F, 0x1E, 0x00, 0x0F, 0x0F, 0xF7, 0xF9, 0xE2, 0xF0, 0x38, 0x0E,
  0x7F, 0x9F, 0xE7, 0xFC, 0x7F, 0x1D, 0xFF, 0x7F, 0xC7, 0xF0, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x70, 0xFF, 0xFF, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0xFF, 0xF0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xFE, 0xFB, 0xC0, 0xF1, 0xFC, 0xFF, 0x3B, 0xDE, 0xFF, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFF, 0x3D, 0xCF, 0x7B, 0xCE, 0xF3, 0xFC, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0xFF, 0xF3, 0xFE,
  0xCD, 0xFB, 0xB7, 0xEF, 0xDF, 0xBF, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F,
  0x8E, 0x70, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xCF, 0xFD, 0xFB, 0xBF,
  0x7F, 0xE7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xC0, 0x1E, 0x07,
  0xF1, 0xFF, 0x78, 0xEF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F,
  0xC7, 0xBF, 0xE7, 0xF8, 0x3E, 0x00, 0xF8, 0x7F, 0xBF, 0xDE, 0xFF, 0x3F,
  0x9F, 0xDF, 0xFE, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x1E, 0x07,
  0xF1, 0xFF, 0x78, 0xEF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F,
  0xC7, 0xBF, 0xE7, 0xF8, 0x3E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0xF8, 0x3F,
  0xCF, 0xFB, 0xDE, 0xF3, 0xBD, 0xEF, 0xFB, 0xFC, 0xFE, 0x3F, 0xCF, 0x73,
  0xDE, 0xF3, 0xBC, 0xF0, 0x3C, 0x7F, 0xFE, 0xE2, 0xE0, 0xF0, 0xFC, 0x7E,
  0x1F, 0x0F, 0x8F, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3D,
  0xFF, 0x7F, 0x8F, 0xC0, 0xF0, 0xFE, 0x1D, 0xC7, 0xB8, 0xF7, 0x9C, 0xF3,
  0x8E, 0xF1, 0xDC, 0x3B, 0x87, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x1E, 0x00,
  0xE1, 0xC7, 0xF8, 0xE3, 0x9C, 0x71, 0xCE, 0x78, 0xE7, 0x3E, 0x73, 0x9F,
  0x79, 0xCD, 0xB8, 0x7E, 0xDC, 0x3F, 0x6E, 0x1F, 0xB7, 0x0F, 0x9F, 0x87,
  0xCF, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF1, 0xEE, 0x39, 0xEF, 0x1D, 0xC3,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xF0, 0xEE, 0x3D, 0xE7, 0x1D,
  0xE3, 0xC0, 0xF1, 0xFE, 0x39, 0xCF, 0x3D, 0xC3, 0xB8, 0x7F, 0x07, 0xC0,
  0xF8, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xBF,
  0xDF, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F,
  0xF8, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x0E,
  0x0E, 0x06, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xFF, 0xF8, 0x0C, 0x03, 0x01, 0xE0, 0x78, 0x3F, 0x0E, 0xC7, 0x39, 0xC6,
  0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0x8E, 0x3C, 0xFE, 0x7F, 0x47,
  0x3F, 0xFF, 0xE7, 0xE7, 0xEF, 0xFF, 0xF3, 0xE0, 0x70, 0x38, 0x1C, 0xCF,
  0xF7, 0xFB, 0xDF, 0xC7, 0xE3, 0xF1, 0xF9, 0xFE, 0xFF, 0xF7, 0x70, 0x1C,
  0xFF, 0xFF, 0x1E, 0x1C, 0x38, 0x70, 0xFE, 0xFC, 0xF8, 0x07, 0x83, 0xC1,
  0xE6, 0xF7, 0xFF, 0xFF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFF, 0xFF, 0xFB,
  0xDC, 0x18, 0x7E, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xE0, 0xF3, 0x7F, 0x3F,
  0x08, 0x7C, 0xF9, 0xC7, 0xFF, 0xFF, 0xBC, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x00, 0x33, 0xBD, 0xFF, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF,
  0xFF, 0xDF, 0xE0, 0xF8, 0x77, 0xFB, 0xF8, 0x70, 0xE0, 0x70, 0x38, 0x1C,
  0xCF, 0xF7, 0xFF, 0xDF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1C,
  0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x19, 0xCE, 0x03, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFE, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x8F,
  0xE7, 0xB9, 0xCE, 0xF3, 0xB8, 0xFE, 0x3F, 0x8F, 0xF3, 0x9C, 0xE7, 0xB8,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE6, 0x33, 0xFD, 0xFF, 0xFF,
  0xFD, 0xE7, 0xE7, 0x9F, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x9E,
  0x7E, 0x79, 0xC0, 0xE6, 0x7F, 0xBF, 0xFE, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xE0, 0x1C, 0x3F, 0x3F, 0xDC, 0xFE, 0x7F, 0x1F, 0x9F,
  0xCF, 0xF7, 0x3F, 0x8F, 0x80, 0xE6, 0x7F, 0xBF, 0xDE, 0xFE, 0x3F, 0x1F,
  0x8F, 0xCF, 0xFF, 0xFF, 0xBB, 0x9C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x33,
  0xBD, 0xFF, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF, 0xFF, 0xDF, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xE7, 0xBF, 0xFF, 0xF3, 0x8E, 0x38, 0xE3,
  0x8E, 0x00, 0x39, 0xFF, 0xF7, 0x2F, 0x1F, 0x9F, 0x0F, 0xDF, 0xFB, 0xE0,
  0x38, 0x70, 0xFF, 0xFF, 0xEF, 0x1E, 0x3C, 0x78, 0xF1, 0xF9, 0xF3, 0xE0,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xFF, 0xFF, 0xDE,
  0xE0, 0xE1, 0xFC, 0xF7, 0x39, 0xCE, 0x73, 0x8F, 0xC3, 0xF0, 0xFC, 0x1E,
  0x07, 0x81, 0xE0, 0xE3, 0x8F, 0xEF, 0xBD, 0xDF, 0x73, 0xB6, 0xE7, 0x6D,
  0xCE, 0xDB, 0x8D, 0xB6, 0x1F, 0x6C, 0x3E, 0xF8, 0x78, 0xF0, 0xF1, 0xE0,
  0xF3, 0xDC, 0xE7, 0xF8, 0xFC, 0x3F, 0x07, 0x83, 0xF0, 0xFC, 0x7F, 0x9C,
  0xEF, 0x3C, 0xE1, 0xFC, 0xF7, 0x39, 0xCE, 0x73, 0x8F, 0xC3, 0xF0, 0xFC,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x1F, 0x07, 0x81, 0x80, 0x7F, 0x7F,
  0x7F, 0x0E, 0x1C, 0x1C, 0x38, 0x78, 0x7F, 0xFF, 0xFF, 0x0E, 0x3C, 0xF9,
  0xC3, 0x87, 0x0E, 0x7C, 0xF1, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x0F, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0xF3, 0xE1, 0xC3,
  0x87, 0x0E, 0x1F, 0x1E, 0x7C, 0xE1, 0xC3, 0x87, 0x0E, 0x7C, 0xF0, 0x41,
  0xF9, 0xFF, 0x8F,
};

const GFXglyph NotoSans_Condensed_Black19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 8, 5, 9, 1, -14 },
  { 12, 11, 14, 11, 0, -14 },
  { 32, 8, 15, 10, 1, -14 },
  { 47, 16, 14, 17, 0, -14 },
  { 75, 13, 14, 13, 0, -14 },
  { 98, 3, 5, 5, 1, -14 },
  { 100, 5, 17, 6, 1, -14 },
  { 111, 6, 17, 6, 0, -14 },
  { 124, 9, 8, 9, 0, -14 },
  { 133, 8, 9, 10, 1, -11 },
  { 142, 3, 6, 5, 1, -3 },
  { 145, 5, 3, 6, 1, -7 },
  { 147, 3, 3, 5, 1, -3 },
  { 149, 8, 14, 8, 0, -14 },
  { 163, 8, 14, 10, 1, -14 },
  { 177, 7, 14, 10, 1, -14 },
  { 190, 9, 14, 10, 0, -14 },
  { 206, 8, 14, 10, 1, -14 },
  { 220, 10, 14, 10, 0, -14 },
  { 238, 8, 14, 10, 1, -14 },
  { 252, 8, 14, 10, 1, -14 },
  { 266, 8, 14, 10, 1, -14 },
  { 280, 8, 14, 10, 1, -14 },
  { 294, 8, 14, 10, 1, -14 },
  { 308, 3, 11, 5, 1, -11 },
  { 313, 3, 14, 5, 1, -11 },
  { 319, 8, 10, 10, 1, -12 },
  { 329, 8, 7, 10, 1, -10 },
  { 336, 8, 10, 10, 1, -12 },
  { 346, 8, 14, 8, 0, -14 },
  { 360, 14, 15, 15, 1, -14 },
  { 387, 12, 14, 12, 0, -14 },
  { 408, 9, 14, 11, 1, -14 },
  { 424, 9, 14, 10, 1, -14 },
  { 440, 10, 14, 12, 1, -14 },
  { 458, 7, 14, 9, 1, -14 },
  { 471, 7, 14, 9, 1, -14 },
  { 484, 10, 14, 12, 1, -14 },
  { 502, 10, 14, 12, 1, -14 },
  { 520, 6, 14, 7, 1, -14 },
  { 531, 6, 18, 6, -1, -14 },
  { 545, 10, 14, 11, 1, -14 },
  { 563, 8, 14, 9, 1, -14 },
  { 577, 14, 14, 16, 1, -14 },
  { 602, 11, 14, 13, 1, -14 },
  { 622, 11, 14, 13, 1, -14 },
  { 642, 9, 14, 11, 1, -14 },
  { 658, 11, 17, 13, 1, -14 },
  { 682, 10, 14, 11, 1, -14 },
  { 700, 8, 14, 9, 1, -14 },
  { 714, 9, 14, 9, 0, -14 },
  { 730, 10, 14, 12, 1, -14 },
  { 748, 11, 14, 11, 0, -14 },
  { 768, 17, 14, 17, 0, -14 },
  { 798, 11, 14, 11, 0, -14 },
  { 818, 11, 14, 11, 0, -14 },
  { 838, 9, 14, 10, 0, -14 },
  { 854, 5, 17, 6, 1, -14 },
  { 865, 8, 14, 8, 0, -14 },
  { 879, 5, 17, 6, 0, -14 },
  { 890, 10, 9, 10, 0, -14 },
  { 902, 10, 3, 10, 0, 1 },
  { 906, 5, 3, 7, 1, -15 },
  { 908, 8, 11, 10, 1, -11 },
  { 919, 9, 14, 11, 1, -14 },
  { 935, 7, 11, 9, 1, -11 },
  { 945, 9, 14, 11, 1, -14 },
  { 961, 8, 11, 10, 1, -11 },
  { 972, 7, 15, 7, 0, -15 },
  { 986, 9, 16, 11, 1, -11 },
  { 1004, 9, 14, 11, 1, -14 },
  { 1020, 3, 15, 5, 1, -15 },
  { 1026, 5, 20, 5, -1, -15 },
  { 1039, 10, 14, 11, 1, -14 },
  { 1057, 3, 14, 5, 1, -14 },
  { 1063, 14, 11, 16, 1, -11 },
  { 1083, 9, 11, 11, 1, -11 },
  { 1096, 9, 11, 10, 1, -11 },
  { 1109, 9, 16, 11, 1, -11 },
  { 1127, 9, 16, 11, 1, -11 },
  { 1145, 6, 11, 8, 1, -11 },
  { 1154, 7, 11, 8, 1, -11 },
  { 1164, 7, 13, 7, 0, -13 },
  { 1176, 9, 11, 11, 1, -11 },
  { 1189, 10, 11, 10, 0, -11 },
  { 1203, 15, 11, 15, 0, -11 },
  { 1224, 10, 11, 10, 0, -11 },
  { 1238, 10, 16, 10, 0, -11 },
  { 1258, 8, 11, 8, 0, -11 },
  { 1269, 7, 17, 7, 0, -14 },
  { 1284, 3, 19, 8, 3, -15 },
  { 1292, 7, 17, 7, 0, -14 },
  { 1307, 8, 4, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Black19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_BLACK19PT7B_H_
