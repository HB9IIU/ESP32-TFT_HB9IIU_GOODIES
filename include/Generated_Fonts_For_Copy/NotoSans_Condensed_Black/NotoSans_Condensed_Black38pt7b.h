#ifndef _NOTOSANS_CONDENSED_BLACK38PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0x9F, 0xBF, 0xFF, 0xFF, 0xFD,
  0xF0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7D, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x03, 0xE3, 0xC0,
  0x1F, 0x3E, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x1F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC1, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x3E,
  0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7C, 0xC3, 0x7E, 0x60, 0x1F, 0x30, 0x0F, 0xD8, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x19, 0xF0, 0x0C, 0xFA, 0x06, 0x7D, 0xE3, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x78,
  0x03, 0xFF, 0x01, 0xF0, 0x0F, 0xFF, 0x03, 0xC0, 0x1F, 0x3E, 0x0F, 0x80,
  0x3E, 0x7C, 0x1F, 0x00, 0x7C, 0xF8, 0x7C, 0x00, 0xF9, 0xF0, 0xF8, 0x01,
  0xF3, 0xE3, 0xE0, 0x03, 0xE7, 0xC7, 0xC0, 0x07, 0xCF, 0x9F, 0x0F, 0x0F,
  0x9F, 0x3E, 0x7F, 0x0F, 0xFE, 0x79, 0xFF, 0x1F, 0xF9, 0xF3, 0xFF, 0x1F,
  0xF3, 0xCF, 0xFF, 0x1F, 0xCF, 0x9F, 0x3E, 0x0C, 0x1F, 0x3E, 0x7C, 0x00,
  0x7C, 0x7C, 0xF8, 0x00, 0xF8, 0xF9, 0xF0, 0x03, 0xE1, 0xF3, 0xE0, 0x07,
  0xC3, 0xE7, 0xC0, 0x1F, 0x07, 0xCF, 0x80, 0x3E, 0x0F, 0x9F, 0x00, 0x78,
  0x1F, 0xFC, 0x01, 0xF0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xE0, 0x0F, 0x80,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xF0, 0xFF, 0xE3, 0xF8, 0xFF, 0xF9,
  0xFC, 0xFF, 0xFD, 0xFC, 0xFE, 0xFF, 0xFE, 0x7F, 0x3F, 0xFE, 0x3F, 0x8F,
  0xFF, 0x1F, 0xC3, 0xFF, 0x8F, 0xE0, 0xFF, 0x87, 0xF8, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7F, 0x83,
  0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x04, 0x3E, 0x17, 0xDF, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xF1, 0xF9,
  0xFC, 0x3C, 0x78, 0x0C, 0x18, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x31, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xF3, 0xF1, 0xFC, 0xFE, 0x7E, 0x1F, 0x9F, 0x87, 0xEF, 0xE1, 0xFB,
  0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xE1, 0xFF, 0xF8, 0x7E, 0xFE,
  0x1F, 0xBF, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7D, 0xFC, 0x73, 0xF8, 0x47,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xF9, 0xF1, 0xFC, 0x70, 0x7F, 0x10, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x0F, 0xFC, 0x1F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0xE1, 0xFE, 0x40, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC1, 0xF7, 0xF0, 0x7D, 0xFC, 0x3E, 0x7F, 0x1F, 0x9F,
  0xC7, 0xC7, 0xF3, 0xF1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFD, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0xF1, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0x00, 0x08, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xC3, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE7,
  0xC1, 0xF7, 0xF8, 0xFD, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFE, 0xFE,
  0xFE, 0x1F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7E, 0x1F, 0xDF,
  0x87, 0xE7, 0xF3, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xE3, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F,
  0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xCF, 0xEF, 0xE1, 0xFB, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x80, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF3, 0xFB, 0xF8,
  0xFE, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0xDF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xF7, 0xE0,
  0xF9, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x3E,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0x00, 0x00, 0xC0, 0x01, 0xF0,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFF, 0x78, 0x7F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x03, 0x83, 0xE3,
  0xE1, 0xFF, 0x9E, 0x3C, 0x3F, 0xF9, 0xF7, 0xC7, 0xFF, 0x9F, 0x7C, 0xFC,
  0xF8, 0xF7, 0x8F, 0x8F, 0x8F, 0x78, 0xF0, 0xF8, 0xFF, 0x9F, 0x0F, 0x8F,
  0xF9, 0xF0, 0xF8, 0xFF, 0x9F, 0x0F, 0x8F, 0xF9, 0xF0, 0xF9, 0xFF, 0x8F,
  0x0F, 0x9F, 0x78, 0xF9, 0xF9, 0xE7, 0x8F, 0xFF, 0xFE, 0x7C, 0x7F, 0xBF,
  0xC7, 0xC3, 0xF1, 0xF8, 0x3E, 0x0E, 0x0E, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x02, 0x00, 0xFE, 0x01, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x7F, 0xBF, 0x87, 0xF7, 0xF0, 0x7E,
  0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFC, 0x71, 0xFC, 0x04, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x27,
  0xFC, 0x78, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x1F, 0xEF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xC1, 0xC7, 0xF8, 0x04, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0xC7, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFC, 0xFF, 0x01, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFE, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFB, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xF7, 0xF0,
  0x3F, 0xBF, 0x81, 0xFE, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xDF, 0x0F, 0xFF, 0xFD, 0xF0, 0xFB, 0xFF, 0xDF, 0x8F,
  0xBF, 0xFE, 0xF8, 0xFB, 0xFF, 0xEF, 0x9F, 0x3F, 0xFE, 0xFD, 0xF3, 0xFF,
  0xEF, 0xDF, 0x3F, 0xFE, 0x7F, 0xF3, 0xFF, 0xE7, 0xFE, 0x3F, 0xFE, 0x7F,
  0xE3, 0xFF, 0xE7, 0xFE, 0x3F, 0xFE, 0x3F, 0xE3, 0xFF, 0xE3, 0xFC, 0x3F,
  0xFE, 0x3F, 0xC3, 0xFF, 0xE3, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1,
  0xF8, 0x3F, 0xFE, 0x1F, 0x83, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7,
  0xE3, 0xFF, 0xEF, 0xE7, 0xFF, 0xCF, 0xCF, 0xFF, 0xDF, 0xDF, 0xFF, 0x9F,
  0xBF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0x7F, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xF8,
  0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x9F, 0xC1, 0xFE, 0xFF, 0x03,
  0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0xFF, 0x03, 0xF9, 0xFC, 0x1F,
  0xE7, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xBF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF8,
  0xFF, 0x9F, 0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xF9, 0xFC, 0x1F, 0xE7, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x3F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0x7E, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0xBF, 0x81, 0xFE, 0x00, 0x40, 0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFE, 0xF9, 0xFC, 0x04, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF,
  0x03, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7,
  0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x3F, 0xFF, 0x01, 0xF8, 0x1F, 0xDF,
  0x81, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0x07, 0xE7, 0xF0, 0x7F, 0x03, 0xF3,
  0xF8, 0x3F, 0xC1, 0xF8, 0xFC, 0x3F, 0xE1, 0xFC, 0x7E, 0x1F, 0xF0, 0xFE,
  0x3F, 0x0F, 0xF8, 0x7E, 0x1F, 0x87, 0xFC, 0x3F, 0x0F, 0xE3, 0xFF, 0x1F,
  0x83, 0xF3, 0xEF, 0x9F, 0xC1, 0xF9, 0xF7, 0xCF, 0xE0, 0xFC, 0xFB, 0xE7,
  0xE0, 0x7E, 0x7D, 0xF3, 0xF0, 0x3F, 0x3E, 0x7D, 0xF8, 0x0F, 0xFF, 0x3E,
  0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF9, 0xFC, 0x1F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x1F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80,
  0xFD, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFE, 0x03,
  0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0xF9, 0xF0, 0x1F, 0x9F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0xC3, 0xF0, 0x7C, 0x3E, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0xC1, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x0F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFB, 0xEF, 0xF9, 0xF3, 0xF8, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0xFC, 0x3F, 0x7F, 0x8F, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xCF, 0xEF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xF7, 0xF8, 0xF8, 0xFC, 0x00,
  0x07, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x8C,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x02, 0x7F, 0x86, 0x7F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x0F, 0xCF, 0xC7, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0xC7, 0xF7, 0xF1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF7, 0xE1, 0xFD, 0xFC, 0x7F,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF, 0x0F, 0xC7, 0xC0,
  0x07, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xBF, 0x9F,
  0x87, 0xE7, 0xE0, 0xF9, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x06,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xCF, 0xC7, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0xC7, 0xF7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF7, 0xE1,
  0xFD, 0xFC, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF,
  0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFD, 0x00, 0x7F, 0x7C, 0x3F, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0xFE, 0x3F, 0x7F, 0xCF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x9F, 0xDF, 0xFB, 0xFF, 0x7F, 0xCF, 0xF9, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xEF, 0xE1,
  0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE,
  0xFE, 0x0F, 0xDF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0xFE, 0x1F, 0xCF, 0xDF, 0xF3, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F,
  0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1,
  0xFC, 0x3F, 0xFE, 0x1F, 0x83, 0xFF, 0xE1, 0xF8, 0x3F, 0xFE, 0x1F, 0x83,
  0xFF, 0xE1, 0xF8, 0x3F, 0xFE, 0x1F, 0x83, 0xFF, 0xE1, 0xF8, 0x3F, 0xFE,
  0x1F, 0x83, 0xFF, 0xE1, 0xF8, 0x3F, 0xFE, 0x1F, 0x83, 0xFF, 0xE1, 0xF8,
  0x3F, 0xFE, 0x1F, 0x83, 0xF0, 0xF8, 0xFE, 0x3F, 0x7F, 0xCF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF8, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0xF8, 0xFC, 0x3F, 0x7F, 0x8F,
  0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xCF, 0xEF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xDF, 0xF3, 0xF7, 0xF8, 0xFC, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xC7, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0xC7, 0xF7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF7, 0xE1,
  0xFD, 0xFC, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF,
  0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xF8,
  0x7F, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xF0,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xF0, 0x6F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF1, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFE, 0xFC, 0xFF, 0xBF, 0x1F, 0xCF, 0xC0, 0xFE, 0x07, 0xF7, 0xE0, 0x7F,
  0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xFB,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFE, 0x1F, 0xE1, 0xFD, 0xF8, 0x7F, 0x87, 0xE7, 0xE1, 0xFE, 0x1F, 0x9F,
  0x87, 0xF8, 0x7E, 0x7F, 0x3F, 0xF3, 0xF8, 0xFC, 0xFF, 0xCF, 0xC3, 0xF3,
  0xFF, 0x3F, 0x0F, 0xCF, 0xFC, 0xFC, 0x3F, 0x3D, 0xF3, 0xF0, 0xFD, 0xF7,
  0xCF, 0xC1, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF,
  0xE0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xE7, 0xF0, 0xFE,
  0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x1F, 0xBF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0xBF, 0x83, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F,
  0xE3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF9, 0xFC, 0x1F, 0x9F, 0x81, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x2F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x1F, 0xC1, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xE0,
  0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x07, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xC3, 0xFE, 0x1F, 0xF1,
  0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xE8, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_Black38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 27, 11, 2, -27 },
  { 25, 15, 10, 19, 2, -27 },
  { 44, 21, 27, 22, 1, -27 },
  { 115, 17, 31, 20, 1, -29 },
  { 181, 31, 28, 33, 1, -28 },
  { 290, 25, 27, 26, 1, -27 },
  { 375, 6, 10, 10, 2, -27 },
  { 383, 10, 34, 13, 2, -28 },
  { 426, 11, 34, 13, 0, -28 },
  { 473, 17, 17, 19, 1, -29 },
  { 510, 18, 19, 20, 1, -23 },
  { 553, 8, 11, 11, 1, -6 },
  { 564, 10, 6, 12, 1, -13 },
  { 572, 7, 7, 11, 2, -7 },
  { 579, 16, 28, 16, 0, -28 },
  { 635, 18, 28, 20, 1, -28 },
  { 698, 15, 27, 20, 1, -27 },
  { 749, 17, 28, 20, 1, -28 },
  { 809, 17, 28, 20, 1, -28 },
  { 869, 18, 27, 20, 1, -27 },
  { 930, 16, 27, 20, 2, -27 },
  { 984, 18, 28, 20, 1, -28 },
  { 1047, 18, 27, 20, 1, -27 },
  { 1108, 18, 28, 20, 1, -28 },
  { 1171, 18, 28, 20, 1, -28 },
  { 1234, 7, 21, 11, 2, -21 },
  { 1253, 8, 26, 11, 1, -21 },
  { 1279, 18, 19, 20, 1, -23 },
  { 1322, 18, 13, 20, 1, -20 },
  { 1352, 18, 19, 20, 1, -23 },
  { 1395, 16, 28, 16, 0, -28 },
  { 1451, 28, 30, 31, 1, -27 },
  { 1556, 24, 27, 24, 0, -27 },
  { 1637, 19, 27, 23, 2, -27 },
  { 1702, 18, 28, 21, 2, -28 },
  { 1765, 20, 27, 24, 2, -27 },
  { 1833, 14, 27, 18, 2, -27 },
  { 1881, 14, 27, 18, 2, -27 },
  { 1929, 20, 28, 24, 2, -28 },
  { 1999, 21, 27, 25, 2, -27 },
  { 2070, 12, 27, 14, 1, -27 },
  { 2111, 12, 36, 12, -3, -27 },
  { 2165, 21, 27, 23, 2, -27 },
  { 2236, 15, 27, 18, 2, -27 },
  { 2287, 28, 27, 32, 2, -27 },
  { 2382, 23, 27, 27, 2, -27 },
  { 2460, 22, 28, 26, 2, -28 },
  { 2537, 18, 27, 21, 2, -27 },
  { 2598, 22, 34, 26, 2, -28 },
  { 2692, 21, 27, 22, 2, -27 },
  { 2763, 17, 28, 19, 1, -28 },
  { 2823, 17, 27, 19, 1, -27 },
  { 2881, 20, 27, 24, 2, -27 },
  { 2949, 23, 27, 23, 0, -27 },
  { 3027, 33, 27, 33, 0, -27 },
  { 3139, 22, 27, 22, 0, -27 },
  { 3214, 22, 27, 22, 0, -27 },
  { 3289, 18, 27, 20, 1, -27 },
  { 3350, 9, 34, 12, 2, -28 },
  { 3389, 16, 28, 16, 0, -28 },
  { 3445, 9, 34, 12, 1, -28 },
  { 3484, 20, 18, 20, 0, -27 },
  { 3529, 19, 5, 19, 0, 2 },
  { 3541, 10, 6, 14, 2, -29 },
  { 3549, 17, 21, 20, 1, -21 },
  { 3594, 18, 29, 21, 2, -29 },
  { 3660, 16, 21, 18, 1, -21 },
  { 3702, 18, 29, 21, 1, -29 },
  { 3768, 18, 21, 20, 1, -21 },
  { 3816, 14, 29, 13, 0, -29 },
  { 3867, 18, 30, 21, 1, -21 },
  { 3935, 18, 29, 22, 2, -29 },
  { 4001, 7, 29, 11, 2, -29 },
  { 4027, 11, 38, 11, -2, -29 },
  { 4080, 20, 29, 21, 2, -29 },
  { 4153, 7, 29, 11, 2, -29 },
  { 4179, 28, 21, 32, 2, -21 },
  { 4253, 18, 21, 22, 2, -21 },
  { 4301, 19, 21, 21, 1, -21 },
  { 4351, 18, 30, 21, 2, -21 },
  { 4419, 18, 30, 21, 1, -21 },
  { 4487, 13, 21, 15, 2, -21 },
  { 4522, 14, 21, 16, 1, -21 },
  { 4559, 14, 25, 15, 0, -25 },
  { 4603, 18, 21, 22, 2, -21 },
  { 4651, 20, 21, 20, 0, -21 },
  { 4704, 30, 21, 30, 0, -21 },
  { 4783, 20, 21, 20, 0, -21 },
  { 4836, 20, 30, 20, 0, -21 },
  { 4911, 15, 21, 16, 1, -21 },
  { 4951, 13, 34, 15, 1, -28 },
  { 5007, 5, 38, 17, 6, -29 },
  { 5031, 13, 34, 15, 1, -28 },
  { 5087, 18, 7, 20, 1, -17 },
};

const GFXfont NotoSans_Condensed_Black38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_BLACK38PT7B_H_
