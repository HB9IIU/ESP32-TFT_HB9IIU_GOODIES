#ifndef _NOTOSANS_CONDENSED_BLACK39PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0xFC, 0xF8, 0x00, 0x00, 0x07, 0x3F, 0x7F, 0xFF, 0xFF,
  0xFB, 0xE0, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E,
  0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x3E, 0x03, 0xE3,
  0xE0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3C, 0x01, 0xF3, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x0F, 0x8F, 0x00, 0x7C, 0xF8, 0x03, 0xE7,
  0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0x03, 0xFF, 0xE3, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFD, 0xCE, 0x7C, 0xE1, 0x3E, 0x70, 0x1F,
  0xB8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1D, 0xFC, 0x0E, 0xFF, 0x07,
  0x7F, 0xF3, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x00,
  0xFE, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x3F, 0xE0, 0x1F, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x3E, 0x00,
  0xFD, 0xF0, 0x3E, 0x00, 0xF9, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x7C, 0x00,
  0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x00,
  0xF8, 0xF9, 0xF0, 0x00, 0xF9, 0xF9, 0xF1, 0xF0, 0xFD, 0xF3, 0xE7, 0xFC,
  0x7F, 0xF3, 0xE7, 0xFE, 0x7F, 0xE7, 0xCF, 0xFE, 0x3F, 0xE7, 0xCF, 0xBF,
  0x1F, 0x8F, 0x9F, 0x9F, 0x00, 0x0F, 0x9F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x1F,
  0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x7C, 0x0F, 0xBF, 0x00, 0x7C, 0x0F, 0xFE,
  0x00, 0xF8, 0x07, 0xFE, 0x00, 0xF8, 0x07, 0xFC, 0x01, 0xF0, 0x01, 0xF8,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0x87, 0xFF, 0x0F, 0xE3, 0xFF, 0xC7,
  0xF1, 0xFF, 0xF9, 0xFC, 0x7F, 0xFF, 0x7F, 0x3F, 0x9F, 0xFF, 0x8F, 0xE3,
  0xFF, 0xE3, 0xF8, 0x7F, 0xF8, 0xFE, 0x1F, 0xFC, 0x3F, 0x83, 0xFE, 0x0F,
  0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xF8, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x43, 0xE0, 0x9C, 0xF9, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x7F, 0x00, 0x3F,
  0xE0, 0x1F, 0xFC, 0x0F, 0xDF, 0x87, 0xF7, 0xF0, 0xF8, 0xF8, 0x1E, 0x1C,
  0x01, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0x3F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x7E, 0x1F, 0xDF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7F, 0x1F,
  0x9F, 0xC7, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xDF, 0xCE,
  0x7F, 0x11, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xF0, 0xFE, 0x60, 0x7F, 0x10, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x8F, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xBF,
  0x83, 0xF7, 0xF0, 0x7C, 0xFE, 0x1F, 0x9F, 0xC3, 0xE3, 0xF8, 0xFC, 0x7F,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0x63,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFC,
  0x03, 0xFB, 0xC7, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFE,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xFC, 0x63, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x84, 0x07, 0xEF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0x7E, 0x1F, 0xDF, 0xC7, 0xF7, 0xFB, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xCF, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7F, 0x1F, 0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xCF, 0xEF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0,
  0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xE1, 0xFB, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x3F, 0xEF, 0xC7, 0xF3, 0xF0, 0x71, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC4, 0x1F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0x80, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x1C,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0x7E, 0xFF, 0x30, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x0F, 0x87, 0xE1, 0xFE, 0x3E, 0x3E, 0x1F, 0xFD, 0xF3, 0xE1, 0xFF, 0xE7,
  0xDF, 0x1F, 0xFF, 0x3E, 0xF9, 0xF8, 0xF9, 0xF7, 0x8F, 0x87, 0xCF, 0xBC,
  0x7C, 0x3C, 0x7F, 0xE3, 0xE1, 0xE3, 0xFF, 0x1E, 0x1F, 0x1F, 0xF8, 0xF0,
  0xF8, 0xFF, 0xC7, 0xC7, 0xC7, 0xFE, 0x3E, 0x3E, 0x3C, 0xF1, 0xFB, 0xFB,
  0xE7, 0xCF, 0xFF, 0xFE, 0x3E, 0x3F, 0xFF, 0xF1, 0xF0, 0xFE, 0x7F, 0x07,
  0xC0, 0x80, 0x40, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x08, 0x03, 0xF8,
  0x07, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F,
  0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xF8, 0x19, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x27, 0xFE, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF8, 0x7F, 0xDF, 0xC1, 0xFE,
  0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x7F, 0x0F,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0x01, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0xC1,
  0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF,
  0x3F, 0xF1, 0xFF, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFF,
  0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0xBF, 0x81, 0xFD,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xEF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xEF, 0x8F, 0xBF, 0xFF, 0x7E, 0x7D, 0xFF, 0xFB, 0xF3, 0xEF, 0xFF, 0xDF,
  0xBF, 0x7F, 0xFE, 0x7D, 0xF3, 0xFF, 0xF3, 0xFF, 0x9F, 0xFF, 0x9F, 0xFC,
  0xFF, 0xFC, 0xFF, 0xE7, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF, 0x1F, 0xF1, 0xFF,
  0xF8, 0xFF, 0x8F, 0xFF, 0xC3, 0xFC, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0,
  0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x1F, 0x07, 0xF0, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xEF, 0xE7, 0xFF,
  0xDF, 0xCF, 0xFF, 0x9F, 0x9F, 0xFF, 0x3F, 0xBF, 0xFE, 0x3F, 0x7F, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xE1, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xCF, 0xF0, 0x7F, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xE1, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xF0, 0x7F, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE7,
  0xF0, 0x7F, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0x9F, 0xC1, 0xFC, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xBF, 0x81, 0xFD, 0xFC,
  0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xFC, 0x1D, 0xFC, 0x02, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE7, 0xF0, 0x7F,
  0x3F, 0x83, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x3F,
  0x8F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x03,
  0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07,
  0xF7, 0xE0, 0x3F, 0x81, 0xFD, 0xF8, 0x0F, 0xE0, 0x7E, 0x7F, 0x07, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x83, 0xF8, 0xFC, 0x1F,
  0xE0, 0xFE, 0x3F, 0x0F, 0xFC, 0x3F, 0x0F, 0xE3, 0xFF, 0x0F, 0xC3, 0xF8,
  0xFF, 0xC7, 0xF0, 0x7E, 0x3F, 0xF1, 0xFC, 0x1F, 0x8F, 0xFC, 0x7F, 0x07,
  0xE7, 0xEF, 0x9F, 0x81, 0xF9, 0xFB, 0xE7, 0xE0, 0x7F, 0x7C, 0xFB, 0xF8,
  0x0F, 0xDF, 0x3E, 0xFE, 0x03, 0xF7, 0xCF, 0xBF, 0x80, 0xFD, 0xF1, 0xFF,
  0xC0, 0x3F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xE1,
  0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8,
  0x3F, 0x87, 0xF8, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xF7, 0xF8, 0x0F, 0xF0,
  0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0x9F, 0xE0, 0xFE, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xCF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xE0, 0x3F,
  0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7C,
  0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0x8F, 0xE1, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xBF,
  0x3F, 0xEF, 0xC7, 0xE1, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x3C, 0x3F, 0xBF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFD, 0xFF, 0x3F, 0x3F,
  0x80, 0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFE, 0x7F, 0x02, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0x7F, 0x8F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x07, 0x8F, 0xE3, 0xFD, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC7, 0xFB, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0x7F, 0x7F, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF1, 0xFE, 0x7E, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x01,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xC7, 0xE3, 0xFC,
  0xFC, 0x7F, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC7,
  0xFB, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0x7F, 0x7F, 0x1F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFE, 0xFE, 0x1F, 0x9F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x40, 0x1F, 0xCF, 0x07, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x7C, 0x3F, 0xBF, 0xCF, 0xDF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFD,
  0xFF, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F,
  0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x0F,
  0xC7, 0xE7, 0xF8, 0xFF, 0x3F, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xC3,
  0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0x87, 0xF0,
  0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x0F, 0xE1, 0xFF,
  0xF8, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0,
  0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xE1, 0xFC,
  0x3F, 0xFF, 0x0F, 0xE1, 0xFC, 0xF8, 0x7C, 0x3F, 0x3F, 0xCF, 0xDF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0x7F, 0x9F, 0xC3, 0xF3,
  0xF0, 0x7F, 0x7E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0x7F, 0x7F, 0x1F, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0xFC, 0x7C, 0x3F, 0x3F, 0x8F, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0xFF, 0x3F,
  0x9F, 0x8F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xC7,
  0xE3, 0xFC, 0xFC, 0x7F, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xC7, 0xFB, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0x7F,
  0x7F, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFE, 0xFE,
  0x1F, 0x9F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0xF8, 0x3F, 0xE7, 0xFF, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xC7, 0x3F,
  0x82, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC4, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xE7, 0xC7, 0xF1, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x9F,
  0x81, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F,
  0x87, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0xFD, 0xF8, 0x7F, 0x83, 0xF7,
  0xE1, 0xFF, 0x0F, 0xDF, 0x87, 0xFC, 0x7F, 0x7F, 0x1F, 0xF1, 0xFD, 0xFC,
  0x7F, 0xC7, 0xE3, 0xF3, 0xFF, 0x1F, 0x8F, 0xCF, 0xBC, 0x7E, 0x3F, 0x3E,
  0xFB, 0xF8, 0xFE, 0xFB, 0xEF, 0xC1, 0xFB, 0xEF, 0xBF, 0x07, 0xEF, 0xBE,
  0xFC, 0x1F, 0xFC, 0xFB, 0xF0, 0x7F, 0xF3, 0xEF, 0x81, 0xFF, 0xC7, 0xBE,
  0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF7, 0xF0, 0xFE, 0x7F, 0x8F, 0xE3, 0xF9,
  0xFC, 0x3F, 0x9F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xF9, 0xFC,
  0x3F, 0x9F, 0xC7, 0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xE3, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9, 0xFC, 0x1F,
  0xDF, 0x80, 0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x02, 0x7F, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8,
  0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE3, 0xFF, 0x1F, 0xF0,
  0xFF, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFC, 0x3F,
  0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x07, 0xF8, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0x07, 0xF8,
  0x1F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x07, 0xF0, 0x20, 0x00, 0x3F, 0x80, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xF0,
};

const GFXglyph NotoSans_Condensed_Black39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 28, 11, 2, -28 },
  { 26, 16, 10, 19, 2, -28 },
  { 46, 21, 28, 23, 1, -28 },
  { 120, 17, 32, 20, 2, -30 },
  { 188, 32, 28, 34, 1, -28 },
  { 300, 26, 28, 27, 1, -28 },
  { 391, 7, 10, 10, 2, -28 },
  { 400, 11, 35, 13, 2, -29 },
  { 449, 12, 35, 13, 0, -29 },
  { 502, 18, 18, 19, 1, -30 },
  { 543, 18, 19, 21, 1, -23 },
  { 586, 8, 11, 11, 1, -6 },
  { 597, 11, 6, 13, 1, -13 },
  { 606, 7, 7, 11, 2, -7 },
  { 613, 17, 28, 17, 0, -28 },
  { 673, 18, 28, 20, 1, -28 },
  { 736, 14, 28, 20, 2, -28 },
  { 785, 17, 28, 20, 1, -28 },
  { 845, 18, 28, 20, 1, -28 },
  { 908, 19, 28, 20, 1, -28 },
  { 975, 17, 28, 20, 2, -28 },
  { 1035, 18, 28, 20, 1, -28 },
  { 1098, 18, 28, 20, 1, -28 },
  { 1161, 18, 28, 20, 1, -28 },
  { 1224, 18, 28, 20, 1, -28 },
  { 1287, 7, 22, 11, 2, -22 },
  { 1307, 8, 27, 11, 1, -22 },
  { 1334, 18, 20, 21, 1, -24 },
  { 1379, 18, 14, 21, 1, -21 },
  { 1411, 18, 20, 21, 1, -24 },
  { 1456, 16, 28, 17, 0, -28 },
  { 1512, 29, 31, 31, 1, -28 },
  { 1625, 24, 28, 24, 0, -28 },
  { 1709, 19, 28, 23, 2, -28 },
  { 1776, 18, 28, 21, 2, -28 },
  { 1839, 21, 28, 25, 2, -28 },
  { 1913, 15, 28, 19, 2, -28 },
  { 1966, 15, 28, 18, 2, -28 },
  { 2019, 21, 28, 25, 2, -28 },
  { 2093, 21, 28, 26, 2, -28 },
  { 2167, 13, 28, 15, 1, -28 },
  { 2213, 13, 37, 12, -3, -28 },
  { 2274, 21, 28, 23, 2, -28 },
  { 2348, 16, 28, 18, 2, -28 },
  { 2404, 29, 28, 33, 2, -28 },
  { 2506, 23, 28, 28, 2, -28 },
  { 2587, 23, 28, 26, 2, -28 },
  { 2668, 18, 28, 22, 2, -28 },
  { 2731, 23, 35, 26, 2, -28 },
  { 2832, 21, 28, 23, 2, -28 },
  { 2906, 17, 28, 19, 1, -28 },
  { 2966, 18, 28, 19, 1, -28 },
  { 3029, 21, 28, 25, 2, -28 },
  { 3103, 23, 28, 23, 0, -28 },
  { 3184, 34, 28, 34, 0, -28 },
  { 3303, 23, 28, 23, 0, -28 },
  { 3384, 22, 28, 22, 0, -28 },
  { 3461, 18, 28, 20, 1, -28 },
  { 3524, 9, 36, 12, 2, -29 },
  { 3565, 17, 28, 17, 0, -28 },
  { 3625, 9, 36, 12, 1, -29 },
  { 3666, 21, 19, 21, 0, -28 },
  { 3716, 20, 4, 20, 0, 3 },
  { 3726, 11, 6, 14, 2, -30 },
  { 3735, 18, 22, 21, 1, -22 },
  { 3785, 18, 30, 22, 2, -30 },
  { 3853, 16, 22, 18, 1, -22 },
  { 3897, 19, 30, 22, 1, -30 },
  { 3969, 18, 22, 20, 1, -22 },
  { 4019, 15, 30, 14, 0, -30 },
  { 4076, 19, 31, 22, 1, -22 },
  { 4150, 18, 30, 22, 2, -30 },
  { 4218, 7, 30, 11, 2, -30 },
  { 4245, 11, 39, 11, -2, -30 },
  { 4299, 20, 30, 22, 2, -30 },
  { 4374, 7, 30, 11, 2, -30 },
  { 4401, 29, 22, 33, 2, -22 },
  { 4481, 18, 22, 22, 2, -22 },
  { 4531, 19, 22, 22, 1, -22 },
  { 4584, 18, 31, 22, 2, -22 },
  { 4654, 19, 31, 22, 1, -22 },
  { 4728, 13, 22, 16, 2, -22 },
  { 4764, 15, 22, 17, 1, -22 },
  { 4806, 14, 26, 15, 0, -26 },
  { 4852, 18, 22, 22, 2, -22 },
  { 4902, 21, 22, 21, 0, -22 },
  { 4960, 30, 22, 31, 0, -22 },
  { 5043, 20, 22, 20, 0, -22 },
  { 5098, 20, 31, 21, 0, -22 },
  { 5176, 15, 22, 17, 1, -22 },
  { 5218, 13, 35, 15, 1, -28 },
  { 5275, 5, 39, 17, 6, -30 },
  { 5300, 13, 35, 15, 1, -28 },
  { 5357, 18, 7, 21, 1, -17 },
};

const GFXfont NotoSans_Condensed_Black39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_BLACK39PT7B_H_
