#ifndef _NOTOSANS_CONDENSED_BLACK50PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x7F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0xFC, 0x0C, 0x00,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xBF, 0xE3, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8,
  0xFF, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0xCF, 0xE1, 0xFE, 0x7F, 0x0F, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x81, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xF7, 0x8F, 0x3F, 0x9E, 0x0C, 0xFE, 0x78,
  0x03, 0xF9, 0xE0, 0x0F, 0xF7, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xE7,
  0xF0, 0x07, 0x9F, 0xE0, 0x1E, 0x7F, 0xE0, 0x79, 0xFF, 0xF1, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0,
  0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xE0,
  0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x7E, 0x07, 0xF0, 0x00, 0xFE,
  0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xE1,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0xFC, 0x00,
  0x07, 0xF1, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x7F, 0x0F, 0xC0, 0xFC,
  0x7E, 0x3F, 0x1F, 0xF8, 0x7F, 0x7F, 0x3F, 0x9F, 0xFE, 0x3F, 0xFF, 0x9F,
  0x8F, 0xFF, 0x8F, 0xFF, 0x9F, 0xCF, 0xFF, 0xC3, 0xFF, 0x8F, 0xC7, 0xFF,
  0xF1, 0xFF, 0x8F, 0xE7, 0xF3, 0xF8, 0x3F, 0x87, 0xE3, 0xF8, 0xFC, 0x00,
  0x03, 0xF1, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x87,
  0xE0, 0x00, 0xFE, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x07, 0xF1, 0xF8, 0x00,
  0x7F, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xFF,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE1, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0x8F, 0xF8,
  0x3F, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0xFF,
  0xC1, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF,
  0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x0C, 0x1F, 0x81, 0x9E, 0x3F, 0x1F, 0x3F, 0xBE, 0xFE, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF,
  0xE0, 0x3F, 0xDF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0x80, 0xF8, 0x3C,
  0x00, 0x70, 0x70, 0x00, 0x40, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x1F,
  0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0x03, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0x87, 0xFB, 0xFE, 0x1F, 0xEF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xDF, 0xE1, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFB, 0xFE, 0x7E, 0x7F, 0xC7, 0x8F, 0xF8, 0x61, 0xFF, 0x08, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xCF, 0xFE, 0x3E, 0x07, 0xFC, 0x38,
  0x0F, 0xF8, 0x20, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x8F, 0x87, 0xFE, 0x30, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xEF, 0xF8, 0x0F, 0xEF, 0xF8, 0x1F,
  0xCF, 0xF8, 0x1F, 0xCF, 0xF8, 0x3F, 0x8F, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F,
  0x0F, 0xF8, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x10, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0xDF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF7,
  0xFE, 0x7F, 0xEF, 0xF8, 0x7F, 0xDF, 0xF0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFB, 0xFE, 0x0F, 0xF7, 0xFC,
  0x3F, 0xE7, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xC3, 0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0x0F, 0xF9,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xFC, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xF3,
  0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xDF, 0xF0, 0xFF, 0xBF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x83, 0xFE,
  0x7F, 0x83, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x83, 0xFE, 0x7F, 0xC3, 0xFF, 0x7F, 0xC7, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFD, 0xFE,
  0x0F, 0xF9, 0xFE, 0x03, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x1F, 0xE7,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x9F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF8, 0xFC, 0x04, 0x00, 0x0F, 0x87,
  0xF8, 0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0xCF, 0xF9, 0xFE, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xCF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xC3, 0xFF, 0x38, 0x0F,
  0xF9, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x0F, 0xFC,
  0x3F, 0x0F, 0xC0, 0xFF, 0xF9, 0xF8, 0x7E, 0x1F, 0xFF, 0xC7, 0xE7, 0xE1,
  0xFF, 0xFE, 0x3F, 0x3F, 0x0F, 0xFF, 0xF1, 0xF9, 0xF8, 0xFE, 0x1F, 0x8F,
  0xDF, 0x87, 0xE0, 0xFC, 0x7E, 0xFC, 0x7F, 0x07, 0xE1, 0xF7, 0xE3, 0xF8,
  0x3F, 0x0F, 0xFF, 0x1F, 0x81, 0xF8, 0x7D, 0xF8, 0xFC, 0x1F, 0xC3, 0xEF,
  0xC7, 0xE0, 0xFE, 0x3F, 0x7E, 0x3F, 0x07, 0xF1, 0xFB, 0xF1, 0xF8, 0x3F,
  0x8F, 0xDF, 0x8F, 0xE1, 0xFC, 0x7E, 0xFC, 0x7F, 0x1F, 0xE7, 0xE7, 0xE1,
  0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0xFB, 0xFF,
  0x07, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00,
  0x7F, 0x80, 0x01, 0xC0, 0x03, 0xFF, 0xC1, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE,
  0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFC, 0x7C, 0x3F, 0xF0, 0x0C, 0x3F, 0xE0, 0x04, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x06, 0x3F, 0xF8, 0x1E, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x06, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFF,
  0xBF, 0xE0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xFB, 0xFE,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xF1, 0xFC, 0x3F,
  0xF8, 0x01, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xFC, 0x03, 0xFD,
  0xFF, 0x80, 0x7F, 0x9F, 0xF8, 0x0F, 0xF3, 0xFF, 0x81, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F,
  0xC0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFE,
  0x3F, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F,
  0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F,
  0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0x83,
  0xFF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xFF, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF,
  0x7F, 0x8F, 0xEF, 0xFF, 0xF9, 0xFC, 0x7F, 0x7F, 0xFF, 0xCF, 0xE3, 0xF3,
  0xFF, 0xFE, 0x7F, 0x3F, 0x9F, 0xFF, 0xF3, 0xFD, 0xFC, 0xFF, 0xFF, 0x8F,
  0xEF, 0xE7, 0xFF, 0xFC, 0x7F, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFD,
  0xFE, 0x1F, 0xFF, 0xEF, 0xF8, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0xF9, 0xFF,
  0x3F, 0xFF, 0xC7, 0xF9, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xF0, 0xFF, 0x7F,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x01, 0xFF,
  0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03,
  0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xC7,
  0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xE7,
  0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFC,
  0xFF, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x87, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF,
  0x81, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0x80,
  0xE7, 0xFC, 0x01, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0x9F,
  0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01,
  0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0xF8,
  0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0xF8, 0xFF,
  0x00, 0xFF, 0x1F, 0x9F, 0x8F, 0xF0, 0x0F, 0xF3, 0xF9, 0xF8, 0xFF, 0x00,
  0xFF, 0x3F, 0x9F, 0x9F, 0xF0, 0x0F, 0xF3, 0xF9, 0xFD, 0xFF, 0x00, 0x7F,
  0xBF, 0x9F, 0xDF, 0xE0, 0x07, 0xFB, 0xF9, 0xFD, 0xFE, 0x00, 0x7F, 0xBF,
  0x0F, 0xDF, 0xE0, 0x07, 0xFF, 0xF0, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x0F,
  0xDF, 0xE0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF,
  0x3F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x1F,
  0xFB, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF,
  0x9F, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xE3,
  0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFB, 0xFF, 0x83, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xEF, 0xF8, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xF9, 0xFC, 0x7F,
  0xE3, 0xF8, 0x7F, 0x83, 0xF0, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0x07, 0xF9, 0xFF, 0x0F, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0xFB,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x8F, 0xE7, 0xFE, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFE, 0x1C, 0xFF, 0xC0, 0x4F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x02, 0xFF, 0xC0, 0x67, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0x87, 0xF8, 0x7F, 0xCF,
  0xF1, 0xFF, 0xDF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xF1, 0xFF, 0xCF,
  0xE0, 0xFE, 0x1F, 0xC0, 0x20, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x03, 0xFB,
  0xFC, 0x07, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x8F, 0xFC, 0x0F, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0xFE,
  0x1F, 0xF1, 0xFC, 0x7F, 0xF7, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFB, 0xFC,
  0x7F, 0xE7, 0xF8, 0x3F, 0x8F, 0xF0, 0x08, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xB0, 0x01, 0xFF, 0x7C, 0x0F, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x07,
  0xF9, 0xFF, 0x8F, 0xF7, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0x3C, 0x7F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x38, 0x00, 0x00, 0x1F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFC, 0x01, 0xE0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0x7F, 0x80, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xA7, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xF0, 0x3F,
  0xE7, 0xF8, 0x1F, 0xF3, 0xFC, 0x1F, 0xF1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xF7,
  0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFD, 0xFF, 0x07, 0xFC, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8,
  0xFF, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0, 0x3F,
  0xEF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0,
  0x7F, 0x07, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0x9F, 0xFE, 0x7F, 0xF9, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0x87,
  0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF,
  0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF,
  0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0x81,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF,
  0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F,
  0xE3, 0xF9, 0xFF, 0xE7, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xC3, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F,
  0xC3, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFE, 0xFF, 0xE3, 0xFC, 0xFF,
  0x87, 0xF8, 0xFE, 0x0F, 0xF0, 0x20, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xF1, 0xFC, 0x7F, 0xF7, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xE3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFB, 0xFC, 0x7F, 0xE7, 0xF8, 0x3F, 0x8F, 0xF0, 0x08,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xEF, 0xEF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xF3, 0xE7, 0xFC, 0x0C, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF6, 0x01, 0xFE, 0xFE,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x47, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xF9, 0xFC, 0xFF, 0xE3,
  0xF8, 0x7F, 0x87, 0xF0, 0x10, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xF7, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F,
  0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE1, 0xFF,
  0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3,
  0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xFF, 0x03, 0xFD,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xFC, 0x1F, 0xE7, 0xFC, 0x3F,
  0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xF0, 0xFF,
  0x1F, 0xE3, 0xFF, 0xE3, 0xFC, 0x3F, 0xC7, 0xEF, 0xC7, 0xF8, 0x7F, 0x8F,
  0xDF, 0x8F, 0xF0, 0x7F, 0x9F, 0xBF, 0x1F, 0xE0, 0xFF, 0x3F, 0x7F, 0x3F,
  0xC1, 0xFE, 0x7E, 0xFE, 0xFF, 0x03, 0xFD, 0xFD, 0xFD, 0xFE, 0x03, 0xFB,
  0xF9, 0xFB, 0xFC, 0x07, 0xF7, 0xE3, 0xF7, 0xF8, 0x0F, 0xEF, 0xC7, 0xEF,
  0xE0, 0x1F, 0xDF, 0x8F, 0xDF, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0,
  0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF3, 0xFE, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0x8F,
  0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0x7F, 0xE7, 0xFC, 0x0F, 0xFB, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD,
  0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFF,
  0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x23, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x80, 0x07, 0xF0,
};

const GFXglyph NotoSans_Condensed_Black50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 37, 14, 2, -36 },
  { 48, 21, 13, 25, 2, -36 },
  { 83, 27, 36, 29, 1, -36 },
  { 205, 22, 41, 26, 2, -38 },
  { 318, 41, 36, 44, 1, -36 },
  { 503, 34, 37, 35, 1, -36 },
  { 661, 9, 13, 13, 2, -36 },
  { 676, 14, 45, 17, 2, -37 },
  { 755, 15, 45, 17, 0, -37 },
  { 840, 23, 23, 25, 1, -38 },
  { 907, 22, 24, 26, 2, -30 },
  { 973, 11, 14, 14, 1, -7 },
  { 993, 14, 7, 16, 1, -17 },
  { 1006, 10, 10, 14, 2, -9 },
  { 1019, 21, 37, 22, 0, -36 },
  { 1117, 22, 37, 26, 2, -36 },
  { 1219, 19, 36, 26, 2, -36 },
  { 1305, 23, 36, 26, 1, -36 },
  { 1409, 22, 37, 26, 2, -36 },
  { 1511, 24, 36, 26, 1, -36 },
  { 1619, 22, 37, 26, 2, -36 },
  { 1721, 23, 37, 26, 2, -36 },
  { 1828, 22, 36, 26, 2, -36 },
  { 1927, 23, 37, 26, 2, -36 },
  { 2034, 24, 37, 26, 1, -36 },
  { 2145, 10, 29, 14, 2, -28 },
  { 2182, 11, 35, 14, 1, -28 },
  { 2231, 22, 26, 26, 2, -31 },
  { 2303, 22, 17, 26, 2, -26 },
  { 2350, 23, 26, 26, 2, -31 },
  { 2425, 21, 37, 22, 0, -36 },
  { 2523, 37, 40, 40, 2, -36 },
  { 2708, 31, 36, 31, 0, -36 },
  { 2848, 24, 36, 30, 3, -36 },
  { 2956, 24, 37, 28, 2, -36 },
  { 3067, 26, 36, 32, 3, -36 },
  { 3184, 19, 36, 24, 3, -36 },
  { 3270, 19, 36, 23, 3, -36 },
  { 3356, 27, 37, 32, 2, -36 },
  { 3481, 27, 36, 33, 3, -36 },
  { 3603, 17, 36, 19, 1, -36 },
  { 3680, 15, 47, 15, -3, -36 },
  { 3769, 27, 36, 30, 3, -36 },
  { 3891, 20, 36, 24, 3, -36 },
  { 3981, 37, 36, 43, 3, -36 },
  { 4148, 29, 36, 35, 3, -36 },
  { 4279, 30, 37, 34, 2, -36 },
  { 4418, 23, 36, 28, 3, -36 },
  { 4522, 30, 45, 34, 2, -36 },
  { 4691, 27, 36, 29, 3, -36 },
  { 4813, 21, 37, 25, 2, -36 },
  { 4911, 23, 36, 25, 1, -36 },
  { 5015, 26, 37, 32, 3, -36 },
  { 5136, 30, 36, 30, 0, -36 },
  { 5271, 44, 36, 44, 0, -36 },
  { 5469, 29, 36, 29, 0, -36 },
  { 5600, 28, 36, 28, 0, -36 },
  { 5726, 24, 36, 26, 1, -36 },
  { 5834, 13, 45, 15, 2, -37 },
  { 5908, 21, 37, 22, 0, -36 },
  { 6006, 12, 45, 15, 1, -37 },
  { 6074, 27, 24, 27, 0, -36 },
  { 6155, 25, 6, 25, 0, 3 },
  { 6174, 14, 8, 18, 2, -38 },
  { 6188, 23, 29, 27, 1, -28 },
  { 6272, 23, 39, 28, 3, -38 },
  { 6385, 20, 29, 23, 2, -28 },
  { 6458, 23, 39, 28, 2, -38 },
  { 6571, 23, 29, 26, 2, -28 },
  { 6655, 18, 38, 18, 1, -38 },
  { 6741, 23, 40, 28, 2, -28 },
  { 6856, 23, 38, 29, 3, -38 },
  { 6966, 9, 39, 14, 3, -39 },
  { 7010, 14, 51, 14, -2, -39 },
  { 7100, 25, 38, 28, 3, -38 },
  { 7219, 8, 38, 14, 3, -38 },
  { 7257, 37, 28, 43, 3, -28 },
  { 7387, 23, 28, 29, 3, -28 },
  { 7468, 24, 29, 28, 2, -28 },
  { 7555, 23, 40, 28, 3, -28 },
  { 7670, 23, 40, 28, 2, -28 },
  { 7785, 17, 28, 20, 3, -28 },
  { 7845, 19, 29, 22, 1, -28 },
  { 7914, 17, 34, 19, 1, -33 },
  { 7987, 23, 29, 29, 3, -28 },
  { 8071, 26, 28, 26, 0, -28 },
  { 8162, 39, 28, 39, 0, -28 },
  { 8299, 26, 28, 26, 0, -28 },
  { 8390, 26, 40, 26, 0, -28 },
  { 8520, 20, 28, 22, 1, -28 },
  { 8590, 17, 44, 19, 1, -36 },
  { 8684, 7, 49, 22, 8, -38 },
  { 8727, 17, 44, 19, 1, -36 },
  { 8821, 23, 9, 26, 2, -22 },
};

const GFXfont NotoSans_Condensed_Black50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_BLACK50PT7B_H_
