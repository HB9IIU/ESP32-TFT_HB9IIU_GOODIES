#ifndef _NOTOSANS_CONDENSED_BLACK20PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEE, 0xEE, 0xE0, 0x4E, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0x0C, 0xC1, 0xB8, 0x77, 0x0E, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xDC,
  0xFF, 0xFF, 0xFC, 0xEC, 0x19, 0x83, 0x30, 0x6E, 0x00, 0x18, 0x1F, 0x1F,
  0xDF, 0xEF, 0x97, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F, 0xC6, 0xFB, 0xEF, 0xF7,
  0xF0, 0x60, 0x30, 0x7C, 0x38, 0x3F, 0x18, 0x1B, 0x9C, 0x1D, 0xCC, 0x0E,
  0xEE, 0x03, 0x77, 0x71, 0xFB, 0x7C, 0x7B, 0xBF, 0x01, 0xBB, 0x81, 0xDD,
  0xC0, 0xCE, 0xE0, 0xE3, 0x70, 0x61, 0xF0, 0x70, 0x78, 0x3F, 0x03, 0xF8,
  0x1C, 0xE0, 0xEF, 0x07, 0xF0, 0x1F, 0x81, 0xF9, 0xDF, 0xDE, 0xEF, 0xF7,
  0x3F, 0x38, 0xF9, 0xFF, 0xCF, 0xFF, 0x3F, 0x7C, 0xFF, 0xFE, 0x3C, 0xE7,
  0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xC7, 0x1C, 0x78, 0xF0,
  0xE1, 0xC7, 0x8E, 0x38, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0xE3, 0x8E,
  0x73, 0xC0, 0x1C, 0x03, 0x06, 0xD9, 0xFE, 0xFF, 0xC7, 0x83, 0xF1, 0xCE,
  0x12, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C,
  0x0E, 0x00, 0xFF, 0xEE, 0xEC, 0xFF, 0xFE, 0x4F, 0xFE, 0x07, 0x83, 0x83,
  0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07,
  0x00, 0x7E, 0x3F, 0xBF, 0xDC, 0xEE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xDF, 0xE7, 0xF1, 0xF0, 0x1E, 0x7D, 0xFF, 0xFE, 0xED, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x3F, 0x7F, 0xDF, 0xE4, 0x70, 0x38,
  0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0xF7, 0xFB, 0xFC, 0xFE, 0x7F,
  0x9B, 0xC0, 0xE0, 0x73, 0xF1, 0xF0, 0xFE, 0x0F, 0x03, 0xE1, 0xFF, 0xEF,
  0xF7, 0xF0, 0x07, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x8F, 0xE7, 0x79, 0xDE,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x7F, 0x3F, 0xBF, 0xDE,
  0x0E, 0x07, 0xF3, 0xFC, 0xFE, 0x07, 0x83, 0xE1, 0xDF, 0xEF, 0xF7, 0xF0,
  0x3F, 0x3F, 0x9E, 0x5E, 0x0E, 0x47, 0xFB, 0xFD, 0xEF, 0xE7, 0xF3, 0xF9,
  0xFF, 0xE7, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xF0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0xC0, 0x7E, 0x7F, 0xBD, 0xDC,
  0xEF, 0x73, 0xF8, 0xF0, 0xFE, 0xF7, 0x73, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0,
  0x7E, 0x7F, 0xBF, 0xDC, 0xFE, 0x7F, 0x3F, 0xFF, 0xFF, 0x7B, 0x83, 0x81,
  0xDF, 0xEF, 0xE7, 0xE0, 0xEF, 0xF4, 0x00, 0x04, 0xFF, 0xE0, 0xEF, 0xF4,
  0x00, 0x00, 0xFF, 0xEE, 0xEC, 0x01, 0x83, 0xC7, 0xEF, 0xCF, 0x07, 0xC1,
  0xFC, 0x1F, 0x03, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x78, 0x3F, 0x07, 0xE0, 0xF8, 0xFD, 0xF9, 0xF0, 0xE0,
  0x40, 0x00, 0x7E, 0xFF, 0x6F, 0x07, 0x07, 0x1F, 0x1E, 0x3C, 0x38, 0x00,
  0x10, 0x3C, 0x3C, 0x38, 0x0F, 0xE0, 0xFF, 0xE7, 0x03, 0x98, 0xF7, 0xEF,
  0xEF, 0x3B, 0xBD, 0xCE, 0xF7, 0x33, 0xDC, 0xCF, 0x37, 0xFE, 0xFF, 0xB9,
  0xCC, 0x70, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x40, 0x0F, 0x81, 0xF8, 0x1F,
  0x81, 0xFC, 0x1D, 0xC3, 0xDC, 0x39, 0xC3, 0x9E, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE7, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0x3F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFF,
  0xEF, 0xF3, 0xFE, 0xF3, 0xFC, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F,
  0xBF, 0xDF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x2F,
  0xF7, 0xF8, 0xFC, 0xFF, 0x1F, 0xF3, 0xFF, 0x79, 0xEF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3B, 0xCF, 0x7F, 0xCF, 0xF9, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xFE, 0xFE, 0xFE, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFE, 0xFE, 0xFE, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x1F, 0xC7, 0xF9, 0xFF, 0x78, 0x0F, 0x01, 0xE0, 0x3D,
  0xFF, 0xBF, 0xF7, 0xFE, 0x3F, 0xC7, 0xBF, 0xF3, 0xFE, 0x3F, 0x80, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0xFF, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0xFF, 0xF0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFB, 0xC0, 0xF1, 0xFE, 0x7B, 0xCE,
  0x7B, 0xCF, 0xF1, 0xFE, 0x3F, 0x87, 0xF8, 0xFF, 0x1E, 0xF3, 0xCE, 0x79,
  0xEF, 0x3D, 0xE3, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xE3, 0xFE, 0xC6, 0xFD, 0xDD, 0xFF, 0xBF, 0xFF, 0x7F, 0xF6, 0xDF, 0xEF,
  0xBF, 0xDF, 0x7F, 0xBE, 0xFF, 0x39, 0xFE, 0x73, 0xC0, 0xF8, 0x7F, 0x87,
  0xFC, 0x7F, 0xC7, 0xFE, 0x7E, 0xE7, 0xEF, 0x7F, 0x77, 0xF7, 0xFF, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0x04, 0x03, 0xF8, 0x7F, 0xC7, 0xFE,
  0xF1, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x1E,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x04, 0x03, 0xF8,
  0x7F, 0xC7, 0xFE, 0xF1, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xEF, 0x1E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x3C, 0x03, 0xC0, 0x1F,
  0xFF, 0x1F, 0xF3, 0xFE, 0x79, 0xEF, 0x3D, 0xE7, 0x3F, 0xE7, 0xF8, 0xFF,
  0x1E, 0xE3, 0xDE, 0x79, 0xCF, 0x3D, 0xE3, 0xC0, 0x7F, 0xFF, 0xFF, 0xE1,
  0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x07, 0x87, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0x3F, 0xE7, 0xFC, 0x7E, 0x00,
  0xF0, 0xFF, 0x0F, 0x70, 0xE7, 0x9E, 0x79, 0xE3, 0x9C, 0x39, 0xC3, 0xFC,
  0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0xF1, 0xC3, 0xF8,
  0xF1, 0xDC, 0x79, 0xEE, 0x3C, 0xF7, 0x3E, 0x7B, 0xDF, 0x39, 0xEF, 0xDC,
  0x76, 0xEE, 0x3B, 0x7F, 0x1F, 0x9F, 0x0F, 0xCF, 0x83, 0xE7, 0xC1, 0xE3,
  0xE0, 0xF1, 0xF0, 0xF1, 0xE7, 0x9C, 0x3B, 0xC3, 0xF8, 0x1F, 0x81, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xF8, 0x3B, 0xC7, 0x9C, 0x79, 0xEF, 0x1F,
  0xF1, 0xEE, 0x3D, 0xE7, 0x1D, 0xE3, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xDF, 0xF7, 0xF8,
  0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xFF, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xC0, 0x0C, 0x01, 0xC0, 0x78, 0x0F, 0x83,
  0xB0, 0x77, 0x1C, 0x63, 0x8E, 0xE1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3,
  0xC6, 0x7E, 0x3F, 0x99, 0xC0, 0xF7, 0xFF, 0xFF, 0x9F, 0xCF, 0xEF, 0xFF,
  0xDE, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0xF7, 0xFF, 0xFF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0xFF, 0xFF, 0xBC, 0x3F, 0x7E, 0xFE, 0xF0, 0xE0,
  0xE0, 0xE0, 0xF1, 0xFF, 0x7F, 0x3E, 0x03, 0x81, 0xC0, 0xE0, 0x77, 0xBF,
  0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFB, 0xFD, 0xEE, 0x3E,
  0x3F, 0xBD, 0xDC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0x3F, 0x8F, 0xC0,
  0x3E, 0x7C, 0xE9, 0xC7, 0xFF, 0xFF, 0x9C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x00, 0x7B, 0xBF, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF,
  0xBF, 0xDE, 0xE0, 0x78, 0x7F, 0xFB, 0xFC, 0xF8, 0xF0, 0x78, 0x38, 0x1C,
  0x0E, 0xF7, 0xFF, 0xFF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCE, 0x4F, 0xF6, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0xF3, 0xC6,
  0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xEF, 0xBE,
  0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF3, 0xFD, 0xEF, 0x73, 0xBC, 0xEE,
  0x3F, 0x8F, 0xF3, 0xDC, 0xF7, 0xBC, 0xFF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0xFF,
  0x38, 0xFE, 0x71, 0xFC, 0xE3, 0xF9, 0xC7, 0xF3, 0x8F, 0xE7, 0x1F, 0xCE,
  0x38, 0xEF, 0x7F, 0xFF, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xE0, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF,
  0xBF, 0x8F, 0x80, 0xEF, 0x7F, 0xFF, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xFF, 0xFF, 0xFB, 0xDC, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x7B, 0xBF, 0xFF,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xBF, 0xDE, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0xEF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC0, 0x7F, 0xFF, 0x97, 0x0F, 0x8F, 0x8F, 0x87, 0xFF, 0xFF, 0xF0, 0x38,
  0x71, 0xFF, 0xFF, 0xEF, 0x1E, 0x3C, 0x78, 0xF0, 0xF9, 0xF3, 0xE0, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xE7, 0xFF, 0xBF, 0xDE, 0x60,
  0xF1, 0xEE, 0x39, 0xCF, 0x39, 0xC7, 0xB8, 0x77, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x00, 0xF3, 0xCF, 0xF3, 0xCE, 0x77, 0xCE, 0x77, 0xCE,
  0x77, 0xFE, 0x76, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78,
  0x1E, 0x78, 0xF3, 0xDE, 0xE3, 0xF8, 0xFC, 0x1F, 0x07, 0xC3, 0xF0, 0xFE,
  0x7F, 0x9C, 0xFF, 0x3C, 0xF1, 0xEE, 0x39, 0xCF, 0x3D, 0xC3, 0xB8, 0x77,
  0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0xF8, 0x1E,
  0x03, 0x80, 0x7F, 0x7F, 0x7F, 0x0E, 0x1E, 0x3C, 0x38, 0x78, 0x7F, 0xFF,
  0xFF, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8F, 0x7C, 0xF1, 0xF0, 0xF1, 0xE3,
  0xC7, 0x87, 0x0F, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF9, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x0F, 0x0E, 0x7C, 0xF1, 0xC3, 0x87,
  0x0E, 0x7C, 0xF0, 0xF0, 0xFF, 0xFF, 0xF0, 0xE0,
};

const GFXglyph NotoSans_Condensed_Black20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 6, 1, -14 },
  { 8, 8, 5, 10, 1, -14 },
  { 13, 11, 14, 12, 0, -14 },
  { 33, 9, 16, 10, 1, -15 },
  { 51, 17, 14, 17, 0, -14 },
  { 81, 13, 14, 14, 1, -14 },
  { 104, 3, 5, 5, 1, -14 },
  { 106, 6, 18, 7, 1, -15 },
  { 120, 6, 18, 7, 0, -15 },
  { 134, 10, 9, 10, 0, -15 },
  { 146, 9, 10, 11, 1, -12 },
  { 158, 4, 6, 6, 1, -3 },
  { 161, 5, 3, 6, 1, -7 },
  { 163, 4, 4, 6, 1, -4 },
  { 165, 9, 14, 9, 0, -14 },
  { 181, 9, 14, 10, 1, -14 },
  { 197, 7, 14, 10, 1, -14 },
  { 210, 9, 14, 10, 0, -14 },
  { 226, 9, 14, 10, 1, -14 },
  { 242, 10, 14, 10, 0, -14 },
  { 260, 9, 14, 10, 1, -14 },
  { 276, 9, 14, 10, 1, -14 },
  { 292, 9, 14, 10, 1, -14 },
  { 308, 9, 14, 10, 1, -14 },
  { 324, 9, 14, 10, 1, -14 },
  { 340, 4, 11, 6, 1, -11 },
  { 346, 4, 14, 6, 1, -11 },
  { 353, 9, 10, 11, 1, -12 },
  { 365, 9, 8, 11, 1, -11 },
  { 374, 9, 10, 11, 1, -12 },
  { 386, 8, 14, 9, 0, -14 },
  { 400, 14, 16, 16, 1, -14 },
  { 428, 12, 14, 12, 0, -14 },
  { 449, 10, 14, 12, 1, -14 },
  { 467, 9, 14, 11, 1, -14 },
  { 483, 11, 14, 13, 1, -14 },
  { 503, 8, 14, 10, 1, -14 },
  { 517, 8, 14, 9, 1, -14 },
  { 531, 11, 14, 13, 1, -14 },
  { 551, 11, 14, 13, 1, -14 },
  { 571, 6, 14, 8, 1, -14 },
  { 582, 6, 18, 6, -1, -14 },
  { 596, 11, 14, 12, 1, -14 },
  { 616, 8, 14, 9, 1, -14 },
  { 630, 15, 14, 17, 1, -14 },
  { 657, 12, 14, 14, 1, -14 },
  { 678, 12, 15, 13, 1, -15 },
  { 701, 9, 14, 11, 1, -14 },
  { 717, 12, 18, 13, 1, -15 },
  { 744, 11, 14, 12, 1, -14 },
  { 764, 8, 14, 10, 1, -14 },
  { 778, 10, 14, 10, 0, -14 },
  { 796, 11, 14, 13, 1, -14 },
  { 816, 12, 14, 12, 0, -14 },
  { 837, 17, 14, 18, 0, -14 },
  { 867, 12, 14, 12, 0, -14 },
  { 888, 11, 14, 11, 0, -14 },
  { 908, 10, 14, 10, 0, -14 },
  { 926, 5, 18, 6, 1, -15 },
  { 938, 9, 14, 9, 0, -14 },
  { 954, 5, 18, 6, 0, -15 },
  { 966, 11, 9, 11, 0, -14 },
  { 979, 10, 3, 10, 0, 1 },
  { 983, 5, 3, 7, 1, -15 },
  { 985, 9, 11, 11, 1, -11 },
  { 998, 9, 15, 11, 1, -15 },
  { 1015, 8, 11, 9, 1, -11 },
  { 1026, 9, 15, 11, 1, -15 },
  { 1043, 9, 11, 10, 1, -11 },
  { 1056, 7, 15, 7, 0, -15 },
  { 1070, 9, 16, 11, 1, -11 },
  { 1088, 9, 15, 11, 1, -15 },
  { 1105, 4, 16, 6, 1, -16 },
  { 1113, 6, 21, 6, -1, -16 },
  { 1129, 10, 15, 11, 1, -15 },
  { 1148, 4, 15, 6, 1, -15 },
  { 1156, 15, 11, 17, 1, -11 },
  { 1177, 9, 11, 11, 1, -11 },
  { 1190, 9, 11, 11, 1, -11 },
  { 1203, 9, 16, 11, 1, -11 },
  { 1221, 9, 16, 11, 1, -11 },
  { 1239, 7, 11, 8, 1, -11 },
  { 1249, 7, 11, 9, 1, -11 },
  { 1259, 7, 13, 8, 0, -13 },
  { 1271, 9, 11, 11, 1, -11 },
  { 1284, 11, 11, 11, 0, -11 },
  { 1300, 16, 11, 16, 0, -11 },
  { 1322, 10, 11, 10, 0, -11 },
  { 1336, 11, 16, 11, 0, -11 },
  { 1358, 8, 11, 9, 0, -11 },
  { 1369, 7, 17, 8, 0, -14 },
  { 1384, 3, 20, 9, 3, -15 },
  { 1392, 7, 17, 8, 0, -14 },
  { 1407, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_Black20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_BLACK20PT7B_H_
