#ifndef _NOTOSANS_CONDENSED_BLACK9PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x70, 0xF5, 0x3F, 0xD5, 0xF5, 0x38, 0x27, 0xE6, 0x3F, 0x62,
  0x40, 0xEC, 0xA8, 0xFE, 0x57, 0x17, 0x26, 0x21, 0xC5, 0x1F, 0xFF, 0x67,
  0xC0, 0xD0, 0x69, 0x6D, 0x93, 0xC9, 0x36, 0xD6, 0x2F, 0x6F, 0x2F, 0x22,
  0x70, 0xE0, 0x70, 0x12, 0x26, 0x44, 0xC0, 0x27, 0xDD, 0xD5, 0x70, 0x7F,
  0x33, 0x33, 0x2F, 0x93, 0x64, 0xF0, 0x2F, 0x16, 0x39, 0xF0, 0x33, 0x9D,
  0xFF, 0x98, 0x74, 0x71, 0x9F, 0x17, 0xCF, 0xDD, 0x70, 0xF1, 0x32, 0x66,
  0x27, 0xD6, 0xFD, 0x70, 0x27, 0xDD, 0x73, 0x60, 0xD1, 0xC0, 0xD0, 0x70,
  0x13, 0xE7, 0x10, 0xF0, 0xF0, 0x8E, 0x37, 0xC0, 0x4F, 0x36, 0x44, 0x60,
  0x10, 0xD9, 0x6D, 0x5A, 0xBF, 0x91, 0x1C, 0x71, 0xC5, 0x9E, 0xFB, 0x30,
  0xFB, 0xEB, 0xBE, 0x13, 0xD1, 0x8C, 0x35, 0xC0, 0xFB, 0x99, 0xBE, 0xF3,
  0xC9, 0xC0, 0xF3, 0xF9, 0x00, 0x13, 0xD1, 0xBD, 0xB5, 0xE0, 0x99, 0xF9,
  0x99, 0xED, 0xB7, 0xC0, 0x24, 0x92, 0x5F, 0xBA, 0xEE, 0xBB, 0x92, 0x49,
  0xC0, 0xCF, 0x7F, 0x6D, 0xB6, 0xD0, 0xDE, 0xFF, 0x7B, 0xCC, 0x11, 0xE4,
  0xF3, 0xCD, 0x27, 0x80, 0xEB, 0xBE, 0x88, 0x11, 0xE4, 0xF3, 0xCD, 0x27,
  0x86, 0x0C, 0xFB, 0xFE, 0xBB, 0x27, 0xC6, 0x3B, 0xF0, 0xF6, 0x66, 0x66,
  0x99, 0x99, 0xBF, 0xDA, 0xD6, 0xE7, 0x18, 0xDB, 0xDA, 0x5A, 0x7A, 0x7E,
  0x66, 0xDB, 0x8C, 0xE5, 0x6C, 0xDA, 0x9C, 0x42, 0x10, 0xF3, 0x26, 0xCF,
  0xFF, 0x6D, 0xB7, 0xE0, 0x8C, 0x46, 0x22, 0x30, 0xF5, 0x57, 0xC0, 0x23,
  0x95, 0x30, 0xF8, 0xC4, 0x71, 0x7D, 0x70, 0xC6, 0x3D, 0xBD, 0xEF, 0xC0,
  0x7D, 0xCD, 0x70, 0x18, 0xDF, 0xBD, 0xED, 0xE0, 0x7D, 0xFC, 0x70, 0x6B,
  0xA4, 0x90, 0x7E, 0xF7, 0xB7, 0xC9, 0xC0, 0xC6, 0x3D, 0xBD, 0xEF, 0x60,
  0xDF, 0xFC, 0xDF, 0xFF, 0xC0, 0xC6, 0x37, 0xEF, 0x6B, 0x60, 0xFF, 0xFC,
  0xF7, 0xB7, 0x6E, 0xDD, 0xA0, 0xF6, 0xF7, 0xBD, 0x80, 0x76, 0xF7, 0xB7,
  0x00, 0xF6, 0xF7, 0xBF, 0x63, 0x00, 0x7E, 0xF7, 0xB7, 0x8C, 0x60, 0xFE,
  0xCC, 0xC0, 0x7C, 0x6B, 0xE0, 0x5D, 0x24, 0xC0, 0xDE, 0xF7, 0xB7, 0x80,
  0xDE, 0x94, 0xE6, 0x00, 0xDF, 0xFD, 0xB3, 0x66, 0xC0, 0xDB, 0x98, 0xED,
  0x80, 0xDA, 0x94, 0xE2, 0x33, 0x80, 0xF2, 0x64, 0xF0, 0x2D, 0xBC, 0xDB,
  0x20, 0xFF, 0xFF, 0xC0, 0x99, 0x22, 0x96, 0x80, 0xFB,
};

const GFXglyph NotoSans_Condensed_Black9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 3, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 0, -7 },
  { 12, 8, 7, 8, 0, -7 },
  { 19, 6, 7, 6, 0, -7 },
  { 25, 2, 2, 2, 0, -6 },
  { 26, 3, 8, 3, 0, -7 },
  { 29, 3, 8, 3, 0, -7 },
  { 32, 4, 4, 4, 0, -7 },
  { 34, 4, 4, 5, 0, -5 },
  { 36, 2, 2, 3, 0, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 2, 2, 3, 0, -2 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 4, 7, 5, 0, -7 },
  { 47, 4, 6, 5, 0, -6 },
  { 50, 4, 7, 5, 0, -7 },
  { 54, 4, 7, 5, 0, -7 },
  { 58, 5, 6, 5, 0, -6 },
  { 62, 4, 6, 5, 0, -6 },
  { 65, 4, 7, 5, 0, -7 },
  { 69, 4, 6, 5, 0, -6 },
  { 72, 4, 7, 5, 0, -7 },
  { 76, 4, 7, 5, 0, -7 },
  { 80, 2, 5, 3, 0, -5 },
  { 82, 2, 6, 3, 0, -5 },
  { 84, 4, 5, 5, 0, -6 },
  { 87, 4, 3, 5, 0, -5 },
  { 89, 4, 5, 5, 0, -6 },
  { 92, 4, 7, 4, 0, -7 },
  { 96, 7, 8, 7, 0, -7 },
  { 103, 6, 6, 6, 0, -6 },
  { 108, 4, 6, 5, 1, -6 },
  { 111, 5, 7, 5, 0, -7 },
  { 116, 4, 6, 6, 1, -6 },
  { 119, 3, 6, 4, 1, -6 },
  { 122, 3, 6, 4, 1, -6 },
  { 125, 5, 7, 6, 0, -7 },
  { 130, 4, 6, 6, 1, -6 },
  { 133, 3, 6, 3, 0, -6 },
  { 136, 3, 8, 3, -1, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 3, 6, 4, 1, -6 },
  { 145, 6, 6, 8, 1, -6 },
  { 150, 5, 6, 6, 1, -6 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 4, 6, 5, 1, -6 },
  { 163, 6, 9, 6, 0, -7 },
  { 170, 4, 6, 5, 1, -6 },
  { 173, 4, 7, 4, 0, -7 },
  { 177, 4, 6, 4, 0, -6 },
  { 180, 4, 6, 6, 1, -6 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 8, 6, 8, 0, -6 },
  { 193, 5, 6, 5, 0, -6 },
  { 197, 5, 6, 5, 0, -6 },
  { 201, 4, 6, 5, 0, -6 },
  { 204, 3, 9, 3, 0, -7 },
  { 208, 4, 7, 4, 0, -7 },
  { 212, 2, 9, 3, 0, -7 },
  { 215, 5, 4, 5, 0, -6 },
  { 218, 5, 1, 5, 0, 1 },
  { 219, 3, 2, 3, 0, -7 },
  { 220, 4, 5, 5, 0, -5 },
  { 223, 5, 7, 5, 0, -7 },
  { 228, 4, 5, 4, 0, -5 },
  { 231, 5, 7, 5, 0, -7 },
  { 236, 4, 5, 5, 0, -5 },
  { 239, 3, 7, 3, 0, -7 },
  { 242, 5, 7, 5, 0, -5 },
  { 247, 5, 7, 5, 0, -7 },
  { 252, 2, 7, 3, 0, -7 },
  { 254, 2, 9, 3, 0, -7 },
  { 257, 5, 7, 5, 0, -7 },
  { 262, 2, 7, 3, 0, -7 },
  { 264, 7, 5, 8, 0, -5 },
  { 269, 5, 5, 5, 0, -5 },
  { 273, 5, 5, 5, 0, -5 },
  { 277, 5, 7, 5, 0, -5 },
  { 282, 5, 7, 5, 0, -5 },
  { 287, 4, 5, 4, 0, -5 },
  { 290, 4, 5, 4, 0, -5 },
  { 293, 3, 6, 3, 0, -6 },
  { 296, 5, 5, 5, 0, -5 },
  { 300, 5, 5, 5, 0, -5 },
  { 304, 7, 5, 7, 0, -5 },
  { 309, 5, 5, 5, 0, -5 },
  { 313, 5, 7, 5, 0, -5 },
  { 318, 4, 5, 4, 0, -5 },
  { 321, 3, 9, 3, 0, -7 },
  { 325, 2, 9, 4, 1, -7 },
  { 328, 3, 9, 3, 0, -7 },
  { 332, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Black9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_BLACK9PT7B_H_
