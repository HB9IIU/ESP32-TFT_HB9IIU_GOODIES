#ifndef _NOTOSANS_CONDENSED_BLACK14PT7B_H_
#define _NOTOSANS_CONDENSED_BLACK14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Black.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Black14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF0, 0xF0, 0xDE, 0xF7, 0xB0, 0x16, 0x36, 0x36, 0x7F, 0x34,
  0x3C, 0xFF, 0x2C, 0x6C, 0x6C, 0x21, 0xCF, 0xFA, 0xE3, 0xC3, 0x8B, 0xAF,
  0xE6, 0x08, 0x71, 0x85, 0x98, 0xDB, 0x0D, 0xB0, 0x5E, 0xE7, 0x7B, 0x05,
  0xB0, 0xDB, 0x09, 0xB1, 0x8E, 0x3C, 0x1F, 0x86, 0x61, 0xF0, 0x3D, 0x9F,
  0xEE, 0xFB, 0x9C, 0x7F, 0x1F, 0xF0, 0xFF, 0x7E, 0xCC, 0xCC, 0xCC, 0xCC,
  0xE7, 0xE6, 0x73, 0x33, 0x33, 0x37, 0x6E, 0x38, 0x23, 0xF7, 0xF3, 0x8D,
  0x8A, 0x00, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C,
  0x61, 0x86, 0x30, 0xC7, 0x18, 0x63, 0x00, 0x38, 0xF9, 0xBB, 0x7E, 0xFD,
  0xDB, 0xB7, 0x7C, 0x78, 0x3B, 0xFF, 0xFB, 0x9C, 0xE7, 0x39, 0xC0, 0x79,
  0xF9, 0x30, 0x61, 0xC3, 0x0E, 0x38, 0xFF, 0xFC, 0xFC, 0xF9, 0x30, 0x63,
  0x87, 0x83, 0xC7, 0xFD, 0xF8, 0x0C, 0x38, 0xF1, 0xE6, 0xCD, 0xBF, 0xFF,
  0x0C, 0x18, 0xFB, 0xEC, 0x3C, 0xFA, 0xF1, 0xE7, 0xFB, 0xE0, 0x3C, 0xF9,
  0x83, 0x47, 0xDD, 0xFB, 0xB7, 0x7C, 0x78, 0xFF, 0xF1, 0x86, 0x38, 0xC3,
  0x1C, 0x63, 0x80, 0x7C, 0xFD, 0xBB, 0xE3, 0x8F, 0x9B, 0xF3, 0x7E, 0xF8,
  0x38, 0xFB, 0xBF, 0x76, 0xEF, 0xCF, 0x86, 0x7C, 0xF0, 0xFC, 0x0F, 0x6D,
  0x80, 0x1B, 0x78, 0x02, 0x1C, 0xFF, 0x8F, 0x07, 0xC1, 0x81, 0xFC, 0x00,
  0x3F, 0xFC, 0x83, 0x0F, 0x0F, 0x3F, 0xCC, 0x20, 0x7B, 0xF8, 0xC7, 0x38,
  0xC0, 0x00, 0x71, 0xC0, 0x1F, 0x07, 0x39, 0x99, 0x37, 0xB5, 0xB7, 0xB6,
  0xD6, 0xDA, 0x7E, 0x60, 0x06, 0x30, 0x7E, 0x00, 0x1C, 0x1E, 0x0F, 0x86,
  0xC7, 0x63, 0xB1, 0xFC, 0xFE, 0xE3, 0x71, 0xC0, 0xF9, 0xFB, 0x3E, 0x6F,
  0xDF, 0xB3, 0xE7, 0xFD, 0xF0, 0x3D, 0xFE, 0x70, 0xC3, 0x0C, 0x39, 0xFD,
  0xF0, 0xF9, 0xFB, 0x3E, 0x3C, 0x78, 0xF3, 0xE7, 0xFD, 0xF0, 0xFF, 0xF1,
  0x8F, 0xFF, 0x18, 0xFF, 0xC0, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC6, 0x00,
  0x3E, 0xFF, 0x8E, 0x0D, 0xFB, 0xF1, 0xF3, 0xFE, 0xFC, 0xC7, 0x8F, 0x1E,
  0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8C, 0xFB, 0xDC, 0xE7, 0x39, 0xCE, 0x7F,
  0xC0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xCF, 0x9F, 0x76, 0xCF,
  0x9F, 0x3F, 0x66, 0xCF, 0x9C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xC0,
  0xE1, 0xFC, 0xFF, 0x3F, 0xCF, 0xF2, 0xF7, 0xBD, 0xEF, 0x7B, 0xCC, 0xF3,
  0x30, 0xE3, 0xF3, 0xF3, 0xFB, 0xDB, 0xDB, 0xDF, 0xCF, 0xCF, 0xC7, 0x7C,
  0xFE, 0xE6, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0xFE, 0x7C, 0xFB, 0xFC, 0xF3,
  0xDF, 0xFF, 0x30, 0xC3, 0x00, 0x7C, 0xFE, 0xE6, 0xC7, 0xC7, 0xC7, 0xC7,
  0xE6, 0xFE, 0x7C, 0x0E, 0x0F, 0xF9, 0xFB, 0x36, 0x6F, 0xDF, 0x36, 0x6E,
  0xCD, 0x9C, 0x3D, 0xF6, 0x5C, 0x78, 0xF0, 0xE3, 0xFF, 0xE0, 0xFF, 0xFC,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xF7, 0xFE, 0xF8, 0xE3, 0xE7, 0x67, 0x66, 0x76, 0x36, 0x3E, 0x3C,
  0x3C, 0x1C, 0xE6, 0x3E, 0x63, 0x67, 0x76, 0xF7, 0x6F, 0x66, 0xF6, 0x7D,
  0x63, 0x9E, 0x39, 0xC3, 0x9C, 0xE7, 0x66, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x7E, 0x66, 0xE7, 0xE7, 0x66, 0x7E, 0x3C, 0x3C, 0x38, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFC, 0x30, 0xE1, 0x87, 0x1C, 0x30, 0xFF, 0xFC, 0xFB, 0x6D,
  0xB6, 0xDB, 0x70, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x30, 0xF3,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0x18, 0x38, 0x38, 0x6C, 0x6C, 0x66, 0xC7,
  0xFF, 0xFC, 0xC6, 0x30, 0x3C, 0xF9, 0x39, 0xF7, 0xFD, 0xFF, 0xBB, 0xC3,
  0x0C, 0x36, 0xFF, 0x3C, 0xF3, 0xCF, 0xFF, 0x80, 0x3D, 0xF6, 0x58, 0xE1,
  0x97, 0xCF, 0x06, 0x0C, 0x19, 0xB7, 0xED, 0xD9, 0xF3, 0x66, 0xFD, 0xD8,
  0x38, 0xF9, 0x9B, 0xFF, 0xEC, 0x1F, 0x1E, 0x3B, 0xDC, 0xFF, 0xB1, 0x8C,
  0x63, 0x18, 0x36, 0xFD, 0xBB, 0x3E, 0x6C, 0xDF, 0xBB, 0x06, 0xFD, 0xF0,
  0xC3, 0x0C, 0x36, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0xFB, 0xFF, 0xFC,
  0x33, 0x23, 0x33, 0x33, 0x33, 0x33, 0xFF, 0xC1, 0x83, 0x06, 0x7D, 0xDB,
  0x3E, 0x7C, 0xFD, 0x9B, 0x38, 0xFF, 0xFF, 0xFC, 0xD9, 0xBF, 0xFC, 0xCF,
  0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xDB, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3,
  0x38, 0xFD, 0x9B, 0x3E, 0x6C, 0xDF, 0x9E, 0xDB, 0xFC, 0xF3, 0xCF, 0x3F,
  0xFE, 0xC3, 0x0C, 0x00, 0x36, 0xFD, 0xBB, 0x3E, 0x6C, 0xDF, 0xBB, 0x06,
  0x0C, 0x18, 0xDF, 0xBD, 0x8C, 0x63, 0x18, 0x7D, 0xEE, 0x9C, 0x38, 0x7F,
  0xFE, 0x23, 0xFE, 0xC6, 0x31, 0x8F, 0x38, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F,
  0xFF, 0xE7, 0xCD, 0xBB, 0x66, 0xC7, 0x8E, 0x1C, 0xEE, 0x7D, 0xDD, 0xAB,
  0x35, 0x67, 0xBC, 0xF7, 0x8E, 0xF1, 0xDC, 0xEE, 0xDD, 0xF1, 0xC3, 0x8F,
  0x9B, 0x77, 0xE7, 0xCD, 0xBB, 0x67, 0xC7, 0x8E, 0x1C, 0x38, 0xE1, 0xC0,
  0xFF, 0xF1, 0x8E, 0x31, 0x8F, 0xFF, 0x39, 0xCC, 0x63, 0x7B, 0x86, 0x31,
  0x8E, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x9C, 0xE3, 0x1C, 0xE6, 0x73,
  0xBD, 0xC0, 0xFB, 0xFC,
};

const GFXglyph NotoSans_Condensed_Black14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 7, 1, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 6, 12, 7, 1, -11 },
  { 26, 12, 10, 12, 0, -10 },
  { 41, 10, 10, 10, 0, -10 },
  { 54, 2, 4, 4, 1, -10 },
  { 55, 4, 12, 5, 1, -10 },
  { 61, 4, 12, 5, 0, -10 },
  { 67, 7, 7, 7, 0, -11 },
  { 74, 6, 6, 7, 1, -8 },
  { 79, 3, 4, 4, 0, -2 },
  { 81, 4, 2, 5, 0, -5 },
  { 82, 2, 2, 4, 1, -2 },
  { 83, 6, 10, 6, 0, -10 },
  { 91, 7, 10, 7, 0, -10 },
  { 100, 5, 10, 7, 1, -10 },
  { 107, 7, 10, 7, 0, -10 },
  { 116, 7, 10, 7, 0, -10 },
  { 125, 7, 10, 7, 0, -10 },
  { 134, 6, 10, 7, 1, -10 },
  { 142, 7, 10, 7, 0, -10 },
  { 151, 6, 10, 7, 1, -10 },
  { 159, 7, 10, 7, 0, -10 },
  { 168, 7, 10, 7, 0, -10 },
  { 177, 2, 8, 4, 1, -8 },
  { 179, 3, 10, 4, 0, -8 },
  { 183, 7, 8, 7, 0, -9 },
  { 190, 6, 5, 7, 1, -7 },
  { 194, 6, 8, 7, 1, -9 },
  { 200, 6, 10, 6, 0, -10 },
  { 208, 11, 11, 11, 0, -10 },
  { 224, 9, 10, 9, 0, -10 },
  { 236, 7, 10, 8, 1, -10 },
  { 245, 6, 10, 8, 1, -10 },
  { 253, 7, 10, 9, 1, -10 },
  { 262, 5, 10, 7, 1, -10 },
  { 269, 5, 10, 7, 1, -10 },
  { 276, 7, 10, 9, 1, -10 },
  { 285, 7, 10, 9, 1, -10 },
  { 294, 5, 10, 5, 0, -10 },
  { 301, 4, 13, 4, -1, -10 },
  { 308, 7, 10, 8, 1, -10 },
  { 317, 5, 10, 7, 1, -10 },
  { 324, 10, 10, 12, 1, -10 },
  { 337, 8, 10, 10, 1, -10 },
  { 347, 8, 10, 9, 1, -10 },
  { 357, 6, 10, 8, 1, -10 },
  { 365, 8, 12, 9, 1, -10 },
  { 377, 7, 10, 8, 1, -10 },
  { 386, 6, 10, 7, 0, -10 },
  { 394, 7, 10, 7, 0, -10 },
  { 403, 7, 10, 9, 1, -10 },
  { 412, 8, 10, 8, 0, -10 },
  { 422, 12, 10, 12, 0, -10 },
  { 437, 8, 10, 8, 0, -10 },
  { 447, 8, 10, 8, 0, -10 },
  { 457, 7, 10, 7, 0, -10 },
  { 466, 3, 12, 4, 1, -10 },
  { 471, 6, 10, 6, 0, -10 },
  { 479, 4, 12, 4, 0, -10 },
  { 485, 8, 7, 8, 0, -10 },
  { 492, 7, 2, 7, 0, 1 },
  { 494, 4, 3, 5, 1, -11 },
  { 496, 7, 8, 7, 0, -8 },
  { 503, 6, 11, 8, 1, -11 },
  { 512, 6, 8, 7, 0, -8 },
  { 518, 7, 11, 8, 0, -11 },
  { 528, 7, 8, 7, 0, -8 },
  { 535, 5, 11, 5, 0, -11 },
  { 542, 7, 11, 8, 0, -8 },
  { 552, 6, 11, 8, 1, -11 },
  { 561, 2, 11, 4, 1, -11 },
  { 564, 4, 14, 4, -1, -11 },
  { 571, 7, 11, 8, 1, -11 },
  { 581, 2, 11, 4, 1, -11 },
  { 584, 10, 8, 12, 1, -8 },
  { 594, 6, 8, 8, 1, -8 },
  { 600, 7, 8, 8, 0, -8 },
  { 607, 6, 11, 8, 1, -8 },
  { 616, 7, 11, 8, 0, -8 },
  { 626, 5, 8, 6, 1, -8 },
  { 631, 6, 8, 6, 0, -8 },
  { 637, 5, 9, 5, 0, -9 },
  { 643, 6, 8, 8, 1, -8 },
  { 649, 7, 8, 7, 0, -8 },
  { 656, 11, 8, 11, 0, -8 },
  { 667, 7, 8, 7, 0, -8 },
  { 674, 7, 11, 7, 0, -8 },
  { 684, 6, 8, 6, 0, -8 },
  { 690, 5, 12, 5, 0, -10 },
  { 698, 2, 14, 6, 2, -11 },
  { 702, 5, 12, 5, 0, -10 },
  { 710, 7, 2, 7, 0, -6 },
};

const GFXfont NotoSans_Condensed_Black14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Black14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Black14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_BLACK14PT7B_H_
