#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xD2, 0x49, 0x05, 0xF8, 0xCF, 0x3C, 0xF3, 0xCC, 0x19,
  0x06, 0x41, 0x90, 0x6C, 0x7F, 0xDF, 0xF1, 0x30, 0x48, 0x32, 0x3F, 0xEF,
  0xF8, 0xD8, 0x26, 0x09, 0x82, 0x60, 0x10, 0x21, 0xFF, 0xBD, 0x1A, 0x34,
  0x38, 0x3C, 0x3C, 0x58, 0x99, 0x7F, 0xDE, 0x08, 0x10, 0x70, 0xC6, 0xC4,
  0x36, 0x61, 0x33, 0x09, 0x90, 0x4D, 0x83, 0x69, 0xDB, 0xDA, 0x76, 0x98,
  0x24, 0xC3, 0x26, 0x19, 0x30, 0x89, 0x8C, 0x68, 0x61, 0xC0, 0x38, 0x1B,
  0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x03, 0x81, 0xE0, 0xF9, 0xB3, 0x6C, 0xF3,
  0x1C, 0xC7, 0x3F, 0xE7, 0x9C, 0xFF, 0xC0, 0x19, 0x98, 0xC6, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x31, 0x8C, 0x31, 0xC0, 0xCC, 0x66, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x66, 0x4C, 0x30, 0x63, 0x5F, 0xF3, 0x8D, 0xB3, 0x00, 0x10,
  0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x7B, 0x68, 0xFF,
  0x5F, 0x80, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0x3C, 0xFB, 0x9E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x6F, 0x8F, 0x00, 0x1C, 0xF7, 0xFB, 0x4C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x7D, 0xFA, 0x18, 0x30, 0x60,
  0xC3, 0x06, 0x18, 0x70, 0xC3, 0x0E, 0x1F, 0xFF, 0x80, 0x7D, 0xFE, 0x18,
  0x30, 0x61, 0xDF, 0x3C, 0x0E, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x00, 0x06,
  0x03, 0x03, 0x81, 0xC1, 0xE0, 0xB0, 0xD8, 0x4C, 0x66, 0x23, 0x3F, 0xFF,
  0xF0, 0x60, 0x30, 0x18, 0x7E, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0x2F, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0xBE, 0x00, 0x3E, 0xFD, 0x86, 0x0C, 0x19, 0x3F,
  0x73, 0xC7, 0x8F, 0x1E, 0x3C, 0x6F, 0xCF, 0x00, 0xFF, 0xFC, 0x18, 0x30,
  0x41, 0x83, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0E, 0x18, 0x00, 0x7C, 0xFE,
  0xC6, 0xC6, 0xC6, 0x6E, 0x7C, 0x38, 0x6E, 0xC6, 0xC6, 0xC3, 0xC6, 0xEE,
  0x7C, 0x79, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0x7E, 0x6C, 0x18, 0x30,
  0xDF, 0xBE, 0x00, 0xFD, 0x00, 0x00, 0x5F, 0x80, 0xFD, 0x00, 0x00, 0x0F,
  0x6D, 0x00, 0x03, 0x0F, 0x3C, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x1E, 0x78,
  0xE0, 0x80, 0x79, 0xF8, 0x38, 0x30, 0xC1, 0x87, 0x0C, 0x30, 0x60, 0xC0,
  0x03, 0x06, 0x0C, 0x00, 0x0F, 0x83, 0x8C, 0x20, 0x66, 0x03, 0x47, 0xBC,
  0xDB, 0xC9, 0x9D, 0x99, 0xD9, 0x9D, 0x99, 0xD9, 0xBC, 0xEE, 0xC4, 0x46,
  0x00, 0x60, 0x03, 0xF8, 0x0F, 0x00, 0x0C, 0x07, 0x81, 0xE0, 0x78, 0x16,
  0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x1F, 0xE7, 0xF9, 0x86, 0x61, 0xB8, 0x7C,
  0x0C, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xFE, 0xFE, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xFF, 0xFE, 0x1F, 0x3F, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x3F, 0x1F, 0xFC, 0x7F, 0x38, 0xDC, 0x7E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x37, 0xF3, 0xF0,
  0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xBE, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x3E, 0xFB, 0x0C, 0x30, 0xC3, 0x0C, 0x00,
  0x1F, 0x9F, 0xDC, 0x2C, 0x0E, 0x06, 0x03, 0x01, 0x8F, 0xC7, 0xE0, 0xF8,
  0x6C, 0x36, 0x19, 0xFC, 0x7E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF7, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x67, 0xF0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x37, 0xB8, 0xC7, 0xC6, 0xCC, 0xCC, 0xD8, 0xF8, 0xF0, 0xF0,
  0xD8, 0xD8, 0xCC, 0xCC, 0xCE, 0xC6, 0xC7, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0x80, 0xE0, 0x7E, 0x07,
  0xE0, 0xFA, 0x0F, 0xB0, 0xBB, 0x1B, 0xB1, 0xB9, 0x9B, 0x99, 0x39, 0xB3,
  0x8B, 0x38, 0xF3, 0x8E, 0x38, 0xE3, 0x86, 0x30, 0xC1, 0xF0, 0xF8, 0x74,
  0x3B, 0x1D, 0x8E, 0x67, 0x33, 0x8D, 0xC6, 0xE3, 0x70, 0xF8, 0x7C, 0x1E,
  0x0E, 0x3E, 0x1F, 0xC6, 0x1B, 0x86, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1D, 0x86, 0x61, 0x9F, 0xC1, 0xE0, 0xFC, 0xFE, 0xE7, 0xE3,
  0xE3, 0xE3, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E,
  0x1F, 0xC6, 0x1B, 0x86, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1D, 0x86, 0x61, 0x9F, 0xC3, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0xFC,
  0x7F, 0x39, 0xDC, 0x6E, 0x37, 0x1B, 0x9D, 0xFC, 0xFC, 0x76, 0x39, 0x9C,
  0xCE, 0x77, 0x1B, 0x8E, 0x7F, 0xFF, 0x06, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0xFF, 0xBE, 0x00, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x36, 0x3B,
  0xF8, 0xF8, 0xC1, 0xF0, 0x66, 0x19, 0x86, 0x61, 0x98, 0xC3, 0x30, 0xCC,
  0x33, 0x0D, 0x81, 0x60, 0x78, 0x1E, 0x07, 0x00, 0xC0, 0xC1, 0x87, 0x87,
  0x0F, 0x8E, 0x1B, 0x1C, 0x36, 0x28, 0xCC, 0x59, 0x99, 0xB3, 0x13, 0x66,
  0x36, 0x4C, 0x6C, 0xB0, 0xD1, 0xE1, 0xE3, 0xC1, 0xC7, 0x83, 0x87, 0x07,
  0x0C, 0x00, 0xE3, 0xB1, 0x99, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x38, 0x1C,
  0x1B, 0x0D, 0x86, 0xC6, 0x33, 0x1B, 0x0E, 0xC3, 0xB1, 0x98, 0xCC, 0xC3,
  0x61, 0xB0, 0xF0, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x7E, 0x7E, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60,
  0x60, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC7, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x18,
  0x0C, 0x0C, 0x04, 0x06, 0x06, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0x0C, 0x06, 0x07, 0x83, 0xC3, 0x31, 0x99, 0x87, 0xC3,
  0xFF, 0x80, 0xC6, 0x30, 0x10, 0xF9, 0x38, 0x30, 0x67, 0xFF, 0xE3, 0xC7,
  0x9F, 0x3B, 0xB0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC8, 0xDE, 0xE7, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFE, 0xDE, 0x19, 0xF6, 0x70, 0xC3, 0x0C,
  0x30, 0xC3, 0x07, 0xCF, 0x03, 0x03, 0x03, 0x03, 0x13, 0x7B, 0xE7, 0xC7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x6F, 0x7B, 0x10, 0xF9, 0x9E, 0x3C,
  0x7F, 0xFF, 0xE0, 0xC1, 0x81, 0xD9, 0xF0, 0x1C, 0xF3, 0x0C, 0x33, 0xE3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x7B, 0xE7, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7F, 0x7B, 0x03, 0x03, 0x86, 0xFE, 0x7C,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC8, 0xDE, 0xE6, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x7C, 0x3F, 0xFF, 0xFF, 0x2D, 0x80, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0xC6, 0xCE, 0xCC,
  0xD8, 0xD8, 0xF8, 0xEC, 0xCC, 0xC6, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x08, 0x4D, 0xEF, 0xE7, 0x3E, 0x73, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0x08, 0xDE, 0xE6, 0xE7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x10, 0x7C, 0x66, 0xC6, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x3C, 0x08, 0xDE, 0xE7, 0xE3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0xFE, 0xDE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x10,
  0x7B, 0xE7, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7F, 0x7B, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x0E, 0xFF, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0x80,
  0x33, 0xFC, 0xB0, 0xC3, 0x87, 0x86, 0x0C, 0x3F, 0xBE, 0x20, 0x82, 0x3E,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x3C, 0xF0, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC7, 0xE7, 0x7F, 0x7B, 0xC3, 0x63, 0x66, 0x66, 0x66,
  0x26, 0x34, 0x3C, 0x3C, 0x1C, 0x18, 0xC7, 0x1B, 0x38, 0xD9, 0x4C, 0xCA,
  0x66, 0x5B, 0x36, 0xD8, 0xB6, 0x87, 0x9C, 0x38, 0xE1, 0xC7, 0x06, 0x38,
  0xE7, 0x66, 0x36, 0x3C, 0x1C, 0x18, 0x3C, 0x3C, 0x66, 0x66, 0xE3, 0xC3,
  0x63, 0x66, 0x66, 0x66, 0x36, 0x34, 0x3C, 0x3C, 0x1C, 0x18, 0x18, 0x18,
  0x30, 0xF0, 0xE0, 0x7C, 0x31, 0xC6, 0x18, 0xC3, 0x18, 0x61, 0xFF, 0xC0,
  0x1C, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0xE3, 0x87, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x83, 0x0C, 0x30,
  0xC3, 0x0C, 0x3C, 0x73, 0x0C, 0x30, 0xC3, 0x0C, 0x63, 0x80, 0xE1, 0xFF,
  0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_Medium21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 6, 5, 8, 1, -15 },
  { 11, 10, 15, 10, 0, -15 },
  { 30, 7, 17, 9, 1, -16 },
  { 45, 13, 15, 15, 1, -15 },
  { 70, 10, 15, 11, 1, -15 },
  { 89, 2, 5, 5, 1, -15 },
  { 91, 5, 18, 6, 1, -15 },
  { 103, 4, 18, 6, 1, -15 },
  { 112, 7, 7, 9, 1, -16 },
  { 119, 8, 10, 9, 1, -12 },
  { 129, 3, 5, 5, 1, -2 },
  { 131, 4, 2, 6, 1, -7 },
  { 132, 3, 3, 5, 1, -3 },
  { 134, 8, 15, 8, 0, -15 },
  { 149, 7, 15, 9, 1, -15 },
  { 163, 6, 15, 9, 1, -15 },
  { 175, 7, 15, 9, 1, -15 },
  { 189, 7, 15, 9, 1, -15 },
  { 203, 9, 15, 9, 0, -15 },
  { 220, 7, 15, 9, 1, -15 },
  { 234, 7, 15, 9, 1, -15 },
  { 248, 7, 15, 9, 1, -15 },
  { 262, 8, 15, 9, 1, -15 },
  { 277, 7, 15, 9, 1, -15 },
  { 291, 3, 11, 5, 1, -11 },
  { 296, 3, 14, 5, 1, -11 },
  { 302, 8, 9, 9, 1, -12 },
  { 311, 8, 6, 9, 1, -10 },
  { 317, 8, 9, 9, 1, -12 },
  { 326, 7, 15, 7, 0, -15 },
  { 340, 12, 17, 14, 1, -15 },
  { 366, 10, 15, 10, 0, -15 },
  { 385, 8, 15, 10, 1, -15 },
  { 400, 8, 15, 10, 1, -15 },
  { 415, 9, 15, 11, 1, -15 },
  { 432, 6, 15, 9, 2, -15 },
  { 444, 6, 15, 8, 2, -15 },
  { 456, 9, 15, 12, 1, -15 },
  { 473, 8, 15, 12, 2, -15 },
  { 488, 4, 15, 6, 1, -15 },
  { 496, 5, 19, 5, -1, -15 },
  { 508, 8, 15, 10, 2, -15 },
  { 523, 7, 15, 8, 1, -15 },
  { 537, 12, 15, 15, 2, -15 },
  { 560, 9, 15, 12, 2, -15 },
  { 577, 10, 15, 12, 1, -15 },
  { 596, 8, 15, 10, 1, -15 },
  { 611, 10, 19, 12, 1, -15 },
  { 635, 9, 15, 10, 1, -15 },
  { 652, 7, 15, 9, 1, -15 },
  { 666, 8, 15, 8, 0, -15 },
  { 681, 9, 15, 11, 1, -15 },
  { 698, 10, 15, 10, 0, -15 },
  { 717, 15, 15, 15, 0, -15 },
  { 746, 9, 15, 9, 0, -15 },
  { 763, 9, 15, 9, 0, -15 },
  { 780, 8, 15, 8, 0, -15 },
  { 795, 5, 18, 7, 1, -15 },
  { 807, 8, 15, 8, 0, -15 },
  { 822, 4, 18, 7, 1, -15 },
  { 831, 9, 8, 10, 0, -15 },
  { 840, 9, 1, 9, 0, 2 },
  { 842, 4, 3, 6, 1, -16 },
  { 844, 7, 12, 9, 1, -12 },
  { 855, 8, 16, 10, 1, -16 },
  { 871, 6, 12, 8, 1, -12 },
  { 880, 8, 16, 10, 1, -16 },
  { 896, 7, 12, 9, 1, -12 },
  { 907, 6, 16, 6, 0, -16 },
  { 919, 8, 17, 10, 1, -12 },
  { 936, 8, 16, 10, 1, -16 },
  { 952, 2, 16, 5, 1, -16 },
  { 956, 3, 21, 5, 0, -16 },
  { 964, 8, 16, 9, 1, -16 },
  { 980, 2, 16, 5, 1, -16 },
  { 984, 12, 12, 15, 1, -12 },
  { 1002, 8, 12, 10, 1, -12 },
  { 1014, 8, 12, 10, 1, -12 },
  { 1026, 8, 17, 10, 1, -12 },
  { 1043, 8, 17, 10, 1, -12 },
  { 1060, 5, 12, 7, 1, -12 },
  { 1068, 6, 12, 7, 1, -12 },
  { 1077, 6, 14, 6, 0, -14 },
  { 1088, 8, 11, 10, 1, -11 },
  { 1099, 8, 11, 8, 0, -11 },
  { 1110, 13, 11, 13, 0, -11 },
  { 1128, 8, 11, 8, 0, -11 },
  { 1139, 8, 16, 8, 0, -11 },
  { 1155, 6, 11, 7, 0, -11 },
  { 1164, 6, 18, 8, 1, -15 },
  { 1178, 2, 21, 9, 3, -16 },
  { 1184, 6, 18, 8, 1, -15 },
  { 1198, 8, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Medium21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM21PT7B_H_
