#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE0, 0x00, 0x0E, 0xFF, 0xFE, 0xF0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1C, 0x07, 0x0E, 0x03,
  0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0x70,
  0x0C, 0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x30, 0xE0, 0x18, 0x70, 0x1C, 0x38, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE1, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC0, 0x30, 0xE0,
  0x38, 0x60, 0x1C, 0x30, 0x0E, 0x38, 0x07, 0x1C, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x1F, 0xF1, 0xFF, 0xE7, 0xFF, 0xBC, 0xC4, 0xE3,
  0x03, 0x8C, 0x0E, 0x30, 0x38, 0xC0, 0xF3, 0x01, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xCE, 0x03, 0x3C, 0x0C, 0xF0,
  0x33, 0xA0, 0xCE, 0xE3, 0xFB, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0x00, 0xE0, 0x1F, 0xC0, 0x70, 0x1F,
  0xE0, 0x70, 0x0E, 0x70, 0x38, 0x07, 0x1C, 0x38, 0x03, 0x8E, 0x1C, 0x03,
  0xC7, 0x0E, 0x01, 0xC3, 0x8E, 0x00, 0xE1, 0xC7, 0x00, 0x70, 0xE3, 0x80,
  0x18, 0x73, 0x80, 0x0E, 0x39, 0xC7, 0x87, 0x1C, 0xE7, 0xE3, 0x9C, 0xE7,
  0xF9, 0xFE, 0x73, 0x9C, 0x7F, 0x33, 0x8E, 0x1F, 0x39, 0xC7, 0x00, 0x1C,
  0xE1, 0xC0, 0x1C, 0x70, 0xE0, 0x0E, 0x38, 0x70, 0x07, 0x1C, 0x38, 0x07,
  0x0E, 0x1C, 0x03, 0x87, 0x1E, 0x01, 0xC3, 0x8E, 0x01, 0xC0, 0xE7, 0x00,
  0xE0, 0x7F, 0x80, 0x70, 0x1F, 0x80, 0x70, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x1E, 0x38, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0xF1, 0xFE, 0x1C, 0x79,
  0xE7, 0x8F, 0x3C, 0xF3, 0xC3, 0xDE, 0x78, 0x3F, 0x8F, 0x07, 0xF1, 0xE0,
  0x7E, 0x3C, 0x07, 0x87, 0xC1, 0xF8, 0x7C, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF,
  0xDF, 0x0F, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x07, 0x87, 0x83,
  0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0,
  0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x83,
  0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x70,
  0x70, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x43, 0x19,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x3F, 0x01, 0xCE, 0x0F, 0x3C,
  0x38, 0x70, 0x21, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x1C, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x00, 0x0F, 0x80, 0xFF, 0x83, 0xFE, 0x1F, 0x7C, 0x78, 0xF3,
  0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC0, 0xEE, 0x03, 0xB8, 0x0E,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x80, 0xEF, 0x03,
  0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x9E, 0x3C, 0x78, 0xF1, 0xFF,
  0x83, 0xFE, 0x07, 0xF0, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x3F, 0xDF, 0xFF,
  0xBD, 0xCF, 0x23, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x1F, 0xC0, 0xFF, 0xCF, 0xFF, 0x9E, 0x3E, 0x20, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9C, 0x3E, 0x20,
  0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x7C, 0x1F, 0xE0, 0x7E, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xE0, 0xFB,
  0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0x78, 0x07, 0x78, 0x07, 0x78, 0x0E,
  0x78, 0x0E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x38, 0x78, 0x38, 0x78, 0x70,
  0x78, 0x70, 0x78, 0xF0, 0x78, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0x8F, 0xFE, 0x7F, 0xF9,
  0x07, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x1F, 0xC1, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x00, 0x03,
  0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0x82, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x3C, 0x39, 0xF8, 0xEF, 0xF3, 0xFF, 0xEF,
  0x87, 0xBC, 0x1E, 0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0xEF, 0x07, 0x9E, 0x1E, 0x78, 0xF8, 0xFF, 0xC3, 0xFE, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3,
  0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x07, 0x3C, 0x1E, 0x78, 0x3C, 0x70, 0x78,
  0xF1, 0xE0, 0xF7, 0x80, 0xFE, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0x7C, 0x3C,
  0x78, 0xF0, 0x79, 0xC0, 0xF7, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xBC, 0x0F, 0x78, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x0F, 0xC0,
  0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x79, 0xE0, 0xF7, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0x78, 0x3D, 0xE1, 0xF7, 0xEF,
  0xCF, 0xF7, 0x1F, 0xDC, 0x3C, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x77,
  0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xF7,
  0x00, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF3, 0xCF, 0x39, 0xE7, 0x9C, 0x73, 0xC0, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01,
  0x00, 0x00, 0x1F, 0x8F, 0xFE, 0x7F, 0xE7, 0x1F, 0x40, 0xF0, 0x0F, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0x9F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x07, 0x07, 0x80,
  0x0F, 0x0E, 0x00, 0x0E, 0x3C, 0x0C, 0x1E, 0x70, 0x7F, 0x1C, 0xE1, 0xFE,
  0x3B, 0x87, 0x1C, 0x77, 0x0E, 0x38, 0xEE, 0x38, 0x70, 0xDC, 0x70, 0xE1,
  0xF8, 0xE1, 0xC3, 0xF1, 0xC3, 0x86, 0xE3, 0x87, 0x1D, 0xC7, 0x0E, 0x3B,
  0x8E, 0x3C, 0x77, 0x1C, 0x78, 0xEE, 0x3C, 0xF3, 0x9C, 0x3F, 0x7F, 0x3C,
  0x3E, 0x7C, 0x38, 0x10, 0x20, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x04, 0x00, 0xFC, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0x70, 0x0E, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x38, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C,
  0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x03, 0xDE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0x8F,
  0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC1, 0xE7, 0x87, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xFE, 0x78, 0x7C, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0x78, 0x1E, 0xF0, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0xE3, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x0C, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0,
  0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF3, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3,
  0xF0, 0xE3, 0xE0, 0x11, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xF7,
  0x80, 0x7B, 0xC0, 0x3D, 0xF0, 0x1E, 0x78, 0x0F, 0x3F, 0x07, 0x8F, 0xFF,
  0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xDF, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x3F, 0xBF, 0xFF, 0xF0, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0xFF, 0x7F, 0x3F,
  0x8F, 0x00, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E,
  0x1E, 0x3C, 0x7C, 0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0xBC,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFB, 0xC1, 0xE7, 0xC3,
  0xC7, 0x87, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x80, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFB, 0x80, 0x3F, 0xF7, 0x00, 0xFF, 0xEF, 0x01, 0xDF,
  0xDE, 0x03, 0xBF, 0x9C, 0x07, 0x7F, 0x38, 0x1C, 0xFE, 0x78, 0x39, 0xFC,
  0x70, 0x73, 0xF8, 0xE1, 0xE7, 0xF1, 0xC3, 0x8F, 0xE3, 0xC7, 0x1F, 0xC3,
  0x8E, 0x3F, 0x87, 0x3C, 0x7F, 0x0F, 0x70, 0xFE, 0x1E, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7C, 0x1F, 0xC0, 0xF8,
  0x3F, 0x81, 0xE0, 0x7F, 0x03, 0xC0, 0xF0, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xDE, 0x0F,
  0xEF, 0x07, 0xF3, 0x83, 0xF9, 0xE1, 0xFC, 0x70, 0xFE, 0x3C, 0x7F, 0x1E,
  0x3F, 0x87, 0x9F, 0xC3, 0xCF, 0xE0, 0xE7, 0xF0, 0x7B, 0xF8, 0x1C, 0xFC,
  0x0F, 0x7E, 0x07, 0xBF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x7B, 0xE0,
  0x1E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x78, 0xF0,
  0x3C, 0x3E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0x03,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xEF, 0xFF,
  0x3F, 0xF8, 0xFF, 0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x0F, 0x1E, 0x01,
  0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x78, 0xF0, 0x3C, 0x3E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7,
  0xFF, 0xCF, 0x0F, 0x9E, 0x0F, 0x3C, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC1, 0xE7, 0x83, 0xC7, 0x87, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x7D, 0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xF0, 0x0F,
  0xF0, 0x7F, 0xF3, 0xFF, 0x9F, 0xDE, 0x78, 0x09, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x1E, 0xF8, 0xFB, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0x7C, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE3,
  0x80, 0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC1, 0xC0, 0xE0, 0x70,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x38, 0x70, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0x80, 0x1C, 0xE0, 0x07, 0x78, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xF7,
  0x00, 0xF8, 0x0F, 0x78, 0x0F, 0x80, 0xF7, 0x81, 0xF8, 0x1E, 0x78, 0x1F,
  0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x38, 0x1D, 0xC1, 0xE3, 0xC1, 0xDC, 0x1E,
  0x3C, 0x3D, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0xC1, 0xC3,
  0x9E, 0x3C, 0x1E, 0x38, 0xE3, 0xC1, 0xE7, 0x8E, 0x78, 0x1E, 0x70, 0xE7,
  0x80, 0xE7, 0x0E, 0x78, 0x0E, 0x70, 0xF7, 0x80, 0xE7, 0x07, 0x78, 0x0F,
  0xF0, 0x77, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x1C,
  0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0x78, 0x07, 0x70, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x39, 0xC0, 0x1C, 0xF0, 0x1E, 0x38, 0x0E,
  0x1E, 0x0F, 0x07, 0x07, 0x03, 0xC7, 0x80, 0xE3, 0x80, 0x7B, 0xC0, 0x1D,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xF1, 0xE1,
  0xE1, 0xC1, 0xC0, 0x1F, 0xE1, 0xFF, 0x8F, 0xFE, 0x20, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x07, 0xF8, 0xFF, 0xCF, 0xFE, 0xF8, 0x77, 0x83,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7B, 0xC7, 0xDF, 0xFE, 0xFF, 0x73,
  0xF1, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE7, 0xE3, 0xDF, 0xE7, 0xFF,
  0xCF, 0xC7, 0xDF, 0x07, 0xBE, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8,
  0x1D, 0xF0, 0x7B, 0xF1, 0xF7, 0xFF, 0xCF, 0x7F, 0x9E, 0x7E, 0x00, 0x1F,
  0xE7, 0xFD, 0xFF, 0xBC, 0x1F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x05,
  0xFF, 0x9F, 0xF1, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x7C, 0xF3, 0xFF, 0xDF,
  0xFF, 0x78, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xF7, 0x87, 0xDF, 0xF7, 0x3F, 0xDC, 0x7E, 0x70, 0x1F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x9F, 0xFC, 0x7F, 0xE0, 0xFF, 0x00, 0x03, 0xC1, 0xFC, 0x3F,
  0x8F, 0xB1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFB, 0xFF, 0x7F,
  0xE1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x00, 0x1F, 0x9C, 0xFF, 0x77, 0xFD, 0xDE, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7D, 0xE1, 0xF7, 0xFF, 0xCF,
  0xEF, 0x1F, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE6,
  0x0F, 0x9F, 0xFC, 0x7F, 0xF1, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF,
  0xCF, 0x7F, 0xBF, 0xFE, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0,
  0x7F, 0xFF, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x3C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xDF,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3,
  0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC3, 0xE7, 0x8F, 0x1E, 0x3C, 0x3C, 0xF0, 0xF3, 0xC1, 0xCF, 0x07,
  0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF9,
  0xEF, 0xE7, 0xFB, 0xFF, 0xFF, 0xF7, 0xE3, 0xF1, 0xFF, 0x87, 0xC1, 0xFF,
  0x07, 0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1F, 0xE0,
  0x78, 0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x07,
  0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1F, 0xE0, 0x78,
  0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xE0, 0xE3, 0xF3,
  0xDF, 0xEF, 0xFF, 0xBF, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x1F,
  0xC0, 0xFF, 0xC7, 0xFF, 0x1E, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x79, 0xE1, 0xE7, 0xFF, 0x0F, 0xFC, 0x1F, 0xC0,
  0xF3, 0xF1, 0xEF, 0xF3, 0xFF, 0xE7, 0xE1, 0xEF, 0x83, 0xDF, 0x03, 0xBC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0E, 0xF8, 0x3D, 0xF8, 0xFB, 0xFF, 0xE7,
  0xBF, 0xCF, 0x3F, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x9C, 0xFF,
  0x77, 0xFD, 0xDE, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7D, 0xE1, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0xE3, 0xFD, 0xFF, 0xFF, 0xFD, 0xFC, 0x3E, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0xCF, 0xFD, 0xFF, 0xF8, 0x2F, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0xF8, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0,
  0x7F, 0x3F, 0x8F, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x7D, 0xE3, 0xF7,
  0xFD, 0xCF, 0xF7, 0x1F, 0x1C, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0x73, 0xC1,
  0xE7, 0x83, 0xC7, 0x07, 0x8E, 0x0E, 0x1E, 0x1C, 0x3C, 0x78, 0x38, 0xF0,
  0x71, 0xC0, 0xF3, 0x81, 0xEF, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x3C, 0x0F,
  0x70, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x7E, 0x0E, 0x78, 0x7E, 0x0E,
  0x38, 0x76, 0x1E, 0x38, 0x77, 0x1E, 0x3C, 0x77, 0x1C, 0x3C, 0xE7, 0x1C,
  0x3C, 0xE7, 0x1C, 0x1C, 0xE7, 0x3C, 0x1C, 0xE3, 0xBC, 0x1C, 0xE3, 0xB8,
  0x1E, 0xE3, 0xB8, 0x1F, 0xC3, 0xB8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xF0,
  0x78, 0x3E, 0xF0, 0x78, 0xF0, 0xE1, 0xE3, 0xC1, 0xE7, 0x03, 0xDE, 0x03,
  0xBC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFE,
  0x01, 0xDC, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0x78, 0x78, 0xF0, 0xE0, 0xF3,
  0xC1, 0xEF, 0x81, 0xC0, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0x73, 0xC1, 0xE7,
  0x83, 0xC7, 0x07, 0x8F, 0x0E, 0x1E, 0x1C, 0x3C, 0x78, 0x38, 0xF0, 0x79,
  0xC0, 0xF3, 0x80, 0xEF, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x7C, 0x1F, 0x83, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC1, 0xF0, 0xFC, 0x1F, 0x03, 0xF8, 0x0F, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x1F, 0x03, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7C, 0x07,
  0xE0, 0x7C, 0x3F, 0x87, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x07, 0xE0, 0xF8, 0x1E, 0x00,
  0x7F, 0x03, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Medium39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 28, 9, 2, -28 },
  { 19, 11, 10, 16, 2, -28 },
  { 33, 17, 28, 18, 1, -28 },
  { 93, 14, 32, 17, 2, -30 },
  { 149, 25, 28, 27, 1, -28 },
  { 237, 19, 28, 20, 1, -28 },
  { 304, 4, 10, 8, 2, -28 },
  { 309, 9, 34, 12, 2, -28 },
  { 348, 9, 34, 12, 1, -28 },
  { 387, 14, 14, 16, 1, -30 },
  { 412, 15, 18, 17, 1, -23 },
  { 446, 6, 9, 9, 1, -4 },
  { 453, 9, 3, 11, 1, -12 },
  { 457, 5, 5, 9, 2, -5 },
  { 461, 13, 28, 15, 1, -28 },
  { 507, 14, 28, 17, 2, -28 },
  { 556, 10, 28, 17, 2, -28 },
  { 591, 14, 28, 17, 1, -28 },
  { 640, 14, 28, 17, 1, -28 },
  { 689, 16, 28, 17, 1, -28 },
  { 745, 13, 28, 17, 2, -28 },
  { 791, 14, 28, 17, 2, -28 },
  { 840, 15, 28, 17, 1, -28 },
  { 893, 15, 28, 17, 1, -28 },
  { 946, 14, 28, 17, 1, -28 },
  { 995, 5, 21, 9, 2, -21 },
  { 1009, 6, 26, 9, 1, -21 },
  { 1029, 15, 18, 17, 1, -23 },
  { 1063, 15, 11, 17, 1, -19 },
  { 1084, 15, 18, 17, 1, -23 },
  { 1118, 12, 28, 13, 0, -28 },
  { 1160, 23, 31, 26, 2, -28 },
  { 1250, 18, 28, 18, 0, -28 },
  { 1313, 15, 28, 19, 3, -28 },
  { 1366, 15, 28, 18, 2, -28 },
  { 1419, 16, 28, 21, 3, -28 },
  { 1475, 11, 28, 16, 3, -28 },
  { 1514, 11, 28, 15, 3, -28 },
  { 1553, 17, 28, 21, 2, -28 },
  { 1613, 16, 28, 21, 3, -28 },
  { 1669, 9, 28, 11, 1, -28 },
  { 1701, 9, 36, 9, -2, -28 },
  { 1742, 15, 28, 18, 3, -28 },
  { 1795, 11, 28, 15, 3, -28 },
  { 1834, 23, 28, 29, 3, -28 },
  { 1915, 17, 28, 23, 3, -28 },
  { 1975, 18, 28, 22, 2, -28 },
  { 2038, 14, 28, 18, 3, -28 },
  { 2087, 18, 35, 22, 2, -28 },
  { 2166, 15, 28, 19, 3, -28 },
  { 2219, 14, 28, 16, 1, -28 },
  { 2268, 15, 28, 15, 0, -28 },
  { 2321, 15, 28, 21, 3, -28 },
  { 2374, 18, 28, 18, 0, -28 },
  { 2437, 28, 28, 28, 0, -28 },
  { 2535, 16, 28, 16, 0, -28 },
  { 2591, 16, 28, 16, 0, -28 },
  { 2647, 13, 28, 15, 1, -28 },
  { 2693, 8, 34, 12, 3, -28 },
  { 2727, 13, 28, 15, 1, -28 },
  { 2773, 9, 34, 12, 1, -28 },
  { 2812, 17, 16, 18, 1, -28 },
  { 2846, 17, 3, 17, 0, 3 },
  { 2853, 7, 6, 11, 2, -30 },
  { 2859, 13, 21, 17, 1, -21 },
  { 2894, 15, 30, 18, 2, -30 },
  { 2951, 11, 21, 14, 2, -21 },
  { 2980, 14, 30, 18, 2, -30 },
  { 3033, 13, 21, 17, 2, -21 },
  { 3068, 11, 30, 10, 0, -30 },
  { 3110, 14, 30, 18, 2, -21 },
  { 3163, 14, 30, 18, 2, -30 },
  { 3216, 4, 29, 9, 2, -29 },
  { 3231, 7, 38, 9, -1, -29 },
  { 3265, 14, 30, 17, 2, -30 },
  { 3318, 4, 30, 9, 2, -30 },
  { 3333, 23, 21, 27, 2, -21 },
  { 3394, 14, 21, 18, 2, -21 },
  { 3431, 14, 21, 18, 2, -21 },
  { 3468, 15, 30, 18, 2, -21 },
  { 3525, 14, 30, 18, 2, -21 },
  { 3578, 10, 21, 12, 2, -21 },
  { 3605, 11, 21, 14, 1, -21 },
  { 3634, 9, 26, 11, 1, -26 },
  { 3664, 14, 21, 18, 2, -21 },
  { 3701, 15, 21, 15, 0, -21 },
  { 3741, 24, 21, 24, 0, -21 },
  { 3804, 15, 21, 15, 0, -21 },
  { 3844, 15, 30, 15, 0, -21 },
  { 3901, 11, 21, 12, 1, -21 },
  { 3930, 11, 34, 14, 1, -28 },
  { 3977, 4, 39, 16, 6, -30 },
  { 3997, 11, 34, 14, 2, -28 },
  { 4044, 15, 5, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Medium39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM39PT7B_H_
