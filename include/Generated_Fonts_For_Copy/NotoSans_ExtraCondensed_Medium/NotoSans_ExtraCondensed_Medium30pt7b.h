#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xC3, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x39, 0x81, 0xCC,
  0x0C, 0x63, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x73, 0x0F,
  0xFF, 0x7F, 0xFB, 0xFF, 0xC6, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0xE0, 0xE6,
  0x06, 0x30, 0x00, 0x04, 0x00, 0x80, 0x10, 0x1F, 0xF7, 0xFC, 0xE8, 0xB9,
  0x07, 0x20, 0xE4, 0x0E, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0x78,
  0x27, 0x04, 0xE0, 0x9F, 0x17, 0x7F, 0xEF, 0xF8, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x18, 0x00, 0x0F, 0x81, 0x81, 0xB8, 0x70, 0x73, 0x0C, 0x0E,
  0x61, 0x81, 0x8C, 0x70, 0x31, 0xCC, 0x06, 0x39, 0x80, 0xC6, 0x70, 0x1C,
  0xCC, 0xF3, 0x99, 0xBF, 0x3F, 0x66, 0x67, 0xCC, 0xCC, 0x33, 0xB9, 0xC0,
  0x67, 0x38, 0x0C, 0xE7, 0x03, 0x9C, 0xE0, 0x63, 0x9C, 0x0C, 0x33, 0x83,
  0x86, 0x60, 0x60, 0xFC, 0x1C, 0x0F, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xF8,
  0x0C, 0x60, 0x71, 0x81, 0xC6, 0x03, 0x18, 0x0E, 0xE0, 0x3B, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x8E, 0x77, 0x3B, 0x9C, 0xEE, 0x3B, 0xB8, 0x7C, 0xE1,
  0xF3, 0x83, 0xCE, 0x1F, 0x3E, 0xFC, 0x7F, 0xB8, 0xFC, 0xF0, 0xFF, 0xFF,
  0xF0, 0x06, 0x1C, 0x70, 0xE3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x0E,
  0x1C, 0x38, 0x30, 0x60, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x0C, 0x1C, 0x18,
  0x18, 0xC1, 0xC1, 0xC3, 0x83, 0x87, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0x60,
  0xC1, 0xC3, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x18, 0x71, 0xC3,
  0x00, 0x0E, 0x03, 0x00, 0xC3, 0x33, 0xFF, 0xFF, 0xF1, 0xE0, 0xFC, 0x33,
  0x9C, 0xE1, 0x10, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x77,
  0x77, 0x6E, 0xC0, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0xF0, 0xFE, 0x38, 0xE7, 0x1C, 0xE1, 0xB8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0x60, 0xEE, 0x39, 0xC7, 0x3D, 0xE3, 0xF8, 0x3E, 0x00, 0x0E, 0x3C, 0xFB,
  0xBE, 0xF9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0x1E, 0x0F, 0xF3, 0xFF, 0x30, 0xE4, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x0F, 0xF3, 0xFF, 0x20, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC1,
  0xF0, 0xFC, 0x1F, 0xC0, 0x7C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x71, 0xEF, 0xF9, 0xFE, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x03, 0x70, 0x1B, 0x81, 0x9C, 0x0C, 0xE0, 0xC7, 0x06, 0x38,
  0x71, 0xC3, 0x0E, 0x38, 0x71, 0x83, 0x9F, 0xFF, 0xFF, 0xF8, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xCF, 0xF9, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x7F, 0x0F, 0xF9, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xF0, 0x3B, 0x8F, 0x7F, 0xC7, 0xF0, 0x03,
  0xC1, 0xF8, 0x7F, 0x1E, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE3, 0x1D,
  0xF3, 0xFF, 0x78, 0xEF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x1D,
  0xC7, 0xBD, 0xE3, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x0E,
  0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x0F, 0xC1, 0xD8, 0x3B, 0x8E, 0x79, 0xC7,
  0xF0, 0x7C, 0x1F, 0x87, 0xBC, 0xE3, 0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xB8, 0xF7, 0xFC, 0x7F, 0x00, 0x0E, 0x07, 0xE1, 0xFE, 0x38, 0xEE,
  0x1D, 0xC1, 0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xBD, 0xF7, 0xFE,
  0x7D, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x23, 0xC7, 0xF0, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x73, 0x9C, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xB9, 0xCE, 0x73, 0x39, 0x80, 0x00, 0x60, 0x3C, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x70, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x1E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x38, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x1C, 0x7F, 0x9F,
  0xE8, 0x70, 0x38, 0x0C, 0x0E, 0x07, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0,
  0xE0, 0x60, 0x30, 0x00, 0x00, 0x06, 0x07, 0x83, 0xC0, 0xE0, 0x00, 0x60,
  0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x0C, 0x00, 0xE7,
  0x0F, 0x19, 0x87, 0xE6, 0x63, 0x99, 0xD8, 0xCE, 0x3E, 0x73, 0x8F, 0x98,
  0xE3, 0xE6, 0x38, 0xF9, 0x8E, 0x7E, 0x63, 0x9F, 0x9C, 0xE6, 0x63, 0xFF,
  0x98, 0xF3, 0xC6, 0x08, 0x61, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x01, 0x01,
  0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3B, 0x01, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x87, 0x0E,
  0x1C, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0xFC, 0x07, 0xE0, 0x1C, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE3, 0xCF, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x0E, 0xFF, 0xEF, 0xFC, 0xFF,
  0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xF3, 0xC2, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xE6, 0x1F, 0xE0, 0x7E, 0xFF, 0x8F,
  0xFC, 0xE3, 0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE,
  0x1E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x3F, 0xF1, 0xFF, 0x8F,
  0x86, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFD, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D,
  0xE0, 0x73, 0xC1, 0xC7, 0x8F, 0x1F, 0xFC, 0x1F, 0xE0, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFE, 0xF8, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE7, 0xFF, 0xE0,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFD, 0xFB, 0xE0,
  0xE0, 0xFE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x78, 0xE7, 0x0E, 0xF0,
  0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x0E, 0x38, 0xE3, 0x8E, 0x3C,
  0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xF8, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0xC0, 0xDF,
  0xB8, 0x77, 0xEE, 0x1D, 0xFB, 0x86, 0x7E, 0x61, 0x9F, 0x9C, 0xE7, 0xE7,
  0x39, 0xF8, 0xCC, 0x7E, 0x33, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF8, 0x78,
  0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE0, 0xC1, 0xC0, 0xF0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xB8, 0x7D, 0xC3, 0xE7, 0x1F, 0x38,
  0xF9, 0xC7, 0xC7, 0x3E, 0x39, 0xF0, 0xEF, 0x87, 0x7C, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x3F, 0x81, 0xFF,
  0x0F, 0x1E, 0x78, 0x39, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70,
  0x1D, 0xE0, 0xF3, 0x83, 0x8F, 0xBE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x1F,
  0xFB, 0x8F, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3B,
  0xFF, 0x7F, 0xCF, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x03, 0x80, 0x3F, 0x81, 0xFF, 0x0F, 0x1E, 0x78, 0x39,
  0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xE0, 0xF3, 0x83,
  0x8F, 0xBE, 0x1F, 0xF0, 0x3F, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0xFF, 0x0F, 0xFC, 0xE3, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x3C, 0xFF, 0x8F, 0xF0, 0xE7, 0x0E, 0x78,
  0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0xF0, 0x0E,
  0x0F, 0xF7, 0xFD, 0xC3, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1F, 0xDF,
  0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x79,
  0xE7, 0xFE, 0x1F, 0x80, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x39, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x81, 0x8E, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x00, 0xDC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x70, 0x1F, 0x81, 0xE0, 0xE7, 0x07,
  0x83, 0x9C, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC3, 0xE0, 0xE7, 0x0F, 0xC7,
  0x0C, 0x37, 0x1C, 0x38, 0xCC, 0x70, 0xE3, 0x31, 0xC3, 0x9C, 0xC7, 0x0E,
  0x73, 0x98, 0x19, 0x8E, 0xE0, 0x76, 0x1B, 0x81, 0xD8, 0x6E, 0x07, 0xE1,
  0xB8, 0x1F, 0x86, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0x70, 0x73, 0x87, 0x0E, 0x38, 0x71, 0xC1, 0x9C, 0x0E,
  0xE0, 0x77, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x0E, 0xE0, 0x77, 0x07, 0x38, 0x38, 0xE1, 0xC7, 0x1C, 0x3C, 0xE0, 0xEE,
  0x07, 0x80, 0xE0, 0x77, 0x07, 0x70, 0xE7, 0x0E, 0x38, 0xE3, 0x9C, 0x39,
  0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF,
  0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0xFF, 0xFF, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x01, 0x98, 0x1C, 0xE0,
  0xE7, 0x0E, 0x1C, 0x70, 0xE7, 0x03, 0xB8, 0x1D, 0x80, 0x70, 0xFF, 0xF8,
  0xF1, 0xC3, 0x87, 0x0C, 0x04, 0x0F, 0xE7, 0xF8, 0x87, 0x01, 0xC0, 0x70,
  0x1C, 0x3F, 0x7F, 0xDE, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFB,
  0x7C, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x7C, 0xFF, 0xDE, 0x3B, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xEF, 0x1D, 0xFF, 0xB3, 0xE0, 0x04, 0x0F,
  0xCF, 0xEF, 0x17, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x81, 0xE2, 0x7F, 0x1F, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC2, 0x39, 0xF3, 0x7F, 0x6E, 0x3D, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB8, 0x77, 0x9E, 0x7E,
  0xC7, 0x98, 0x1F, 0x87, 0xF1, 0xC7, 0x38, 0x66, 0x0F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x30, 0x07, 0x00, 0xF0, 0x8F, 0xF0, 0xFE,
  0x0F, 0x0F, 0xC7, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0xFE, 0xFF, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x08, 0x07, 0xCC, 0xFD, 0xB8, 0xF7, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDE, 0x79, 0xFB,
  0x1E, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0xE7, 0x9F, 0xF1, 0xF8, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x23, 0xBE, 0xFF, 0xFC, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7B, 0xBE, 0xF0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0E, 0xE3, 0x9C,
  0x73, 0x9C, 0x77, 0x0E, 0xE1, 0xF8, 0x3F, 0x87, 0xF0, 0xE7, 0x1C, 0xE3,
  0x8E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x04, 0x67, 0xCF, 0xB7, 0xEF, 0xFE, 0x7C,
  0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0,
  0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F,
  0xC3, 0x87, 0xE1, 0xC3, 0x80, 0x02, 0x33, 0xED, 0xFF, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xC0, 0x04, 0x01, 0xF8, 0x3F, 0xC7, 0x1E, 0x70, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0x60, 0xE7, 0x0E,
  0x79, 0xC3, 0xFC, 0x1F, 0x80, 0x02, 0x19, 0xF3, 0x7F, 0x78, 0xEE, 0x1F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3,
  0xBC, 0x77, 0xFE, 0xEF, 0x9C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x08, 0x07, 0xCC, 0xFD, 0xB8, 0xF7, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDE, 0x79, 0xFB,
  0x1E, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x05,
  0x9F, 0x7E, 0xFF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0x08, 0x3F, 0x9F, 0xDC, 0x2E, 0x07, 0x03, 0xC0, 0xF0, 0x7E,
  0x0F, 0x83, 0xC0, 0xE0, 0x3C, 0x1B, 0x1D, 0xFE, 0xFE, 0x00, 0x18, 0x18,
  0x38, 0x38, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x39, 0x3F, 0x1F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xF7,
  0xED, 0xF3, 0xE0, 0x76, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xC3, 0x1C, 0x39,
  0xC3, 0x9C, 0x39, 0x81, 0xB8, 0x1B, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0xE0, 0xE0, 0xEC, 0x3C, 0x39, 0xC7, 0xC7, 0x38, 0xD8, 0xE7,
  0x1B, 0x1C, 0xE3, 0x63, 0x0C, 0xEC, 0xE1, 0xDD, 0xDC, 0x3B, 0x3B, 0x87,
  0x63, 0x60, 0x6C, 0x6C, 0x0D, 0x8F, 0x81, 0xB1, 0xF0, 0x3C, 0x3E, 0x07,
  0x87, 0x80, 0x70, 0x70, 0x70, 0xEE, 0x38, 0xE7, 0x1C, 0xE1, 0xB8, 0x3F,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7E, 0x1D, 0xC3, 0x9C, 0xE3, 0x9C,
  0x3F, 0x87, 0xE0, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xC3, 0x1C, 0x39,
  0xC3, 0x9C, 0x39, 0x81, 0xB8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xBC, 0x07, 0x80, 0x78,
  0x00, 0xFF, 0xFF, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0x0F, 0x87, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0x0E, 0x07, 0xC0, 0xE0, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0x0F, 0x80, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x7C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01,
  0xE0, 0x78, 0x7C, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x71, 0xF0, 0xF8, 0x70, 0x00, 0x30, 0x3F, 0x87, 0xFF, 0xC3, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 8, 7, 12, 2, -21 },
  { 16, 13, 21, 14, 1, -21 },
  { 51, 11, 25, 13, 1, -23 },
  { 86, 19, 22, 21, 1, -22 },
  { 139, 14, 22, 15, 1, -22 },
  { 178, 3, 7, 6, 2, -21 },
  { 181, 7, 27, 9, 1, -22 },
  { 205, 7, 27, 9, 1, -22 },
  { 229, 10, 11, 12, 1, -23 },
  { 243, 11, 14, 13, 1, -18 },
  { 263, 4, 7, 7, 1, -3 },
  { 267, 7, 2, 8, 1, -9 },
  { 269, 3, 4, 7, 2, -4 },
  { 271, 11, 22, 11, 0, -22 },
  { 302, 11, 22, 13, 1, -22 },
  { 333, 7, 21, 13, 2, -21 },
  { 352, 11, 22, 13, 1, -22 },
  { 383, 11, 22, 13, 1, -22 },
  { 414, 13, 22, 13, 0, -22 },
  { 450, 11, 21, 13, 1, -21 },
  { 479, 11, 22, 13, 1, -22 },
  { 510, 11, 21, 13, 1, -21 },
  { 539, 11, 22, 13, 1, -22 },
  { 570, 11, 22, 13, 1, -22 },
  { 601, 3, 16, 7, 2, -16 },
  { 607, 5, 20, 7, 1, -16 },
  { 620, 11, 13, 13, 1, -17 },
  { 638, 11, 9, 13, 1, -15 },
  { 651, 11, 13, 13, 1, -17 },
  { 669, 9, 22, 10, 0, -22 },
  { 694, 18, 24, 20, 1, -22 },
  { 748, 14, 21, 14, 0, -21 },
  { 785, 12, 21, 15, 2, -21 },
  { 817, 12, 22, 14, 1, -22 },
  { 850, 12, 21, 16, 2, -21 },
  { 882, 9, 21, 12, 2, -21 },
  { 906, 9, 21, 12, 2, -21 },
  { 930, 14, 22, 17, 1, -22 },
  { 969, 12, 21, 16, 2, -21 },
  { 1001, 7, 21, 9, 1, -21 },
  { 1020, 7, 27, 7, -2, -21 },
  { 1044, 12, 21, 14, 2, -21 },
  { 1076, 9, 21, 11, 2, -21 },
  { 1100, 18, 21, 22, 2, -21 },
  { 1148, 13, 21, 18, 2, -21 },
  { 1183, 14, 22, 17, 1, -22 },
  { 1222, 11, 21, 14, 2, -21 },
  { 1251, 14, 27, 17, 1, -22 },
  { 1299, 12, 21, 14, 2, -21 },
  { 1331, 10, 22, 12, 1, -22 },
  { 1359, 11, 21, 12, 0, -21 },
  { 1388, 12, 21, 16, 2, -21 },
  { 1420, 14, 21, 14, 0, -21 },
  { 1457, 22, 21, 22, 0, -21 },
  { 1515, 13, 21, 13, 0, -21 },
  { 1550, 12, 21, 12, 0, -21 },
  { 1582, 10, 21, 11, 1, -21 },
  { 1609, 6, 27, 9, 2, -22 },
  { 1630, 11, 22, 11, 0, -22 },
  { 1661, 6, 27, 9, 1, -22 },
  { 1682, 13, 12, 14, 1, -21 },
  { 1702, 13, 1, 13, 0, 3 },
  { 1704, 6, 5, 8, 1, -23 },
  { 1708, 10, 17, 13, 1, -17 },
  { 1730, 11, 23, 14, 2, -23 },
  { 1762, 9, 17, 11, 1, -17 },
  { 1782, 11, 23, 14, 1, -23 },
  { 1814, 11, 16, 13, 1, -16 },
  { 1836, 9, 23, 8, 0, -23 },
  { 1862, 11, 24, 14, 1, -17 },
  { 1895, 10, 23, 14, 2, -23 },
  { 1924, 3, 22, 7, 2, -22 },
  { 1933, 6, 29, 7, -1, -22 },
  { 1955, 11, 23, 13, 2, -23 },
  { 1987, 3, 23, 7, 2, -23 },
  { 1996, 17, 17, 21, 2, -17 },
  { 2033, 10, 17, 14, 2, -17 },
  { 2055, 12, 17, 14, 1, -17 },
  { 2081, 11, 24, 14, 2, -17 },
  { 2114, 11, 24, 14, 1, -17 },
  { 2147, 7, 17, 10, 2, -17 },
  { 2162, 9, 17, 10, 1, -17 },
  { 2182, 8, 20, 8, 0, -20 },
  { 2202, 10, 16, 14, 2, -16 },
  { 2222, 12, 16, 12, 0, -16 },
  { 2246, 19, 16, 19, 0, -16 },
  { 2284, 11, 16, 12, 0, -16 },
  { 2306, 12, 23, 12, 0, -16 },
  { 2341, 8, 16, 10, 1, -16 },
  { 2357, 9, 26, 11, 1, -21 },
  { 2387, 3, 30, 12, 5, -23 },
  { 2399, 9, 26, 11, 1, -21 },
  { 2429, 11, 5, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Medium30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM30PT7B_H_
