#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0x07,
  0xBF, 0xFF, 0xFF, 0xDE, 0x10, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07,
  0xFC, 0x0E, 0x70, 0x38, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x38, 0x38, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xE0, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x7E, 0xC7, 0x9E, 0x30, 0x4F, 0x8C, 0x03, 0xE3, 0x00, 0xF0, 0xC0,
  0x3E, 0x30, 0x0F, 0x8C, 0x01, 0xF3, 0x00, 0x7E, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03,
  0x3E, 0x00, 0xC7, 0xC0, 0x31, 0xF0, 0x0C, 0x3C, 0x03, 0x0F, 0x00, 0xC7,
  0xE0, 0x31, 0xFE, 0x0C, 0xFB, 0xFB, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x83,
  0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x7F, 0x80, 0x3C, 0x00,
  0xFF, 0x00, 0x78, 0x03, 0xCF, 0x00, 0xF0, 0x07, 0x0E, 0x03, 0xC0, 0x1E,
  0x1E, 0x07, 0x80, 0x3C, 0x3C, 0x0E, 0x00, 0x78, 0x78, 0x3C, 0x00, 0xF0,
  0xF0, 0x78, 0x01, 0xE1, 0xE0, 0xE0, 0x03, 0xC3, 0xC3, 0xC0, 0x07, 0x87,
  0x87, 0x80, 0x0F, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x3C, 0x00, 0x3C, 0x3C,
  0x78, 0x78, 0x78, 0x79, 0xE3, 0xF8, 0xF0, 0xF3, 0xCF, 0xF8, 0xF1, 0xC7,
  0x1F, 0xF9, 0xFF, 0x9E, 0x78, 0xF1, 0xFE, 0x3C, 0xF1, 0xE3, 0xFC, 0x71,
  0xE1, 0xE3, 0xF1, 0xE3, 0xC3, 0xC0, 0x03, 0xC7, 0x87, 0x80, 0x07, 0x0E,
  0x0F, 0x00, 0x1E, 0x1C, 0x1E, 0x00, 0x3C, 0x38, 0x3C, 0x00, 0xF0, 0x70,
  0x78, 0x01, 0xE0, 0xF0, 0xF0, 0x03, 0xC1, 0xE1, 0xE0, 0x0F, 0x03, 0xC3,
  0xC0, 0x1E, 0x07, 0x87, 0x00, 0x38, 0x0F, 0x1E, 0x00, 0xF0, 0x0F, 0x3C,
  0x01, 0xE0, 0x1F, 0xF0, 0x03, 0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x9E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x3E, 0x7C, 0x3E, 0x7E, 0x7C, 0x3C, 0x7C, 0x3E, 0x7C, 0x7C, 0x3F, 0x7C,
  0xF8, 0x1F, 0x7C, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF0,
  0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x7E, 0x1F, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0x7C, 0x1F, 0xFE, 0x3E, 0x0F, 0xF8, 0x3F,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xE7, 0x00,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07, 0x0E,
  0x3B, 0xF7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xF7, 0x80, 0xF3, 0xE0, 0xF8, 0xF8, 0xF8, 0x7C, 0x1C, 0x18,
  0x02, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x3E, 0x7C, 0xFB, 0xF7, 0xCF, 0x9F, 0x3C, 0x79, 0xF3, 0xC7, 0x8E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE2, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0x3F, 0x0F, 0x87,
  0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xEF, 0x80, 0x7B,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE1, 0xF0, 0xF8, 0xFC, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xDF,
  0xFC, 0xFF, 0xC7, 0xDC, 0x3E, 0x41, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x3F, 0x1C, 0x07, 0xC2,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x78, 0x3F, 0x18, 0x07, 0xE4, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE8, 0x01, 0xFB, 0x80, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0E, 0xF8, 0x00, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xCF, 0x80, 0x3C,
  0xF8, 0x03, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x0F, 0x80, 0xF0, 0xF8, 0x0F,
  0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x87,
  0x80, 0xF8, 0x78, 0x0F, 0x8F, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE8, 0x01, 0xFB, 0x80,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xC1,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x1C, 0x0F, 0x9F, 0xC3, 0xEF,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xE0, 0xFB, 0xF0, 0x3E, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xE7, 0xE0, 0xF8, 0xF8,
  0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7E, 0x1F, 0x9F, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xDE,
  0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x87, 0xC1, 0xF3,
  0xE0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3E, 0x3F, 0x1F, 0x07, 0xE7, 0xC0, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7E, 0x3F, 0x1F, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xF7, 0xE3, 0xFD, 0xFF, 0xFF,
  0x3F, 0xF7, 0xC7, 0xF9, 0xE0, 0xFC, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x04, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x88,
  0x3C, 0xFD, 0xFB, 0xF7, 0xEF, 0x86, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x9F, 0x3E, 0xF9, 0xF3,
  0xE7, 0x8F, 0x3E, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x38, 0x7E, 0x20, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x03, 0xFE, 0x1C, 0x78, 0x3F,
  0xF0, 0xF7, 0x83, 0xFF, 0x87, 0xBC, 0x1E, 0x3C, 0x3D, 0xE1, 0xE1, 0xE1,
  0xEF, 0x0F, 0x0F, 0x07, 0x70, 0x70, 0x78, 0x3F, 0x87, 0x83, 0xC1, 0xFC,
  0x3C, 0x1E, 0x0F, 0xE1, 0xE0, 0xF0, 0x7F, 0x0F, 0x07, 0x83, 0xF8, 0x78,
  0x3C, 0x1F, 0xC3, 0xC1, 0xE1, 0xFE, 0x1E, 0x1F, 0x0F, 0xF0, 0xF0, 0xF8,
  0x7F, 0x83, 0xC7, 0xC3, 0x9C, 0x1E, 0x76, 0x3C, 0xF0, 0xFF, 0xBF, 0xC7,
  0x83, 0xF9, 0xFE, 0x3C, 0x0F, 0x87, 0xE1, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x08, 0x00, 0x7F, 0x03, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x03, 0xE7,
  0x80, 0x03, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xC7, 0xC0, 0x07, 0xC7,
  0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x83,
  0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC0, 0xFC, 0xFC, 0x07,
  0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3E, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x07, 0xCF,
  0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07,
  0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xE1, 0xE1, 0xF8, 0x04, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x0E, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E,
  0x0F, 0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0x7C, 0xFC, 0x03, 0xF7, 0xE0, 0x0F,
  0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x07, 0xEF,
  0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x8F, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xC1, 0xF8, 0x01, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xF7, 0xC0, 0x7F, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x87, 0xF0, 0x3F, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xF8,
  0xFC, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E,
  0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F,
  0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xEF, 0xF7, 0x80, 0x0F,
  0x7F, 0xBC, 0x00, 0x7B, 0xFD, 0xE0, 0x07, 0xFF, 0xEF, 0x80, 0x3D, 0xFF,
  0x3C, 0x01, 0xEF, 0xF9, 0xE0, 0x1F, 0x7F, 0xCF, 0x00, 0xF3, 0xFE, 0x7C,
  0x07, 0x9F, 0xF1, 0xE0, 0x3C, 0xFF, 0x8F, 0x03, 0xE7, 0xFC, 0x7C, 0x1E,
  0x3F, 0xE1, 0xE0, 0xF1, 0xFF, 0x0F, 0x07, 0x8F, 0xF8, 0x78, 0x78, 0x7F,
  0xC3, 0xE3, 0xC3, 0xFE, 0x0F, 0x1E, 0x1F, 0xF0, 0x79, 0xF0, 0xFF, 0x83,
  0xEF, 0x07, 0xFC, 0x1F, 0x78, 0x3F, 0xE0, 0x7B, 0xC1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x03, 0xFE, 0x03, 0xF8, 0x1F,
  0xF0, 0x1F, 0x80, 0xFF, 0x80, 0xFC, 0x07, 0xFC, 0x03, 0xE0, 0x3F, 0xE0,
  0x1E, 0x01, 0xF0, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xDE, 0x01, 0xFF, 0x7C, 0x07, 0xFC, 0xF0, 0x1F,
  0xF3, 0xE0, 0x7F, 0xCF, 0x81, 0xFF, 0x1F, 0x07, 0xFC, 0x7C, 0x1F, 0xF0,
  0xF0, 0x7F, 0xC3, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1F, 0x1F, 0xF0, 0x7C,
  0x7F, 0xC0, 0xF9, 0xFF, 0x03, 0xE7, 0xFC, 0x07, 0x9F, 0xF0, 0x1F, 0x7F,
  0xC0, 0x7D, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF,
  0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x17, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC1, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x07,
  0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0,
  0xFC, 0xFC, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE0, 0xFC, 0x3E, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xE7,
  0xFB, 0xF3, 0xF0, 0x1B, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7D, 0xF0, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x80, 0x1F, 0x7C,
  0x01, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xFC, 0x03,
  0xE7, 0xC0, 0x1F, 0xC0, 0x3E, 0x3C, 0x03, 0xFC, 0x03, 0xE3, 0xE0, 0x3F,
  0xC0, 0x3E, 0x3E, 0x03, 0xDC, 0x07, 0xC3, 0xE0, 0x3D, 0xE0, 0x7C, 0x3E,
  0x03, 0xDE, 0x07, 0xC1, 0xE0, 0x79, 0xE0, 0x7C, 0x1F, 0x07, 0x9E, 0x07,
  0xC1, 0xF0, 0x79, 0xE0, 0xF8, 0x1F, 0x07, 0x8F, 0x0F, 0x81, 0xF0, 0xF8,
  0xF0, 0xF8, 0x0F, 0x0F, 0x0F, 0x0F, 0x80, 0xF8, 0xF0, 0xF0, 0xF8, 0x0F,
  0x8F, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x79, 0xF0, 0x0F, 0x9F, 0x07, 0x9F,
  0x00, 0x79, 0xE0, 0x79, 0xF0, 0x07, 0x9E, 0x07, 0x9F, 0x00, 0x7D, 0xE0,
  0x79, 0xE0, 0x07, 0xDE, 0x03, 0xBE, 0x00, 0x3D, 0xE0, 0x3F, 0xE0, 0x03,
  0xDC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x7C,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x83, 0xE0, 0x3C, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x3C,
  0x7C, 0x01, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xCF, 0x00, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F,
  0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xF0, 0xF8, 0x00,
  0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xCF, 0x00, 0x1E, 0x3C,
  0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80,
  0x0F, 0xBE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0x00,
  0x40, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xF7, 0xF0, 0x80, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFD, 0xFF, 0xFE, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xFE, 0xFF, 0xBF, 0xF7, 0xDF, 0xF9, 0xE7, 0xF0, 0xF0, 0x40,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x7E, 0x0F, 0xBF, 0xE1, 0xF7, 0xFE, 0x3F, 0xFF,
  0xE7, 0xF0, 0x7C, 0xFC, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3D, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0xC1, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0x3F, 0xE1, 0xE3, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xE0, 0x9F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x03, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xE0, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x04, 0x0F, 0x87, 0xF1, 0xF1, 0xFF, 0x3E,
  0x7F, 0xF7, 0xCF, 0xFF, 0xFB, 0xF0, 0x7F, 0x7C, 0x0F, 0xEF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xEF,
  0xC1, 0xFC, 0xFF, 0xFF, 0x9F, 0xFD, 0xF1, 0xFF, 0xBE, 0x1F, 0xC3, 0xC0,
  0x40, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFE, 0xFC, 0x3E,
  0x1F, 0x1F, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01,
  0xEF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x18, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xE0, 0x01, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x01, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x7C, 0x7F, 0xCF,
  0x8F, 0xFD, 0xF3, 0xFF, 0xFE, 0xFC, 0x1F, 0xDF, 0x03, 0xFB, 0xE0, 0x3F,
  0x7C, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xDF, 0x03, 0xFB,
  0xF0, 0x7F, 0x3F, 0xFF, 0xE7, 0xFF, 0x7C, 0x7F, 0xCF, 0x87, 0xF1, 0xF0,
  0x10, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF9, 0x00, 0x3E, 0x3E, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x08, 0x1F, 0x3F, 0x8F, 0xBF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3C, 0x7F, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF9, 0xFF, 0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F,
  0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xBE, 0x0F, 0xEF, 0x83, 0xF1, 0xE0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x20, 0x02, 0x07, 0x8F, 0xE0, 0xFE, 0x3C, 0xFF, 0x8F, 0xF9, 0xEF, 0xFE,
  0xFF, 0xEF, 0x7F, 0xF7, 0xFF, 0x7F, 0x0F, 0xF0, 0xFF, 0xF0, 0x3F, 0x03,
  0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE,
  0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07,
  0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80,
  0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x20, 0x78, 0xFE, 0x3C, 0xFF, 0x9E,
  0xFF, 0xEF, 0x7F, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7C, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x3E,
  0x78, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xE7, 0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF1,
  0xF0, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x1E, 0x3F, 0x83, 0xCF, 0xFC, 0x79, 0xFF, 0x8F,
  0xFF, 0xF9, 0xFC, 0x1F, 0x3F, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x7C,
  0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x0F, 0xBF, 0x03, 0xF7, 0xF0, 0x7C, 0xFF,
  0xFF, 0x9F, 0x7F, 0xE3, 0xEF, 0xF8, 0x7C, 0x7E, 0x0F, 0x82, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0x00, 0x01, 0xFC, 0x7C, 0x7F, 0xCF, 0x9F, 0xFD, 0xF3, 0xFF,
  0xFE, 0xFC, 0x1F, 0xDF, 0x03, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xDF, 0x03, 0xFB, 0xF0, 0x7F, 0x3F, 0xFF,
  0xE7, 0xFF, 0x7C, 0x7F, 0xCF, 0x87, 0xF1, 0xF0, 0x10, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x2F, 0x1F, 0xF3, 0xFF, 0x3F, 0xF7, 0xFF, 0x7F, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0x00, 0x7F, 0xC3, 0xFF, 0xDF,
  0xFE, 0xFF, 0xFB, 0xE0, 0x6F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x06, 0x00, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x10,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xF0,
  0xFE, 0xFF, 0xFF, 0x7F, 0xF7, 0x9F, 0xF3, 0xC7, 0xF1, 0xE0, 0x40, 0x00,
  0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7C,
  0x78, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x83, 0xC1, 0xF0,
  0x78, 0x3E, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0,
  0x7C, 0xF0, 0x0F, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0,
  0x7D, 0xF0, 0x3F, 0x80, 0xF3, 0xE0, 0x7F, 0x01, 0xE7, 0xC0, 0xFE, 0x07,
  0xC7, 0x81, 0xFC, 0x0F, 0x8F, 0x03, 0xBC, 0x1F, 0x1F, 0x07, 0x78, 0x3C,
  0x3E, 0x1E, 0xF0, 0x78, 0x7C, 0x3D, 0xE1, 0xF0, 0x78, 0x79, 0xC3, 0xE0,
  0xF0, 0xF3, 0xC7, 0x81, 0xF1, 0xC7, 0x8F, 0x03, 0xE7, 0x8F, 0x3E, 0x03,
  0xCF, 0x1E, 0x7C, 0x07, 0x9E, 0x3C, 0xF8, 0x0F, 0x3C, 0x39, 0xE0, 0x1F,
  0x70, 0x7B, 0xC0, 0x3E, 0xE0, 0xF7, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0xF8, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF8, 0xF0, 0x7C, 0x3E,
  0x1F, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x0F, 0x7C, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xDF, 0x01, 0xF7, 0xC0, 0x7C, 0xF0, 0x1E,
  0x3E, 0x0F, 0x87, 0x83, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x0F, 0xBE, 0x03,
  0xEF, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x01,
  0x3F, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3C, 0x03, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0xFF,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xE0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x03, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xEC, 0x03, 0xFC, 0x80, 0x07, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 37, 12, 3, -36 },
  { 29, 14, 13, 20, 3, -36 },
  { 52, 22, 36, 24, 1, -36 },
  { 151, 18, 41, 22, 2, -38 },
  { 244, 31, 36, 35, 2, -36 },
  { 384, 24, 37, 25, 1, -36 },
  { 495, 5, 13, 11, 3, -36 },
  { 504, 12, 44, 15, 2, -36 },
  { 570, 12, 44, 15, 1, -36 },
  { 636, 17, 18, 21, 2, -38 },
  { 675, 19, 24, 22, 1, -30 },
  { 732, 7, 13, 12, 2, -6 },
  { 744, 12, 5, 14, 1, -16 },
  { 752, 6, 7, 12, 3, -6 },
  { 758, 18, 36, 19, 1, -36 },
  { 839, 18, 37, 22, 2, -36 },
  { 923, 13, 36, 22, 3, -36 },
  { 982, 18, 36, 22, 2, -36 },
  { 1063, 18, 37, 22, 2, -36 },
  { 1147, 20, 36, 22, 1, -36 },
  { 1237, 18, 37, 22, 2, -36 },
  { 1321, 18, 37, 22, 2, -36 },
  { 1405, 19, 36, 22, 1, -36 },
  { 1491, 18, 37, 22, 2, -36 },
  { 1575, 18, 37, 22, 2, -36 },
  { 1659, 6, 28, 12, 3, -27 },
  { 1680, 7, 34, 12, 2, -27 },
  { 1710, 20, 23, 22, 1, -29 },
  { 1768, 20, 15, 22, 1, -25 },
  { 1806, 20, 23, 22, 1, -29 },
  { 1864, 16, 37, 17, 0, -36 },
  { 1938, 29, 40, 34, 2, -36 },
  { 2083, 24, 36, 24, 0, -36 },
  { 2191, 20, 36, 25, 3, -36 },
  { 2281, 20, 37, 23, 2, -36 },
  { 2374, 21, 36, 26, 3, -36 },
  { 2469, 14, 36, 21, 4, -36 },
  { 2532, 14, 36, 20, 4, -36 },
  { 2595, 23, 37, 28, 2, -36 },
  { 2702, 20, 36, 27, 4, -36 },
  { 2792, 11, 36, 15, 2, -36 },
  { 2842, 11, 46, 12, -3, -36 },
  { 2906, 20, 36, 23, 4, -36 },
  { 2996, 15, 36, 19, 3, -36 },
  { 3064, 29, 36, 37, 4, -36 },
  { 3195, 22, 36, 29, 4, -36 },
  { 3294, 24, 37, 28, 2, -36 },
  { 3405, 18, 36, 23, 3, -36 },
  { 3486, 24, 45, 28, 2, -36 },
  { 3621, 20, 36, 24, 3, -36 },
  { 3711, 17, 37, 21, 2, -36 },
  { 3790, 18, 36, 20, 1, -36 },
  { 3871, 21, 37, 27, 3, -36 },
  { 3969, 23, 36, 23, 0, -36 },
  { 4073, 36, 36, 36, 0, -36 },
  { 4235, 21, 36, 21, 0, -36 },
  { 4330, 21, 36, 21, 0, -36 },
  { 4425, 17, 36, 19, 1, -36 },
  { 4502, 11, 44, 16, 3, -36 },
  { 4563, 17, 36, 19, 1, -36 },
  { 4640, 11, 44, 16, 1, -36 },
  { 4701, 22, 20, 23, 1, -36 },
  { 4756, 22, 3, 21, 0, 4 },
  { 4765, 10, 8, 14, 2, -38 },
  { 4775, 17, 29, 22, 2, -28 },
  { 4837, 19, 39, 24, 3, -38 },
  { 4930, 15, 29, 18, 2, -28 },
  { 4985, 19, 39, 24, 2, -38 },
  { 5078, 18, 28, 22, 2, -27 },
  { 5141, 15, 38, 13, 0, -38 },
  { 5213, 19, 40, 24, 2, -28 },
  { 5308, 17, 38, 23, 3, -38 },
  { 5389, 5, 37, 11, 3, -37 },
  { 5413, 9, 49, 11, -1, -37 },
  { 5469, 18, 38, 21, 3, -38 },
  { 5555, 5, 38, 11, 3, -38 },
  { 5579, 29, 28, 35, 3, -28 },
  { 5681, 17, 28, 23, 3, -28 },
  { 5741, 19, 29, 23, 2, -28 },
  { 5810, 19, 40, 24, 3, -28 },
  { 5905, 19, 40, 24, 2, -28 },
  { 6000, 12, 28, 16, 3, -28 },
  { 6042, 14, 29, 17, 2, -28 },
  { 6093, 12, 34, 14, 1, -33 },
  { 6144, 17, 28, 23, 3, -27 },
  { 6204, 19, 27, 20, 0, -27 },
  { 6269, 31, 27, 31, 0, -27 },
  { 6374, 18, 27, 19, 1, -27 },
  { 6435, 19, 39, 20, 0, -27 },
  { 6528, 14, 27, 16, 1, -27 },
  { 6576, 14, 44, 18, 2, -36 },
  { 6653, 5, 50, 21, 8, -38 },
  { 6685, 14, 44, 18, 2, -36 },
  { 6762, 20, 7, 22, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Medium50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM50PT7B_H_
