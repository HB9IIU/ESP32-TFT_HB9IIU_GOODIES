#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x66, 0xF6, 0xEA, 0x7B, 0x13, 0x80, 0x56, 0xBA, 0xF3,
  0xAC, 0x46, 0x4D, 0xAF, 0xC0, 0x5A, 0xA4, 0x95, 0x58, 0x5D, 0x80, 0x4B,
  0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x25, 0x00, 0x76, 0xDA, 0xC0, 0x75, 0x50,
  0xE4, 0x95, 0xC0, 0xE4, 0xB3, 0xC0, 0x2D, 0xDE, 0x40, 0x73, 0x13, 0xC0,
  0x73, 0xDA, 0xC0, 0xE4, 0xA4, 0x80, 0x75, 0xBA, 0xC0, 0x56, 0xB2, 0x80,
  0x90, 0x98, 0x2B, 0x10, 0xFC, 0x89, 0xC0, 0xC5, 0x20, 0x80, 0x32, 0x6F,
  0xBB, 0xA0, 0xC0, 0x46, 0x6E, 0xA9, 0xD7, 0x6B, 0x80, 0x6A, 0x48, 0xC0,
  0xD6, 0xDB, 0x80, 0xEB, 0xB0, 0xEB, 0xA0, 0x74, 0x8B, 0x97, 0xB6, 0xFB,
  0x40, 0xD5, 0x70, 0xFF, 0xBA, 0x6D, 0x40, 0xAA, 0xB0, 0x99, 0xBF, 0xFD,
  0xB6, 0xFB, 0x40, 0x65, 0x99, 0x97, 0xFF, 0xA0, 0x65, 0x99, 0x97, 0x10,
  0xDB, 0x6D, 0x40, 0x73, 0x13, 0xC0, 0xE9, 0x24, 0x80, 0xB6, 0xDB, 0x80,
  0x9A, 0xA6, 0x64, 0xA6, 0xDB, 0x9E, 0x59, 0x20, 0xAD, 0x27, 0x40, 0xB5,
  0xA4, 0x80, 0xE5, 0x29, 0xC0, 0xFE, 0x91, 0x22, 0x40, 0xD5, 0x5C, 0x46,
  0xB0, 0xE0, 0xC0, 0xEE, 0xF0, 0x93, 0xDB, 0xC0, 0xF2, 0x30, 0x2E, 0xDA,
  0xC0, 0xFE, 0x30, 0x6E, 0xA0, 0xF6, 0xB2, 0xC0, 0x93, 0xDB, 0x40, 0xBC,
  0xBF, 0xAE, 0xF0, 0xFC, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0xF6, 0xB0, 0xF6,
  0xF9, 0x00, 0xF6, 0xB2, 0x40, 0xEA, 0xF8, 0xE0, 0xBA, 0x40, 0xB6, 0xB0,
  0xB5, 0x20, 0xAD, 0x54, 0xA0, 0xA9, 0x50, 0xB5, 0x25, 0x00, 0xDB, 0x29,
  0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 3, 2, 3, 0, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 6, 4, 0, -6 },
  { 9, 5, 6, 6, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 2, 0, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 3, 3, 3, 0, -6 },
  { 23, 3, 4, 4, 0, -5 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -3 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 6, 3, 0, -6 },
  { 31, 3, 6, 4, 0, -6 },
  { 34, 2, 6, 4, 0, -6 },
  { 36, 3, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 3, 6, 4, 0, -6 },
  { 45, 3, 6, 4, 0, -6 },
  { 48, 3, 6, 4, 0, -6 },
  { 51, 3, 6, 4, 0, -6 },
  { 54, 3, 6, 4, 0, -6 },
  { 57, 3, 6, 4, 0, -6 },
  { 60, 1, 4, 2, 0, -4 },
  { 61, 1, 5, 2, 0, -4 },
  { 62, 3, 4, 4, 0, -5 },
  { 64, 3, 2, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -5 },
  { 67, 3, 6, 3, 0, -6 },
  { 70, 5, 7, 5, 0, -6 },
  { 75, 4, 6, 4, 0, -6 },
  { 78, 3, 6, 4, 1, -6 },
  { 81, 3, 6, 4, 0, -6 },
  { 84, 3, 6, 4, 1, -6 },
  { 87, 2, 6, 3, 1, -6 },
  { 89, 2, 6, 3, 1, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 3, 6, 4, 1, -6 },
  { 97, 2, 6, 2, 0, -6 },
  { 99, 1, 8, 2, 0, -6 },
  { 100, 3, 6, 4, 1, -6 },
  { 103, 2, 6, 3, 1, -6 },
  { 105, 4, 6, 6, 1, -6 },
  { 108, 3, 6, 5, 1, -6 },
  { 111, 4, 6, 5, 0, -6 },
  { 114, 2, 6, 4, 1, -6 },
  { 116, 4, 7, 5, 0, -6 },
  { 120, 3, 6, 4, 1, -6 },
  { 123, 3, 6, 3, 0, -6 },
  { 126, 3, 6, 3, 0, -6 },
  { 129, 3, 6, 4, 1, -6 },
  { 132, 4, 6, 4, 0, -6 },
  { 135, 6, 6, 6, 0, -6 },
  { 140, 3, 6, 3, 0, -6 },
  { 143, 3, 6, 3, 0, -6 },
  { 146, 3, 6, 3, 0, -6 },
  { 149, 1, 7, 3, 1, -6 },
  { 150, 3, 6, 3, 0, -6 },
  { 153, 2, 7, 3, 0, -6 },
  { 155, 4, 3, 4, 0, -6 },
  { 157, 3, 1, 3, 0, 0 },
  { 158, 2, 1, 2, 0, -6 },
  { 159, 3, 4, 3, 0, -4 },
  { 161, 3, 6, 4, 0, -6 },
  { 164, 3, 4, 3, 0, -4 },
  { 166, 3, 6, 4, 0, -6 },
  { 169, 3, 4, 3, 0, -4 },
  { 171, 2, 6, 2, 0, -6 },
  { 173, 3, 6, 4, 0, -4 },
  { 176, 3, 6, 4, 0, -6 },
  { 179, 1, 6, 2, 0, -6 },
  { 180, 1, 8, 2, 0, -6 },
  { 181, 2, 6, 3, 1, -6 },
  { 183, 1, 6, 2, 0, -6 },
  { 184, 5, 4, 6, 0, -4 },
  { 187, 3, 4, 4, 0, -4 },
  { 189, 3, 4, 4, 0, -4 },
  { 191, 3, 6, 4, 0, -4 },
  { 194, 3, 6, 4, 0, -4 },
  { 197, 2, 4, 3, 0, -4 },
  { 198, 3, 4, 3, 0, -4 },
  { 200, 2, 5, 2, 0, -5 },
  { 202, 3, 4, 4, 0, -4 },
  { 204, 3, 4, 3, 0, -4 },
  { 206, 5, 4, 5, 0, -4 },
  { 209, 3, 4, 3, 0, -4 },
  { 211, 3, 6, 3, 0, -4 },
  { 214, 2, 4, 3, 0, -4 },
  { 215, 3, 7, 3, 0, -6 },
  { 218, 1, 8, 3, 1, -6 },
  { 219, 3, 7, 3, 0, -6 },
  { 222, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Medium8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM8PT7B_H_
