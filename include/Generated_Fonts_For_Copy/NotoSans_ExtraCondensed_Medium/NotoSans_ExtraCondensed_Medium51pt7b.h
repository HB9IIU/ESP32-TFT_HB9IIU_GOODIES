#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x00, 0x00, 0x47,
  0xFF, 0xFF, 0xFF, 0xDF, 0x10, 0xF8, 0x7F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3,
  0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1E, 0xF8, 0x3D, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x80, 0x1C,
  0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x38, 0x38, 0x01,
  0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x83, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0E,
  0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x03, 0xFF, 0xC1, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x38, 0x6F, 0x8E, 0x03, 0xE3, 0x80,
  0xF8, 0xE0, 0x3E, 0x38, 0x0F, 0x8E, 0x03, 0xE3, 0x80, 0x7C, 0xE0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xEF, 0xC0, 0x39, 0xF0, 0x0E, 0x3C, 0x03, 0x8F,
  0x00, 0xE3, 0xC0, 0x38, 0xF8, 0x0E, 0x7F, 0x83, 0xBF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0x0E, 0x00, 0x7F, 0xE0, 0x1E, 0x00,
  0x78, 0xF0, 0x1E, 0x00, 0x70, 0xF0, 0x1C, 0x00, 0xF0, 0xF0, 0x3C, 0x00,
  0xF0, 0xF0, 0x3C, 0x00, 0xF0, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x78, 0x00,
  0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x78, 0xF0, 0x00,
  0xF0, 0xF0, 0xF0, 0x00, 0xF0, 0xF1, 0xE0, 0x00, 0xF0, 0xF1, 0xE3, 0xF0,
  0xF0, 0xF1, 0xC7, 0xF8, 0x70, 0xF3, 0xC7, 0xFC, 0x78, 0xF3, 0xCF, 0x3C,
  0x7F, 0xE3, 0x8F, 0x1E, 0x3F, 0xE7, 0x9E, 0x1E, 0x1F, 0xC7, 0x9E, 0x1E,
  0x0F, 0x0F, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x1F, 0x00, 0x0F, 0x1E, 0x0F,
  0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x1C, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x1F, 0x00, 0x3C, 0x1E, 0x1E, 0x00, 0x38, 0x1E, 0x1E,
  0x00, 0x78, 0x0E, 0x1E, 0x00, 0x78, 0x0F, 0x1E, 0x00, 0xF0, 0x0F, 0x3C,
  0x00, 0xF0, 0x07, 0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x01, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE1,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0x07, 0xC1, 0xFF, 0xC3, 0xE1, 0xF3, 0xE1, 0xF1, 0xF8, 0xF8, 0xF8,
  0xF8, 0x7C, 0x7C, 0x7C, 0x1F, 0x7C, 0x7E, 0x0F, 0xFE, 0x3E, 0x03, 0xFF,
  0x1F, 0x00, 0xFF, 0x0F, 0x80, 0x7F, 0x87, 0xE0, 0x1F, 0x81, 0xF0, 0x0F,
  0xC0, 0xFC, 0x0F, 0xF0, 0x7F, 0x0F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xDF, 0x83, 0xFF, 0xC7, 0xE0, 0xFF, 0x83, 0xF8, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0x00, 0x00, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x06, 0x0E,
  0x0F, 0xE7, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x00,
  0xFE, 0x00, 0xF7, 0x80, 0xFB, 0xE0, 0xF8, 0xF8, 0xFC, 0x7E, 0x1C, 0x1C,
  0x06, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x79, 0xF3, 0xC7, 0x8F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x21, 0xEF, 0xFF, 0xFF,
  0xF7, 0x88, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x0F, 0x87, 0xC7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x01,
  0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF8,
  0xF8, 0x7E, 0x3F, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x8F, 0xFC, 0xFB, 0xEF, 0x9F, 0xF8, 0xFB, 0x87, 0xC8, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1C, 0x07, 0xE2, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFE, 0xFF, 0x1C, 0x07, 0xE2, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7E, 0xE0, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x07, 0x9F,
  0x00, 0x3C, 0xF8, 0x01, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xE1, 0xF0, 0x0F,
  0x0F, 0x80, 0x78, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x70, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE8, 0x01, 0xFB, 0xC0, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x8F, 0xC3, 0xE7, 0xF8, 0xFB, 0xFF, 0x3F, 0xFF, 0xEF,
  0xF1, 0xFB, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF,
  0x87, 0xF1, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x07,
  0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0x7C, 0x3F,
  0x0F, 0xCF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7C, 0x7F, 0x1F, 0x07, 0xE7, 0xE0, 0x7E,
  0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F, 0xCF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x03, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x87, 0xC7,
  0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFF, 0x03, 0xF7, 0xC1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFD, 0xF1,
  0xFE, 0x7C, 0x1E, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0x00, 0x00,
  0x33, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x47, 0xFF, 0xFF, 0xFF, 0xDE, 0x30, 0x18, 0x7D,
  0xFB, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF,
  0x9E, 0x3C, 0xF9, 0xE3, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xC0, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xCC, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE3, 0xC0,
  0x3F, 0x07, 0x8F, 0x03, 0xFF, 0x1E, 0x3C, 0x1F, 0xFC, 0x39, 0xE0, 0xF8,
  0xF0, 0xF7, 0x83, 0xC3, 0xC3, 0xDE, 0x1E, 0x0F, 0x0F, 0x78, 0x78, 0x7C,
  0x3D, 0xC1, 0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0x83, 0xFC, 0x3C, 0x1E, 0x0F,
  0xF0, 0xF0, 0x78, 0x3F, 0xC3, 0xC1, 0xE0, 0xFF, 0x0F, 0x07, 0x83, 0xFC,
  0x3C, 0x1E, 0x0F, 0xF0, 0xF0, 0x78, 0x3B, 0xC1, 0xE1, 0xE1, 0xE7, 0x07,
  0x8F, 0x87, 0x9E, 0x1F, 0x77, 0x3C, 0x78, 0x3F, 0xDF, 0xF1, 0xE0, 0xFE,
  0x3F, 0x87, 0x81, 0xF0, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x06, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xE7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x00,
  0xF8, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7C, 0x0F, 0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xF7, 0xC1, 0xFE, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFC, 0x06,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x01, 0x0F, 0xE0, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x83, 0xFC, 0x7C, 0x07, 0xE3,
  0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xBE, 0x00,
  0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E,
  0x7C, 0x07, 0xE3, 0xE0, 0x7F, 0x1F, 0x3F, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFC, 0x03, 0x87, 0xF0, 0x01, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xF7, 0xC0, 0x7F, 0xEF,
  0x80, 0xFF, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xE0,
  0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x0F, 0xE0, 0x3E, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x7F, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xEE, 0xFE,
  0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8,
  0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F,
  0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80,
  0xF9, 0xF8, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0xF8, 0x0F, 0xCF,
  0x80, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF,
  0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFD, 0xE0,
  0x03, 0xFF, 0xF7, 0x80, 0x0F, 0x7F, 0xDF, 0x00, 0x3D, 0xFF, 0x7C, 0x00,
  0xF7, 0xFC, 0xF0, 0x07, 0xDF, 0xF3, 0xC0, 0x1E, 0x7F, 0xCF, 0x80, 0x79,
  0xFF, 0x1E, 0x01, 0xE7, 0xFC, 0x78, 0x0F, 0x1F, 0xF1, 0xE0, 0x3C, 0x7F,
  0xC7, 0xC0, 0xF1, 0xFF, 0x0F, 0x07, 0xC7, 0xFC, 0x3C, 0x1E, 0x1F, 0xF0,
  0xF8, 0x78, 0x7F, 0xC3, 0xE1, 0xE1, 0xFF, 0x07, 0x8F, 0x87, 0xFC, 0x1E,
  0x3C, 0x1F, 0xF0, 0x7C, 0xF0, 0x7F, 0xC0, 0xF7, 0xC1, 0xFF, 0x03, 0xDE,
  0x07, 0xFC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x81,
  0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F,
  0xC0, 0x3E, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xF7, 0xC0, 0x3F,
  0xDF, 0x00, 0xFF, 0x3C, 0x03, 0xFC, 0xF8, 0x0F, 0xF3, 0xE0, 0x3F, 0xC7,
  0xC0, 0xFF, 0x1F, 0x03, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8, 0x3F, 0xC3, 0xE0,
  0xFF, 0x07, 0xC3, 0xFC, 0x1F, 0x0F, 0xF0, 0x3E, 0x3F, 0xC0, 0xF8, 0xFF,
  0x01, 0xF3, 0xFC, 0x07, 0xCF, 0xF0, 0x1F, 0x3F, 0xC0, 0x3E, 0xFF, 0x00,
  0xFB, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F,
  0x80, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x07, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x1F,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8, 0x7F, 0x8F,
  0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F,
  0x8F, 0x81, 0xF8, 0xF8, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xE7,
  0xFF, 0xF7, 0xFF, 0xF3, 0xF0, 0x39, 0xF0, 0x05, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x80,
  0x3F, 0xF8, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF8,
  0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF8, 0x00, 0xF1, 0xF0,
  0x01, 0xE3, 0xE0, 0x03, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x07, 0xBE, 0x00,
  0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xDF,
  0x00, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xC0,
  0x1F, 0x3E, 0x00, 0xFE, 0x00, 0xF9, 0xF0, 0x07, 0xF0, 0x07, 0xC7, 0xC0,
  0x3B, 0x80, 0x7E, 0x3E, 0x03, 0xDE, 0x03, 0xE1, 0xF0, 0x1E, 0xF0, 0x1F,
  0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x7C, 0x07, 0xBC, 0x07, 0xC1, 0xE0, 0x3D,
  0xE0, 0x7E, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0x7C, 0x1E, 0x3C, 0x1F, 0x03,
  0xE0, 0xF1, 0xE0, 0xF8, 0x1F, 0x07, 0x8F, 0x07, 0xC0, 0x78, 0x3C, 0x78,
  0x3E, 0x03, 0xE3, 0xE3, 0xE3, 0xE0, 0x1F, 0x1F, 0x0F, 0x1F, 0x00, 0xF8,
  0xF0, 0x78, 0xF8, 0x07, 0xC7, 0x83, 0xC7, 0xC0, 0x1E, 0x3C, 0x1E, 0x3E,
  0x00, 0xFB, 0xE0, 0xFB, 0xE0, 0x07, 0xDF, 0x03, 0xDF, 0x00, 0x3E, 0xF0,
  0x1E, 0xF8, 0x01, 0xF7, 0x80, 0xF7, 0xC0, 0x07, 0xBC, 0x07, 0xBE, 0x00,
  0x3D, 0xE0, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0x8F,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE1, 0xE0,
  0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xF8, 0x01, 0xF0,
  0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xFC, 0x03, 0xE3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x1E, 0x1E, 0x00,
  0xF8, 0x7C, 0x03, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xE0,
  0x1E, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07,
  0xBE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xC3, 0xF0, 0x80,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFE, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xFE, 0xF7, 0xBF, 0xFB, 0xDF, 0xF9, 0xE3, 0xF8, 0xF0,
  0x60, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3E, 0x0F, 0x9F, 0xE1, 0xF7, 0xFE, 0x3F,
  0xFF, 0xE7, 0xF8, 0xFC, 0xFE, 0x0F, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xDF, 0xC0, 0xFB, 0xF8,
  0x3F, 0x7F, 0xFF, 0xCF, 0xBF, 0xF9, 0xE7, 0xFE, 0x3C, 0x3F, 0x80, 0x01,
  0x80, 0x03, 0xF8, 0x0F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0xF8, 0xC7, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x81, 0x3F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x83, 0xF1,
  0xF0, 0xFF, 0x3E, 0x3F, 0xF7, 0xCF, 0xFF, 0xF9, 0xF8, 0xFF, 0x7E, 0x0F,
  0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x9F, 0xFF, 0xF3, 0xFF, 0xDE,
  0x3F, 0xF3, 0xC3, 0xFC, 0x78, 0x0C, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0x79, 0xF0,
  0x1E, 0x78, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x08, 0xFC,
  0x06, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x20,
  0x00, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFC, 0x41, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xC7,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0xE1, 0xE1, 0xFE, 0x3C, 0x7F, 0xE7, 0x9F, 0xFF,
  0xF3, 0xF1, 0xFE, 0xFC, 0x1F, 0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x7F,
  0x3F, 0xFF, 0xE7, 0xFF, 0x7C, 0x7F, 0xEF, 0x87, 0xF9, 0xF0, 0x10, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF9,
  0x00, 0x3F, 0x3C, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE3, 0xF0, 0xF9, 0xFE, 0x3E, 0xFF, 0xCF, 0xFF, 0xFB,
  0xFE, 0xFE, 0xFE, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x77, 0xFF, 0xFF, 0xBC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0xFF, 0xFD, 0xFE,
  0xFE, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFB, 0xE0, 0x7F, 0x7C, 0x0F, 0xC7, 0xC1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0xFC, 0x0F, 0xC3, 0xC7, 0xF8, 0x7F, 0x8F, 0x3F, 0xF3, 0xFF,
  0x3D, 0xFF, 0xDF, 0xFE, 0xFF, 0x3F, 0xF3, 0xFB, 0xF8, 0x3F, 0x83, 0xEF,
  0xC0, 0xFC, 0x0F, 0xBF, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0,
  0x3F, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF8, 0x0F,
  0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03, 0xE0,
  0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x07,
  0xFE, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF,
  0x80, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0,
  0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0xFC,
  0x3C, 0x7F, 0x8F, 0x3F, 0xF3, 0xDF, 0xFE, 0xFF, 0x1F, 0xBF, 0x83, 0xEF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF1,
  0xF8, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x81, 0xF1, 0xF0, 0x7E, 0x3F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x04, 0x00, 0xF0, 0xFC,
  0x1E, 0x3F, 0xC3, 0xCF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF1, 0xFD, 0xFC, 0x1F,
  0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xBF, 0x81, 0xF7, 0xF0, 0x7E, 0xFF, 0xFF, 0x9F, 0x7F, 0xF3,
  0xE7, 0xFC, 0x7C, 0x7F, 0x0F, 0x83, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE1, 0xE1,
  0xFE, 0x3C, 0x7F, 0xE7, 0x9F, 0xFF, 0xF3, 0xF1, 0xFE, 0xFC, 0x1F, 0xDF,
  0x01, 0xFB, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x7F, 0x3F, 0xFF, 0xE7, 0xFF, 0x7C, 0x7F,
  0xEF, 0x87, 0xF1, 0xF0, 0x10, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC,
  0xFD, 0xE7, 0xEF, 0xFF, 0x7F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0xDF,
  0xFE, 0xFC, 0x3B, 0xE0, 0x2F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x02, 0x00, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F,
  0x01, 0x80, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFD, 0xF0, 0xFF, 0x7F, 0xFF, 0xCF, 0xFD,
  0xF3, 0xFF, 0x3C, 0x7F, 0x0F, 0x03, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF9, 0xF0,
  0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x78, 0x07,
  0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x0F,
  0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x3C, 0x3E, 0x0F,
  0xF0, 0x7C, 0x3E, 0x0E, 0x70, 0x7C, 0x3E, 0x1E, 0x70, 0x7C, 0x1E, 0x1E,
  0x78, 0x78, 0x1E, 0x1E, 0x78, 0x78, 0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x1E,
  0x78, 0xF8, 0x1F, 0x3C, 0x38, 0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C,
  0x3C, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xB8,
  0x3D, 0xE0, 0x07, 0xB8, 0x1D, 0xE0, 0x07, 0xF8, 0x1D, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0,
  0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x07,
  0xFF, 0x03, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7C, 0xF0, 0x1F, 0x3E, 0x07, 0x8F, 0x83,
  0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1,
  0xE0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0,
  0x0F, 0x8F, 0x00, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0x9E,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x04, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0x7F, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x03, 0xF0, 0x1F, 0xC0,
  0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0, 0x3F, 0x80,
  0xFF, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x7F, 0x03, 0xFE, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x13, 0xFC, 0x01, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x80, 0x1F, 0xC8, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 37, 12, 3, -36 },
  { 29, 15, 13, 20, 3, -36 },
  { 54, 22, 36, 24, 1, -36 },
  { 153, 18, 42, 22, 2, -39 },
  { 248, 32, 37, 36, 2, -37 },
  { 396, 25, 38, 26, 1, -37 },
  { 515, 5, 13, 11, 3, -36 },
  { 524, 12, 45, 15, 2, -37 },
  { 592, 12, 45, 15, 1, -37 },
  { 660, 17, 18, 21, 2, -39 },
  { 699, 19, 24, 22, 2, -30 },
  { 756, 7, 13, 12, 2, -6 },
  { 768, 12, 5, 14, 1, -16 },
  { 776, 6, 8, 12, 3, -7 },
  { 782, 18, 37, 19, 1, -37 },
  { 866, 18, 38, 22, 2, -37 },
  { 952, 13, 36, 22, 3, -36 },
  { 1011, 18, 37, 22, 2, -37 },
  { 1095, 18, 38, 22, 2, -37 },
  { 1181, 21, 37, 22, 1, -37 },
  { 1279, 18, 37, 22, 2, -36 },
  { 1363, 18, 38, 22, 2, -37 },
  { 1449, 20, 36, 22, 1, -36 },
  { 1539, 19, 38, 22, 2, -37 },
  { 1630, 18, 38, 22, 2, -37 },
  { 1716, 6, 29, 12, 3, -28 },
  { 1738, 7, 35, 12, 2, -28 },
  { 1769, 20, 23, 22, 1, -30 },
  { 1827, 20, 14, 22, 1, -25 },
  { 1862, 19, 23, 22, 2, -30 },
  { 1917, 15, 38, 17, 1, -37 },
  { 1989, 30, 41, 34, 2, -37 },
  { 2143, 24, 36, 24, 0, -36 },
  { 2251, 19, 36, 25, 4, -36 },
  { 2337, 20, 38, 23, 2, -37 },
  { 2432, 21, 36, 27, 4, -36 },
  { 2527, 15, 36, 21, 4, -36 },
  { 2595, 15, 36, 20, 4, -36 },
  { 2663, 23, 38, 28, 2, -37 },
  { 2773, 20, 36, 28, 4, -36 },
  { 2863, 11, 36, 15, 2, -36 },
  { 2913, 12, 46, 12, -3, -36 },
  { 2982, 20, 36, 24, 4, -36 },
  { 3072, 15, 36, 19, 4, -36 },
  { 3140, 30, 36, 37, 4, -36 },
  { 3275, 22, 36, 30, 4, -36 },
  { 3374, 24, 38, 29, 2, -37 },
  { 3488, 18, 36, 23, 4, -36 },
  { 3569, 24, 46, 29, 2, -37 },
  { 3707, 20, 36, 24, 4, -36 },
  { 3797, 17, 38, 21, 2, -37 },
  { 3878, 19, 36, 20, 1, -36 },
  { 3964, 21, 37, 27, 3, -36 },
  { 4062, 23, 36, 23, 0, -36 },
  { 4166, 37, 36, 37, 0, -36 },
  { 4333, 21, 36, 22, 0, -36 },
  { 4428, 21, 36, 21, 0, -36 },
  { 4523, 17, 36, 19, 1, -36 },
  { 4600, 11, 45, 16, 3, -37 },
  { 4662, 18, 37, 19, 1, -37 },
  { 4746, 11, 45, 16, 1, -37 },
  { 4808, 22, 20, 24, 1, -36 },
  { 4863, 22, 4, 22, 0, 4 },
  { 4874, 10, 8, 14, 2, -39 },
  { 4884, 17, 29, 22, 2, -28 },
  { 4946, 19, 40, 24, 3, -39 },
  { 5041, 15, 29, 18, 2, -28 },
  { 5096, 19, 40, 24, 2, -39 },
  { 5191, 18, 29, 22, 2, -28 },
  { 5257, 15, 39, 14, 0, -39 },
  { 5331, 19, 40, 24, 2, -28 },
  { 5426, 18, 39, 24, 3, -39 },
  { 5514, 5, 38, 11, 3, -38 },
  { 5538, 9, 50, 11, -1, -38 },
  { 5595, 19, 39, 22, 3, -39 },
  { 5688, 5, 39, 11, 3, -39 },
  { 5713, 30, 28, 36, 3, -28 },
  { 5818, 18, 28, 24, 3, -28 },
  { 5881, 19, 29, 23, 2, -28 },
  { 5950, 19, 40, 24, 3, -28 },
  { 6045, 19, 40, 24, 2, -28 },
  { 6140, 13, 28, 16, 3, -28 },
  { 6186, 14, 29, 18, 2, -28 },
  { 6237, 12, 35, 14, 1, -34 },
  { 6290, 18, 29, 24, 3, -28 },
  { 6356, 20, 28, 20, 0, -28 },
  { 6426, 32, 28, 32, 0, -28 },
  { 6538, 18, 28, 20, 1, -28 },
  { 6601, 20, 40, 20, 0, -28 },
  { 6701, 14, 28, 16, 1, -28 },
  { 6750, 14, 45, 18, 2, -37 },
  { 6829, 5, 51, 21, 8, -39 },
  { 6861, 15, 45, 18, 2, -37 },
  { 6946, 20, 8, 22, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Medium51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM51PT7B_H_
