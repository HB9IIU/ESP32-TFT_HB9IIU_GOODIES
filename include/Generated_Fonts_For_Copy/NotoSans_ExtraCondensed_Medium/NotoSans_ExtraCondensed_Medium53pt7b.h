#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF1,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x7D, 0xFF, 0xFF, 0xFF, 0xCF, 0x84, 0x00,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0xF0, 0x7D, 0xE0, 0xFB, 0xC1, 0xF7, 0x83,
  0xCF, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x83, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E,
  0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0xF0, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xF9, 0xFF, 0xFE,
  0x7F, 0xE7, 0xCF, 0x9C, 0x13, 0xE3, 0x80, 0x7C, 0x70, 0x0F, 0x8E, 0x01,
  0xF1, 0xC0, 0x3E, 0x38, 0x03, 0xE7, 0x00, 0x7E, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0xEF, 0xC0, 0x1C, 0x7C, 0x03, 0x8F, 0x80, 0x70, 0xF0,
  0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0xFE, 0x07, 0x1F, 0xF0, 0xEF, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xBE, 0x01, 0xE0, 0x07, 0x8F, 0x00, 0xF0, 0x03, 0xC7, 0x80, 0xF0,
  0x03, 0xC1, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x0F,
  0x00, 0x0F, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC7, 0x80, 0x03, 0xC1, 0xE3,
  0xC0, 0x01, 0xE0, 0xF1, 0xE3, 0xF0, 0xF0, 0x79, 0xE3, 0xFC, 0x3C, 0x78,
  0xF1, 0xFF, 0x1E, 0x3C, 0x79, 0xF7, 0xCF, 0xBE, 0x78, 0xF1, 0xE3, 0xFE,
  0x3C, 0xF0, 0xF1, 0xFF, 0x3E, 0x78, 0x78, 0x3E, 0x1E, 0x3C, 0x3E, 0x00,
  0x0F, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x83, 0xC0,
  0x03, 0xC3, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x1F,
  0x00, 0x3C, 0x0F, 0x0F, 0x00, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x01, 0xF7,
  0xC0, 0x1E, 0x00, 0x7F, 0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x78, 0x00,
  0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x7C, 0x1F, 0xFC, 0x1F, 0x0F, 0xDF, 0x87,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF8, 0xFC, 0xFC, 0x7C, 0x1F, 0x3E, 0x1F, 0x03,
  0xEF, 0x8F, 0xC0, 0xFF, 0xE3, 0xF0, 0x1F, 0xF0, 0xFC, 0x07, 0xFC, 0x3F,
  0x00, 0xFE, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x0F, 0xE0, 0x7E, 0x07, 0xFC,
  0x1F, 0xC3, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0xFC, 0x1F, 0xFE,
  0x1F, 0x81, 0xFF, 0x07, 0xF0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFB,
  0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE0, 0x01, 0xF0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x18, 0x78, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xCF, 0x01, 0xF3, 0xE0, 0xF8,
  0x7C, 0x1E, 0x1E, 0x03, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3B, 0xFF, 0xFF, 0xFF, 0xF7,
  0xC4, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xF0, 0x7E,
  0x3E, 0x0F, 0x87, 0xE3, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xF0,
  0x7F, 0x87, 0xFC, 0x7D, 0xE7, 0xFF, 0x7E, 0xFF, 0xE7, 0xDE, 0x3E, 0x61,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0xF8, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE3, 0xF8, 0xE0, 0x1F, 0x88, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xC3, 0xF8, 0xE0, 0x1F, 0x88, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x80, 0x0F, 0xDE, 0x07, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1D, 0xF0, 0x00, 0xF7, 0xC0,
  0x03, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xC7, 0xC0, 0x0F,
  0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1F,
  0x01, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x8C, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF0, 0x81, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x80, 0x3F, 0xB8, 0x1F,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFE, 0x08,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x3F, 0x07,
  0xCF, 0xF8, 0xFB, 0xFF, 0x9F, 0x7F, 0xF3, 0xFE, 0xFF, 0x7F, 0x07, 0xEF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xE3, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0xFC, 0x3F, 0x1F, 0x81, 0xFB, 0xF0,
  0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xF3, 0xF8, 0x7E, 0x0F, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xE7, 0xE0, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xF3, 0xF8, 0xFC, 0x1F,
  0x1F, 0x03, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x3F, 0xBF, 0x8F, 0xF3, 0xFF, 0xFE,
  0x7F, 0xF7, 0xC7, 0xFC, 0xF8, 0x7F, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x08, 0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0xFF, 0xF7,
  0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x9F, 0xFF, 0xFF, 0xFF, 0x7C, 0x40, 0x1C, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x78, 0xFE, 0x60, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x0F, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x0F, 0xE0, 0xF1,
  0xE0, 0x7F, 0xF1, 0xE3, 0xC1, 0xFF, 0xE1, 0xEF, 0x83, 0xE7, 0xC3, 0xDE,
  0x0F, 0x8F, 0x87, 0xBC, 0x1E, 0x1E, 0x0F, 0x78, 0x7C, 0x3C, 0x1E, 0xF0,
  0xF0, 0x78, 0x3D, 0xE1, 0xE0, 0xF0, 0x7F, 0x83, 0xC1, 0xE0, 0xFF, 0x07,
  0x83, 0xC1, 0xFE, 0x0F, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0x07, 0xF8, 0x3C,
  0x1E, 0x0F, 0xF0, 0x78, 0x3C, 0x1F, 0xE0, 0xF0, 0xF8, 0x3D, 0xE1, 0xE1,
  0xF0, 0xF3, 0xC3, 0xE3, 0x71, 0xE7, 0x83, 0xFE, 0xFF, 0x8F, 0x07, 0xFD,
  0xFF, 0x1E, 0x07, 0xF1, 0xFC, 0x3E, 0x03, 0xC1, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xFE, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C,
  0x78, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01,
  0xF8, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0x80, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07,
  0xCF, 0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0xF8, 0x7F, 0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xE3, 0xE1, 0xF8,
  0x04, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x21, 0xFE, 0x1E, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0C, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xE0, 0x7F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xFC, 0xF8, 0x03,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF,
  0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x1F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x87, 0xC3,
  0xF8, 0x01, 0x8F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x80, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0xC0, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x7F, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE8, 0x7E, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0xF0, 0x10, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00,
  0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x7E, 0x1F,
  0x03, 0xF0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xF8,
  0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x7E, 0x00, 0xFB,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3,
  0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFB, 0xC0, 0x01, 0xFF, 0xF7, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1E, 0xFF, 0xDE, 0x00, 0x3D, 0xFF, 0xBE, 0x00, 0xFB, 0xFF,
  0x7C, 0x01, 0xE7, 0xFE, 0x78, 0x03, 0xCF, 0xFC, 0xF0, 0x0F, 0x9F, 0xF9,
  0xF0, 0x1F, 0x3F, 0xF3, 0xE0, 0x3C, 0x7F, 0xE3, 0xC0, 0x78, 0xFF, 0xC7,
  0xC1, 0xF1, 0xFF, 0x8F, 0x83, 0xC3, 0xFF, 0x0F, 0x07, 0x87, 0xFE, 0x1E,
  0x1F, 0x0F, 0xFC, 0x3E, 0x3E, 0x1F, 0xF8, 0x7C, 0x78, 0x3F, 0xF0, 0x78,
  0xF0, 0x7F, 0xE0, 0xF3, 0xE0, 0xFF, 0xC1, 0xF7, 0x81, 0xFF, 0x83, 0xEF,
  0x03, 0xFF, 0x03, 0xDE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F, 0x80,
  0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07,
  0xC0, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF7, 0xC0, 0x3F, 0xEF, 0x80, 0x7F, 0xEF, 0x00, 0xFF, 0xDF, 0x01, 0xFF,
  0xBE, 0x03, 0xFF, 0x3E, 0x07, 0xFE, 0x7C, 0x0F, 0xFC, 0x7C, 0x1F, 0xF8,
  0xF8, 0x3F, 0xF1, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x83,
  0xE3, 0xFF, 0x07, 0xC7, 0xFE, 0x07, 0xCF, 0xFC, 0x0F, 0x9F, 0xF8, 0x1F,
  0xBF, 0xF0, 0x1F, 0x7F, 0xE0, 0x3E, 0x7F, 0xC0, 0x3E, 0xFF, 0x80, 0x7D,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9,
  0xF0, 0x3F, 0xBE, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0x81,
  0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xE7,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x37, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7C, 0x0F, 0xE3, 0xE0, 0x3F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0xCF,
  0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC1, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x01, 0xF9,
  0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x00, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x80, 0xE7, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xBF, 0x9F,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3E, 0xFE, 0x03, 0xF3, 0xFC, 0x7F,
  0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07,
  0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7F, 0xF0, 0x00, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xC0,
  0x1F, 0x9F, 0x00, 0x3F, 0x80, 0x3E, 0x3F, 0x00, 0xFF, 0x00, 0x7C, 0x3E,
  0x01, 0xFE, 0x00, 0xF8, 0x7C, 0x03, 0xDE, 0x03, 0xF0, 0xF8, 0x07, 0xBC,
  0x07, 0xE1, 0xF0, 0x0F, 0x78, 0x0F, 0x83, 0xF0, 0x3E, 0xF0, 0x1F, 0x03,
  0xE0, 0x7D, 0xE0, 0x3E, 0x07, 0xC0, 0xF3, 0xC0, 0xFC, 0x0F, 0x81, 0xE7,
  0xC1, 0xF8, 0x1F, 0x03, 0xC7, 0x83, 0xE0, 0x3F, 0x0F, 0x8F, 0x07, 0xC0,
  0x3E, 0x1F, 0x1E, 0x0F, 0x80, 0x7C, 0x3C, 0x3C, 0x3F, 0x00, 0xF8, 0x78,
  0x7C, 0x7E, 0x01, 0xF0, 0xF0, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0xF1, 0xF0,
  0x03, 0xE7, 0xC1, 0xE3, 0xE0, 0x07, 0xCF, 0x03, 0xC7, 0xC0, 0x0F, 0x9E,
  0x07, 0xDF, 0x00, 0x1F, 0x3C, 0x07, 0xBE, 0x00, 0x1E, 0x78, 0x0F, 0x7C,
  0x00, 0x3D, 0xF0, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x3D, 0xF0, 0x00, 0xFF,
  0x80, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x77, 0x80, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF8,
  0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x1F,
  0xBE, 0x00, 0x7C, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x81, 0xF8, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80,
  0x03, 0xEF, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x3C, 0x1E, 0x00,
  0xF8, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1C, 0x1F, 0x84, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF,
  0xFD, 0xFE, 0x1F, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xDF,
  0xFF, 0xF7, 0xFF, 0x7C, 0xFF, 0x9F, 0x1F, 0xC3, 0xC0, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x87, 0xE0, 0xF9, 0xFF, 0x0F, 0xBF, 0xF8, 0xFB, 0xFF,
  0xCF, 0xF9, 0xFC, 0xFE, 0x07, 0xEF, 0xE0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E,
  0xFE, 0x07, 0xEF, 0xF0, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF, 0xF8, 0xF9, 0xFF,
  0x8F, 0x8F, 0xE0, 0x00, 0x18, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFE, 0x3F, 0x8E, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0x3F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x1F,
  0x0F, 0xF9, 0xF1, 0xFF, 0xDF, 0x3F, 0xFD, 0xF3, 0xF9, 0xFF, 0x7E, 0x07,
  0xF7, 0xE0, 0x7F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7,
  0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF3, 0xF0, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x0F, 0xF9, 0xF0, 0x7F, 0x0F, 0x00, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF1,
  0xF8, 0x7C, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x02, 0x3F, 0x01,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x03,
  0xE0, 0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF, 0xDF, 0x3F, 0x9F, 0xF7,
  0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F,
  0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFD, 0xF0, 0xFF, 0x9F, 0x07, 0xF1, 0xF0,
  0x18, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE4, 0x00, 0x7E, 0x70, 0x0F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3F,
  0x0F, 0x9F, 0xF1, 0xF7, 0xFF, 0x3E, 0xFF, 0xF7, 0xFE, 0xFE, 0xFE, 0x07,
  0xDF, 0xC0, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x21, 0xEF, 0xFF, 0xFF, 0xE7,
  0x80, 0x00, 0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x02, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0xFF, 0xBF, 0xCF, 0xF3, 0xF8, 0x78, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x03,
  0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x3F,
  0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0x3E, 0x0F, 0xE7, 0xC1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFD,
  0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xE1,
  0xE3, 0xFE, 0x1F, 0xF3, 0xEF, 0xFE, 0x7F, 0xE7, 0xDF, 0xFD, 0xFF, 0xEF,
  0xF9, 0xFF, 0x9F, 0xDF, 0xC1, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x1F, 0xFE,
  0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0x7F, 0xF0,
  0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00,
  0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07,
  0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E,
  0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0,
  0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80,
  0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0xF0, 0x7E, 0x1E, 0x3F, 0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xEF, 0xF9,
  0xFD, 0xFC, 0x1F, 0xBF, 0x81, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x9F, 0xC3, 0xE0,
  0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x0F,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x02,
  0x00, 0xF0, 0x7E, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF,
  0x8F, 0xCF, 0xE0, 0x7E, 0xFE, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xE0,
  0x7E, 0xFF, 0x0F, 0xCF, 0xBF, 0xFC, 0xFB, 0xFF, 0x8F, 0x9F, 0xF8, 0xF8,
  0xFE, 0x0F, 0x81, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF, 0xDF, 0x3F, 0x9F, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0x0F,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFD, 0xF0, 0xFF, 0x9F, 0x07, 0xF1, 0xF0, 0x18,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x8F, 0xFE, 0x7F,
  0xF7, 0xFF, 0xBF, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xF9, 0xFF,
  0xFB, 0xFF, 0xEF, 0xC3, 0xDF, 0x01, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x87,
  0xFE, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x23, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFE, 0x01, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFB, 0xE0, 0x7F,
  0x7E, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xEF, 0x9F, 0xF9, 0xF0, 0xFE, 0x3E,
  0x02, 0x00, 0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x78, 0x07, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x00,
  0x3C, 0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xBE, 0x01, 0xF8, 0x07, 0xDF, 0x01, 0xFC, 0x07, 0xCF, 0x80, 0xFE, 0x03,
  0xE7, 0xC0, 0x7F, 0x01, 0xF1, 0xE0, 0x3F, 0x80, 0xF8, 0xF8, 0x1D, 0xE0,
  0x78, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E, 0x0F, 0x78, 0x3E, 0x1F, 0x07, 0xBC,
  0x1F, 0x07, 0xC3, 0xDE, 0x0F, 0x83, 0xE1, 0xE7, 0x87, 0x81, 0xF1, 0xE3,
  0xC7, 0xC0, 0xF8, 0xF1, 0xE3, 0xE0, 0x7C, 0x78, 0xF1, 0xF0, 0x1E, 0x3C,
  0x78, 0xF0, 0x0F, 0x9E, 0x3E, 0x78, 0x07, 0xDF, 0x0F, 0x7C, 0x03, 0xEF,
  0x07, 0xBE, 0x00, 0xF7, 0x83, 0xDF, 0x00, 0x7B, 0xC1, 0xEF, 0x00, 0x3D,
  0xE0, 0xF7, 0x80, 0x1F, 0xF0, 0x3B, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xFF, 0x80,
  0xF9, 0xF0, 0x3F, 0x3F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xC7,
  0xC0, 0xF9, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7E,
  0x07, 0xC7, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1F,
  0x7E, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x80, 0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07,
  0x8F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0x80, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0x7E, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFA, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 39, 13, 3, -38 },
  { 36, 15, 14, 21, 3, -38 },
  { 63, 23, 38, 25, 1, -38 },
  { 173, 19, 43, 23, 2, -40 },
  { 276, 33, 38, 37, 2, -38 },
  { 433, 26, 39, 27, 1, -38 },
  { 560, 6, 14, 11, 3, -38 },
  { 571, 12, 46, 16, 3, -38 },
  { 640, 12, 46, 16, 1, -38 },
  { 709, 18, 18, 22, 2, -40 },
  { 750, 20, 25, 23, 2, -31 },
  { 813, 8, 13, 12, 2, -6 },
  { 826, 13, 5, 15, 1, -17 },
  { 835, 6, 8, 12, 3, -7 },
  { 841, 19, 38, 20, 1, -38 },
  { 932, 19, 39, 23, 2, -38 },
  { 1025, 13, 38, 23, 3, -38 },
  { 1087, 19, 38, 23, 2, -38 },
  { 1178, 19, 39, 23, 2, -38 },
  { 1271, 22, 38, 23, 1, -38 },
  { 1376, 18, 39, 23, 3, -38 },
  { 1464, 19, 39, 23, 2, -38 },
  { 1557, 20, 38, 23, 1, -38 },
  { 1652, 20, 39, 23, 2, -38 },
  { 1750, 19, 39, 23, 2, -38 },
  { 1843, 6, 30, 13, 3, -29 },
  { 1866, 8, 36, 13, 2, -29 },
  { 1902, 21, 24, 23, 1, -31 },
  { 1965, 20, 15, 23, 2, -26 },
  { 2003, 20, 24, 23, 2, -31 },
  { 2063, 16, 39, 18, 1, -38 },
  { 2141, 31, 42, 36, 2, -38 },
  { 2304, 25, 38, 25, 0, -38 },
  { 2423, 20, 38, 26, 4, -38 },
  { 2518, 20, 39, 24, 3, -38 },
  { 2616, 22, 38, 28, 4, -38 },
  { 2721, 15, 38, 22, 4, -38 },
  { 2793, 15, 38, 21, 4, -38 },
  { 2865, 23, 39, 29, 3, -38 },
  { 2978, 21, 38, 29, 4, -38 },
  { 3078, 12, 38, 15, 2, -38 },
  { 3135, 12, 49, 13, -3, -38 },
  { 3209, 21, 38, 25, 4, -38 },
  { 3309, 15, 38, 20, 4, -38 },
  { 3381, 31, 38, 39, 4, -38 },
  { 3529, 23, 38, 31, 4, -38 },
  { 3639, 24, 39, 30, 3, -38 },
  { 3756, 19, 38, 24, 4, -38 },
  { 3847, 24, 47, 30, 3, -38 },
  { 3988, 21, 38, 25, 4, -38 },
  { 4088, 18, 39, 22, 2, -38 },
  { 4176, 19, 38, 21, 1, -38 },
  { 4267, 21, 39, 28, 4, -38 },
  { 4370, 24, 38, 24, 0, -38 },
  { 4484, 39, 38, 39, 0, -38 },
  { 4670, 22, 38, 22, 0, -38 },
  { 4775, 22, 38, 22, 0, -38 },
  { 4880, 18, 38, 20, 1, -38 },
  { 4966, 11, 46, 17, 4, -38 },
  { 5030, 19, 38, 20, 1, -38 },
  { 5121, 11, 46, 17, 2, -38 },
  { 5185, 23, 21, 25, 1, -38 },
  { 5246, 23, 4, 23, 0, 4 },
  { 5258, 11, 9, 15, 2, -41 },
  { 5271, 18, 30, 23, 2, -29 },
  { 5339, 20, 41, 25, 3, -40 },
  { 5442, 16, 30, 19, 2, -29 },
  { 5502, 20, 41, 25, 2, -40 },
  { 5605, 19, 30, 23, 2, -29 },
  { 5677, 16, 41, 14, 0, -41 },
  { 5759, 20, 42, 25, 2, -29 },
  { 5864, 19, 40, 25, 3, -40 },
  { 5959, 6, 40, 12, 3, -40 },
  { 5989, 10, 53, 12, -1, -40 },
  { 6056, 19, 40, 22, 3, -40 },
  { 6151, 5, 40, 12, 3, -40 },
  { 6176, 31, 29, 37, 3, -29 },
  { 6289, 19, 29, 25, 3, -29 },
  { 6358, 20, 30, 24, 2, -29 },
  { 6433, 20, 42, 25, 3, -29 },
  { 6538, 20, 42, 25, 2, -29 },
  { 6643, 13, 29, 17, 3, -29 },
  { 6691, 15, 30, 19, 2, -29 },
  { 6748, 13, 36, 15, 1, -35 },
  { 6807, 19, 30, 25, 3, -29 },
  { 6879, 21, 29, 21, 0, -29 },
  { 6956, 33, 29, 33, 0, -29 },
  { 7076, 19, 29, 21, 1, -29 },
  { 7145, 21, 42, 21, 0, -29 },
  { 7256, 15, 29, 17, 1, -29 },
  { 7311, 15, 46, 19, 2, -38 },
  { 7398, 4, 53, 22, 9, -40 },
  { 7425, 15, 46, 19, 2, -38 },
  { 7512, 21, 7, 23, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Medium53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM53PT7B_H_
