#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDC, 0xA5, 0x20, 0x14, 0x68, 0x93, 0xF2, 0x45,
  0xBF, 0xFF, 0x28, 0xD1, 0x20, 0x23, 0xFF, 0x4A, 0x70, 0xC5, 0x2D, 0x7C,
  0x42, 0x00, 0x40, 0x38, 0x8A, 0x62, 0xD0, 0xB4, 0x2A, 0xEE, 0xA9, 0x2A,
  0x12, 0xC4, 0xB3, 0x28, 0x8E, 0x10, 0x38, 0x6C, 0x6C, 0x28, 0x38, 0x73,
  0x5A, 0xCE, 0xC6, 0x6E, 0x7B, 0xEA, 0x2D, 0x6D, 0x24, 0x93, 0x64, 0xC8,
  0xC4, 0x62, 0x33, 0x31, 0x33, 0x32, 0x64, 0xC0, 0x25, 0x7E, 0xED, 0x80,
  0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xFA, 0xF0, 0xF0, 0x0C, 0x21,
  0x84, 0x10, 0xC2, 0x08, 0x61, 0x0C, 0x00, 0x23, 0xB7, 0x18, 0xC6, 0x31,
  0x8C, 0x76, 0xE0, 0x37, 0xF3, 0x33, 0x33, 0x33, 0x30, 0x67, 0xE6, 0x11,
  0x8C, 0xC6, 0x66, 0x21, 0xF0, 0x67, 0xE6, 0x11, 0xB9, 0xC3, 0x08, 0x67,
  0xE0, 0x0C, 0x38, 0x71, 0x62, 0xC9, 0x93, 0x7F, 0xFE, 0x18, 0x30, 0xFE,
  0x21, 0x0F, 0x4C, 0x21, 0x0C, 0xFC, 0x13, 0xF1, 0x88, 0x7F, 0x71, 0x8C,
  0x76, 0xE0, 0xFC, 0x10, 0xC3, 0x08, 0x61, 0x84, 0x30, 0xC6, 0x00, 0x23,
  0xE8, 0xA2, 0xD9, 0xC7, 0x36, 0x8A, 0x3D, 0xBC, 0x27, 0xA7, 0x18, 0xC7,
  0x6D, 0x08, 0xCD, 0xC0, 0xF8, 0x03, 0xC0, 0xF8, 0x03, 0xE8, 0x06, 0x39,
  0xC7, 0x03, 0x81, 0xC0, 0x80, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0xC0, 0xE0,
  0x70, 0x73, 0x8C, 0x20, 0x00, 0x27, 0xC6, 0x31, 0x88, 0x84, 0x20, 0x18,
  0xC0, 0x08, 0x1F, 0x10, 0x58, 0x39, 0xCD, 0xA6, 0xD3, 0x49, 0xB4, 0xCD,
  0xB0, 0x08, 0x03, 0xE0, 0x18, 0x38, 0x38, 0x2C, 0x2C, 0x64, 0x7C, 0x7E,
  0x46, 0xC2, 0xC3, 0xFB, 0x3C, 0xF3, 0xFB, 0xEC, 0xF1, 0xCF, 0x3F, 0x80,
  0x19, 0xF4, 0x30, 0xC2, 0x08, 0x20, 0xC3, 0x06, 0x4F, 0xF9, 0x9B, 0x16,
  0x3C, 0x78, 0xF1, 0xE2, 0xCD, 0xBB, 0xE0, 0xFE, 0x31, 0x8F, 0xFF, 0x18,
  0xC6, 0x3E, 0xFE, 0x31, 0x8C, 0x7F, 0x18, 0xC6, 0x30, 0x18, 0xFD, 0x86,
  0x0C, 0x10, 0x23, 0xC3, 0xC7, 0x8D, 0x99, 0xF0, 0xC7, 0x8F, 0x1E, 0x3F,
  0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xF2, 0x22, 0x22, 0x22, 0x22, 0xF0,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xCD, 0x93, 0x66, 0x8F, 0x1E,
  0x34, 0x6C, 0xC9, 0x9B, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3E,
  0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xF2, 0xF4, 0xBD, 0x6F, 0x73, 0xDC, 0xF3,
  0x3C, 0xCC, 0xC3, 0xC7, 0x8F, 0x9D, 0x3B, 0x76, 0xE5, 0xCF, 0x8F, 0x18,
  0x10, 0xFB, 0x1E, 0x3C, 0x70, 0x60, 0xC1, 0xC7, 0x8D, 0xB1, 0xE0, 0xFB,
  0x3C, 0xF3, 0xCF, 0xEF, 0x30, 0xC3, 0x0C, 0x00, 0x10, 0xFB, 0x1E, 0x3C,
  0x70, 0x60, 0xC1, 0xC7, 0x8D, 0xB3, 0xE0, 0xC1, 0x81, 0x80, 0xFB, 0x3C,
  0xF3, 0xCF, 0xED, 0x36, 0xCB, 0x3C, 0xC0, 0x27, 0xE1, 0x0C, 0x71, 0xC3,
  0x18, 0xE7, 0xE0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC5, 0x99, 0xE0, 0xC3, 0x8D,
  0x1A, 0x26, 0x4D, 0x8B, 0x14, 0x38, 0x70, 0x60, 0xC6, 0x3C, 0x62, 0x46,
  0x64, 0xE6, 0x6B, 0x66, 0xB4, 0x69, 0x42, 0x94, 0x39, 0xC3, 0x1C, 0x31,
  0x80, 0xC6, 0xD8, 0xA1, 0xC3, 0x86, 0x0E, 0x14, 0x6C, 0x9B, 0x18, 0xC6,
  0x99, 0xB3, 0x43, 0x87, 0x0C, 0x08, 0x10, 0x20, 0x40, 0xFC, 0x21, 0x86,
  0x10, 0xC2, 0x18, 0x43, 0x0F, 0xC0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCF, 0xF0, 0xC1, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x20, 0xC0, 0xFF,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x18, 0x70, 0xB3, 0x24, 0x78,
  0x40, 0xFE, 0xCC, 0x76, 0xC6, 0x3F, 0xCE, 0x73, 0xE8, 0xC3, 0x0C, 0x3C,
  0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xEE, 0x7F, 0xC8, 0x88, 0x8D, 0x70, 0x0C,
  0x30, 0xDB, 0xFE, 0x38, 0xE3, 0x8E, 0x3D, 0xDF, 0x76, 0xE3, 0x1F, 0xC2,
  0x19, 0x78, 0x3B, 0x18, 0xEF, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0x6F, 0xF8,
  0xE3, 0x8E, 0x38, 0xF7, 0x7C, 0x30, 0xBE, 0xF0, 0xC3, 0x0C, 0x3E, 0xFB,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xF3, 0xFF, 0xFF, 0x6C, 0x36, 0xDB, 0x6D,
  0xB6, 0xF6, 0xC3, 0x0C, 0x33, 0xDB, 0x4F, 0x3C, 0xD3, 0x6D, 0xB3, 0xFF,
  0xFF, 0xFF, 0xB3, 0x7F, 0xF3, 0x39, 0x1C, 0x8E, 0x47, 0x23, 0x91, 0xC8,
  0x80, 0xBB, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCC, 0x73, 0xE8, 0xA3, 0x8E,
  0x38, 0xB6, 0x70, 0xBA, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xFB, 0x0C, 0x30,
  0xC0, 0x6F, 0xF8, 0xE3, 0x8E, 0x38, 0xF7, 0x7C, 0x30, 0xC3, 0x0C, 0xBB,
  0xCC, 0xCC, 0xCC, 0xC0, 0x6F, 0x8C, 0xE3, 0x1B, 0xE0, 0x26, 0x7F, 0x66,
  0x66, 0x66, 0x70, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0x7C, 0xC7, 0x34,
  0xD2, 0x69, 0xE3, 0x8C, 0x30, 0xCC, 0xF3, 0x34, 0xC9, 0x32, 0x5E, 0x9C,
  0xE7, 0x38, 0xCC, 0x33, 0x00, 0xCD, 0x27, 0x8E, 0x30, 0xC7, 0x92, 0xCC,
  0xC7, 0x34, 0xD2, 0x69, 0xE3, 0x8C, 0x30, 0xC3, 0x38, 0xC0, 0x7B, 0xC4,
  0x62, 0x31, 0x88, 0xF8, 0x76, 0x66, 0x64, 0x84, 0x66, 0x66, 0x71, 0xFF,
  0xFF, 0xC6, 0x66, 0x66, 0x36, 0x66, 0x66, 0xC8, 0x63, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Medium16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 6, 1, -11 },
  { 7, 7, 11, 8, 0, -11 },
  { 17, 5, 13, 7, 1, -12 },
  { 26, 10, 12, 11, 1, -12 },
  { 41, 8, 12, 8, 0, -12 },
  { 53, 2, 4, 3, 1, -11 },
  { 54, 3, 15, 5, 1, -12 },
  { 60, 4, 15, 5, 0, -12 },
  { 68, 5, 5, 7, 1, -12 },
  { 72, 7, 7, 7, 0, -9 },
  { 79, 2, 4, 4, 1, -2 },
  { 80, 4, 1, 5, 0, -5 },
  { 81, 2, 2, 4, 1, -2 },
  { 82, 6, 11, 6, 0, -11 },
  { 91, 5, 12, 7, 1, -12 },
  { 99, 4, 11, 7, 1, -11 },
  { 105, 5, 12, 7, 1, -12 },
  { 113, 5, 12, 7, 1, -12 },
  { 121, 7, 11, 7, 0, -11 },
  { 131, 5, 11, 7, 1, -11 },
  { 138, 5, 12, 7, 1, -12 },
  { 146, 6, 11, 7, 0, -11 },
  { 155, 6, 12, 7, 1, -12 },
  { 164, 5, 12, 7, 1, -12 },
  { 172, 2, 9, 4, 1, -9 },
  { 175, 2, 11, 4, 1, -9 },
  { 178, 7, 7, 7, 0, -9 },
  { 185, 7, 5, 7, 0, -8 },
  { 190, 7, 7, 7, 0, -9 },
  { 197, 5, 12, 5, 0, -12 },
  { 205, 9, 13, 11, 1, -12 },
  { 220, 8, 11, 8, 0, -11 },
  { 231, 6, 11, 8, 1, -11 },
  { 240, 6, 12, 7, 1, -12 },
  { 249, 7, 11, 8, 1, -11 },
  { 259, 5, 11, 7, 1, -11 },
  { 266, 5, 11, 6, 1, -11 },
  { 273, 7, 12, 9, 1, -12 },
  { 284, 7, 11, 9, 1, -11 },
  { 294, 4, 11, 5, 0, -11 },
  { 300, 4, 14, 4, -1, -11 },
  { 307, 7, 11, 7, 1, -11 },
  { 317, 5, 11, 6, 1, -11 },
  { 324, 10, 11, 12, 1, -11 },
  { 338, 7, 11, 9, 1, -11 },
  { 348, 7, 12, 9, 1, -12 },
  { 359, 6, 11, 7, 1, -11 },
  { 368, 7, 15, 9, 1, -12 },
  { 382, 6, 11, 8, 1, -11 },
  { 391, 5, 12, 7, 1, -12 },
  { 399, 6, 11, 6, 0, -11 },
  { 408, 7, 11, 9, 1, -11 },
  { 418, 7, 11, 7, 0, -11 },
  { 428, 12, 11, 12, 0, -11 },
  { 445, 7, 11, 7, 0, -11 },
  { 455, 7, 11, 7, 0, -11 },
  { 465, 6, 11, 6, 0, -11 },
  { 474, 4, 15, 5, 1, -12 },
  { 482, 6, 11, 6, 0, -11 },
  { 491, 4, 15, 5, 0, -12 },
  { 499, 7, 6, 7, 0, -11 },
  { 505, 7, 1, 7, 0, 1 },
  { 506, 3, 2, 4, 1, -12 },
  { 507, 5, 9, 7, 1, -9 },
  { 513, 6, 12, 8, 1, -12 },
  { 522, 4, 9, 6, 1, -9 },
  { 527, 6, 12, 8, 1, -12 },
  { 536, 5, 9, 7, 1, -9 },
  { 542, 5, 12, 4, 0, -12 },
  { 550, 6, 13, 8, 1, -9 },
  { 560, 6, 12, 8, 1, -12 },
  { 569, 2, 12, 4, 1, -12 },
  { 572, 3, 16, 4, 0, -12 },
  { 578, 6, 12, 7, 1, -12 },
  { 587, 2, 12, 4, 1, -12 },
  { 590, 9, 9, 11, 1, -9 },
  { 601, 6, 9, 8, 1, -9 },
  { 608, 6, 9, 7, 1, -9 },
  { 615, 6, 13, 8, 1, -9 },
  { 625, 6, 13, 8, 1, -9 },
  { 635, 4, 9, 5, 1, -9 },
  { 640, 4, 9, 6, 1, -9 },
  { 645, 4, 11, 4, 0, -11 },
  { 651, 6, 9, 8, 1, -9 },
  { 658, 6, 9, 6, 0, -9 },
  { 665, 10, 9, 10, 0, -9 },
  { 677, 6, 9, 6, 0, -9 },
  { 684, 6, 13, 6, 0, -9 },
  { 694, 5, 9, 5, 0, -9 },
  { 700, 4, 14, 6, 1, -11 },
  { 707, 1, 16, 7, 3, -12 },
  { 709, 4, 14, 6, 1, -11 },
  { 716, 7, 2, 7, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Medium16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM16PT7B_H_
