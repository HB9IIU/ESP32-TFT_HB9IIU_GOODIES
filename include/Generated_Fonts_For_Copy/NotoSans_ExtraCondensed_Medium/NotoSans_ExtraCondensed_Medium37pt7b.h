#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x3B, 0xFF, 0xFB, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xEF,
  0x1D, 0xE3, 0xBC, 0x73, 0x8E, 0x61, 0xC0, 0x07, 0x1C, 0x07, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x18,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x3F, 0xC7, 0xFF, 0x3F, 0xFB, 0xD8, 0xDC, 0xC0,
  0xE6, 0x07, 0x30, 0x39, 0x81, 0xEC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x07, 0xF0, 0x37, 0x81, 0x9E, 0x0C, 0x70, 0x63, 0xC3, 0x3F, 0x1B,
  0xDF, 0xFE, 0xFF, 0xE3, 0xFC, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x7E, 0x03, 0x81, 0xFC, 0x0E, 0x03, 0x9C, 0x1C, 0x07,
  0x38, 0x38, 0x0E, 0x70, 0xE0, 0x38, 0x61, 0xC0, 0x70, 0xE3, 0x80, 0xE1,
  0xCE, 0x01, 0xC3, 0x9C, 0x03, 0x86, 0x30, 0x03, 0x1C, 0xE3, 0xC7, 0x39,
  0xCF, 0xCE, 0x73, 0x3B, 0x8F, 0xCE, 0x73, 0x9F, 0x9D, 0xC7, 0x0C, 0x73,
  0x8E, 0x00, 0xE7, 0x1C, 0x01, 0xCE, 0x38, 0x07, 0x1C, 0x70, 0x0E, 0x38,
  0xE0, 0x18, 0x71, 0xC0, 0x70, 0x63, 0x80, 0xE0, 0xE7, 0x01, 0x81, 0xDE,
  0x07, 0x01, 0xF8, 0x0E, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x38, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x79, 0xEF, 0x1C, 0x79, 0xE7, 0x3C, 0x7B, 0xCF, 0x0F,
  0xF3, 0xC1, 0xF8, 0xF0, 0x7E, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xE3, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFB, 0xE1, 0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xF7, 0x60,
  0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70,
  0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C,
  0x1C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E,
  0x17, 0xF7, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC0, 0xEF, 0x0F, 0x38,
  0xF1, 0xE0, 0x84, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0xE3, 0x9E, 0x79, 0xC7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x77,
  0xBF, 0xF7, 0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x3F, 0x81, 0xFE, 0x0F, 0xFC, 0x38, 0x71, 0xE1, 0xE7, 0x87, 0x9C,
  0x0E, 0x70, 0x39, 0xC0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xC0, 0xF7, 0x03, 0xDC, 0x0E, 0x78, 0x39,
  0xE1, 0xE7, 0x87, 0x8F, 0x3C, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x07,
  0xC3, 0xF1, 0xFC, 0xFF, 0x7F, 0xFE, 0xF7, 0x3C, 0x8F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x80, 0xFF, 0x87,
  0xFF, 0x3F, 0x7C, 0x60, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFF, 0x8F,
  0xFF, 0x1E, 0x7C, 0x60, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0xB0, 0x3E, 0xFF, 0xF3, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x6E, 0x01, 0xDC, 0x03, 0xB8, 0x0E,
  0xF0, 0x1D, 0xE0, 0x73, 0xC0, 0xE7, 0x83, 0x8F, 0x07, 0x1E, 0x0C, 0x3C,
  0x38, 0x78, 0x70, 0xF1, 0xC1, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x00, 0xF8, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x7A, 0x07,
  0xDF, 0xFC, 0xFF, 0xC7, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x07,
  0xE4, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x3C, 0x1D, 0xFC, 0x7F, 0xF1, 0xF3, 0xEF, 0x87, 0xBE, 0x0E, 0xF0, 0x3D,
  0xC0, 0xF7, 0x03, 0xDC, 0x0F, 0x70, 0x3D, 0xE0, 0xF7, 0x83, 0x8F, 0x1E,
  0x3F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78,
  0x79, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x78, 0x39, 0xE1, 0xE3, 0xCF, 0x07,
  0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x0F, 0x3C, 0x78, 0x79, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1E, 0x7F, 0xF8,
  0xFF, 0xC1, 0xFE, 0x00, 0x07, 0x80, 0x7F, 0x03, 0xFE, 0x1F, 0xFC, 0x78,
  0x71, 0xC1, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0x70, 0x7D, 0xE1, 0xF7, 0xFF, 0xCF, 0xEE, 0x1F, 0xB8, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x7F, 0xE1,
  0xFF, 0x07, 0xF0, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0xF7, 0xFE, 0xE0, 0x39, 0xF7, 0xDE, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0x9E, 0x79, 0xC7, 0x1C, 0xE0,
  0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xF8,
  0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0x38, 0x00, 0xC0, 0x00, 0x0E, 0x07, 0xFC, 0xFF, 0xE7, 0xBE,
  0x40, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1E, 0x07, 0x81, 0xC0, 0x1E,
  0x1C, 0x00, 0x70, 0xE0, 0x01, 0xCE, 0x02, 0x0E, 0x70, 0xFE, 0x3B, 0x0F,
  0xF1, 0xF8, 0x73, 0x8F, 0xC7, 0x1C, 0x7E, 0x38, 0xE3, 0xF1, 0xC7, 0x1F,
  0x9C, 0x38, 0xF8, 0xE1, 0xC7, 0xC7, 0x0E, 0x3E, 0x18, 0x71, 0xF8, 0xE3,
  0x8F, 0xC7, 0x3C, 0x6E, 0x3F, 0xFF, 0x70, 0xF9, 0xF3, 0x83, 0x87, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x40, 0x3F, 0x1E,
  0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x1E, 0x70, 0x0F,
  0x38, 0x07, 0x1C, 0x03, 0x8F, 0x01, 0xC7, 0x81, 0xE1, 0xC0, 0xF0, 0xE0,
  0x70, 0x78, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0x03, 0xC7, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x39, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x38, 0x3E, 0xE0, 0x7B, 0x81,
  0xEE, 0x07, 0xB8, 0x1E, 0xE0, 0x7B, 0x81, 0xEE, 0x1F, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0xCE, 0x0F, 0xB8, 0x1E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x81, 0xEE, 0x0F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x00,
  0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3C, 0x09, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x82, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0x07, 0xCE, 0x07, 0x9C, 0x07, 0xB8,
  0x0F, 0x70, 0x1E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7,
  0x01, 0xEE, 0x07, 0x9C, 0x0F, 0x38, 0x7C, 0x7F, 0xF8, 0xFF, 0xC1, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xEF, 0xFD, 0xFF, 0xB8, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFD, 0xFF, 0xBF, 0xF7, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xDE, 0x3E, 0x02, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x07, 0x78, 0x07, 0x7C, 0x07, 0x3E,
  0x07, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3C, 0xFF, 0xFF, 0xC7, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0xFC, 0xFF,
  0xFF, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0F, 0xFE, 0xFE, 0xFC, 0xE0,
  0x3F, 0x81, 0xEE, 0x07, 0xB8, 0x3C, 0xE1, 0xE3, 0x87, 0x8E, 0x3C, 0x38,
  0xF0, 0xE7, 0x83, 0x9E, 0x0E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x3C, 0xF0, 0xE3, 0xC3, 0x87, 0x8E, 0x1E, 0x38, 0x38, 0xE0, 0xF3,
  0x83, 0xCE, 0x07, 0xB8, 0x1E, 0xE0, 0x3F, 0x80, 0xF0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFE, 0xE0, 0x3F, 0xFB, 0x80, 0xEF, 0xEE, 0x03, 0xBF, 0xBC, 0x0E,
  0xFE, 0x70, 0x73, 0xF9, 0xC1, 0xCF, 0xE7, 0x07, 0x3F, 0x9E, 0x3C, 0xFE,
  0x38, 0xE3, 0xF8, 0xE3, 0x8F, 0xE3, 0x8E, 0x3F, 0x87, 0x70, 0xFE, 0x1D,
  0xC3, 0xF8, 0x77, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0xFE, 0x0F, 0x83,
  0xF8, 0x3E, 0x0F, 0xE0, 0xF0, 0x3F, 0x81, 0xC0, 0xF0, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xEE, 0x07, 0xEE,
  0x07, 0xEF, 0x07, 0xE7, 0x07, 0xE7, 0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE1, 0xC7, 0xE1, 0xE7, 0xE0, 0xE7, 0xE0, 0xF7, 0xE0, 0x77, 0xE0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xEF, 0xC7, 0xC1, 0xE3,
  0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0xF3, 0xC0, 0x79,
  0xE0, 0x7C, 0x7C, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xC3, 0xEE, 0x0F, 0x70, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC1, 0xEE, 0x3F, 0x7F, 0xF3, 0xFF, 0x1F,
  0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xEF, 0xC7, 0xC1, 0xE3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x0E, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xF7, 0x00, 0xF3, 0xC0, 0x79, 0xE0, 0x7C, 0x7C, 0x7C, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x7C,
  0xE0, 0xFB, 0x81, 0xEE, 0x07, 0xB8, 0x1E, 0xE0, 0x7B, 0x81, 0xEE, 0x0F,
  0x38, 0x7C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x38, 0xE0, 0xE3, 0xC3, 0x87,
  0x0E, 0x1E, 0x38, 0x78, 0xE0, 0xF3, 0x83, 0xCE, 0x07, 0xB8, 0x1E, 0xE0,
  0x3F, 0x80, 0xF0, 0x07, 0x80, 0xFF, 0xCF, 0xFE, 0xFF, 0xE7, 0x81, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xFC, 0x1E, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x01,
  0xEF, 0x03, 0xDF, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0xF0, 0x07,
  0xF8, 0x03, 0xDC, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x78, 0xE0,
  0x38, 0x70, 0x1C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x07, 0x03, 0x83, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0xBC,
  0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x0E, 0x01, 0xFE, 0x03, 0xE0,
  0x3D, 0xC0, 0x7C, 0x07, 0x38, 0x0F, 0x81, 0xE7, 0x81, 0xF0, 0x3C, 0xF0,
  0x36, 0x07, 0x9E, 0x0E, 0xE0, 0xF1, 0xC1, 0xDC, 0x1C, 0x38, 0x3B, 0x87,
  0x87, 0x87, 0x70, 0xF0, 0xF0, 0xEE, 0x1E, 0x1E, 0x39, 0xC3, 0xC1, 0xC7,
  0x1C, 0x70, 0x38, 0xE3, 0x8E, 0x07, 0x1C, 0x73, 0xC0, 0xF3, 0x8E, 0x78,
  0x1E, 0xE1, 0xCF, 0x01, 0xDC, 0x1D, 0xC0, 0x3B, 0x83, 0xB8, 0x07, 0x70,
  0x7F, 0x00, 0xEE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x1E,
  0x70, 0x38, 0xF0, 0xF1, 0xE1, 0xE1, 0xC7, 0x83, 0xCF, 0x03, 0x9C, 0x07,
  0x78, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1C, 0xE0, 0x79, 0xC0, 0xF3, 0xC3,
  0xC3, 0x87, 0x87, 0x8E, 0x0F, 0x3C, 0x0E, 0x78, 0x1F, 0xE0, 0x3C, 0xF0,
  0x1E, 0xE0, 0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x0F, 0x1E,
  0x0E, 0x3C, 0x1E, 0x70, 0x1D, 0xE0, 0x3B, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xFE, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E,
  0xE0, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x1C, 0x70,
  0x1C, 0xF0, 0x1E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3C, 0x3C, 0x1E, 0x0E, 0x07, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x41, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0xF9, 0xFF, 0xDF, 0x9E, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFB, 0xFD, 0xDF, 0xEE,
  0x7E, 0x70, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF8,
  0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0E, 0xF8, 0x7B, 0xFF, 0xEE,
  0x7F, 0x38, 0xF8, 0x1F, 0xE7, 0xF9, 0xFF, 0x3C, 0x2F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x2F, 0xF8, 0xFF, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x0F, 0x9C, 0x7F,
  0x73, 0xFF, 0xDF, 0x1F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xDC, 0x07, 0x70,
  0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xF7, 0x83, 0xDE,
  0x0F, 0x78, 0x7C, 0xFF, 0xF3, 0xFD, 0xC3, 0xE7, 0x1F, 0x81, 0xFE, 0x1F,
  0xF8, 0xE1, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x13,
  0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3F, 0x9F, 0xF3, 0xFE, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x0F, 0x9C, 0x7F, 0x73,
  0xFF, 0xDF, 0x1F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xDC, 0x07, 0x70, 0x1F,
  0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xF7, 0x83, 0xDE, 0x0F,
  0x7C, 0x7C, 0xFF, 0xF3, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x40, 0x3D, 0xC3, 0xE7, 0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF7, 0xE7, 0xFF, 0xBF, 0xFD, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x70, 0x6F, 0xFF, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C,
  0x3C, 0x78, 0xF0, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1F, 0x7F, 0xF7, 0xEF, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7B,
  0xC1, 0xCF, 0x0F, 0x3C, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x38, 0x3D, 0xE0,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3E, 0xF0, 0xF1, 0xC3, 0xC7, 0x8F, 0x0E,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xE3, 0xF3, 0xBF, 0xDF, 0xEE, 0xFF, 0x7F, 0xBE, 0x3F, 0x1E, 0xF8, 0x78,
  0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xE7, 0xE7, 0x7F, 0xBB, 0xFD, 0xF0,
  0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x70, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x1E, 0x78, 0x3D,
  0xE0, 0xF7, 0x01, 0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07,
  0x70, 0x1D, 0xC0, 0x77, 0x83, 0xDE, 0x0F, 0x3C, 0x78, 0xFF, 0xE1, 0xFF,
  0x03, 0xF8, 0xE3, 0xE3, 0x9F, 0xCF, 0xFF, 0xBE, 0x1E, 0xF8, 0x3B, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0E, 0xF8, 0x7B, 0xFF, 0xEF, 0x7F, 0x3C,
  0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x9C, 0x7F, 0x73, 0xFF, 0xDF, 0x1F,
  0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xF7, 0x83, 0xDE, 0x0F, 0x7C, 0x7C, 0xFF,
  0xF3, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xE3, 0xF3, 0xFB, 0xFF,
  0xDF, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x1F, 0xCF, 0xFD, 0xFF, 0x78,
  0x2F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x78, 0x0F, 0xC1, 0xFF, 0xFB, 0xFF, 0x3F, 0x80, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0xFF, 0xFF, 0xFE, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xFC,
  0xFE, 0x3F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0x78, 0xFB, 0xFF, 0xDF, 0xEE, 0x7E, 0x70, 0xF0,
  0x1D, 0xC0, 0xF7, 0x03, 0xDE, 0x0E, 0x78, 0x38, 0xE1, 0xE3, 0x87, 0x8E,
  0x1C, 0x3C, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x1E, 0xE0, 0x3B, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0xF0, 0x3C,
  0x1E, 0xE0, 0xF8, 0x3D, 0xC1, 0xF0, 0x73, 0xC3, 0xE0, 0xE7, 0x86, 0xC1,
  0xCF, 0x0D, 0xC7, 0x8E, 0x3B, 0x8E, 0x1C, 0x77, 0x1C, 0x3C, 0xEE, 0x38,
  0x79, 0xCC, 0xF0, 0x73, 0x1D, 0xE0, 0xEE, 0x3B, 0x81, 0xDC, 0x77, 0x03,
  0xB8, 0xEE, 0x07, 0x71, 0xDC, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x78, 0x3D, 0xE1, 0xE3,
  0x87, 0x8F, 0x1C, 0x1C, 0xF0, 0x7B, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xCE, 0x0F, 0x3C,
  0x3C, 0x70, 0xE1, 0xE7, 0x83, 0xBC, 0x0F, 0xF0, 0x1D, 0xC0, 0xF7, 0x03,
  0xDE, 0x0E, 0x78, 0x38, 0xE1, 0xE3, 0x87, 0x8F, 0x1C, 0x3C, 0x70, 0x71,
  0xC1, 0xCF, 0x07, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xFE, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x02, 0x78, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0xFC, 0x3F, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x3F, 0x07, 0x80, 0xFC, 0x07, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x1E, 0x01, 0xF8, 0x0F, 0x07, 0xE1, 0xF0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE1, 0xFC, 0x3F, 0x07, 0x80, 0x10, 0x05, 0xFC, 0x1F, 0xFF, 0xFB, 0xFF,
  0x81, 0xFA, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 11, 9, 15, 2, -26 },
  { 31, 16, 26, 17, 1, -26 },
  { 83, 13, 30, 16, 2, -28 },
  { 132, 23, 27, 26, 1, -27 },
  { 210, 18, 27, 19, 1, -27 },
  { 271, 4, 9, 8, 2, -26 },
  { 276, 8, 33, 11, 2, -27 },
  { 309, 8, 33, 11, 1, -27 },
  { 342, 13, 13, 15, 1, -28 },
  { 364, 14, 18, 16, 1, -22 },
  { 396, 6, 9, 9, 1, -4 },
  { 403, 8, 4, 10, 1, -12 },
  { 407, 5, 5, 9, 2, -5 },
  { 411, 13, 27, 14, 1, -27 },
  { 455, 14, 27, 16, 1, -27 },
  { 503, 10, 26, 16, 2, -26 },
  { 536, 14, 27, 16, 1, -27 },
  { 584, 14, 27, 16, 1, -27 },
  { 632, 15, 27, 16, 1, -27 },
  { 683, 13, 26, 16, 2, -26 },
  { 726, 14, 27, 16, 1, -27 },
  { 774, 14, 26, 16, 1, -26 },
  { 820, 14, 27, 16, 1, -27 },
  { 868, 14, 27, 16, 1, -27 },
  { 916, 5, 20, 9, 2, -20 },
  { 929, 6, 25, 9, 1, -20 },
  { 948, 14, 17, 16, 1, -22 },
  { 978, 14, 10, 16, 1, -18 },
  { 996, 14, 17, 16, 1, -22 },
  { 1026, 12, 27, 12, 0, -27 },
  { 1067, 21, 30, 25, 2, -27 },
  { 1146, 17, 26, 17, 0, -26 },
  { 1202, 14, 26, 18, 3, -26 },
  { 1248, 14, 27, 17, 2, -27 },
  { 1296, 15, 26, 20, 3, -26 },
  { 1345, 11, 26, 15, 3, -26 },
  { 1381, 11, 26, 15, 3, -26 },
  { 1417, 16, 27, 20, 2, -27 },
  { 1471, 15, 26, 20, 3, -26 },
  { 1520, 9, 26, 11, 1, -26 },
  { 1550, 8, 33, 9, -2, -26 },
  { 1583, 14, 26, 17, 3, -26 },
  { 1629, 11, 26, 14, 3, -26 },
  { 1665, 22, 26, 27, 3, -26 },
  { 1737, 16, 26, 22, 3, -26 },
  { 1789, 17, 27, 21, 2, -27 },
  { 1847, 13, 26, 17, 3, -26 },
  { 1890, 17, 33, 21, 2, -27 },
  { 1961, 14, 26, 18, 3, -26 },
  { 2007, 13, 27, 15, 1, -27 },
  { 2051, 14, 26, 15, 0, -26 },
  { 2097, 15, 26, 20, 2, -26 },
  { 2146, 17, 26, 17, 0, -26 },
  { 2202, 27, 26, 27, 0, -26 },
  { 2290, 15, 26, 16, 0, -26 },
  { 2339, 15, 26, 15, 0, -26 },
  { 2388, 12, 26, 14, 1, -26 },
  { 2427, 7, 33, 12, 3, -27 },
  { 2456, 13, 27, 14, 1, -27 },
  { 2500, 8, 33, 12, 1, -27 },
  { 2533, 16, 14, 17, 1, -26 },
  { 2561, 16, 3, 16, 0, 3 },
  { 2567, 8, 6, 10, 1, -28 },
  { 2573, 13, 20, 16, 1, -20 },
  { 2606, 14, 28, 18, 2, -28 },
  { 2655, 11, 20, 13, 2, -20 },
  { 2683, 14, 28, 18, 1, -28 },
  { 2732, 13, 20, 16, 2, -20 },
  { 2765, 11, 28, 10, 0, -28 },
  { 2804, 14, 29, 18, 1, -20 },
  { 2855, 13, 28, 17, 2, -28 },
  { 2901, 4, 28, 8, 2, -28 },
  { 2915, 7, 37, 8, -1, -28 },
  { 2948, 14, 28, 16, 2, -28 },
  { 2997, 4, 28, 8, 2, -28 },
  { 3011, 22, 20, 26, 2, -20 },
  { 3066, 13, 20, 17, 2, -20 },
  { 3099, 14, 20, 17, 1, -20 },
  { 3134, 14, 29, 18, 2, -20 },
  { 3185, 14, 29, 18, 1, -20 },
  { 3236, 9, 20, 12, 2, -20 },
  { 3259, 11, 20, 13, 1, -20 },
  { 3287, 9, 24, 10, 1, -24 },
  { 3314, 13, 20, 17, 2, -20 },
  { 3347, 14, 20, 15, 0, -20 },
  { 3382, 23, 20, 23, 0, -20 },
  { 3440, 14, 20, 14, 0, -20 },
  { 3475, 14, 29, 15, 0, -20 },
  { 3526, 10, 20, 12, 1, -20 },
  { 3551, 11, 32, 13, 1, -26 },
  { 3595, 3, 37, 15, 6, -28 },
  { 3609, 11, 32, 13, 1, -26 },
  { 3653, 14, 6, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Medium37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM37PT7B_H_
