#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF0, 0x80, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFD, 0xF8,
  0x7E, 0x7E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0xF9, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1F,
  0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0,
  0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF0,
  0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1,
  0xF0, 0x00, 0xF0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFB, 0x9F, 0x1F, 0x8E, 0x0C, 0x7C, 0x38, 0x01,
  0xF0, 0xE0, 0x07, 0xC3, 0x80, 0x1F, 0x0E, 0x00, 0x7C, 0x38, 0x01, 0xF0,
  0xE0, 0x07, 0xE3, 0x80, 0x1F, 0xCE, 0x00, 0x3F, 0xB8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3B, 0xF8, 0x00, 0xE3, 0xE0, 0x03,
  0x8F, 0xC0, 0x0E, 0x1F, 0x00, 0x38, 0x7C, 0x00, 0xE1, 0xF0, 0x03, 0x87,
  0xE0, 0x0E, 0x3F, 0xE0, 0x38, 0xFB, 0xE0, 0xEF, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x7C,
  0x01, 0xE0, 0x01, 0xF0, 0xF0, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x3E, 0x00,
  0x1E, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE1,
  0xF0, 0x00, 0x3E, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x3E, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0xF8, 0x7E, 0x07, 0x83, 0xE3, 0xC3, 0xFC, 0x1E, 0x0F, 0x1F,
  0x1F, 0xF8, 0x7C, 0x3C, 0x78, 0xFF, 0xF0, 0xF1, 0xF1, 0xE3, 0xE7, 0xC3,
  0xFF, 0x8F, 0x8F, 0x0F, 0x8F, 0xFE, 0x3C, 0x7C, 0x3E, 0x1F, 0xF1, 0xF1,
  0xF0, 0xF8, 0x3F, 0x87, 0xC7, 0xC1, 0xE0, 0x00, 0x1E, 0x1E, 0x07, 0x80,
  0x00, 0xF8, 0x78, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x7C, 0x00, 0x0F, 0x07,
  0x81, 0xF0, 0x00, 0x7C, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x1F, 0x00,
  0x07, 0x81, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x1F,
  0x07, 0x80, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0xF8, 0x00,
  0x78, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0x0F, 0x8F, 0x00, 0x0F, 0x80, 0x3F,
  0xFC, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x07, 0xE3, 0xFF, 0xE0, 0x7C, 0x3F, 0x3F, 0x0F, 0xC7,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xCF, 0xC1, 0xFC, 0xFC, 0xFC, 0x0F,
  0xDF, 0x8F, 0xC0, 0x7F, 0xF8, 0xFC, 0x07, 0xFF, 0x8F, 0xC0, 0x3F, 0xF0,
  0xFC, 0x01, 0xFF, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0xE0, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xC1, 0xFF, 0xF0, 0xFE, 0x07,
  0xFE, 0x07, 0xF0, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0xFC, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0x83, 0xE0, 0xCF, 0x9E,
  0x3E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x78, 0x01, 0xFB, 0xE0, 0x0F, 0x8F,
  0x80, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8, 0x3E, 0x0F, 0x00, 0x60, 0x70, 0x01,
  0x01, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F,
  0x87, 0xC7, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1C, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x18, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD,
  0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x1F,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF, 0x7F,
  0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x38, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC3,
  0x80, 0x3F, 0x04, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xF0, 0x1F, 0xC3, 0x00,
  0x3F, 0x08, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x80, 0x03, 0xFB,
  0x80, 0x1F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3D, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0x3F, 0x00,
  0x07, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xC7, 0xE0, 0x03, 0xE3, 0xF0,
  0x01, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF0, 0x7E, 0x00, 0xF8, 0x3F,
  0x00, 0x78, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3C, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0x80,
  0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE8, 0x00, 0xFE, 0x70,
  0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x3F, 0x81, 0xF3, 0xFF, 0x07, 0xDF, 0xFE, 0x1F, 0x7F,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFE, 0x0F, 0xEF, 0xF0, 0x1F, 0xBF, 0x80, 0x7E,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C,
  0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xEF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0,
  0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F,
  0x9F, 0x80, 0x3E, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x8F, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x9F, 0x80, 0x7E, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFD,
  0xFC, 0x07, 0xE7, 0xFC, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0x87,
  0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF,
  0x80, 0x7F, 0x7E, 0x03, 0xFD, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x1F, 0xFE, 0xF8, 0x3F, 0xF3, 0xE0, 0x7F, 0x8F, 0x80, 0x10, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x7E, 0x7E, 0x7F,
  0xFF, 0x7F, 0x7E, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7E, 0x7E,
  0x7F, 0xFF, 0x7F, 0x7E, 0x7E, 0x08, 0x0C, 0x1F, 0x8F, 0xC7, 0xF3, 0xF9,
  0xFC, 0xFC, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE3, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3,
  0xE1, 0xF1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9C, 0x0F, 0xE6, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x04, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x38, 0x03, 0xC3, 0xE0, 0x3F, 0xF8, 0x7C, 0xF8, 0x0F, 0xFF,
  0x0F, 0x9F, 0x03, 0xFF, 0xE1, 0xF3, 0xE0, 0xFC, 0x7C, 0x1E, 0x78, 0x1F,
  0x0F, 0x83, 0xDF, 0x07, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3E, 0x0F, 0xFC,
  0x1E, 0x07, 0xC1, 0xFF, 0x87, 0xC0, 0xF8, 0x3F, 0xE0, 0xF8, 0x1F, 0x07,
  0xFC, 0x1F, 0x03, 0xE0, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xF0, 0x7C, 0x0F,
  0x03, 0xFE, 0x0F, 0x83, 0xE0, 0x7B, 0xC1, 0xF0, 0x7C, 0x0F, 0x78, 0x3E,
  0x0F, 0x81, 0xEF, 0x07, 0xC1, 0xF0, 0x3D, 0xE0, 0xF8, 0x3E, 0x0F, 0xBE,
  0x0F, 0x87, 0xE1, 0xE7, 0xC1, 0xF1, 0xDC, 0x7C, 0xF8, 0x3F, 0xFB, 0xFF,
  0x1F, 0x03, 0xFE, 0x7F, 0xE1, 0xE0, 0x3F, 0xC7, 0xF8, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x00, 0x03, 0xFC, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0x81, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0xFE,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC,
  0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7E, 0x03, 0xFC, 0xFC, 0x01,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF,
  0x80, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC,
  0x0F, 0x0F, 0xF0, 0x04, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x83, 0xFC, 0x07, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xE1, 0xFF, 0xC3, 0xF0, 0x0F,
  0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0x87, 0xE0,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xF0, 0x0F, 0x03, 0xF8, 0x00, 0x60, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0x7E, 0x1F, 0xE0, 0x0F, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xFF, 0x7F, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x7F, 0xC1,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFD,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xDF, 0x00, 0x0F, 0xBF, 0xFD, 0xF0, 0x00, 0xFB, 0xFF, 0xDF,
  0x00, 0x0F, 0xBF, 0xFD, 0xF8, 0x01, 0xF3, 0xFF, 0xCF, 0x80, 0x1F, 0x3F,
  0xFC, 0xF8, 0x01, 0xF3, 0xFF, 0xCF, 0x80, 0x1F, 0x3F, 0xFC, 0x7C, 0x03,
  0xE3, 0xFF, 0xC7, 0xC0, 0x3E, 0x3F, 0xFC, 0x7C, 0x03, 0xE3, 0xFF, 0xC7,
  0xE0, 0x7C, 0x3F, 0xFC, 0x3E, 0x07, 0xC3, 0xFF, 0xC3, 0xE0, 0x7C, 0x3F,
  0xFC, 0x3E, 0x07, 0xC3, 0xFF, 0xC3, 0xF0, 0xF8, 0x3F, 0xFC, 0x1F, 0x0F,
  0x83, 0xFF, 0xC1, 0xF0, 0xF8, 0x3F, 0xFC, 0x1F, 0x1F, 0x03, 0xFF, 0xC0,
  0xF9, 0xF0, 0x3F, 0xFC, 0x0F, 0x9F, 0x03, 0xFF, 0xC0, 0xF9, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFE, 0xF8, 0x03, 0xFF, 0xDF, 0x80, 0x7F, 0xFB, 0xF0,
  0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0xE7, 0xE0, 0x3F, 0xFC, 0x7C, 0x07, 0xFF,
  0x8F, 0xC0, 0xFF, 0xF0, 0xF8, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC3, 0xF0,
  0x7F, 0xF8, 0x3F, 0x0F, 0xFF, 0x07, 0xE1, 0xFF, 0xE0, 0x7C, 0x3F, 0xFC,
  0x0F, 0xC7, 0xFF, 0x81, 0xF8, 0xFF, 0xF0, 0x1F, 0x9F, 0xFE, 0x03, 0xF3,
  0xFF, 0xC0, 0x3F, 0x7F, 0xF8, 0x07, 0xE7, 0xFF, 0x00, 0x7C, 0xFF, 0xE0,
  0x0F, 0xDF, 0xFC, 0x01, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xF0, 0xFF, 0xCF, 0xC0, 0x7F, 0x3F, 0x00, 0xFE,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x07, 0xF3,
  0xF1, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x5F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F,
  0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0x8F, 0xE0,
  0x0C, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE8, 0x00, 0x3F, 0x60, 0x03, 0xFB, 0xE0, 0x3F, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3E,
  0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE7, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x80, 0x07,
  0xE7, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x07, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xBE, 0x01, 0xF8, 0x3F, 0x00, 0x7B, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0xBE,
  0x01, 0xF8, 0x1F, 0x80, 0xF9, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x9F, 0x01,
  0xF8, 0x1F, 0x80, 0xF9, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x9F, 0x03, 0xF0,
  0x0F, 0x81, 0xF1, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x1F, 0x03, 0xF0, 0x0F,
  0xC1, 0xF0, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x0F, 0x87, 0xE0, 0x07, 0xE3, 0xE0,
  0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x7C, 0xFC,
  0x00, 0x3E, 0x7C, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xC0, 0x3C, 0xFC, 0x00,
  0x3F, 0x7C, 0x03, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x00, 0x1F,
  0x78, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x3E,
  0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x01, 0xFE, 0x00,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xE0, 0x7E,
  0x08, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFE, 0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x1F, 0xF7, 0xFF, 0xDF,
  0x3F, 0xFD, 0xF3, 0xFF, 0x8F, 0x1F, 0xE0, 0xF0, 0x10, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x0F, 0x8F, 0xF8, 0x3E, 0x7F, 0xF0, 0xFB, 0xFF, 0xE3, 0xEF, 0xFF, 0xCF,
  0xF8, 0x7F, 0x3F, 0xC0, 0xFE, 0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E,
  0xFF, 0x03, 0xF3, 0xFF, 0x3F, 0xCF, 0xBF, 0xFE, 0x3E, 0x7F, 0xF8, 0xF9,
  0xFF, 0xC3, 0xE1, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xF0, 0x63, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0x1F,
  0xF7, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3E, 0x0F, 0xC1, 0xFF, 0x1F, 0x87, 0xFF, 0x3F, 0x1F,
  0xFF, 0x7E, 0x3F, 0xFF, 0xFC, 0xFF, 0x1F, 0xF9, 0xF8, 0x0F, 0xF3, 0xF0,
  0x1F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF,
  0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x9F, 0x80, 0xFF, 0x3F, 0x81, 0xFE, 0x7F,
  0x8F, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xF9, 0xF0, 0xFF, 0xE3, 0xE0, 0x7F,
  0x87, 0xC0, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x0C, 0x1F, 0xE0,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0x10, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x7C, 0x3F,
  0xF8, 0xF8, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0xCF, 0xC0,
  0x7F, 0x9F, 0x80, 0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x07, 0xF9, 0xFC,
  0x1F, 0xF3, 0xFE, 0xFF, 0xE3, 0xFF, 0xEF, 0xC3, 0xFF, 0xDF, 0x87, 0xFF,
  0x3F, 0x03, 0xFC, 0x7E, 0x00, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x20, 0x01, 0xF8, 0x70, 0x07, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x03, 0xE3, 0xFE,
  0x1F, 0x3F, 0xF8, 0xFB, 0xFF, 0xE7, 0xDF, 0xFF, 0x3F, 0xE3, 0xFD, 0xFE,
  0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x38, 0xF9,
  0xFF, 0xFF, 0xEF, 0xDF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xC0, 0x03, 0x80, 0xF8, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xE3, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xF8,
  0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xF7,
  0xF0, 0x0F, 0xBF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xEF, 0xC0,
  0xFE, 0x3E, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x3C, 0x3F,
  0xE0, 0xFF, 0x8F, 0x9F, 0xFC, 0x7F, 0xF3, 0xEF, 0xFF, 0x3F, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xBF, 0xE3, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x1F, 0xFC, 0x03, 0xF0,
  0x07, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00,
  0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x87, 0xFC, 0x3E, 0x7F, 0xF1, 0xF7,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xC7, 0xFB, 0xFC, 0x0F, 0xDF, 0xC0, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x01, 0xF3, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE1,
  0xFC, 0x0F, 0xC1, 0xFE, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x03, 0xE3,
  0xFE, 0x0F, 0x9F, 0xFC, 0x3E, 0xFF, 0xF8, 0xFB, 0xFF, 0xF3, 0xFE, 0x1F,
  0xCF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3E, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0xC0,
  0xFC, 0xFF, 0xCF, 0xF3, 0xEF, 0xFF, 0x8F, 0x9F, 0xFE, 0x3E, 0x7F, 0xF0,
  0xF8, 0x7F, 0x83, 0xE0, 0x70, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x7C,
  0x3F, 0xF8, 0xF8, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0xCF,
  0xC0, 0x7F, 0x9F, 0x80, 0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8,
  0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x07, 0xF9,
  0xFC, 0x1F, 0xF3, 0xFE, 0xFF, 0xE3, 0xFF, 0xEF, 0xC3, 0xFF, 0xDF, 0x87,
  0xFF, 0x3F, 0x03, 0xFC, 0x7E, 0x00, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC3, 0xFF, 0x1F, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xF8, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xFF,
  0x8F, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xF0, 0x3B, 0xF0, 0x09, 0xF8,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x02, 0xC0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE1, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFF, 0x70, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x00, 0x70, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFD, 0xF3, 0xFF, 0xDF, 0x3F, 0xF8, 0xF0, 0xFF, 0x0F, 0x01, 0x80,
  0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07,
  0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C,
  0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x80, 0x7E, 0xFC,
  0x03, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0xE0, 0x1F, 0x1F, 0x01, 0xFF, 0x01,
  0xF8, 0xFC, 0x0F, 0xF8, 0x0F, 0xC7, 0xE0, 0x7B, 0xE0, 0x7C, 0x3F, 0x03,
  0xDF, 0x03, 0xE0, 0xF8, 0x1E, 0x78, 0x3F, 0x07, 0xC1, 0xF3, 0xC1, 0xF8,
  0x3F, 0x0F, 0x9E, 0x0F, 0xC1, 0xF8, 0x7C, 0xF8, 0x7C, 0x0F, 0xC3, 0xC7,
  0xC3, 0xE0, 0x3E, 0x1E, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0xF1, 0xF8, 0x0F,
  0xCF, 0x87, 0x8F, 0x80, 0x7E, 0x7C, 0x3C, 0x7C, 0x01, 0xF3, 0xE1, 0xF3,
  0xE0, 0x0F, 0x9E, 0x0F, 0xBF, 0x00, 0x7C, 0xF0, 0x7D, 0xF8, 0x03, 0xEF,
  0x81, 0xEF, 0x80, 0x1F, 0x7C, 0x0F, 0x7C, 0x00, 0x7F, 0xE0, 0x7B, 0xE0,
  0x03, 0xFE, 0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x0F,
  0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3F,
  0x7E, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x02,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xA0, 0x07, 0xFE, 0x40, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 44, 14, 4, -43 },
  { 40, 18, 16, 24, 3, -43 },
  { 76, 26, 43, 28, 1, -43 },
  { 216, 22, 49, 26, 2, -46 },
  { 351, 38, 44, 42, 2, -43 },
  { 560, 28, 44, 30, 2, -43 },
  { 714, 7, 16, 13, 3, -43 },
  { 728, 13, 52, 18, 3, -43 },
  { 813, 14, 52, 18, 1, -43 },
  { 904, 21, 22, 25, 2, -46 },
  { 962, 23, 28, 26, 2, -35 },
  { 1043, 9, 15, 14, 2, -7 },
  { 1060, 13, 6, 17, 2, -19 },
  { 1070, 8, 9, 14, 3, -8 },
  { 1079, 21, 43, 23, 1, -43 },
  { 1192, 22, 44, 26, 2, -43 },
  { 1313, 16, 43, 26, 3, -43 },
  { 1399, 22, 43, 26, 2, -43 },
  { 1518, 22, 44, 26, 2, -43 },
  { 1639, 25, 43, 26, 1, -43 },
  { 1774, 21, 44, 26, 3, -43 },
  { 1890, 22, 44, 26, 2, -43 },
  { 2011, 22, 43, 26, 2, -43 },
  { 2130, 22, 44, 26, 2, -43 },
  { 2251, 22, 44, 26, 2, -43 },
  { 2372, 8, 34, 14, 3, -33 },
  { 2406, 9, 41, 14, 2, -33 },
  { 2453, 23, 27, 26, 2, -35 },
  { 2531, 23, 18, 26, 2, -30 },
  { 2583, 23, 27, 26, 2, -35 },
  { 2661, 18, 44, 20, 1, -43 },
  { 2760, 35, 48, 40, 3, -43 },
  { 2970, 28, 43, 28, 0, -43 },
  { 3121, 23, 43, 30, 4, -43 },
  { 3245, 23, 45, 27, 3, -44 },
  { 3375, 25, 43, 32, 4, -43 },
  { 3510, 18, 43, 25, 4, -43 },
  { 3607, 18, 43, 24, 4, -43 },
  { 3704, 27, 44, 33, 3, -43 },
  { 3853, 25, 43, 33, 4, -43 },
  { 3988, 14, 43, 18, 2, -43 },
  { 4064, 13, 55, 14, -3, -43 },
  { 4154, 24, 43, 28, 4, -43 },
  { 4283, 18, 43, 23, 4, -43 },
  { 4380, 36, 43, 44, 4, -43 },
  { 4574, 27, 43, 35, 4, -43 },
  { 4720, 28, 44, 34, 3, -43 },
  { 4874, 22, 43, 27, 4, -43 },
  { 4993, 28, 53, 34, 3, -43 },
  { 5179, 24, 43, 29, 4, -43 },
  { 5308, 21, 45, 25, 2, -44 },
  { 5427, 22, 43, 24, 1, -43 },
  { 5546, 24, 44, 32, 4, -43 },
  { 5678, 28, 43, 28, 0, -43 },
  { 5829, 44, 43, 44, 0, -43 },
  { 6066, 25, 43, 25, 0, -43 },
  { 6201, 25, 43, 25, 0, -43 },
  { 6336, 20, 43, 23, 1, -43 },
  { 6444, 13, 53, 19, 4, -43 },
  { 6531, 21, 43, 23, 1, -43 },
  { 6644, 13, 53, 19, 2, -43 },
  { 6731, 26, 24, 28, 1, -43 },
  { 6809, 26, 4, 26, 0, 5 },
  { 6822, 12, 10, 17, 2, -46 },
  { 6837, 20, 34, 26, 2, -33 },
  { 6922, 22, 47, 28, 4, -46 },
  { 7052, 18, 34, 22, 2, -33 },
  { 7129, 23, 47, 28, 2, -46 },
  { 7265, 22, 34, 26, 2, -33 },
  { 7359, 17, 46, 16, 1, -46 },
  { 7457, 23, 47, 28, 2, -33 },
  { 7593, 21, 46, 28, 4, -46 },
  { 7714, 7, 45, 13, 3, -45 },
  { 7754, 11, 59, 13, -1, -45 },
  { 7836, 21, 46, 25, 4, -46 },
  { 7957, 5, 46, 13, 4, -46 },
  { 7986, 34, 33, 42, 4, -33 },
  { 8127, 21, 33, 28, 4, -33 },
  { 8214, 23, 34, 27, 2, -33 },
  { 8312, 22, 47, 28, 4, -33 },
  { 8442, 23, 47, 28, 2, -33 },
  { 8578, 14, 33, 19, 4, -33 },
  { 8636, 17, 34, 21, 2, -33 },
  { 8709, 15, 41, 17, 1, -40 },
  { 8786, 20, 33, 28, 4, -32 },
  { 8869, 23, 32, 24, 0, -32 },
  { 8961, 37, 32, 38, 0, -32 },
  { 9109, 22, 32, 23, 1, -32 },
  { 9197, 23, 46, 24, 0, -32 },
  { 9330, 17, 32, 19, 1, -32 },
  { 9398, 17, 53, 21, 2, -43 },
  { 9511, 5, 60, 25, 10, -46 },
  { 9549, 18, 53, 21, 2, -43 },
  { 9669, 23, 8, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Medium60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM60PT7B_H_
