#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x08,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83,
  0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x07, 0x87, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xF7, 0x3C, 0x7C, 0x70, 0x47, 0xC7, 0x00, 0xF8, 0x70, 0x0F, 0x87, 0x00,
  0xF8, 0x70, 0x0F, 0x87, 0x00, 0x7C, 0x70, 0x07, 0xE7, 0x00, 0x7F, 0x70,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x73, 0xE0, 0x07, 0x1F, 0x00,
  0x71, 0xF0, 0x07, 0x1F, 0x00, 0x71, 0xF0, 0x07, 0x1F, 0x80, 0x71, 0xFE,
  0x07, 0x3E, 0xFC, 0x7F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x7C,
  0xF0, 0x07, 0x80, 0x1E, 0x1E, 0x03, 0xE0, 0x07, 0x87, 0x80, 0xF0, 0x03,
  0xE1, 0xE0, 0x3C, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x07, 0x80,
  0x0F, 0x07, 0xC1, 0xE0, 0x03, 0xC1, 0xF0, 0xF0, 0x00, 0xF0, 0x7C, 0x3C,
  0x00, 0x3C, 0x1F, 0x1F, 0x00, 0x0F, 0x07, 0xC7, 0x80, 0x03, 0xC1, 0xF1,
  0xE0, 0x00, 0xF0, 0x78, 0xF8, 0x7C, 0x3E, 0x1E, 0x3C, 0x7F, 0x87, 0x87,
  0x8F, 0x1F, 0xF1, 0xE1, 0xE7, 0x8F, 0xFE, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F,
  0xFC, 0x79, 0xF1, 0xE3, 0xFE, 0x3C, 0x78, 0x7C, 0x7F, 0x0F, 0x1E, 0x0F,
  0x07, 0x87, 0xC7, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0xF0, 0x00, 0x78, 0x78,
  0x3C, 0x00, 0x3E, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x1E,
  0x07, 0x83, 0xC0, 0x0F, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x78, 0x7C, 0x00,
  0xF0, 0x0F, 0x1E, 0x00, 0x78, 0x03, 0xEF, 0x80, 0x1E, 0x00, 0x7F, 0xC0,
  0x0F, 0x80, 0x1F, 0xF0, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x1F, 0x07, 0xFF, 0x83, 0xE1, 0xF9, 0xF8, 0xFC, 0x7E, 0x1F,
  0x1F, 0x8F, 0xC3, 0xF3, 0xE1, 0xF0, 0x3E, 0x7C, 0x3E, 0x07, 0xFF, 0x87,
  0xC0, 0x7F, 0xE1, 0xF8, 0x07, 0xFC, 0x3F, 0x00, 0xFF, 0x83, 0xE0, 0x0F,
  0xE0, 0x7C, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x1F, 0xF8, 0x1F,
  0xC7, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0x03, 0xFF, 0xC7,
  0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x01, 0x03, 0xC0, 0x9C, 0x78, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0x78, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x83, 0xC1, 0xE0,
  0x30, 0x30, 0x02, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C,
  0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF9, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF,
  0xDF, 0x7E, 0x7F, 0xF1, 0xF7, 0x87, 0xCC, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xC1, 0xFC, 0x30,
  0x0F, 0xC2, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0x81, 0xFC, 0x30, 0x0F, 0xE2, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0xC0, 0x0F, 0xEF, 0x83, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x02, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x77, 0xC0, 0x03, 0xDF, 0x00, 0x0F,
  0x7C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C,
  0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x07,
  0x81, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x38, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xD0, 0x03, 0xF3, 0xC1, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x04, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x78, 0xFF,
  0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x07, 0xEF, 0xE0,
  0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7,
  0xC0, 0x3F, 0x7E, 0x03, 0xE3, 0xE0, 0x3E, 0x3F, 0x07, 0xE3, 0xF8, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xBF,
  0x83, 0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xF0, 0x7E, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xF1,
  0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xE0, 0x7F,
  0x7F, 0x0F, 0xF7, 0xFF, 0xDF, 0x3F, 0xFD, 0xF1, 0xFF, 0xBE, 0x0F, 0xF3,
  0xE0, 0x3C, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x02, 0x0F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x1C, 0x3E, 0x7F,
  0x7F, 0x7F, 0x7F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F,
  0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0x70, 0x7F, 0x40, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x3F, 0x83, 0xC3, 0xE0, 0x7F, 0xF1, 0xF1, 0xE0, 0x7F, 0xF8, 0x78,
  0xF0, 0x7E, 0x7C, 0x3C, 0xF8, 0x3C, 0x3C, 0x1E, 0x78, 0x3E, 0x1E, 0x0F,
  0x3C, 0x1E, 0x0F, 0x07, 0x9E, 0x0F, 0x07, 0x83, 0xEF, 0x0F, 0x83, 0xC1,
  0xF7, 0x87, 0xC1, 0xE0, 0xFB, 0xC3, 0xC0, 0xF0, 0x7F, 0xE1, 0xE0, 0x78,
  0x3F, 0xF0, 0xF0, 0x3C, 0x1E, 0xF8, 0x78, 0x1E, 0x0F, 0x7C, 0x3C, 0x1F,
  0x07, 0x9E, 0x1F, 0x0F, 0x83, 0xCF, 0x0F, 0x87, 0xC1, 0xE7, 0x83, 0xC3,
  0xE1, 0xE3, 0xC1, 0xF3, 0xB8, 0xF1, 0xE0, 0xFF, 0xDF, 0xF0, 0xF8, 0x3F,
  0xCF, 0xF8, 0x7C, 0x0F, 0xC3, 0xF8, 0x1E, 0x01, 0xC0, 0x70, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xF3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0x83, 0xFE, 0x7C, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E,
  0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80,
  0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x01, 0xFC, 0xFF, 0xFF, 0xC7,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7C, 0x07,
  0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0xBF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xF0, 0x78, 0x7E, 0x00, 0x87, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x04, 0x3F, 0xF3, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0x01, 0xFE, 0x3E, 0x01, 0xFC, 0x7C, 0x01, 0xFC, 0xF8, 0x01, 0xF9,
  0xF0, 0x03, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF,
  0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x9F, 0x00, 0x3F,
  0x3E, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xF8, 0x07, 0xF1, 0xF0, 0x3F, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x3E, 0x1F, 0xC0, 0x04,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x80, 0x1F, 0x1F, 0xC0, 0x1F,
  0x1F, 0xF0, 0x7F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x87,
  0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x87, 0xE0, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xEF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F,
  0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F,
  0x83, 0xF0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x9F,
  0x80, 0x3E, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xE7, 0xC0, 0x3F,
  0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x07,
  0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8,
  0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFB, 0xC0, 0x03, 0xFF, 0xFB, 0xE0, 0x03, 0xDF, 0xFB, 0xE0,
  0x07, 0xDF, 0xFB, 0xE0, 0x07, 0xDF, 0xF9, 0xE0, 0x07, 0xDF, 0xF9, 0xF0,
  0x07, 0x9F, 0xF9, 0xF0, 0x0F, 0x9F, 0xF8, 0xF0, 0x0F, 0x9F, 0xF8, 0xF8,
  0x0F, 0x1F, 0xF8, 0xF8, 0x0F, 0x1F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0x78,
  0x1F, 0x1F, 0xF8, 0x7C, 0x1E, 0x1F, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0x7C,
  0x3E, 0x1F, 0xF8, 0x3C, 0x3C, 0x1F, 0xF8, 0x3E, 0x3C, 0x1F, 0xF8, 0x3E,
  0x7C, 0x1F, 0xF8, 0x1E, 0x7C, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x07,
  0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x03,
  0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFB, 0xE0, 0x1F, 0xFB,
  0xF0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8,
  0xF8, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8,
  0x1F, 0x9F, 0xF8, 0x0F, 0x9F, 0xF8, 0x0F, 0xDF, 0xF8, 0x07, 0xDF, 0xF8,
  0x07, 0xDF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0x80, 0x03,
  0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F,
  0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB,
  0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xE0, 0x3F, 0x8F, 0x80, 0x7E, 0x3E, 0x01,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFC,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8,
  0x0F, 0xE3, 0xE0, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x1F,
  0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xEF,
  0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0x1F, 0x9F, 0x80, 0x63, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFB,
  0x80, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3E, 0xFC,
  0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xFC, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x00, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xE0, 0x01,
  0xF3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x7C, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x3E, 0x00,
  0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0x00,
  0x7C, 0x3E, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xF7, 0x80, 0xFC, 0x1F,
  0x01, 0xE7, 0x80, 0xF8, 0x1F, 0x01, 0xE7, 0x80, 0xF8, 0x1F, 0x01, 0xE7,
  0x80, 0xF8, 0x1F, 0x03, 0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8,
  0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0x0F, 0x83,
  0xC3, 0xC1, 0xF0, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC3, 0xE3,
  0xF0, 0x07, 0xC7, 0xC3, 0xE3, 0xE0, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x07,
  0xC7, 0x81, 0xE3, 0xE0, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xCF, 0x81,
  0xF7, 0xE0, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0xF7, 0xC0,
  0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x03, 0xFF,
  0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0xEF, 0x80, 0x07, 0xDF, 0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3,
  0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00,
  0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x1F, 0x84, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03,
  0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xF7, 0xFF, 0xBD, 0xFF, 0xCF, 0x3F,
  0xF3, 0xC7, 0xF0, 0xF0, 0x60, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0xC3, 0xF7, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xCF, 0xE7, 0xF8, 0x3F, 0x3F, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xC0,
  0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF,
  0x80, 0x7D, 0xFC, 0x07, 0xEF, 0xF0, 0x3E, 0x7F, 0xC3, 0xF3, 0xEF, 0xFF,
  0x9F, 0x7F, 0xF8, 0xF9, 0xFF, 0x87, 0xC3, 0xF8, 0x00, 0x02, 0x00, 0x01,
  0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xFC, 0xF1, 0xF8, 0x08,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x9F, 0xC1, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x3F, 0x1F, 0x87, 0xFC, 0xFC, 0x7F, 0xF7, 0xE3, 0xFF, 0xDF, 0x3F,
  0x9F, 0xF9, 0xF8, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xC0, 0x1F,
  0xBE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00,
  0x7E, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x9F, 0x83, 0xFC, 0xFF, 0xFB, 0xE3,
  0xFF, 0xDF, 0x0F, 0xFC, 0xF8, 0x3F, 0xC7, 0xC0, 0x20, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0,
  0x7C, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x01, 0xEF, 0xC0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x43, 0xF8, 0x1C, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x7F, 0xC7, 0xC7, 0xFF, 0x3E,
  0x3F, 0xFD, 0xF3, 0xFD, 0xFF, 0x9F, 0x83, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0,
  0x7F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBE,
  0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF9, 0xFC, 0x7F,
  0xCF, 0xFF, 0xBE, 0x3F, 0xFB, 0xF0, 0xFF, 0xDF, 0x83, 0xF8, 0xFC, 0x02,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x18, 0x03, 0xF0, 0xFD, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x0F, 0xDF, 0xF8, 0xFD, 0xFF, 0xCF, 0xBF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0x7E, 0xFE, 0x03, 0xEF, 0xE0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7B, 0xFF, 0xFF, 0xFD, 0xF3, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xBF, 0xEF, 0xFB, 0xFC, 0xFF, 0x3F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0xFC, 0xF8,
  0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF3,
  0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0x81, 0xF9, 0xF8, 0x3F, 0x1F, 0x07, 0xC3,
  0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xFC, 0x7C, 0x0F, 0x8F, 0x81,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7E, 0x03,
  0xF0, 0xF9, 0xFF, 0x8F, 0xFC, 0xFB, 0xFF, 0x8F, 0xFE, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xDF, 0xFE, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0xFE, 0x07, 0xF0,
  0x3F, 0xFE, 0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0,
  0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0,
  0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0,
  0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0,
  0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0,
  0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0,
  0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0,
  0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x7E, 0x0F,
  0x9F, 0xF8, 0xF9, 0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0xDF, 0xEF, 0xF0, 0x7E,
  0xFE, 0x03, 0xEF, 0xE0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF8,
  0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xE1, 0xFC, 0x3F, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xF8, 0x7E,
  0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF1, 0xF7, 0xFF, 0xCF, 0xF8, 0xFE, 0x7F,
  0x83, 0xF3, 0xF8, 0x0F, 0xDF, 0xC0, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F,
  0xBF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF8, 0x07, 0xDF, 0xC0,
  0x7E, 0xFF, 0x03, 0xF7, 0xFC, 0x3F, 0x3E, 0xFF, 0xF9, 0xFB, 0xFF, 0x8F,
  0xDF, 0xF8, 0x7E, 0x3F, 0x83, 0xF0, 0x60, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x7F, 0xC7, 0xC7, 0xFF, 0x3E, 0x3F,
  0xFD, 0xF3, 0xF9, 0xFF, 0x9F, 0x83, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F,
  0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00,
  0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF9, 0xFC, 0x7F, 0xCF,
  0xFF, 0xBE, 0x3F, 0xFB, 0xF0, 0xFF, 0xDF, 0x83, 0xF8, 0xFC, 0x02, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0xF8, 0x7F, 0xE3, 0xFF,
  0x9F, 0xFE, 0xFF, 0xFB, 0xFB, 0xFF, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0xFE, 0x1C, 0xF8,
  0x04, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x80, 0x3E, 0xF0, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0x02, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x87, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE1, 0x1F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x80, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF, 0xF7,
  0x9F, 0xFC, 0xF1, 0xFF, 0x9E, 0x1F, 0xC3, 0xC0, 0x40, 0x00, 0xFC, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9E, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xDF, 0x00, 0xFC,
  0x01, 0xF7, 0xC0, 0x3F, 0x80, 0xFD, 0xF0, 0x0F, 0xE0, 0x3E, 0x7E, 0x07,
  0xF8, 0x0F, 0x8F, 0x81, 0xFE, 0x03, 0xE3, 0xE0, 0x7F, 0x80, 0xF8, 0xF8,
  0x1E, 0xF0, 0x7C, 0x3E, 0x07, 0xBC, 0x1F, 0x0F, 0xC3, 0xEF, 0x07, 0xC1,
  0xF0, 0xF3, 0xC1, 0xF0, 0x7C, 0x3C, 0xF0, 0x7C, 0x1F, 0x0F, 0x3E, 0x3E,
  0x07, 0xC3, 0xC7, 0x8F, 0x81, 0xF8, 0xF1, 0xE3, 0xE0, 0x3E, 0x7C, 0x78,
  0xF8, 0x0F, 0x9E, 0x1E, 0x3C, 0x03, 0xE7, 0x87, 0x9F, 0x00, 0xF9, 0xE1,
  0xF7, 0xC0, 0x1E, 0x78, 0x3D, 0xF0, 0x07, 0x9E, 0x0F, 0x7C, 0x01, 0xFF,
  0x03, 0xDE, 0x00, 0x7F, 0xC0, 0xF7, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xE0, 0x7C, 0x3E,
  0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF9, 0xF0, 0x0F, 0x9F, 0x00,
  0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x01, 0xF9, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0x7E, 0xFC,
  0x03, 0xEF, 0x80, 0x3F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7E,
  0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0,
  0x7C, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x3D, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x01,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0x3F, 0xFA, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 40, 13, 3, -39 },
  { 36, 16, 14, 22, 3, -39 },
  { 64, 24, 39, 26, 1, -39 },
  { 181, 20, 45, 24, 2, -42 },
  { 294, 34, 41, 38, 2, -40 },
  { 469, 27, 41, 28, 1, -40 },
  { 608, 6, 14, 12, 3, -39 },
  { 619, 12, 49, 16, 3, -40 },
  { 693, 13, 49, 16, 1, -40 },
  { 773, 19, 20, 23, 2, -42 },
  { 821, 21, 26, 24, 2, -32 },
  { 890, 8, 13, 13, 2, -6 },
  { 903, 13, 5, 16, 1, -17 },
  { 912, 7, 8, 13, 3, -7 },
  { 919, 19, 39, 21, 1, -39 },
  { 1012, 20, 41, 24, 2, -40 },
  { 1115, 14, 39, 24, 3, -39 },
  { 1184, 20, 40, 24, 2, -40 },
  { 1284, 20, 41, 24, 2, -40 },
  { 1387, 22, 39, 24, 1, -39 },
  { 1495, 19, 40, 24, 3, -39 },
  { 1590, 20, 41, 24, 2, -40 },
  { 1693, 20, 39, 24, 2, -39 },
  { 1791, 20, 41, 24, 2, -40 },
  { 1894, 20, 41, 24, 2, -40 },
  { 1997, 7, 31, 13, 3, -30 },
  { 2025, 8, 37, 13, 2, -30 },
  { 2062, 21, 25, 24, 2, -32 },
  { 2128, 21, 16, 24, 2, -27 },
  { 2170, 21, 25, 24, 2, -32 },
  { 2236, 16, 41, 18, 1, -40 },
  { 2318, 33, 45, 37, 2, -40 },
  { 2504, 26, 39, 26, 0, -39 },
  { 2631, 21, 39, 27, 4, -39 },
  { 2734, 21, 41, 25, 3, -40 },
  { 2842, 23, 39, 29, 4, -39 },
  { 2955, 16, 39, 23, 4, -39 },
  { 3033, 16, 39, 22, 4, -39 },
  { 3111, 24, 41, 30, 3, -40 },
  { 3234, 22, 39, 30, 4, -39 },
  { 3342, 12, 39, 16, 2, -39 },
  { 3401, 12, 50, 13, -3, -39 },
  { 3476, 22, 39, 26, 4, -39 },
  { 3584, 16, 39, 21, 4, -39 },
  { 3662, 32, 39, 40, 4, -39 },
  { 3818, 24, 39, 32, 4, -39 },
  { 3935, 25, 41, 31, 3, -40 },
  { 4064, 19, 39, 25, 4, -39 },
  { 4157, 25, 49, 31, 3, -40 },
  { 4311, 22, 39, 26, 4, -39 },
  { 4419, 19, 41, 23, 2, -40 },
  { 4517, 20, 39, 22, 1, -39 },
  { 4615, 22, 40, 30, 4, -39 },
  { 4725, 25, 39, 25, 0, -39 },
  { 4847, 40, 39, 40, 0, -39 },
  { 5042, 23, 39, 23, 0, -39 },
  { 5155, 23, 39, 23, 0, -39 },
  { 5268, 19, 39, 21, 1, -39 },
  { 5361, 12, 49, 17, 4, -40 },
  { 5435, 19, 39, 21, 1, -39 },
  { 5528, 11, 49, 17, 2, -40 },
  { 5596, 24, 22, 26, 1, -39 },
  { 5662, 24, 3, 24, 0, 5 },
  { 5671, 11, 9, 15, 2, -42 },
  { 5684, 18, 31, 24, 2, -30 },
  { 5754, 21, 43, 26, 3, -42 },
  { 5867, 17, 31, 20, 2, -30 },
  { 5933, 21, 43, 26, 2, -42 },
  { 6046, 20, 31, 24, 2, -30 },
  { 6124, 16, 42, 15, 0, -42 },
  { 6208, 21, 43, 26, 2, -30 },
  { 6321, 20, 42, 26, 3, -42 },
  { 6426, 6, 41, 12, 3, -41 },
  { 6457, 10, 54, 12, -1, -41 },
  { 6525, 19, 42, 23, 4, -42 },
  { 6625, 6, 42, 12, 3, -42 },
  { 6657, 32, 30, 39, 3, -30 },
  { 6777, 20, 30, 26, 3, -30 },
  { 6852, 21, 31, 25, 2, -30 },
  { 6934, 21, 43, 26, 3, -30 },
  { 7047, 21, 43, 26, 2, -30 },
  { 7160, 14, 30, 17, 3, -30 },
  { 7213, 16, 31, 19, 2, -30 },
  { 7275, 14, 37, 15, 1, -36 },
  { 7340, 19, 31, 26, 3, -30 },
  { 7414, 21, 30, 22, 0, -30 },
  { 7493, 34, 30, 34, 0, -30 },
  { 7621, 20, 30, 21, 1, -30 },
  { 7696, 21, 43, 22, 0, -30 },
  { 7809, 16, 30, 18, 1, -30 },
  { 7869, 15, 48, 20, 2, -39 },
  { 7959, 5, 55, 23, 9, -42 },
  { 7994, 16, 48, 20, 2, -39 },
  { 8090, 21, 7, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Medium55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM55PT7B_H_
