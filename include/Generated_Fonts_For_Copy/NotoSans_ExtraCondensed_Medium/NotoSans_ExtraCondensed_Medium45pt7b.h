#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF3,
  0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x1D, 0xFF, 0xFF, 0xFF, 0xF8, 0x7B, 0xC3,
  0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0xDE, 0x1E, 0x03, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0x87, 0x80, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07,
  0x87, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xE1, 0xE0,
  0x0E, 0x1E, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0E, 0x1C,
  0x01, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F,
  0xFE, 0x7D, 0x8E, 0xF9, 0x82, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF1,
  0x80, 0xF9, 0x80, 0x7D, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xBE, 0x01, 0x9F, 0x01, 0x8F, 0x01, 0x8F, 0x01,
  0x8F, 0x01, 0x8F, 0x81, 0x9F, 0xE1, 0xBE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F,
  0xF0, 0x07, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x7F, 0x80, 0x78, 0x07,
  0xFC, 0x07, 0x00, 0xF3, 0xC0, 0xF0, 0x0F, 0x1C, 0x0E, 0x00, 0xE1, 0xE0,
  0xE0, 0x0E, 0x1E, 0x1E, 0x00, 0xE1, 0xE1, 0xC0, 0x0E, 0x1E, 0x1C, 0x00,
  0xE1, 0xE3, 0xC0, 0x0E, 0x1E, 0x38, 0x00, 0xE1, 0xE7, 0x80, 0x0E, 0x1E,
  0x78, 0x70, 0xE1, 0xE7, 0x1F, 0x8F, 0x1C, 0xF3, 0xFC, 0xF3, 0xCE, 0x3F,
  0xC7, 0xFC, 0xE7, 0x9E, 0x7F, 0x9E, 0x70, 0xE3, 0xF1, 0xC7, 0x0E, 0x04,
  0x1C, 0x70, 0xF0, 0x03, 0xC7, 0x0F, 0x00, 0x38, 0xF0, 0xF0, 0x03, 0x8F,
  0x0F, 0x00, 0x78, 0x70, 0xF0, 0x07, 0x07, 0x0F, 0x00, 0xF0, 0x70, 0xE0,
  0x0F, 0x07, 0x0E, 0x00, 0xE0, 0x70, 0xE0, 0x1E, 0x07, 0x9E, 0x01, 0xC0,
  0x3F, 0xC0, 0x1C, 0x03, 0xFC, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x3C, 0x00, 0x78,
  0xF8, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xC3, 0xFF,
  0x0F, 0x1F, 0x3E, 0x3C, 0x7C, 0x78, 0xF1, 0xE1, 0xF7, 0xCF, 0x83, 0xDE,
  0x3E, 0x0F, 0xF8, 0xF8, 0x1F, 0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E,
  0x03, 0xF0, 0x7C, 0x1F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x0F, 0xFE,
  0x3E, 0x0F, 0xF0, 0xFC, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x61, 0xC2, 0x7D,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F,
  0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x0C, 0x38, 0x04, 0x10, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7D, 0xF7, 0xDE, 0x79,
  0xEF, 0xBC, 0xF3, 0xCE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3E, 0xFC, 0x7C, 0x3C, 0x78, 0x3E, 0x78, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0x78,
  0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xE0, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xDF, 0x7F, 0xCF,
  0xF1, 0xEC, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x80, 0x07,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC7, 0xE1, 0x80, 0xF8, 0x80, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x3F, 0xF0,
  0x7F, 0xF8, 0xFF, 0xFC, 0xF8, 0xFC, 0x60, 0x3E, 0x40, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x80, 0x7E, 0xF9, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1D, 0xE0, 0x07, 0x78, 0x03, 0x9E, 0x00, 0xE7,
  0x80, 0x71, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0,
  0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0xF0,
  0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x20, 0x7E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0xC0, 0x7E, 0xF9, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x20, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0xC4, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x40, 0xF3, 0xF8, 0xF7, 0xFC,
  0xFF, 0xFC, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1F,
  0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x03, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0,
  0x1F, 0x78, 0x0F, 0xBE, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xE1, 0xE0,
  0xF9, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xDF,
  0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF7, 0xC0, 0xFB, 0xF1, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF8, 0x7E, 0xFC, 0xF8, 0x3C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7E, 0xFF, 0x7F, 0xEF, 0x3F, 0xDF, 0x1F,
  0x9E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x67, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x80, 0xF7, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1D, 0xFF, 0xFF, 0xFE, 0x7D, 0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7D, 0xF7, 0xDE, 0x79, 0xEF,
  0x3C, 0xF3, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x7C, 0xFC, 0x81, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0xF0, 0x00,
  0x1E, 0x38, 0x0F, 0x83, 0x9E, 0x0F, 0xF8, 0xF7, 0x87, 0xFE, 0x3D, 0xC1,
  0xE7, 0x87, 0x70, 0xF1, 0xE1, 0xFC, 0x38, 0x78, 0x7F, 0x1E, 0x1E, 0x1F,
  0xC7, 0x87, 0x87, 0xE1, 0xE1, 0xE1, 0xF8, 0x78, 0x78, 0x7E, 0x1E, 0x1E,
  0x1F, 0x87, 0x87, 0x87, 0xE1, 0xE1, 0xC1, 0xFC, 0x78, 0xF0, 0xFF, 0x1E,
  0x3E, 0x3B, 0xC3, 0xCF, 0x9E, 0xF0, 0xFF, 0x7F, 0x1C, 0x1F, 0x9F, 0xC7,
  0x83, 0xC3, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x40, 0x0F, 0xE0, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3E, 0x07, 0xC0, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x3C, 0x3E,
  0x01, 0xE1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x0F,
  0x3C, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x81, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xF7,
  0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xFE, 0x7C, 0x1F, 0xBE, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xF1, 0xFE, 0xF8, 0xF8, 0x08, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x08, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0x83, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xF3, 0xE1, 0xF8, 0x06, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0xF3, 0xF0,
  0x0F, 0x1F, 0x80, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x8F,
  0xBF, 0xEF, 0xF3, 0xF8, 0xFC, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x3E,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF,
  0x03, 0xE3, 0xC0, 0xF8, 0xF8, 0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0x7F, 0xBC, 0x01,
  0xEF, 0xF7, 0x80, 0x3D, 0xFE, 0xF0, 0x07, 0xBF, 0xCE, 0x00, 0xE7, 0xF9,
  0xE0, 0x3C, 0xFF, 0x3C, 0x07, 0x9F, 0xE7, 0x80, 0xF3, 0xFC, 0x78, 0x3C,
  0x7F, 0x8F, 0x07, 0x8F, 0xF1, 0xE0, 0xF1, 0xFE, 0x3C, 0x1C, 0x3F, 0xC3,
  0xC7, 0x87, 0xF8, 0x78, 0xF0, 0xFF, 0x0F, 0x1E, 0x1F, 0xE0, 0xE7, 0x83,
  0xFC, 0x1E, 0xF0, 0x7F, 0x83, 0xDE, 0x0F, 0xF0, 0x7B, 0x81, 0xFE, 0x07,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x01, 0xF0, 0x1F,
  0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x80, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0x78, 0x0F, 0xF7, 0x80, 0xFF, 0x7C, 0x0F, 0xF3,
  0xC0, 0xFF, 0x3E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF8, 0xFF, 0x07, 0x8F, 0xF0, 0x7C, 0xFF, 0x03, 0xCF,
  0xF0, 0x3C, 0xFF, 0x03, 0xEF, 0xF0, 0x1E, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFC, 0xFC, 0x1F, 0x81, 0xF0, 0xF8, 0x0F,
  0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF3,
  0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0x7C, 0x07, 0xC3, 0xF0, 0x7E, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81,
  0xFC, 0xFC, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7D, 0xE0,
  0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x8F, 0x00, 0x7C,
  0x7C, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x3E,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xCF,
  0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x87, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE3, 0xC0, 0xF8, 0xF8,
  0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0x81, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x1F, 0x01, 0xC0, 0x1F, 0xF0, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0xDF, 0x81,
  0xBE, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x7D,
  0xF0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1F, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xBE, 0x00, 0xF8, 0x03, 0xCF,
  0x00, 0x7C, 0x01, 0xE7, 0x80, 0x7E, 0x01, 0xF3, 0xC0, 0x3F, 0x80, 0xF9,
  0xF0, 0x1F, 0xC0, 0x78, 0x78, 0x0E, 0xE0, 0x3C, 0x3C, 0x07, 0x70, 0x1E,
  0x1E, 0x07, 0xB8, 0x1F, 0x0F, 0x03, 0xDE, 0x0F, 0x87, 0xC1, 0xEF, 0x07,
  0x81, 0xE0, 0xF7, 0x83, 0xC0, 0xF0, 0x73, 0xC1, 0xE0, 0x78, 0x78, 0xE1,
  0xF0, 0x3C, 0x3C, 0x70, 0xF8, 0x1F, 0x1E, 0x3C, 0x78, 0x07, 0x8F, 0x1E,
  0x3C, 0x03, 0xC7, 0x0F, 0x1E, 0x01, 0xE7, 0x83, 0x9F, 0x00, 0xF3, 0xC1,
  0xCF, 0x80, 0x7D, 0xE0, 0xF7, 0x80, 0x1E, 0xF0, 0x7B, 0xC0, 0x0F, 0x70,
  0x3D, 0xE0, 0x07, 0xB8, 0x0E, 0xF0, 0x03, 0xFC, 0x07, 0x78, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x7C,
  0x07, 0xC7, 0x80, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E,
  0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x9E, 0x00, 0xF7, 0xC0, 0x1E,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7B,
  0xC0, 0x0F, 0x7C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1F, 0x03, 0xC1,
  0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x9E, 0x01,
  0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x3E, 0x03,
  0xC3, 0xC0, 0x78, 0x7C, 0x1F, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1F, 0x1F,
  0x03, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x00,
  0xF3, 0xC0, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x18, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFF, 0x0F, 0xFF,
  0x3F, 0xFF, 0x3F, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x3F, 0x7C, 0x7F, 0x7F, 0xEF, 0x3F, 0xCF,
  0x1F, 0x8F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x70, 0x3C,
  0xFE, 0x1E, 0xFF, 0x8F, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDF,
  0x01, 0xEF, 0x81, 0xF7, 0xE0, 0xF3, 0xF9, 0xF9, 0xFF, 0xF8, 0xF7, 0xFC,
  0x71, 0xFC, 0x00, 0x01, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F, 0xF7, 0xE1, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0xBF, 0x9C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x83, 0x87, 0xC7, 0xF3, 0xE7, 0xFD, 0xF3, 0xFF, 0xFB,
  0xE1, 0xFD, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x81, 0xFB, 0xE0, 0xFD,
  0xF9, 0xFE, 0x7F, 0xEF, 0x3F, 0xE7, 0x87, 0xE3, 0xC0, 0x01, 0x80, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x02, 0x3E, 0x0E, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x03,
  0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0x20, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0xE3, 0xCF,
  0xF9, 0xE7, 0xFF, 0xF7, 0xE3, 0xFB, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF,
  0x03, 0xF7, 0xC1, 0xFB, 0xF3, 0xFC, 0xFF, 0xFE, 0x7F, 0xDF, 0x0F, 0xCF,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x79, 0x00,
  0x7C, 0xE0, 0x7C, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x01, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE1, 0xC3, 0xCF, 0xE7, 0xBF, 0xEF, 0xFF,
  0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3C, 0x4F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1F, 0xFF, 0xFE, 0xFC, 0x78, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8,
  0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFD, 0xE0, 0xF9, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x3C, 0x38, 0xFE,
  0x3F, 0xCE, 0x7F, 0xDF, 0xF3, 0xFF, 0xF7, 0xFE, 0xFC, 0x7F, 0x8F, 0xBE,
  0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xC0, 0x78, 0x1F, 0xF0, 0x1E, 0x07,
  0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0,
  0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0xE1, 0xC7, 0xF3, 0x9F, 0xF7, 0xFF,
  0xFF, 0xE3, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1E, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x78,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xBE, 0x03, 0xCF, 0x03, 0xE7, 0xC1,
  0xE1, 0xF1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xE0,
  0x71, 0xFC, 0x3D, 0xFF, 0x1F, 0xFF, 0xCF, 0xC3, 0xE7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07,
  0xBE, 0x03, 0xDF, 0x03, 0xEF, 0xC1, 0xE7, 0xF3, 0xF3, 0xFF, 0xF1, 0xEF,
  0xF8, 0xF3, 0xF8, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xE3, 0xCF, 0xF9, 0xE7, 0xFF, 0xF7,
  0xC3, 0xFB, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x03, 0xF7, 0xC1, 0xFB,
  0xF3, 0xFC, 0xFF, 0xFE, 0x7F, 0xDF, 0x0F, 0xCF, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x7F, 0x9F,
  0xFB, 0xFF, 0xFD, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xFF, 0x8F, 0xFE,
  0xFF, 0xF7, 0x83, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xDF, 0xFE, 0x7F, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0xFC, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xEF, 0xFD, 0xDF,
  0xF3, 0x8F, 0xC7, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF0, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF7, 0x81, 0xF8,
  0x1E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x7C, 0x1F, 0x81, 0xE3,
  0xC1, 0xFC, 0x3E, 0x3C, 0x3D, 0xC3, 0xC3, 0xC3, 0xDC, 0x3C, 0x3C, 0x39,
  0xC3, 0xC3, 0xE3, 0x9C, 0x3C, 0x1E, 0x39, 0xE7, 0x81, 0xE7, 0x9E, 0x78,
  0x1E, 0x78, 0xE7, 0x81, 0xE7, 0x0E, 0x78, 0x0F, 0x70, 0xE7, 0x80, 0xF7,
  0x0E, 0xF0, 0x0F, 0x70, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0x9E, 0x0F, 0x8F, 0x87,
  0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x7C, 0x0F, 0x9E, 0x07, 0x8F, 0x83, 0xC3,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF9, 0xF0, 0x3D, 0xF0, 0x1F, 0xF8, 0x07, 0xBC,
  0x03, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C,
  0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x3F, 0x81, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xF0, 0x3F, 0x83, 0xF0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x5F, 0xF0, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0xFF, 0xA0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 32, 11, 3, -32 },
  { 21, 13, 11, 18, 2, -32 },
  { 39, 20, 32, 21, 1, -32 },
  { 119, 16, 37, 20, 2, -34 },
  { 193, 28, 33, 31, 2, -33 },
  { 309, 22, 33, 23, 1, -33 },
  { 400, 5, 11, 10, 2, -32 },
  { 407, 10, 39, 13, 2, -32 },
  { 456, 10, 39, 13, 1, -32 },
  { 505, 16, 16, 19, 1, -34 },
  { 537, 17, 22, 20, 1, -27 },
  { 584, 6, 11, 10, 2, -5 },
  { 593, 11, 4, 13, 1, -14 },
  { 599, 5, 6, 11, 3, -6 },
  { 603, 16, 32, 17, 1, -32 },
  { 667, 16, 33, 20, 2, -33 },
  { 733, 11, 32, 20, 3, -32 },
  { 777, 17, 33, 20, 1, -33 },
  { 848, 16, 33, 20, 2, -33 },
  { 914, 18, 32, 20, 1, -32 },
  { 986, 16, 32, 20, 2, -32 },
  { 1050, 16, 33, 20, 2, -33 },
  { 1116, 17, 32, 20, 1, -32 },
  { 1184, 17, 33, 20, 1, -33 },
  { 1255, 16, 33, 20, 2, -33 },
  { 1321, 5, 24, 11, 3, -24 },
  { 1336, 6, 30, 11, 2, -24 },
  { 1359, 18, 20, 20, 1, -26 },
  { 1404, 17, 13, 20, 1, -22 },
  { 1432, 18, 20, 20, 1, -26 },
  { 1477, 14, 33, 15, 0, -33 },
  { 1535, 26, 36, 30, 2, -32 },
  { 1652, 21, 32, 21, 0, -32 },
  { 1736, 17, 32, 22, 3, -32 },
  { 1804, 17, 33, 21, 2, -33 },
  { 1875, 19, 32, 24, 3, -32 },
  { 1951, 13, 32, 19, 3, -32 },
  { 2003, 13, 32, 18, 3, -32 },
  { 2055, 20, 33, 25, 2, -33 },
  { 2138, 19, 32, 25, 3, -32 },
  { 2214, 11, 32, 13, 1, -32 },
  { 2258, 10, 41, 11, -2, -32 },
  { 2310, 18, 32, 21, 3, -32 },
  { 2382, 13, 32, 17, 3, -32 },
  { 2434, 27, 32, 33, 3, -32 },
  { 2542, 20, 32, 26, 3, -32 },
  { 2622, 21, 33, 25, 2, -33 },
  { 2709, 16, 32, 21, 3, -32 },
  { 2773, 21, 41, 25, 2, -33 },
  { 2881, 18, 32, 21, 3, -32 },
  { 2953, 15, 33, 19, 2, -33 },
  { 3015, 17, 32, 18, 0, -32 },
  { 3083, 18, 32, 24, 3, -32 },
  { 3155, 21, 32, 21, 0, -32 },
  { 3239, 33, 32, 33, 0, -32 },
  { 3371, 19, 32, 19, 0, -32 },
  { 3447, 19, 32, 19, 0, -32 },
  { 3523, 15, 32, 17, 1, -32 },
  { 3583, 10, 39, 14, 3, -32 },
  { 3632, 16, 32, 17, 1, -32 },
  { 3696, 10, 39, 14, 1, -32 },
  { 3745, 19, 18, 21, 1, -32 },
  { 3788, 19, 3, 19, 0, 4 },
  { 3796, 9, 7, 13, 2, -34 },
  { 3804, 16, 25, 19, 1, -25 },
  { 3854, 17, 34, 21, 3, -34 },
  { 3927, 13, 25, 16, 2, -25 },
  { 3968, 17, 34, 21, 2, -34 },
  { 4041, 16, 25, 19, 2, -25 },
  { 4091, 13, 34, 12, 0, -34 },
  { 4147, 17, 36, 21, 2, -25 },
  { 4224, 15, 34, 21, 3, -34 },
  { 4288, 4, 34, 10, 3, -34 },
  { 4305, 8, 45, 10, -1, -34 },
  { 4350, 16, 34, 19, 3, -34 },
  { 4418, 4, 34, 10, 3, -34 },
  { 4435, 26, 25, 32, 3, -25 },
  { 4517, 15, 25, 21, 3, -25 },
  { 4564, 17, 25, 21, 2, -25 },
  { 4618, 17, 36, 21, 3, -25 },
  { 4695, 17, 36, 21, 2, -25 },
  { 4772, 11, 25, 14, 3, -25 },
  { 4807, 13, 25, 16, 1, -25 },
  { 4848, 11, 30, 13, 1, -30 },
  { 4890, 15, 24, 21, 3, -24 },
  { 4935, 17, 24, 18, 0, -24 },
  { 4986, 28, 24, 28, 0, -24 },
  { 5070, 17, 24, 17, 0, -24 },
  { 5121, 17, 35, 18, 0, -24 },
  { 5196, 13, 24, 14, 1, -24 },
  { 5235, 13, 39, 16, 1, -32 },
  { 5299, 4, 45, 19, 7, -34 },
  { 5322, 13, 39, 16, 2, -32 },
  { 5386, 18, 6, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Medium45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM45PT7B_H_
