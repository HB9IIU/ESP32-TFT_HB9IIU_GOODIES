#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x66, 0x60, 0x00, 0xFF,
  0xFF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B, 0x86, 0xE1,
  0x80, 0x06, 0x38, 0x1C, 0x60, 0x38, 0xC0, 0x71, 0x80, 0xC3, 0x01, 0x8E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xC0, 0x71, 0x80, 0xE3, 0x01,
  0x8E, 0x03, 0x1C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x71, 0x80, 0xE3,
  0x01, 0xC6, 0x03, 0x1C, 0x06, 0x38, 0x0C, 0x70, 0x18, 0xE0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x1F, 0xC3, 0xFF, 0x3F, 0xF9, 0xC8, 0x5E, 0x40, 0xE2,
  0x07, 0x10, 0x1C, 0x80, 0xF4, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x02, 0x70, 0x13, 0x80, 0x8E, 0x04, 0x68, 0x27, 0x79, 0xFB, 0xFF, 0x8F,
  0xF0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00, 0x01, 0xF0,
  0x18, 0x1F, 0xC1, 0xC0, 0xCE, 0x0C, 0x06, 0x30, 0x60, 0x71, 0xC7, 0x03,
  0x8E, 0x30, 0x1C, 0x73, 0x80, 0xE3, 0x9C, 0x07, 0x1C, 0xC0, 0x38, 0xEE,
  0x38, 0xC6, 0x77, 0xE6, 0x73, 0x3F, 0xBF, 0xBB, 0x9C, 0xF9, 0x9C, 0xE1,
  0x0C, 0xE3, 0x00, 0xE7, 0x18, 0x06, 0x38, 0xC0, 0x71, 0xC6, 0x03, 0x8E,
  0x30, 0x18, 0x71, 0x81, 0xC3, 0x9C, 0x0E, 0x0C, 0xE0, 0x60, 0x7E, 0x07,
  0x01, 0xE0, 0x06, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x39, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xC0, 0x3D, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x0E, 0x7B, 0x8E, 0xF3, 0xCE, 0xF1, 0xDE,
  0xE1, 0xFC, 0xE0, 0xFC, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0xFC, 0x7F, 0xFC,
  0x7F, 0xDE, 0x3F, 0x8F, 0xFE, 0xEE, 0xEE, 0xEE, 0xE0, 0x0E, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0xE0, 0x0F, 0x00, 0x60, 0x06, 0x08, 0x61, 0xF6, 0xFF,
  0xFF, 0x7F, 0xC0, 0xF0, 0x1F, 0x83, 0x9C, 0x79, 0xE1, 0x08, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF,
  0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x3B, 0xDE, 0xE7, 0x39, 0xDC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x02, 0x00,
  0xFE, 0x0F, 0xF0, 0x7B, 0xC7, 0x8E, 0x38, 0x79, 0xC1, 0xCE, 0x0E, 0x70,
  0x77, 0x83, 0xBC, 0x1D, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0E,
  0xF0, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x3C, 0x70, 0xFF, 0x87,
  0xF8, 0x1F, 0x80, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xFF, 0xBD, 0x9E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x03, 0xFC, 0x7F, 0xEF, 0x9E,
  0x60, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x03, 0xFC, 0xFF,
  0xE7, 0x1E, 0x40, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xE1, 0xF8, 0x1F, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF8, 0x0F, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0x70, 0x3B, 0x81, 0x9C, 0x1C,
  0xE0, 0xC7, 0x0E, 0x38, 0x61, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x7F, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1F, 0xE3, 0xFE, 0x7F, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xF8, 0x1F, 0xFF, 0xBF, 0xE7, 0xF8, 0x00, 0xC0,
  0x3F, 0x07, 0xF8, 0x3E, 0x43, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x88, 0x1D, 0xF1, 0xFF, 0xCF, 0xDF, 0x7C, 0x3B, 0xC1, 0xDE, 0x0E,
  0xF0, 0x7F, 0x83, 0xDC, 0x1E, 0xE0, 0xE7, 0x07, 0x3C, 0x78, 0xFF, 0x83,
  0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x03, 0x00, 0xFE, 0x0F, 0xF8, 0xF1,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x71, 0xC7, 0x0F, 0x78,
  0x3F, 0x80, 0xF8, 0x1F, 0xE0, 0xE7, 0x8E, 0x1E, 0xF0, 0x77, 0x03, 0xF8,
  0x0F, 0xC0, 0x7F, 0x07, 0xF8, 0x39, 0xF7, 0xC7, 0xFC, 0x1F, 0xC0, 0x02,
  0x01, 0xF8, 0x3F, 0xC7, 0xDE, 0x70, 0xEF, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0xF1, 0xF7, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x7F, 0xC7, 0xF8, 0x7F,
  0x00, 0x2F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x13,
  0xDE, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3B, 0xDE, 0xE7,
  0x3B, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3C, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0xF8,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x78, 0x03, 0x00, 0x10, 0x00, 0x04,
  0x0F, 0xF3, 0xFF, 0x39, 0xE4, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0x03, 0x83, 0x80, 0x38, 0x70, 0x03,
  0x9C, 0x00, 0x33, 0x87, 0xC7, 0xE1, 0xFC, 0xFC, 0x73, 0x8F, 0x8C, 0x71,
  0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x8E, 0x38, 0xF1, 0xC7, 0x1E, 0x38, 0xE3,
  0xC7, 0x18, 0x78, 0xE7, 0x9F, 0x1C, 0xF3, 0x71, 0xF7, 0xEE, 0x1C, 0x79,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x02, 0x03, 0xF7, 0x80,
  0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E,
  0x70, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x77, 0x87, 0xBF, 0xF9, 0xFF,
  0x8F, 0xFF, 0x78, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFF, 0x07, 0xFF, 0xFB, 0xFF, 0x9F, 0xF8, 0x01, 0xC0, 0x7F, 0xC7,
  0xFC, 0x7C, 0xE7, 0x81, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x08, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x1E,
  0xF0, 0xF3, 0xFF, 0xCF, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0xC0, 0x0F, 0xF8, 0x7F,
  0xF9, 0xF9, 0xE3, 0xC0, 0x4F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0x80, 0xF7, 0x81, 0xE7, 0x83,
  0xCF, 0xFF, 0x8F, 0xFF, 0x07, 0xFC, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x9E, 0xFE, 0xFC, 0x78, 0xF0, 0x3F, 0xC1, 0xEF, 0x07,
  0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xEE, 0x0F, 0x3C, 0x3C, 0x70, 0xF1,
  0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xEF, 0x03, 0xBC,
  0x0F, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFE, 0xC0, 0x3F, 0xF7, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x6F, 0xF7, 0x07, 0x7F, 0xB8, 0x3B, 0xFD, 0xC1, 0xDF,
  0xE6, 0x1C, 0xFF, 0x38, 0xE7, 0xF9, 0xC7, 0x3F, 0xCE, 0x31, 0xFE, 0x3B,
  0x8F, 0xF1, 0xDC, 0x7F, 0x8E, 0xE3, 0xFC, 0x76, 0x1F, 0xE1, 0xF0, 0xFF,
  0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC1, 0xC1, 0xFE, 0x0E, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xEE, 0x0F, 0xEE, 0x0F,
  0xF7, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF,
  0xF1, 0xCF, 0xF0, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0x00,
  0x0F, 0xF0, 0x3F, 0xF8, 0x3E, 0xF8, 0x78, 0x3C, 0x70, 0x1C, 0xF0, 0x1E,
  0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E,
  0x70, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0,
  0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x3E, 0xF8, 0x78, 0x3C, 0x70, 0x1C,
  0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0xF0, 0x73, 0xC1,
  0xCF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x3F, 0xF8, 0xFF,
  0xC3, 0xFE, 0x0F, 0x3C, 0x3C, 0x70, 0xF1, 0xC3, 0xC7, 0x8F, 0x0E, 0x3C,
  0x3C, 0xF0, 0x73, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0x06, 0x01, 0xFE, 0x3F,
  0xF7, 0xFE, 0x78, 0x2F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFC, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xDC, 0x0F,
  0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0xF0, 0x0F, 0xF0, 0x0E, 0x70,
  0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x38,
  0x3C, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0xF8, 0x1E,
  0x03, 0x9C, 0x0F, 0x01, 0xCE, 0x07, 0xC0, 0xE7, 0x03, 0xE0, 0xF3, 0x81,
  0xF0, 0x79, 0xE1, 0xD8, 0x38, 0x70, 0xEC, 0x1C, 0x38, 0x77, 0x0E, 0x1C,
  0x3B, 0x8F, 0x0E, 0x19, 0xC7, 0x87, 0x9C, 0xE3, 0x81, 0xCE, 0x31, 0xC0,
  0xE7, 0x1C, 0xE0, 0x73, 0x8E, 0xF0, 0x39, 0xC7, 0x78, 0x1C, 0xC3, 0xB8,
  0x07, 0xE0, 0xDC, 0x03, 0xF0, 0x6E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7C, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x78, 0x3D,
  0xE0, 0xE3, 0x87, 0x8F, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xEE, 0x03, 0xB8,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xB8, 0x1E, 0xE0, 0x73, 0xC3, 0xC7, 0x0E, 0x1C, 0x38, 0x79, 0xE0,
  0xE7, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x38,
  0x70, 0xE1, 0xC3, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F,
  0xFF, 0xE0, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x73,
  0x81, 0xCE, 0x0E, 0x1C, 0x38, 0x71, 0xC1, 0xE7, 0x03, 0xB8, 0x0E, 0xE0,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x07, 0x07,
  0xFC, 0x3F, 0xE3, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x1F, 0xF3,
  0xFF, 0x78, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0x7B, 0xF7,
  0xF7, 0x3E, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x70, 0xE7, 0xC7, 0x7F, 0x3E, 0x3D, 0xE0, 0xEF, 0x07,
  0x78, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF,
  0x07, 0x78, 0x3B, 0xC3, 0xDF, 0xBE, 0xEF, 0xE7, 0x3E, 0x00, 0x07, 0x03,
  0xFC, 0xFF, 0x1E, 0x27, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3F, 0xC7, 0xF8, 0x7F,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE1, 0xC7, 0x1F, 0xB9, 0xFD, 0xDF, 0x3E, 0xF0, 0xF7, 0x07, 0xB8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x07, 0xB8,
  0x3D, 0xE1, 0xE7, 0xBF, 0x3F, 0xB8, 0xF9, 0xC0, 0x07, 0x01, 0xFC, 0x3F,
  0xE3, 0x8E, 0x70, 0x77, 0x07, 0x70, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x81, 0x3E, 0xF1, 0xFF, 0x0F,
  0xE0, 0x07, 0xC3, 0xF1, 0xF8, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x7F,
  0xBF, 0xE3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x0E, 0x00,
  0xFD, 0xCF, 0xEE, 0xF1, 0xF7, 0x87, 0xB8, 0x3D, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xEF, 0x0F,
  0x7F, 0xF9, 0xFD, 0xC7, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE8,
  0x1E, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x38, 0xEF, 0xCE, 0xFE, 0xF8, 0xEF, 0x0F,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xEF, 0xF6, 0x00,
  0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x1C, 0x3C,
  0x78, 0x60, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0xBF, 0x7E, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x70,
  0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF8, 0xF3, 0x8E, 0x38, 0xE1, 0xCE, 0x1C,
  0xE1, 0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x83, 0x0E, 0xFC, 0xFC, 0xEF, 0xEF, 0xEF,
  0x9F, 0x9E, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFE, 0x0F, 0x07,
  0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0,
  0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F,
  0x07, 0xE0, 0xF0, 0x70, 0x03, 0x0E, 0xFC, 0xEF, 0xEF, 0x8E, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x07, 0x00, 0xFE,
  0x0F, 0xF8, 0xF1, 0xE7, 0x87, 0x38, 0x3D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xEF, 0x0E, 0x3F,
  0xF0, 0xFF, 0x03, 0xF0, 0x03, 0x87, 0x7E, 0x3B, 0xF9, 0xF1, 0xEF, 0x07,
  0x78, 0x3B, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF8, 0x3B, 0xC1, 0xDE, 0x1E, 0xFD, 0xF7, 0x7F, 0x39, 0xF1, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0x06, 0x00, 0xFD, 0xCF, 0xEE, 0xF9, 0xF7, 0x87, 0xB8, 0x3D, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1,
  0xEF, 0x0F, 0x7F, 0xF9, 0xFD, 0xC7, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0xE7, 0xEF, 0xFF,
  0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x0E, 0x0F, 0xF7, 0xFB, 0xC6, 0xE0, 0x38, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x0F, 0xFF,
  0xBF, 0xEF, 0xF0, 0x38, 0x38, 0x38, 0x78, 0xFF, 0xFF, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7F, 0x3F,
  0x1F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFF, 0x0F, 0xF1, 0xF7,
  0xFF, 0x7F, 0x73, 0xE7, 0xF0, 0x3B, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x87,
  0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xE7, 0x07, 0x70, 0x3B, 0x81,
  0xDC, 0x06, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x78,
  0x3B, 0x87, 0xC3, 0xDC, 0x3E, 0x1C, 0xE1, 0xF0, 0xE7, 0x0D, 0x87, 0x1C,
  0x6E, 0x38, 0xE7, 0x73, 0xC7, 0x3B, 0x9C, 0x39, 0xCC, 0xE1, 0xCE, 0x67,
  0x07, 0x63, 0xB8, 0x3B, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x00, 0x70, 0x7B,
  0xC7, 0x8E, 0x38, 0x79, 0xC1, 0xDC, 0x0E, 0xE0, 0x3F, 0x01, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x3B, 0x81, 0xDC, 0x1E, 0xF0, 0xE3, 0x87, 0x1E,
  0x70, 0x77, 0x83, 0xC0, 0xF0, 0x3B, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x87,
  0x1C, 0x78, 0xE3, 0x87, 0x1C, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x3B, 0x80,
  0xDC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC3, 0xF0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x3F, 0x0F, 0x03, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3F,
  0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x38, 0x0E, 0x03, 0xF0, 0x1C, 0x1F, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC3, 0xF0, 0xF8, 0x00, 0x7C,
  0x0F, 0xFC, 0xF3, 0xFF, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 24, 8, 2, -24 },
  { 13, 10, 9, 14, 2, -24 },
  { 25, 15, 24, 16, 1, -24 },
  { 70, 13, 28, 15, 1, -26 },
  { 116, 21, 25, 24, 1, -25 },
  { 182, 16, 25, 17, 1, -25 },
  { 232, 4, 9, 7, 2, -24 },
  { 237, 7, 29, 10, 2, -24 },
  { 263, 8, 29, 10, 1, -24 },
  { 292, 12, 12, 14, 1, -26 },
  { 310, 13, 16, 15, 1, -20 },
  { 336, 5, 8, 8, 1, -4 },
  { 341, 8, 3, 10, 1, -11 },
  { 344, 4, 4, 8, 2, -4 },
  { 346, 12, 24, 13, 1, -24 },
  { 382, 13, 25, 15, 1, -25 },
  { 423, 9, 24, 15, 2, -24 },
  { 450, 12, 25, 15, 1, -25 },
  { 488, 12, 25, 15, 1, -25 },
  { 526, 13, 24, 15, 1, -24 },
  { 565, 11, 24, 15, 2, -24 },
  { 598, 13, 25, 15, 1, -25 },
  { 639, 13, 24, 15, 1, -24 },
  { 678, 13, 25, 15, 1, -25 },
  { 719, 12, 25, 15, 1, -25 },
  { 757, 4, 19, 8, 2, -19 },
  { 767, 5, 23, 8, 1, -19 },
  { 782, 13, 16, 15, 1, -20 },
  { 808, 13, 10, 15, 1, -17 },
  { 825, 13, 16, 15, 1, -20 },
  { 851, 11, 25, 11, 0, -25 },
  { 886, 19, 28, 23, 2, -25 },
  { 953, 16, 24, 16, 0, -24 },
  { 1001, 13, 24, 17, 2, -24 },
  { 1040, 13, 25, 16, 2, -25 },
  { 1081, 14, 24, 18, 2, -24 },
  { 1123, 10, 24, 14, 2, -24 },
  { 1153, 10, 24, 13, 2, -24 },
  { 1183, 15, 25, 19, 2, -25 },
  { 1230, 14, 24, 19, 2, -24 },
  { 1272, 8, 24, 10, 1, -24 },
  { 1296, 8, 31, 8, -2, -24 },
  { 1327, 14, 24, 16, 2, -24 },
  { 1369, 10, 24, 13, 2, -24 },
  { 1399, 21, 24, 25, 2, -24 },
  { 1462, 16, 24, 20, 2, -24 },
  { 1510, 16, 25, 19, 2, -25 },
  { 1560, 12, 24, 16, 2, -24 },
  { 1596, 16, 31, 19, 2, -25 },
  { 1658, 14, 24, 16, 2, -24 },
  { 1700, 12, 25, 14, 1, -25 },
  { 1738, 13, 24, 13, 0, -24 },
  { 1777, 14, 24, 18, 2, -24 },
  { 1819, 16, 24, 16, 0, -24 },
  { 1867, 25, 24, 25, 0, -24 },
  { 1942, 14, 24, 14, 0, -24 },
  { 1984, 14, 24, 14, 0, -24 },
  { 2026, 11, 24, 13, 1, -24 },
  { 2059, 8, 29, 11, 2, -24 },
  { 2088, 12, 24, 13, 1, -24 },
  { 2124, 7, 29, 11, 1, -24 },
  { 2150, 14, 13, 16, 1, -24 },
  { 2173, 15, 2, 15, 0, 3 },
  { 2177, 7, 5, 9, 1, -26 },
  { 2182, 12, 19, 15, 1, -19 },
  { 2211, 13, 26, 16, 2, -26 },
  { 2254, 11, 19, 12, 1, -19 },
  { 2281, 13, 26, 16, 1, -26 },
  { 2324, 12, 19, 15, 1, -19 },
  { 2353, 10, 26, 9, 0, -26 },
  { 2386, 13, 27, 16, 1, -19 },
  { 2430, 12, 26, 16, 2, -26 },
  { 2469, 4, 25, 8, 2, -25 },
  { 2482, 7, 33, 8, -1, -25 },
  { 2511, 12, 26, 14, 2, -26 },
  { 2550, 3, 26, 7, 2, -26 },
  { 2560, 20, 19, 24, 2, -19 },
  { 2608, 12, 19, 16, 2, -19 },
  { 2637, 13, 19, 16, 1, -19 },
  { 2668, 13, 27, 16, 2, -19 },
  { 2712, 13, 27, 16, 1, -19 },
  { 2756, 8, 19, 11, 2, -19 },
  { 2775, 10, 19, 12, 1, -19 },
  { 2799, 8, 22, 10, 1, -22 },
  { 2821, 12, 18, 16, 2, -18 },
  { 2848, 13, 18, 13, 0, -18 },
  { 2878, 21, 18, 21, 0, -18 },
  { 2926, 13, 18, 13, 0, -18 },
  { 2956, 13, 26, 13, 0, -18 },
  { 2999, 9, 18, 11, 1, -18 },
  { 3020, 10, 29, 12, 1, -24 },
  { 3057, 3, 34, 14, 6, -26 },
  { 3070, 10, 29, 12, 1, -24 },
  { 3107, 13, 4, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Medium34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM34PT7B_H_
