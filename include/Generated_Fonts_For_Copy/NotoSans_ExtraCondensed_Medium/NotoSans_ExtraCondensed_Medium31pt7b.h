#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium31pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x60, 0x00, 0xEF, 0xFE,
  0xE7, 0xF3, 0xF9, 0xDC, 0x6E, 0x37, 0x1B, 0x8D, 0xC6, 0x0C, 0x60, 0x63,
  0x03, 0x18, 0x18, 0xC0, 0xC6, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0x18, 0xC0,
  0xC6, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x7F, 0xFB, 0xFF, 0xC6, 0x30, 0x31,
  0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x39, 0xC0, 0x06, 0x00, 0xC0,
  0x18, 0x0F, 0xE3, 0xFE, 0xFF, 0xF9, 0x87, 0x30, 0xE6, 0x1C, 0xC1, 0xD8,
  0x3F, 0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x37, 0x06, 0x60, 0xCC, 0x1B, 0xE3,
  0x7F, 0xFC, 0xFF, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x3C, 0x0E, 0x0F,
  0xC1, 0x81, 0x98, 0x30, 0x73, 0x8E, 0x0E, 0x71, 0x81, 0xCE, 0x30, 0x39,
  0xCE, 0x07, 0x39, 0x80, 0xE7, 0x71, 0x1C, 0xEC, 0xF9, 0x99, 0x9F, 0xBF,
  0x77, 0x33, 0xCC, 0xC6, 0x01, 0x98, 0xC0, 0x73, 0x18, 0x0C, 0x63, 0x01,
  0x8C, 0x60, 0x71, 0x8C, 0x0C, 0x31, 0x83, 0x87, 0x70, 0x60, 0x7C, 0x0C,
  0x07, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xE7, 0x01, 0x8E, 0x07, 0x1C, 0x06,
  0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF8,
  0xE7, 0x71, 0xDC, 0x77, 0x38, 0xEE, 0x70, 0xFC, 0xE0, 0xF1, 0xC1, 0xE3,
  0x83, 0xC7, 0xDF, 0xC7, 0xFB, 0xC7, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0x1E,
  0x30, 0xE1, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xE1, 0xC3, 0x87, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0xE0,
  0xE1, 0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x18, 0x70, 0xC3, 0x80, 0x0E,
  0x01, 0xC0, 0x38, 0x47, 0x2F, 0xFD, 0xFF, 0xC3, 0x80, 0xF8, 0x3B, 0x8E,
  0x78, 0xC6, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x73, 0xDC, 0xE7, 0x33, 0x9C, 0xFF, 0xFF, 0xF8, 0xEE, 0xFE, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x00, 0x1F, 0x87, 0xF1, 0xEF, 0x38, 0xE7, 0x0E,
  0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0x70, 0xEE, 0x1D, 0xC7, 0x3F, 0xE3, 0xF8, 0x3E, 0x00,
  0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0xE7, 0x47, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x3F, 0x9F,
  0xF9, 0xCF, 0x20, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x9F, 0xF9, 0x8F, 0x20, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC7, 0xF0, 0xF8, 0x1F, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0xF3, 0xEF, 0xFD, 0xFE, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0x70, 0x1B, 0x81,
  0x9C, 0x0C, 0xE0, 0xC7, 0x06, 0x38, 0x71, 0xC3, 0x0E, 0x38, 0x71, 0x83,
  0x9F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F,
  0x0F, 0xF1, 0xFF, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1E, 0x07, 0xF9, 0xEF, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0xF8, 0x9C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE7, 0x9D, 0xFB, 0xFF, 0xF8, 0x7F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x70, 0xEE, 0x1D, 0xC3, 0x9D, 0xE3, 0xFC,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1F,
  0x83, 0xFC, 0x71, 0xE7, 0x0E, 0x60, 0xE6, 0x0E, 0x70, 0xE7, 0x1E, 0x3B,
  0xC3, 0xF8, 0x1F, 0x03, 0xF8, 0x7B, 0xC7, 0x1E, 0xE0, 0xEE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xE7, 0x1E, 0x7F, 0xC3, 0xF8, 0x1F, 0x07, 0xF1, 0xEF,
  0x38, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0xC7, 0xBF,
  0xF3, 0xFE, 0x3D, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x23, 0xC7,
  0xF0, 0xFC, 0x00, 0xEE, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xEF, 0xE0,
  0x73, 0x9E, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEE, 0x73, 0x99,
  0xCE, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x7F, 0x3F,
  0xE6, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x07, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C,
  0x07, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x38, 0x1C, 0x0E, 0x01, 0xC3,
  0x80, 0x18, 0x60, 0x03, 0x9C, 0x7E, 0x33, 0x0F, 0xC6, 0x63, 0x98, 0xCC,
  0x63, 0x1B, 0x9C, 0x63, 0xF3, 0x8C, 0x6E, 0x71, 0x8D, 0xCE, 0x31, 0xB9,
  0xCE, 0x33, 0x19, 0xC6, 0x63, 0xEF, 0x8C, 0x3D, 0xF1, 0xC2, 0x08, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x08, 0x03, 0xEF, 0x00, 0x3F, 0xE0, 0x00,
  0x60, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xEC, 0x01,
  0xDC, 0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xE0, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x83, 0x87, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x78, 0x38, 0xE0, 0x79,
  0xC0, 0x73, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xC0, 0xFF, 0x8F, 0xFC, 0xE3,
  0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF,
  0x8F, 0xFE, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0x07, 0xF1, 0xFF, 0x1E, 0x33, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xF7, 0x1F,
  0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xCE, 0x0F, 0x70, 0x3B,
  0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x07, 0xB8, 0x79, 0xFF, 0xCF, 0xFC,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x0F, 0xF0, 0xFF, 0xCF, 0x8E, 0xF0, 0x17, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3B, 0x81, 0xDE, 0x0E, 0x7C,
  0xF1, 0xFF, 0x87, 0xF8, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1C, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xCF, 0xFF, 0xC0,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xF7,
  0xC0, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xC3, 0x8E, 0x3C, 0x71, 0xC3, 0x9E,
  0x1C, 0xE0, 0xEF, 0x07, 0x70, 0x3F, 0x81, 0xFE, 0x0F, 0x70, 0x7B, 0xC3,
  0x8E, 0x1C, 0x78, 0xE1, 0xC7, 0x0F, 0x38, 0x39, 0xC1, 0xCE, 0x07, 0x70,
  0x3C, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF,
  0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0D, 0xFB, 0x03, 0xBF, 0x70, 0x77, 0xEE, 0x0C, 0xFC,
  0xC1, 0x9F, 0x98, 0x73, 0xF3, 0x8E, 0x7E, 0x71, 0x8F, 0xC6, 0x71, 0xF8,
  0xEE, 0x3F, 0x1D, 0x87, 0xE3, 0xB0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xF0,
  0xF0, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xC0, 0xF0, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7E, 0xE1, 0xFB, 0x87, 0xE7, 0x1F, 0x9C,
  0x7E, 0x71, 0xF8, 0xE7, 0xE3, 0x9F, 0x87, 0x7E, 0x1D, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xF0, 0x0F, 0xE0,
  0x3F, 0xE0, 0xF9, 0xE1, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0xB8,
  0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00, 0xEE, 0x01,
  0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1C, 0xF0, 0x38, 0xE0, 0xF1, 0xFF, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x1F, 0xFB, 0xFF, 0x70, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x8F, 0x7F, 0xEF, 0xF9, 0xF0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x0F,
  0xE0, 0x3F, 0xE0, 0xF9, 0xE1, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00, 0xEE,
  0x01, 0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1C, 0xF0, 0x38, 0xE0, 0xF1, 0xFF,
  0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0x0E, 0x78, 0xE3,
  0x8E, 0x38, 0xE1, 0xCE, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0x1F,
  0xE7, 0xF9, 0xFF, 0x38, 0x2E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x3E,
  0x07, 0x7F, 0xEF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0x9C, 0x1C, 0xFB, 0xE3,
  0xFE, 0x0F, 0xE0, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDC, 0x0E, 0x70, 0x39,
  0xC0, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0x87, 0x07, 0x18,
  0x1C, 0xE0, 0x73, 0x80, 0xCE, 0x03, 0xB0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x38, 0x1F, 0xC0, 0x70, 0x39,
  0xC1, 0xE0, 0x73, 0x83, 0xC0, 0xE7, 0x07, 0xC1, 0xCE, 0x0F, 0x87, 0x1C,
  0x1B, 0x0E, 0x1C, 0x76, 0x1C, 0x38, 0xEC, 0x38, 0x71, 0xDC, 0x70, 0xE3,
  0x39, 0xC1, 0xC6, 0x73, 0x81, 0x9C, 0x67, 0x03, 0xB8, 0xCE, 0x07, 0x71,
  0xDC, 0x0E, 0xC3, 0xF0, 0x1D, 0x87, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x7B,
  0x83, 0x8E, 0x3C, 0x71, 0xC1, 0x8E, 0x0E, 0xE0, 0x77, 0x01, 0xF8, 0x0F,
  0x80, 0x3C, 0x01, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x77, 0x03, 0xB8,
  0x38, 0xE1, 0xC7, 0x0E, 0x3C, 0xE0, 0xE7, 0x07, 0x78, 0x3C, 0xE0, 0x7B,
  0x83, 0x9C, 0x1C, 0xE1, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x83, 0xB8, 0x1D,
  0xC0, 0xEC, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xFF, 0xF8, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0xFF, 0xFC, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xF8, 0x06, 0x00, 0x38,
  0x03, 0xC0, 0x1F, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0x07, 0x1C, 0x70, 0xE3,
  0x83, 0xB8, 0x1D, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x87,
  0x0C, 0x1F, 0x1F, 0xE3, 0xBC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x7F, 0x7F,
  0xDC, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFB, 0x3C, 0xC0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x3C, 0xEF, 0xDF,
  0xFB, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7F, 0x0F, 0xF3, 0xBF, 0xF6, 0x7C, 0x0F, 0xCF, 0xE3, 0xF9,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x88, 0xFE, 0x1F, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x71, 0xE7, 0x3F, 0x77, 0xFF, 0x70, 0xF7, 0x0F,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F,
  0x70, 0xF7, 0x9F, 0x3F, 0x71, 0xF7, 0x0F, 0x07, 0xF0, 0xEF, 0x38, 0x77,
  0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x1E, 0x11, 0xFE, 0x1F, 0xC0, 0x07, 0x0F, 0xC7, 0xE7, 0x83, 0x81,
  0xC0, 0xE0, 0x7E, 0xFF, 0x7F, 0x8E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1E, 0x73, 0xF7,
  0x7F, 0xF7, 0x0F, 0x70, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x70, 0xF7, 0x0F, 0x79, 0xF3, 0xF7, 0x1E, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE6, 0x1E, 0x7F, 0xC7, 0xF8, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x7C, 0xFF, 0xDF, 0xFB, 0xC7,
  0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0x71, 0xC6, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF,
  0xFB, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x07, 0xE1, 0xDC, 0x73, 0x8E, 0x73, 0x8E, 0xE1, 0xDC, 0x3F, 0x87, 0xF0,
  0xF7, 0x1C, 0xE3, 0x8E, 0x71, 0xCE, 0x3D, 0xC3, 0xB8, 0x77, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x0F, 0x37, 0xE7,
  0xEF, 0xFF, 0xFB, 0xC7, 0x8F, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1C, 0x1F,
  0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1,
  0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xC0, 0xCF,
  0x9B, 0xFB, 0xFF, 0x78, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xE0, 0x0F,
  0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0xEF, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x79, 0xE3, 0xFC, 0x1F,
  0x80, 0xC7, 0x9D, 0xFB, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFE, 0x77, 0xFE, 0xEF,
  0x9C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1E, 0x73,
  0xF7, 0x7F, 0xF7, 0x0F, 0x70, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x70, 0xF7, 0x0F, 0x79, 0xF3, 0xF7, 0x1E, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xC7, 0xCE,
  0xFE, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x3F, 0x3F, 0xFD, 0xDC, 0x0E, 0x07, 0x03, 0xC0, 0xF8,
  0x3E, 0x0F, 0x81, 0xE0, 0x70, 0x3C, 0x1F, 0x9F, 0xFE, 0xFE, 0x00, 0x18,
  0x18, 0x38, 0x3F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3D, 0x1F, 0x1F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE,
  0x1F, 0xC3, 0xFC, 0xFB, 0xF7, 0x3C, 0xE0, 0xE0, 0x7E, 0x07, 0x70, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0x38, 0xC3, 0x9C, 0x39, 0xC1, 0x9C, 0x19, 0x81,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xE0, 0xEC,
  0x1E, 0x1D, 0xC3, 0xC3, 0xB8, 0xF8, 0x67, 0x1F, 0x1C, 0xE3, 0x63, 0x8C,
  0x6E, 0x71, 0xCD, 0xCE, 0x3B, 0x99, 0x87, 0x73, 0x70, 0xEC, 0x6E, 0x0D,
  0x8D, 0xC1, 0xB1, 0xF8, 0x3E, 0x3E, 0x07, 0xC3, 0xC0, 0x78, 0x78, 0x0E,
  0x0F, 0x00, 0x70, 0xF7, 0x0E, 0x39, 0xE3, 0x9C, 0x39, 0xC1, 0xF8, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x39, 0xC3, 0x9C, 0x70,
  0xE7, 0x0E, 0xF0, 0xF0, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x70, 0xE3,
  0x0E, 0x38, 0xC3, 0x9C, 0x39, 0xC1, 0x9C, 0x1D, 0x81, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0x87, 0xC7,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x8F, 0x87,
  0x03, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x0F, 0x07, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x7C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xF8, 0x1C, 0x3E, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x7C, 0x7C, 0x38, 0x00, 0x78,
  0x1F, 0xF3, 0xDF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_Medium31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 22, 7, 2, -22 },
  { 12, 9, 8, 12, 2, -22 },
  { 21, 13, 22, 15, 1, -22 },
  { 57, 11, 26, 14, 1, -24 },
  { 93, 19, 22, 22, 1, -22 },
  { 146, 15, 22, 16, 1, -22 },
  { 188, 3, 8, 7, 2, -22 },
  { 191, 7, 27, 9, 2, -22 },
  { 215, 7, 27, 9, 1, -22 },
  { 239, 11, 11, 13, 1, -24 },
  { 255, 12, 14, 14, 1, -18 },
  { 276, 5, 8, 7, 1, -4 },
  { 281, 7, 3, 9, 1, -10 },
  { 284, 4, 4, 7, 2, -4 },
  { 286, 11, 22, 12, 0, -22 },
  { 317, 11, 22, 14, 1, -22 },
  { 348, 8, 22, 14, 2, -22 },
  { 370, 11, 22, 14, 1, -22 },
  { 401, 11, 22, 14, 1, -22 },
  { 432, 13, 22, 14, 0, -22 },
  { 468, 11, 22, 14, 1, -22 },
  { 499, 11, 22, 14, 1, -22 },
  { 530, 12, 22, 14, 1, -22 },
  { 563, 12, 22, 14, 1, -22 },
  { 596, 11, 22, 14, 1, -22 },
  { 627, 4, 17, 7, 2, -17 },
  { 636, 5, 21, 7, 1, -17 },
  { 650, 12, 14, 14, 1, -18 },
  { 671, 12, 9, 14, 1, -15 },
  { 685, 12, 14, 14, 1, -18 },
  { 706, 10, 22, 10, 0, -22 },
  { 734, 19, 25, 21, 1, -22 },
  { 794, 15, 22, 15, 0, -22 },
  { 836, 12, 22, 15, 2, -22 },
  { 869, 12, 22, 14, 1, -22 },
  { 902, 13, 22, 16, 2, -22 },
  { 938, 9, 22, 13, 2, -22 },
  { 963, 9, 22, 12, 2, -22 },
  { 988, 13, 22, 17, 2, -22 },
  { 1024, 13, 22, 17, 2, -22 },
  { 1060, 7, 22, 9, 1, -22 },
  { 1080, 7, 28, 7, -2, -22 },
  { 1105, 13, 22, 14, 2, -22 },
  { 1141, 9, 22, 12, 2, -22 },
  { 1166, 19, 22, 23, 2, -22 },
  { 1219, 14, 22, 18, 2, -22 },
  { 1258, 15, 22, 17, 1, -22 },
  { 1300, 11, 22, 14, 2, -22 },
  { 1331, 15, 27, 17, 1, -22 },
  { 1382, 12, 22, 15, 2, -22 },
  { 1415, 11, 22, 13, 1, -22 },
  { 1446, 12, 22, 12, 0, -22 },
  { 1479, 13, 22, 17, 2, -22 },
  { 1515, 14, 22, 14, 0, -22 },
  { 1554, 23, 22, 23, 0, -22 },
  { 1618, 13, 22, 13, 0, -22 },
  { 1654, 13, 22, 13, 0, -22 },
  { 1690, 10, 22, 12, 1, -22 },
  { 1718, 7, 27, 10, 2, -22 },
  { 1742, 11, 22, 12, 0, -22 },
  { 1773, 7, 27, 10, 1, -22 },
  { 1797, 13, 12, 15, 1, -22 },
  { 1817, 13, 2, 13, 0, 3 },
  { 1821, 6, 5, 9, 1, -24 },
  { 1825, 10, 17, 13, 1, -17 },
  { 1847, 11, 24, 15, 2, -24 },
  { 1880, 10, 17, 11, 1, -17 },
  { 1902, 12, 24, 15, 1, -24 },
  { 1938, 11, 17, 13, 1, -17 },
  { 1962, 9, 24, 8, 0, -24 },
  { 1989, 12, 24, 15, 1, -17 },
  { 2025, 11, 24, 15, 2, -24 },
  { 2058, 3, 23, 7, 2, -23 },
  { 2067, 6, 30, 7, -1, -23 },
  { 2090, 11, 24, 13, 2, -24 },
  { 2123, 3, 24, 7, 2, -24 },
  { 2132, 18, 17, 22, 2, -17 },
  { 2171, 11, 17, 15, 2, -17 },
  { 2195, 12, 17, 14, 1, -17 },
  { 2221, 11, 24, 15, 2, -17 },
  { 2254, 12, 24, 15, 1, -17 },
  { 2290, 8, 17, 10, 2, -17 },
  { 2307, 9, 17, 11, 1, -17 },
  { 2327, 8, 20, 9, 0, -20 },
  { 2347, 11, 17, 15, 2, -17 },
  { 2371, 12, 17, 12, 0, -17 },
  { 2397, 19, 17, 19, 0, -17 },
  { 2438, 12, 17, 12, 0, -17 },
  { 2464, 12, 24, 12, 0, -17 },
  { 2500, 8, 17, 10, 1, -17 },
  { 2517, 9, 27, 11, 1, -22 },
  { 2548, 3, 31, 13, 5, -24 },
  { 2560, 9, 27, 11, 1, -22 },
  { 2591, 12, 4, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Medium31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM31PT7B_H_
