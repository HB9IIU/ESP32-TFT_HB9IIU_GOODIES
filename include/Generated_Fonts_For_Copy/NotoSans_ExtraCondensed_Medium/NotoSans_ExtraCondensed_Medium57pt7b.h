#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium57pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF,
  0x7C, 0x20, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xDF, 0x83, 0xEF, 0xC1,
  0xF7, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x7C, 0x00, 0xF8,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01,
  0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x07,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x07, 0xC1, 0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFB, 0x8F, 0x1F, 0x1C, 0x08,
  0xF8, 0xE0, 0x0F, 0x87, 0x00, 0x7C, 0x38, 0x03, 0xE1, 0xC0, 0x1F, 0x8E,
  0x00, 0x7C, 0x70, 0x03, 0xF3, 0x80, 0x1F, 0xDC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1C, 0xFC, 0x00, 0xE3, 0xE0, 0x07, 0x1F, 0x80,
  0x38, 0x7C, 0x01, 0xC3, 0xE0, 0x0E, 0x1F, 0x00, 0x70, 0xFC, 0x03, 0x8F,
  0xBC, 0x1C, 0xFD, 0xFE, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x01, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0x80,
  0x3C, 0x00, 0x7C, 0xF8, 0x07, 0xC0, 0x07, 0x87, 0x80, 0x78, 0x00, 0x78,
  0x7C, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0xF8, 0x00, 0xF8, 0x3C, 0x0F, 0x00,
  0x0F, 0x83, 0xC0, 0xF0, 0x00, 0xF8, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xC1,
  0xE0, 0x00, 0xF8, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC3, 0xC0, 0x00, 0xF8,
  0x3C, 0x3C, 0x00, 0x0F, 0x83, 0xC7, 0xC0, 0x00, 0xF8, 0x3C, 0x78, 0x3E,
  0x0F, 0x87, 0xC7, 0x87, 0xF0, 0x78, 0x7C, 0xF8, 0xFF, 0x87, 0x87, 0x8F,
  0x1F, 0xFC, 0x7C, 0x78, 0xF1, 0xE3, 0xC3, 0xFF, 0x9F, 0x3E, 0x3E, 0x3F,
  0xF1, 0xE3, 0xC1, 0xE1, 0xFE, 0x1E, 0x3C, 0x1E, 0x0F, 0xC3, 0xE3, 0xC1,
  0xE0, 0x00, 0x3C, 0x3C, 0x1E, 0x00, 0x07, 0xC7, 0xC1, 0xE0, 0x00, 0x78,
  0x7C, 0x1F, 0x00, 0x07, 0x87, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x1F, 0x00,
  0x0F, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x1F, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC1, 0xE0, 0x03, 0xE0,
  0x3E, 0x3E, 0x00, 0x3C, 0x01, 0xE3, 0xC0, 0x03, 0xC0, 0x1F, 0x7C, 0x00,
  0x7C, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x1F, 0x0F, 0xFF, 0x07, 0xE3, 0xF3,
  0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x87, 0xE3, 0xE3, 0xF0, 0x7E, 0x7C,
  0x7C, 0x07, 0xDF, 0x8F, 0x80, 0xFF, 0xF1, 0xF0, 0x0F, 0xFC, 0x3E, 0x01,
  0xFF, 0x87, 0xC0, 0x1F, 0xE0, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x0F, 0xF0, 0x7F, 0x03, 0xFF, 0x07, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE7, 0xE0, 0xFF, 0xF0, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0,
  0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xE7, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x04,
  0x0F, 0x06, 0x7C, 0xF3, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0x9F,
  0x01, 0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xE0, 0xF8, 0x0E, 0x06, 0x00, 0x20,
  0x40, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x7E, 0x03,
  0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7D,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1,
  0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0x7F, 0xFC, 0xFD, 0xF1,
  0xF9, 0xC3, 0xF1, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xFC, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xC0, 0xFE,
  0x30, 0x07, 0xE2, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0x80, 0xFE, 0x30, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFE, 0xFC, 0x7F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x80, 0x0F, 0xCC, 0x01, 0xFC, 0xF8, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x50, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x7C, 0xFF, 0x83, 0xEF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xF8, 0x7F, 0x7F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF3, 0xF0,
  0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xC1, 0xFC, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFD, 0xFE,
  0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x01, 0xF8,
  0xFC, 0x1F, 0x87, 0xF1, 0xFC, 0x1F, 0xDF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07,
  0xF1, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x9F, 0x00, 0xFD, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xF0, 0x7F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x03, 0xFF, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F,
  0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xBE, 0x0F, 0xF9, 0xF0, 0x3F, 0x8F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x08, 0x1E, 0x3F, 0x7F,
  0x7F, 0x7F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF3, 0x81, 0xF9,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x07, 0x87, 0x80, 0x7F, 0x83, 0xE7, 0xC0, 0x7F, 0xF1, 0xF3, 0xC0,
  0xFF, 0xF0, 0x79, 0xE0, 0x7E, 0xF8, 0x3C, 0xF0, 0x7C, 0x3C, 0x1E, 0xF8,
  0x3C, 0x1E, 0x0F, 0xF8, 0x3E, 0x0F, 0x07, 0xFC, 0x1F, 0x07, 0x81, 0xFE,
  0x0F, 0x03, 0xC0, 0xFF, 0x07, 0x81, 0xE0, 0x7F, 0x83, 0xC0, 0xF0, 0x3F,
  0xC1, 0xE0, 0xF8, 0x3F, 0xE0, 0xF0, 0x7C, 0x1F, 0xF0, 0x78, 0x3E, 0x0F,
  0xF8, 0x3C, 0x1F, 0x07, 0xBC, 0x1E, 0x0F, 0x83, 0xDE, 0x0F, 0x07, 0xC1,
  0xEF, 0x07, 0x83, 0xE0, 0xF7, 0x83, 0xE3, 0xF0, 0xF3, 0xC0, 0xFB, 0xFC,
  0xF9, 0xF0, 0x7F, 0xCF, 0xF8, 0xF8, 0x1F, 0xE7, 0xFC, 0x3C, 0x07, 0xE1,
  0xFC, 0x1F, 0x00, 0x80, 0x10, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C,
  0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xF0, 0x3F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xC0,
  0xFF, 0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x01,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x80, 0xC1, 0xFC, 0x01, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x06, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0x87, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x07,
  0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x80, 0x78,
  0x7F, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F,
  0x9F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xFC, 0x01, 0xF0, 0xFF, 0xDF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xBF, 0x00, 0xFE, 0x7E, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xF7, 0xFE, 0xF8, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x1F, 0x7F,
  0xEF, 0x80, 0x07, 0x9F, 0xF9, 0xE0, 0x03, 0xEF, 0xFE, 0x7C, 0x00, 0xFB,
  0xFF, 0x9F, 0x00, 0x3E, 0xFF, 0xE7, 0xC0, 0x0F, 0x3F, 0xF8, 0xF8, 0x07,
  0xCF, 0xFE, 0x3E, 0x01, 0xF3, 0xFF, 0x8F, 0x80, 0x7C, 0xFF, 0xE3, 0xE0,
  0x3E, 0x3F, 0xF8, 0x7C, 0x0F, 0x8F, 0xFE, 0x1F, 0x03, 0xE3, 0xFF, 0x87,
  0xC0, 0xF0, 0xFF, 0xE0, 0xF0, 0x7C, 0x3F, 0xF8, 0x3E, 0x1F, 0x0F, 0xFE,
  0x0F, 0x87, 0xC3, 0xFF, 0x83, 0xE3, 0xE0, 0xFF, 0xE0, 0x7C, 0xF8, 0x3F,
  0xF8, 0x1F, 0x3E, 0x0F, 0xFE, 0x07, 0xCF, 0x03, 0xFF, 0x81, 0xF7, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xF8, 0x07,
  0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xE0,
  0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFE, 0xF8, 0x03, 0xFF, 0x7E, 0x01, 0xFF, 0x9F, 0x00,
  0xFF, 0xCF, 0x80, 0x7F, 0xE3, 0xE0, 0x3F, 0xF1, 0xF0, 0x1F, 0xF8, 0xFC,
  0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x1F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83,
  0xE0, 0xFF, 0xC1, 0xF8, 0x7F, 0xE0, 0x7C, 0x3F, 0xF0, 0x3F, 0x1F, 0xF8,
  0x0F, 0x8F, 0xFC, 0x07, 0xE7, 0xFE, 0x01, 0xF3, 0xFF, 0x00, 0xF9, 0xFF,
  0x80, 0x7E, 0xFF, 0xC0, 0x1F, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC3,
  0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE,
  0xFC, 0x7F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0x87, 0xFC, 0x3F, 0x03, 0xFC, 0x7E,
  0x03, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xE3, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xF8, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xF8, 0x3C, 0x7E, 0x00, 0x47, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0xC0, 0x07, 0xEF, 0x01, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E,
  0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0,
  0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xEF,
  0xC0, 0x03, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x7C, 0x00,
  0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xF8,
  0x01, 0xF1, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0x80, 0x3F,
  0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x78, 0x03, 0xE0, 0xFC,
  0x03, 0xDF, 0x00, 0xF8, 0x3F, 0x00, 0xF7, 0xC0, 0x7E, 0x07, 0xC0, 0x3D,
  0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xCF, 0x01,
  0xF0, 0x1F, 0x81, 0xF3, 0xE0, 0x7C, 0x07, 0xE0, 0x78, 0xF8, 0x3F, 0x00,
  0xF8, 0x1E, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x8F, 0x83, 0xF0, 0x0F, 0x83,
  0xE1, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x7C, 0x3E, 0x00, 0xFC, 0x3C, 0x1F,
  0x1F, 0x80, 0x1F, 0x0F, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xC1, 0xF1, 0xF8,
  0x01, 0xF1, 0xF0, 0x3C, 0x7C, 0x00, 0x7E, 0x7C, 0x0F, 0x1F, 0x00, 0x1F,
  0x9E, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0xFB, 0xF0, 0x00, 0xFB, 0xE0,
  0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x07, 0xBE, 0x00, 0x0F, 0xBE, 0x01, 0xEF,
  0x80, 0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x00, 0x7F, 0xC0, 0x1E, 0xF8, 0x00,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1,
  0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xE7,
  0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x83,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xE1,
  0xFC, 0x10, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF9, 0xFF, 0xFF, 0x7F, 0x83, 0xEF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xBE, 0x7F, 0xE3,
  0xC7, 0xF8, 0x78, 0x18, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x87, 0xE0, 0x7C, 0xFF, 0xC3, 0xEF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xDF, 0xE7, 0xF0, 0x3F, 0x3F, 0x80, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7F, 0x03, 0xF3, 0xFE, 0x3F, 0x9F,
  0xFF, 0xF8, 0xF3, 0xFF, 0xC7, 0x8F, 0xFC, 0x3C, 0x3F, 0xC0, 0x00, 0x20,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFE, 0xF1,
  0xFC, 0x08, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x4F, 0xF0, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x8F, 0x87, 0xFE, 0x7C, 0x7F, 0xFB,
  0xE3, 0xFF, 0xFF, 0x3F, 0xDF, 0xF9, 0xF8, 0x1F, 0xDF, 0x80, 0xFE, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x81,
  0xFC, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFE, 0x78, 0x7F, 0xE3, 0xC1,
  0xFE, 0x1E, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0x7E, 0x3E, 0x03, 0xE7, 0xE0,
  0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x02, 0x1F, 0xC0,
  0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x01,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0xC4, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x78, 0x7F, 0xE3, 0xC3, 0xFF,
  0x9E, 0x3F, 0xFF, 0xF3, 0xFD, 0xFF, 0x9F, 0x81, 0xFD, 0xF8, 0x0F, 0xEF,
  0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF9, 0xF8,
  0x1F, 0xCF, 0xE3, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xEF, 0x87, 0xFE, 0x7C,
  0x1F, 0xE3, 0xE0, 0x08, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x80, 0x0F, 0xC7,
  0x81, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x8F, 0xE1, 0xF3,
  0xFF, 0x3E, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x11,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC4, 0x00, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xC0, 0x01, 0x01, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFE,
  0x7F, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0x70, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x80, 0xF8,
  0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7C,
  0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xE7, 0xC0, 0xFC,
  0x7C, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0xFE, 0x03, 0xF8, 0x78, 0xFF, 0x87, 0xFE, 0x3C, 0xFF, 0xE7, 0xFF, 0x9E,
  0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF0, 0x7F, 0xC1, 0xFB,
  0xF0, 0x1F, 0xC0, 0xFD, 0xF8, 0x0F, 0xE0, 0x3E, 0xFC, 0x07, 0xE0, 0x1F,
  0x7C, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0x80,
  0x7F, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xF0,
  0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7E,
  0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xF0, 0x0F,
  0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x01,
  0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xC0,
  0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0xF0, 0xFE, 0x1E, 0x3F, 0xF3,
  0xCF, 0xFE, 0x7B, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xE0, 0xFC,
  0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xE0, 0x0F,
  0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x7F, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0C,
  0x00, 0xF0, 0xFE, 0x07, 0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xF9, 0xFE, 0x7F, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xF0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x3F, 0xE3, 0xF9,
  0xFF, 0xFF, 0x8F, 0xBF, 0xFC, 0x7C, 0xFF, 0xC3, 0xE3, 0xFC, 0x1F, 0x02,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x78, 0x7F, 0xE3, 0xC7, 0xFF, 0x9E, 0x3F, 0xFF, 0xF3, 0xFD,
  0xFF, 0x9F, 0x81, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xE1, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xEF, 0x87, 0xFE, 0x7C, 0x1F, 0xE3, 0xE0, 0x08, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0,
  0xFF, 0xC7, 0xEF, 0x3F, 0xBC, 0xFE, 0xF7, 0xFB, 0xFE, 0x2F, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFE, 0xFE, 0x1E, 0xFC, 0x06, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xF8, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x11, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x06, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F,
  0x7F, 0xBF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0x8F, 0x0F, 0xF0,
  0xF0, 0x08, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF,
  0x80, 0x3E, 0x7E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x3F,
  0x00, 0x7D, 0xF0, 0x0F, 0xE0, 0x1F, 0xBF, 0x01, 0xFE, 0x03, 0xF7, 0xE0,
  0x3F, 0xC0, 0x7C, 0x7C, 0x07, 0xF8, 0x0F, 0x8F, 0x80, 0xFF, 0x01, 0xF1,
  0xF0, 0x3F, 0xE0, 0x7E, 0x3F, 0x07, 0xBE, 0x0F, 0x87, 0xE0, 0xF3, 0xC1,
  0xF0, 0x7C, 0x1E, 0x78, 0x3E, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xF0, 0xF9,
  0xE1, 0xF8, 0x3F, 0x1F, 0x3E, 0x3E, 0x03, 0xE3, 0xC7, 0xC7, 0xC0, 0x7C,
  0x78, 0x78, 0xF8, 0x0F, 0x8F, 0x0F, 0x1F, 0x01, 0xF3, 0xE1, 0xE7, 0xC0,
  0x3E, 0x7C, 0x3C, 0xF8, 0x03, 0xEF, 0x07, 0xDF, 0x00, 0x7D, 0xE0, 0xFB,
  0xE0, 0x0F, 0xBC, 0x0F, 0x7C, 0x01, 0xF7, 0x81, 0xEF, 0x00, 0x3E, 0xF0,
  0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF3,
  0xE0, 0x1F, 0x9F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87,
  0xE0, 0x7C, 0x3E, 0x03, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7E, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0xC7, 0xC0,
  0x3E, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFD, 0xF0, 0x03,
  0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3E, 0x7E, 0x00, 0xF8, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0,
  0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C,
  0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x11, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x05, 0xFF, 0x80, 0x3F, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE8, 0x01, 0xFF, 0x20,
  0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 42, 14, 3, -41 },
  { 38, 17, 15, 23, 3, -41 },
  { 70, 25, 41, 27, 1, -41 },
  { 199, 21, 46, 25, 2, -43 },
  { 320, 36, 42, 40, 2, -41 },
  { 509, 27, 42, 29, 2, -41 },
  { 651, 6, 15, 12, 3, -41 },
  { 663, 13, 50, 17, 3, -41 },
  { 745, 13, 50, 17, 1, -41 },
  { 827, 20, 20, 23, 2, -43 },
  { 877, 21, 27, 25, 2, -34 },
  { 948, 8, 14, 13, 2, -7 },
  { 962, 13, 5, 16, 2, -18 },
  { 971, 7, 8, 13, 3, -7 },
  { 978, 20, 41, 22, 1, -41 },
  { 1081, 21, 42, 25, 2, -41 },
  { 1192, 15, 41, 25, 3, -41 },
  { 1269, 20, 41, 25, 2, -41 },
  { 1372, 20, 42, 25, 2, -41 },
  { 1477, 23, 41, 25, 1, -41 },
  { 1595, 20, 42, 25, 3, -41 },
  { 1700, 21, 42, 25, 2, -41 },
  { 1811, 21, 41, 25, 2, -41 },
  { 1919, 21, 42, 25, 2, -41 },
  { 2030, 21, 42, 25, 2, -41 },
  { 2141, 7, 32, 14, 3, -31 },
  { 2169, 8, 38, 14, 2, -31 },
  { 2207, 21, 26, 25, 2, -33 },
  { 2276, 21, 16, 25, 2, -28 },
  { 2318, 21, 26, 25, 2, -33 },
  { 2387, 17, 42, 19, 1, -41 },
  { 2477, 33, 46, 38, 3, -41 },
  { 2667, 27, 41, 27, 0, -41 },
  { 2806, 22, 41, 28, 4, -41 },
  { 2919, 22, 42, 26, 3, -41 },
  { 3035, 23, 41, 30, 4, -41 },
  { 3153, 17, 41, 23, 4, -41 },
  { 3241, 17, 41, 23, 4, -41 },
  { 3329, 25, 42, 31, 3, -41 },
  { 3461, 23, 41, 31, 4, -41 },
  { 3579, 13, 41, 17, 2, -41 },
  { 3646, 13, 52, 14, -3, -41 },
  { 3731, 23, 41, 27, 4, -41 },
  { 3849, 17, 41, 22, 4, -41 },
  { 3937, 34, 41, 42, 4, -41 },
  { 4112, 25, 41, 33, 4, -41 },
  { 4241, 26, 42, 32, 3, -41 },
  { 4378, 20, 41, 26, 4, -41 },
  { 4481, 26, 51, 32, 3, -41 },
  { 4647, 23, 41, 27, 4, -41 },
  { 4765, 20, 42, 24, 2, -41 },
  { 4870, 21, 41, 23, 1, -41 },
  { 4978, 23, 42, 31, 4, -41 },
  { 5099, 26, 41, 26, 0, -41 },
  { 5233, 42, 41, 41, 0, -41 },
  { 5449, 24, 41, 24, 0, -41 },
  { 5572, 24, 41, 24, 0, -41 },
  { 5695, 19, 41, 21, 1, -41 },
  { 5793, 12, 50, 18, 4, -41 },
  { 5868, 20, 41, 22, 1, -41 },
  { 5971, 12, 50, 18, 2, -41 },
  { 6046, 25, 23, 27, 1, -41 },
  { 6118, 25, 4, 24, 0, 5 },
  { 6131, 12, 9, 16, 2, -44 },
  { 6145, 19, 32, 25, 2, -31 },
  { 6221, 21, 44, 27, 4, -43 },
  { 6337, 17, 32, 21, 2, -31 },
  { 6405, 21, 44, 27, 2, -43 },
  { 6521, 20, 32, 25, 2, -31 },
  { 6601, 16, 44, 15, 1, -44 },
  { 6689, 21, 45, 27, 2, -31 },
  { 6808, 19, 43, 27, 4, -43 },
  { 6911, 6, 43, 13, 3, -43 },
  { 6944, 10, 57, 13, -1, -43 },
  { 7016, 20, 43, 24, 4, -43 },
  { 7124, 5, 43, 13, 4, -43 },
  { 7151, 33, 31, 40, 4, -31 },
  { 7279, 19, 31, 27, 4, -31 },
  { 7353, 22, 32, 26, 2, -31 },
  { 7441, 21, 45, 27, 4, -31 },
  { 7560, 21, 45, 27, 2, -31 },
  { 7679, 14, 31, 18, 4, -31 },
  { 7734, 16, 32, 20, 2, -31 },
  { 7798, 14, 39, 16, 1, -38 },
  { 7867, 20, 32, 27, 3, -31 },
  { 7947, 22, 31, 22, 0, -31 },
  { 8033, 35, 31, 36, 0, -31 },
  { 8169, 21, 31, 22, 1, -31 },
  { 8251, 22, 45, 22, 0, -31 },
  { 8375, 16, 31, 18, 1, -31 },
  { 8437, 16, 50, 20, 2, -41 },
  { 8537, 5, 57, 24, 9, -44 },
  { 8573, 17, 50, 20, 2, -41 },
  { 8680, 22, 8, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Medium57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM57PT7B_H_
