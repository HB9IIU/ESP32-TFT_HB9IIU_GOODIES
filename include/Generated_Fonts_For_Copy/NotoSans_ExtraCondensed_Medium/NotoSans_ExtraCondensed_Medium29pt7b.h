#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0B, 0xFE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0x0C, 0xE0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18,
  0xC1, 0x8C, 0xFF, 0xFF, 0xFF, 0x19, 0xC1, 0x98, 0x19, 0x83, 0x98, 0x31,
  0x8F, 0xFF, 0xFF, 0xF3, 0x18, 0x33, 0x83, 0x30, 0x33, 0x06, 0x30, 0x63,
  0x00, 0x04, 0x00, 0x80, 0x3C, 0x1F, 0xE7, 0xFD, 0xC8, 0xB9, 0x07, 0x20,
  0xE4, 0x0E, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0B, 0x81, 0x30, 0x27, 0x04,
  0xF0, 0xBB, 0xFF, 0x7F, 0xC0, 0x40, 0x08, 0x01, 0x00, 0x20, 0x38, 0x0C,
  0x1F, 0x06, 0x06, 0xE1, 0x83, 0x98, 0x60, 0xC6, 0x30, 0x31, 0x8C, 0x0C,
  0x67, 0x03, 0x19, 0x80, 0xE6, 0x62, 0x39, 0xBB, 0xE6, 0xEC, 0xD9, 0xF3,
  0x63, 0x39, 0x98, 0xC0, 0x66, 0x30, 0x19, 0x8C, 0x0C, 0x63, 0x03, 0x18,
  0xC1, 0xC6, 0x30, 0x61, 0xDC, 0x18, 0x3E, 0x0E, 0x07, 0x00, 0x1E, 0x00,
  0xFC, 0x03, 0xB8, 0x1C, 0xE0, 0x71, 0x81, 0xCE, 0x03, 0x38, 0x0E, 0xC0,
  0x3F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x8E, 0xF7, 0x3B, 0x8C, 0xCE, 0x3F,
  0x38, 0x7C, 0xE1, 0xE3, 0x87, 0x8F, 0x3F, 0x1F, 0xFE, 0x3E, 0x3C, 0xFF,
  0xFD, 0xB6, 0x0E, 0x18, 0x71, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC1, 0x87,
  0x0E, 0x1C, 0x38, 0x30, 0x60, 0xE1, 0xC3, 0x83, 0x07, 0x06, 0x0E, 0x0C,
  0x1C, 0xC1, 0x87, 0x0C, 0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x31,
  0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE7, 0x1C, 0xE3, 0x00, 0x0C, 0x03, 0x00,
  0xC3, 0xB7, 0xFF, 0xC7, 0x81, 0xE0, 0xFC, 0x73, 0x8C, 0xC0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x77, 0x76, 0xEE, 0xC0, 0xFF, 0xFF,
  0xC0, 0xDF, 0xF0, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x1E, 0x07, 0xF1, 0xFE,
  0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x77, 0x06, 0xE0, 0xDC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xB8, 0x37, 0x0E, 0x61, 0xCE, 0x39, 0xEE, 0x1F, 0xC1,
  0xF0, 0x0E, 0x3C, 0xFB, 0xFF, 0xFD, 0xD3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x3E, 0x1F, 0xEF, 0xF9,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0F,
  0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x3F, 0xEF, 0x79, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x8F, 0xC3,
  0xF0, 0xFE, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x3F, 0xFE,
  0xFF, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0D,
  0xC0, 0xDC, 0x19, 0xC1, 0x9C, 0x39, 0xC3, 0x1C, 0x71, 0xC6, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0x9F,
  0xE7, 0xF9, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x7E, 0x1F, 0xE7, 0xFC,
  0x07, 0x01, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x7C, 0x7F, 0xFE, 0x7F,
  0x00, 0x07, 0xC3, 0xF8, 0xFF, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xEF, 0x1F, 0xF3, 0xEF, 0x78, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0x60,
  0xCE, 0x39, 0xEF, 0x1F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x1F,
  0x07, 0xF1, 0xEF, 0x30, 0xEE, 0x0D, 0xC1, 0x98, 0x73, 0x8E, 0x3B, 0x87,
  0xE0, 0x7C, 0x1F, 0xC7, 0x3D, 0xC3, 0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xC7, 0x3F, 0xE3, 0xF0, 0x1E, 0x0F, 0xC7, 0xFB, 0xC7, 0xE1, 0xF8, 0x7E,
  0x0F, 0x83, 0xE1, 0xF8, 0x77, 0x3D, 0xFF, 0x3E, 0xC2, 0x30, 0x1C, 0x07,
  0x01, 0x80, 0xE8, 0x79, 0xFC, 0x7E, 0x00, 0xDF, 0xF0, 0x00, 0x00, 0x0D,
  0xFF, 0x67, 0x77, 0x00, 0x00, 0x00, 0x00, 0x07, 0x77, 0x66, 0xEC, 0x00,
  0x20, 0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x38, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x70, 0x06, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x3E, 0x7F,
  0x9F, 0xE8, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x07, 0x83, 0x83, 0x81,
  0x80, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x0F, 0x07, 0x81, 0xC0, 0x01, 0xF0,
  0x03, 0xFE, 0x03, 0x87, 0x83, 0x00, 0xC3, 0x80, 0x31, 0x80, 0x19, 0xC7,
  0xCE, 0xC7, 0xE3, 0x67, 0x31, 0xF3, 0x18, 0xF9, 0x8C, 0x7C, 0xC6, 0x3C,
  0x63, 0x1F, 0x31, 0x8F, 0x98, 0xC7, 0xCE, 0xF6, 0x63, 0xDF, 0x30, 0xC6,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x37, 0x00, 0xDC, 0x07,
  0x30, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x18, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x1C, 0x1C, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x1C,
  0xFE, 0x1F, 0xF3, 0xFF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1,
  0xDF, 0xF3, 0xFE, 0x73, 0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x9F, 0x7F, 0xEF, 0xF0, 0x07, 0xC1, 0xFF, 0x1F, 0xE3, 0x82, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3E, 0x61, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xF8, 0xFF, 0xCE, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xBF, 0xDC, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xDF, 0xEE, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x03, 0xE0, 0x7F,
  0xC7, 0xFE, 0x78, 0x13, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x3F, 0xC1, 0xFE, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x78,
  0x39, 0xC1, 0xCF, 0x8E, 0x3F, 0xF0, 0xFF, 0x00, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE7, 0xFF, 0xE0, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xFB, 0xEE, 0x00, 0xE0, 0xEE, 0x0E, 0xE1,
  0xCE, 0x1C, 0xE3, 0x8E, 0x78, 0xE7, 0x0E, 0xE0, 0xEE, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0xF7, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1,
  0xEE, 0x0E, 0xE0, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x3F, 0xFF, 0xFF, 0xF8, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0xDF, 0xE0, 0x6F, 0xF0, 0x7F, 0xD8, 0x3F, 0xEC, 0x1B, 0xF7,
  0x0D, 0xFB, 0x8E, 0xFC, 0xC6, 0x7E, 0x63, 0x3F, 0x3B, 0x9F, 0x8D, 0xCF,
  0xC6, 0xC7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C,
  0x38, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0,
  0xFD, 0xC7, 0xEE, 0x3F, 0x31, 0xF9, 0xCF, 0xC6, 0x7E, 0x3B, 0xF1, 0xDF,
  0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0x80,
  0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x0E, 0x1E, 0x70, 0x39, 0xC0, 0xE7, 0x01,
  0xDC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0,
  0x77, 0x01, 0xDC, 0x0E, 0x70, 0x38, 0xE1, 0xE3, 0xCF, 0x07, 0xF8, 0x0F,
  0xC0, 0xFC, 0x3F, 0xEF, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x7B, 0xFE, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x0E, 0x1E, 0x70,
  0x39, 0xC0, 0xE7, 0x01, 0xDC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x70, 0x38, 0xE1, 0xE3,
  0xCF, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0xFC, 0x0F, 0xF8, 0xFF, 0x8E, 0x3C, 0xE1, 0xCE, 0x1C, 0xE1,
  0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xFF, 0x8F, 0xF0, 0xFF, 0x0E, 0x70, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xF0, 0x1F, 0x0F,
  0xF7, 0xFB, 0xC2, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x78, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x7F, 0x7B, 0xFE, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0x79, 0xE7, 0xFC,
  0x3F, 0x80, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39,
  0xC1, 0xC7, 0x0E, 0x38, 0x61, 0xC7, 0x0E, 0x38, 0x31, 0xC1, 0xCC, 0x0E,
  0xE0, 0x77, 0x01, 0xB8, 0x0D, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x70,
  0x00, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0E, 0xC0, 0xE0, 0x67,
  0x0F, 0x87, 0x38, 0x6C, 0x39, 0xC3, 0x61, 0xCE, 0x1B, 0x0E, 0x30, 0xD8,
  0x61, 0xCE, 0xE7, 0x0E, 0x77, 0x38, 0x73, 0x19, 0xC3, 0x98, 0xCE, 0x0C,
  0xC6, 0x60, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x77, 0x0E,
  0x30, 0xE3, 0x8E, 0x39, 0xC1, 0x9C, 0x1D, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1D, 0xC3, 0x9C, 0x39, 0xC3, 0x0E,
  0x70, 0xE7, 0x0E, 0xE0, 0x70, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x30,
  0xE3, 0x9C, 0x39, 0xC1, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x60, 0x70, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFF, 0xF0, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0E, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x38, 0x01, 0xE0, 0x1F, 0x00, 0xFC, 0x06, 0x60, 0x73, 0x83, 0x1C, 0x38,
  0x61, 0x83, 0x9C, 0x0D, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3,
  0x87, 0x1F, 0x1F, 0xE3, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x7C, 0xFF, 0x79,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xF7, 0xFD, 0xF3, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xC7, 0xFC, 0xFF, 0xDC, 0x3B, 0x87,
  0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xDC, 0x3B, 0x87, 0x79,
  0xED, 0xF9, 0x9E, 0x00, 0x1F, 0x1F, 0xDF, 0xCE, 0x07, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0xC4, 0xFE, 0x3E, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0x39, 0xFF, 0x7F, 0xEE, 0x3F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0xC3,
  0xB8, 0xF7, 0xFE, 0x7C, 0xC0, 0x1E, 0x0F, 0xE7, 0xB9, 0xC7, 0x60, 0xF8,
  0x3E, 0x0F, 0xFF, 0xFF, 0xF8, 0x0E, 0x01, 0x80, 0x70, 0x1E, 0x13, 0xFC,
  0x7E, 0x0F, 0x8F, 0x8F, 0x47, 0x03, 0x81, 0xC0, 0xF9, 0xFC, 0xFE, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x1C, 0x67, 0xFD, 0xFF, 0xB8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x0E, 0xE3, 0xCF, 0xF9, 0xF7,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0xE7, 0xFC, 0xFF, 0x0F, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xF3, 0x7E, 0xFF, 0xB8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x70, 0x5F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08,
  0x71, 0xC6, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x6F, 0xBE, 0xF0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x1F, 0x8E, 0xE3, 0xB9, 0xCE, 0xE3, 0xB8,
  0xFC, 0x37, 0x0F, 0xE3, 0x98, 0xE7, 0x39, 0xCE, 0x3B, 0x8E, 0xE1, 0xF8,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCF, 0x1E,
  0x6F, 0xDF, 0xBF, 0xFF, 0xDC, 0x78, 0xEE, 0x1C, 0x3F, 0x0E, 0x1F, 0x87,
  0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E,
  0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xCF, 0x37, 0xEF, 0xFB,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x1F, 0x07, 0xF1, 0xEF, 0x38, 0xE6, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB0, 0x77, 0x0C, 0xE3, 0x8F,
  0xE0, 0xF8, 0xCF, 0x1B, 0xF3, 0xFF, 0x70, 0xEE, 0x1D, 0xC1, 0xB8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x70, 0xEE, 0x1D, 0xE7, 0xBF, 0xE7, 0x78,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x67,
  0xFD, 0xFF, 0xB8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x77, 0x0E, 0xE3, 0xCF, 0xF9, 0xF7, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0xCF, 0xBF, 0x7F, 0x8E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x3E, 0x7F, 0xF7, 0xE0,
  0xE0, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x07, 0x07, 0xC7, 0xFF, 0xFE,
  0x18, 0x38, 0x38, 0x3E, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x39, 0x3F, 0x1F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF9,
  0xF7, 0xFD, 0xF3, 0xE0, 0xFC, 0x1D, 0x83, 0xB8, 0x67, 0x1C, 0xE3, 0x8C,
  0x71, 0xCC, 0x39, 0x87, 0x70, 0x6E, 0x0D, 0x81, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0xE1, 0xE1, 0xF8, 0x78, 0x76, 0x1E, 0x19, 0xC7, 0x86, 0x71, 0xE3,
  0x9C, 0x6C, 0xE3, 0x3B, 0x38, 0xCC, 0xCC, 0x3B, 0x33, 0x0E, 0xCD, 0xC3,
  0xB3, 0xF0, 0x7C, 0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x70, 0xEE, 0x39, 0xC7, 0x1C, 0xC3, 0xB8, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x1D, 0xC3, 0x98, 0xE3, 0x9C, 0x77, 0x07, 0xE0,
  0xFC, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0x63, 0x8C, 0x71, 0xCC, 0x39, 0x83,
  0x70, 0x6E, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFE, 0xFE, 0xFE, 0x0E, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0x03,
  0x0F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0xF0,
  0xF0, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xF0, 0xF8,
  0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1E, 0x0F, 0x0F, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF8, 0xF0, 0x80, 0x78,
  0x3F, 0xFE, 0x3F, 0xC1, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 8, 8, 12, 2, -21 },
  { 17, 12, 21, 14, 1, -21 },
  { 49, 11, 24, 13, 1, -22 },
  { 82, 18, 21, 20, 1, -21 },
  { 130, 14, 21, 15, 1, -21 },
  { 167, 3, 8, 6, 2, -21 },
  { 170, 7, 26, 9, 1, -21 },
  { 193, 6, 26, 9, 1, -21 },
  { 213, 10, 10, 12, 1, -22 },
  { 226, 11, 14, 13, 1, -17 },
  { 246, 4, 7, 7, 1, -3 },
  { 250, 6, 3, 8, 1, -9 },
  { 253, 3, 4, 7, 2, -4 },
  { 255, 11, 21, 11, 0, -21 },
  { 284, 11, 21, 13, 1, -21 },
  { 313, 7, 21, 13, 2, -21 },
  { 332, 10, 21, 13, 1, -21 },
  { 359, 10, 21, 13, 1, -21 },
  { 386, 12, 21, 13, 0, -21 },
  { 418, 10, 21, 13, 1, -21 },
  { 445, 11, 21, 13, 1, -21 },
  { 474, 11, 21, 13, 1, -21 },
  { 503, 11, 21, 13, 1, -21 },
  { 532, 10, 21, 13, 1, -21 },
  { 559, 3, 16, 7, 2, -16 },
  { 565, 4, 20, 7, 1, -16 },
  { 575, 11, 13, 13, 1, -17 },
  { 593, 11, 8, 13, 1, -14 },
  { 604, 11, 13, 13, 1, -17 },
  { 622, 9, 21, 10, 0, -21 },
  { 646, 17, 23, 19, 1, -21 },
  { 695, 14, 21, 14, 0, -21 },
  { 732, 11, 21, 14, 2, -21 },
  { 761, 12, 21, 13, 1, -21 },
  { 793, 12, 21, 15, 2, -21 },
  { 825, 9, 21, 12, 2, -21 },
  { 849, 9, 21, 11, 2, -21 },
  { 873, 13, 21, 16, 1, -21 },
  { 908, 12, 21, 16, 2, -21 },
  { 940, 7, 21, 8, 1, -21 },
  { 959, 6, 27, 7, -1, -21 },
  { 980, 12, 21, 14, 2, -21 },
  { 1012, 9, 21, 11, 2, -21 },
  { 1036, 17, 21, 21, 2, -21 },
  { 1081, 13, 21, 17, 2, -21 },
  { 1116, 14, 21, 16, 1, -21 },
  { 1153, 10, 21, 13, 2, -21 },
  { 1180, 14, 26, 16, 1, -21 },
  { 1226, 12, 21, 14, 2, -21 },
  { 1258, 10, 21, 12, 1, -21 },
  { 1285, 11, 21, 11, 0, -21 },
  { 1314, 12, 21, 16, 2, -21 },
  { 1346, 13, 21, 13, 0, -21 },
  { 1381, 21, 21, 21, 0, -21 },
  { 1437, 12, 21, 12, 0, -21 },
  { 1469, 12, 21, 12, 0, -21 },
  { 1501, 9, 21, 11, 1, -21 },
  { 1525, 6, 26, 9, 2, -21 },
  { 1545, 11, 21, 11, 0, -21 },
  { 1574, 6, 26, 9, 1, -21 },
  { 1594, 13, 12, 14, 0, -21 },
  { 1614, 13, 2, 12, 0, 2 },
  { 1618, 6, 4, 8, 1, -22 },
  { 1621, 10, 16, 12, 1, -16 },
  { 1641, 11, 22, 14, 2, -22 },
  { 1672, 9, 16, 11, 1, -16 },
  { 1690, 11, 22, 14, 1, -22 },
  { 1721, 10, 16, 12, 1, -16 },
  { 1741, 9, 22, 8, 0, -22 },
  { 1766, 11, 23, 14, 1, -16 },
  { 1798, 10, 22, 14, 2, -22 },
  { 1826, 3, 22, 6, 2, -22 },
  { 1835, 6, 29, 6, -1, -22 },
  { 1857, 10, 22, 12, 2, -22 },
  { 1885, 3, 22, 6, 2, -22 },
  { 1894, 17, 16, 20, 2, -16 },
  { 1928, 10, 16, 14, 2, -16 },
  { 1948, 11, 16, 13, 1, -16 },
  { 1970, 11, 23, 14, 2, -16 },
  { 2002, 11, 23, 14, 1, -16 },
  { 2034, 7, 16, 9, 2, -16 },
  { 2048, 8, 16, 10, 1, -16 },
  { 2064, 8, 19, 8, 0, -19 },
  { 2083, 10, 16, 14, 2, -16 },
  { 2103, 11, 16, 11, 0, -16 },
  { 2125, 18, 16, 18, 0, -16 },
  { 2161, 11, 16, 11, 0, -16 },
  { 2183, 11, 23, 11, 0, -16 },
  { 2215, 8, 16, 9, 1, -16 },
  { 2231, 8, 26, 10, 1, -21 },
  { 2257, 2, 29, 12, 5, -22 },
  { 2265, 8, 26, 10, 1, -21 },
  { 2291, 11, 4, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Medium29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM29PT7B_H_
