#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1F, 0xCF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3F, 0x87, 0x00, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x07,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFB, 0x8F, 0xC7,
  0xF1, 0xC0, 0xE7, 0xF0, 0xE0, 0x03, 0xF0, 0x70, 0x01, 0xF8, 0x38, 0x00,
  0xFC, 0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x3F, 0x07, 0x00, 0x1F, 0x83, 0x80,
  0x0F, 0xE1, 0xC0, 0x03, 0xF8, 0xE0, 0x01, 0xFE, 0x70, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1C, 0xFF, 0x00, 0x0E, 0x3F, 0x80, 0x07, 0x0F, 0xE0,
  0x03, 0x83, 0xF0, 0x01, 0xC1, 0xF8, 0x00, 0xE0, 0xFC, 0x00, 0x70, 0x7E,
  0x00, 0x38, 0x3F, 0x00, 0x1C, 0x3F, 0xC0, 0x0E, 0x1F, 0xBC, 0x07, 0x1F,
  0xDF, 0xC3, 0xBF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x7C,
  0x00, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x1F, 0x80, 0x00, 0xF8,
  0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7E,
  0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x7C,
  0x07, 0x01, 0xF0, 0x3F, 0x1F, 0x87, 0xF8, 0x3E, 0x07, 0xC3, 0xE1, 0xFF,
  0xC7, 0xE0, 0xF8, 0x7C, 0x7F, 0xF8, 0x7C, 0x1F, 0x1F, 0x0F, 0xFF, 0x8F,
  0x87, 0xE3, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0xFF,
  0x1F, 0x0F, 0x83, 0xE3, 0xFF, 0xC3, 0xE3, 0xF0, 0x7C, 0x3F, 0xF0, 0xFC,
  0x7E, 0x0F, 0xC3, 0xFC, 0x1F, 0x0F, 0x81, 0xF8, 0x1E, 0x03, 0xE1, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3E,
  0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF7, 0xE0, 0x00, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x1F, 0x81, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xFC, 0x0F,
  0xE1, 0xFE, 0x7F, 0x07, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE1,
  0xFC, 0x7F, 0x07, 0xF8, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x3F, 0x80, 0x7F,
  0x7F, 0x1F, 0xC0, 0x3F, 0xBF, 0x0F, 0xE0, 0x0F, 0xFF, 0x87, 0xF0, 0x03,
  0xFF, 0xC3, 0xF8, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xE0, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0,
  0x0F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xBF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0xF0, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0x3E, 0x7C, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x01, 0x00, 0xF8, 0x08, 0xF0, 0x7C, 0x1C, 0x7F, 0x3E, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7,
  0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0x01, 0x80, 0x00,
  0x80, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xF3, 0xF0,
  0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xFC, 0x1F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xF7, 0xF7,
  0xF9, 0xFF, 0xFC, 0x7F, 0x7E, 0x1F, 0xDF, 0x07, 0xF3, 0x81, 0xFC, 0x40,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x87, 0xFE, 0xFF, 0xE0, 0xF8, 0x07, 0xFC, 0x1C, 0x00, 0xFF, 0x06,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87,
  0xFC, 0x7F, 0xE0, 0xF8, 0x03, 0xFC, 0x18, 0x00, 0x7F, 0x04, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF9,
  0x00, 0x03, 0xFC, 0x70, 0x01, 0xFF, 0x1F, 0xC1, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x3E, 0xFE,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00,
  0x0F, 0x8F, 0xE0, 0x00, 0x7C, 0x7F, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x3E,
  0x1F, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x07, 0xF0, 0x01, 0xF0, 0x3F,
  0x80, 0x0F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xC0, 0x7F, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF0,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F,
  0xE0, 0x7C, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xB0, 0x00, 0x7F, 0x9E, 0x00, 0x7F,
  0xCF, 0xE1, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x70, 0x1F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC1,
  0xF0, 0x0F, 0xE3, 0xFE, 0x07, 0xE3, 0xFF, 0xC3, 0xF3, 0xFF, 0xF1, 0xFB,
  0xFF, 0xF8, 0xFD, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0x3F, 0xE0, 0x3F, 0xDF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFD, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01,
  0xF9, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xFC, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0x8F, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x7F,
  0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07,
  0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0,
  0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xCF,
  0xE0, 0x3F, 0xF3, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xDF,
  0x83, 0xFF, 0xF7, 0xE0, 0x7F, 0xF9, 0xF8, 0x0F, 0xFC, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x06, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xDF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x7E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF1, 0xFD, 0xFE, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xF3, 0xF0, 0x60, 0x0F,
  0x83, 0xF8, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xCF, 0xF0, 0xFE, 0x1F, 0x80,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFC, 0xFF, 0xCF, 0x00, 0xFE, 0x20, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0xFE, 0x01, 0xF0, 0x7C, 0x01, 0xFF, 0xF0, 0xFC, 0x7E, 0x03,
  0xFF, 0xF8, 0x3E, 0x3E, 0x01, 0xFF, 0xF8, 0x1F, 0x1F, 0x01, 0xFC, 0xFC,
  0x0F, 0x9F, 0x81, 0xF8, 0x3E, 0x07, 0xEF, 0xC0, 0xF8, 0x1F, 0x03, 0xF7,
  0xC0, 0xFC, 0x0F, 0x80, 0xFB, 0xE0, 0x7E, 0x07, 0xC0, 0x7D, 0xF0, 0x3E,
  0x03, 0xE0, 0x3F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xFC, 0x1F, 0x80, 0xF8,
  0x0F, 0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xFF,
  0x03, 0xF0, 0x3F, 0x01, 0xFF, 0x81, 0xF8, 0x1F, 0x80, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xBF,
  0x03, 0xE0, 0xFE, 0x07, 0xDF, 0x81, 0xF0, 0x7F, 0x07, 0xC7, 0xC0, 0xFC,
  0x3B, 0xC3, 0xE3, 0xE0, 0x3F, 0xFD, 0xFF, 0xF1, 0xF0, 0x1F, 0xFC, 0xFF,
  0xF0, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x7E, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00,
  0x7F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0x7F,
  0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F,
  0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0xCF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x0E, 0x0F,
  0xF8, 0x00, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x20, 0x7F, 0xC0, 0x1C, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x83, 0xF8, 0x1F, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0xFE, 0x00, 0x7F,
  0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFD, 0xFC,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x7F, 0x9F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0xE1, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE7, 0xFC, 0x07, 0xFE,
  0x00, 0x3C, 0x07, 0xFC, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF8,
  0x00, 0x7F, 0x07, 0xFC, 0x00, 0x7F, 0x07, 0xFF, 0xDF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0xE7, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xC0, 0x0F, 0xF9,
  0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x8F,
  0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xBF, 0x00, 0x01,
  0xFB, 0xFF, 0xDF, 0x80, 0x00, 0xFD, 0xFF, 0xEF, 0xC0, 0x00, 0x7E, 0xFF,
  0xF3, 0xF0, 0x00, 0x3E, 0x7F, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0xFF, 0x3F, 0x00, 0x0F, 0xCF, 0xFF, 0x9F, 0x80, 0x0F,
  0xC7, 0xFF, 0xCF, 0xC0, 0x07, 0xE3, 0xFF, 0xE7, 0xE0, 0x03, 0xF1, 0xFF,
  0xF1, 0xF8, 0x01, 0xF0, 0xFF, 0xF8, 0xFC, 0x01, 0xF8, 0x7F, 0xFC, 0x7E,
  0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0xFF, 0x0F, 0xC0, 0x7E,
  0x0F, 0xFF, 0x87, 0xE0, 0x3F, 0x07, 0xFF, 0xC3, 0xF0, 0x1F, 0x83, 0xFF,
  0xE0, 0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x7E, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F,
  0x07, 0xE0, 0x7F, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0xFE, 0x07, 0xE1, 0xF0,
  0x1F, 0xFF, 0x03, 0xF1, 0xF8, 0x0F, 0xFF, 0x81, 0xF8, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x1F,
  0xBF, 0x00, 0xFF, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xEF, 0xC0, 0x03, 0xFF, 0xDF, 0xC0, 0x07, 0xFF, 0xBF, 0x80, 0x0F, 0xFF,
  0x3F, 0x80, 0x1F, 0xFE, 0x7F, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x7F, 0xF8,
  0xFE, 0x00, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xE3,
  0xF8, 0x07, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0x87, 0xF0, 0x1F, 0xFF, 0x07,
  0xE0, 0x3F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F,
  0xC1, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0xC0, 0x7F,
  0x0F, 0xFF, 0x80, 0x7E, 0x1F, 0xFF, 0x00, 0xFE, 0x3F, 0xFE, 0x01, 0xFC,
  0x7F, 0xFC, 0x01, 0xFC, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xF0, 0x03, 0xFB,
  0xFF, 0xE0, 0x07, 0xF7, 0xFF, 0xC0, 0x07, 0xEF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3A, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xF8, 0x1F, 0xF9, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xFC, 0xFE, 0x07, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0, 0x7C, 0x7F, 0x80,
  0x08, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x80, 0x01, 0xFE, 0xC0, 0x03, 0xFC, 0xF8, 0x07,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7,
  0xFC, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x7C, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xBF, 0x00, 0x7F,
  0x01, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x7C, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0x8F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF1, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x0F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xF8, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xC0, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x0F, 0x87, 0xF0, 0x00,
  0xFE, 0x3F, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0xC0,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xE3, 0xE0, 0x0F, 0x9F, 0xC0, 0x00, 0xFE, 0xFC, 0x01, 0xF3,
  0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x0F, 0xBF, 0x00, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0x81, 0xFE,
  0x06, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x7F, 0x83, 0xFF, 0x7F, 0xFF, 0xBF,
  0x3F, 0xFF, 0xBF, 0x3F, 0xFF, 0x3F, 0x1F, 0xFE, 0x1F, 0x0F, 0xFC, 0x1F,
  0x01, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xF8, 0x3F, 0x9F,
  0xFF, 0x0F, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFB, 0xFF, 0x3F,
  0xF0, 0x1F, 0xCF, 0xF8, 0x07, 0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x3F,
  0xBF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0xFE, 0xFF, 0x80, 0x3F, 0xBF, 0xE0, 0x0F, 0xEF, 0xFC, 0x07, 0xF3,
  0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xBF, 0xFF, 0x8F, 0xC7, 0xFF,
  0xC3, 0xF0, 0xFF, 0xE0, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x04, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xEF, 0x87, 0xF8, 0x04, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x11, 0xFF, 0x87, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x02, 0x01, 0xFC, 0x07, 0xF8, 0x7F,
  0x07, 0xFF, 0x1F, 0xC3, 0xFF, 0xE7, 0xF1, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF,
  0xFF, 0x3F, 0xF3, 0xFF, 0xCF, 0xF0, 0x3F, 0xF7, 0xF8, 0x07, 0xFD, 0xFC,
  0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xE0,
  0x1F, 0xF3, 0xF8, 0x0F, 0xFC, 0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0xEF, 0xC7,
  0xFF, 0xF3, 0xF0, 0xFF, 0xFC, 0xFC, 0x1F, 0xFE, 0x3F, 0x03, 0xFE, 0x0F,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x80,
  0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x02, 0x3F, 0xC0, 0x06, 0x1F, 0xE0, 0x1E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xF8, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x83, 0xF0, 0x7F,
  0xF0, 0xFC, 0x3F, 0xFE, 0x3F, 0x1F, 0xFF, 0xCF, 0xC7, 0xFF, 0xFB, 0xF3,
  0xFF, 0x7F, 0xFC, 0xFF, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xC0, 0x0F,
  0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFE, 0x01, 0xFF,
  0x3F, 0x80, 0xFF, 0xCF, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x7F, 0x0F, 0xFF, 0x9F, 0xC1, 0xFF, 0xE7, 0xF0, 0x3F, 0xE1, 0xFC, 0x01,
  0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF9, 0x00, 0x01, 0xFC, 0x30, 0x00, 0xFF, 0x0F, 0x80, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x04, 0x01, 0xFC, 0x3F, 0xE0, 0xFE, 0x3F, 0xF8, 0x7F,
  0x3F, 0xFE, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7,
  0xFE, 0x07, 0xFB, 0xFE, 0x01, 0xFD, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x3F,
  0x7F, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xF8, 0x7C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x03, 0xE0, 0x1F, 0x81,
  0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xFA, 0x3F, 0x9F, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF,
  0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xDF,
  0xC0, 0x3F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x7E, 0x0F,
  0xF0, 0x0F, 0xF8, 0x3F, 0x1F, 0xFE, 0x0F, 0xFF, 0x1F, 0x9F, 0xFF, 0x8F,
  0xFF, 0x8F, 0xCF, 0xFF, 0xCF, 0xFF, 0xE7, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0x83, 0xFF, 0xC1, 0xFE, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xFF,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x01, 0x00, 0x7E, 0x0F, 0xF8, 0x3F, 0x0F, 0xFE, 0x1F, 0x8F,
  0xFF, 0x8F, 0xCF, 0xFF, 0xE7, 0xEF, 0xFF, 0xF3, 0xFF, 0xEF, 0xFD, 0xFF,
  0x81, 0xFE, 0xFF, 0x80, 0x7F, 0x7F, 0xC0, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F,
  0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0x00, 0x3F, 0x07, 0xFC, 0x0F, 0xC3, 0xFF, 0x83, 0xF1,
  0xFF, 0xF0, 0xFC, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0x1F, 0xF3,
  0xFF, 0x01, 0xFC, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x0F, 0xEF, 0xF0, 0x03,
  0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xEF, 0xF8, 0x03, 0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0xC0, 0x7F,
  0x3F, 0xF8, 0x7F, 0xCF, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0xF8, 0xFE, 0x7F,
  0xFC, 0x3F, 0x8F, 0xFE, 0x0F, 0xE1, 0xFF, 0x03, 0xF8, 0x0E, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x83, 0xF0, 0x7F, 0xF0,
  0xFC, 0x3F, 0xFE, 0x3F, 0x1F, 0xFF, 0xCF, 0xC7, 0xFF, 0xFB, 0xF3, 0xFF,
  0x3F, 0xFC, 0xFF, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xC0, 0x0F, 0xF7,
  0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x3F,
  0x80, 0xFF, 0xCF, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x7F,
  0x0F, 0xFF, 0x9F, 0xC1, 0xFF, 0xC7, 0xF0, 0x3F, 0xE1, 0xFC, 0x01, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x02, 0x3F, 0x07, 0xFF, 0xC3, 0xFB,
  0xF1, 0xFE, 0xFC, 0xFF, 0xBF, 0x3F, 0xEF, 0xDF, 0xFB, 0xF7, 0xFE, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0x83, 0xE7, 0xF0, 0x0C, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x00, 0xE0, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F,
  0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xCF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0x9F, 0x1F, 0xFF, 0x1F, 0x0F, 0xFE, 0x1F, 0x07, 0xFC, 0x1F, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00,
  0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xFC, 0x03, 0xF9,
  0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0x8F, 0xC0,
  0x7F, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xCF,
  0x81, 0xFC, 0x3F, 0x81, 0xF3, 0xE0, 0x7F, 0x0F, 0xE0, 0x7C, 0xF8, 0x1F,
  0x81, 0xF8, 0x3F, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x8F, 0xC1, 0xF8, 0x1F,
  0xC3, 0xE1, 0xF0, 0xFE, 0x07, 0xF0, 0xF8, 0x7C, 0x3F, 0x81, 0xFC, 0x3E,
  0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0x0F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x03, 0xF1, 0xF0, 0x7E, 0x7F, 0x00, 0xFE, 0x7C, 0x0F, 0x9F, 0x80,
  0x1F, 0x9F, 0x03, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0xF9, 0xF8, 0x01, 0xFB,
  0xF0, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x0F, 0x9F, 0x80, 0x1F, 0xBE, 0x03,
  0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x3F, 0xDF, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xE1, 0xF8, 0x03,
  0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF7,
  0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x43, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0xFE, 0x00, 0x04, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0xC0, 0x03, 0xFF, 0x90, 0x00, 0x1F,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 51, 17, 4, -50 },
  { 59, 20, 18, 28, 4, -50 },
  { 104, 31, 50, 33, 1, -50 },
  { 298, 25, 57, 31, 3, -53 },
  { 477, 43, 52, 49, 3, -51 },
  { 757, 33, 52, 35, 2, -51 },
  { 972, 7, 18, 15, 4, -50 },
  { 988, 16, 61, 21, 3, -50 },
  { 1110, 16, 61, 21, 2, -50 },
  { 1232, 25, 25, 29, 2, -53 },
  { 1311, 27, 33, 31, 2, -41 },
  { 1423, 11, 17, 16, 2, -8 },
  { 1447, 16, 6, 20, 2, -22 },
  { 1459, 8, 10, 16, 4, -9 },
  { 1469, 25, 50, 27, 1, -50 },
  { 1626, 25, 52, 31, 3, -51 },
  { 1789, 18, 50, 31, 4, -50 },
  { 1902, 26, 51, 31, 2, -51 },
  { 2068, 26, 52, 31, 2, -51 },
  { 2237, 29, 50, 31, 1, -50 },
  { 2419, 25, 51, 31, 3, -50 },
  { 2579, 25, 52, 31, 3, -51 },
  { 2742, 26, 50, 31, 2, -50 },
  { 2905, 26, 52, 31, 2, -51 },
  { 3074, 26, 52, 31, 2, -51 },
  { 3243, 9, 39, 17, 4, -38 },
  { 3287, 11, 47, 17, 2, -38 },
  { 3352, 27, 32, 31, 2, -41 },
  { 3460, 27, 20, 31, 2, -35 },
  { 3528, 27, 32, 31, 2, -41 },
  { 3636, 21, 52, 23, 1, -51 },
  { 3773, 41, 56, 47, 3, -50 },
  { 4060, 33, 50, 33, 0, -50 },
  { 4267, 27, 50, 34, 5, -50 },
  { 4436, 27, 52, 32, 3, -51 },
  { 4612, 29, 50, 37, 5, -50 },
  { 4794, 21, 50, 29, 5, -50 },
  { 4926, 21, 50, 28, 5, -50 },
  { 5058, 32, 52, 39, 3, -51 },
  { 5266, 28, 50, 38, 5, -50 },
  { 5441, 16, 50, 20, 2, -50 },
  { 5541, 16, 64, 17, -4, -50 },
  { 5669, 28, 50, 33, 5, -50 },
  { 5844, 21, 50, 27, 5, -50 },
  { 5976, 41, 50, 51, 5, -50 },
  { 6233, 31, 50, 41, 5, -50 },
  { 6427, 33, 52, 39, 3, -51 },
  { 6642, 25, 50, 32, 5, -50 },
  { 6799, 33, 63, 39, 3, -51 },
  { 7059, 28, 50, 33, 5, -50 },
  { 7234, 24, 52, 29, 3, -51 },
  { 7390, 26, 50, 28, 1, -50 },
  { 7553, 28, 51, 38, 5, -50 },
  { 7732, 32, 50, 32, 0, -50 },
  { 7932, 51, 50, 51, 0, -50 },
  { 8251, 29, 50, 30, 0, -50 },
  { 8433, 29, 50, 29, 0, -50 },
  { 8615, 23, 50, 26, 2, -50 },
  { 8759, 15, 61, 22, 5, -50 },
  { 8874, 25, 50, 27, 1, -50 },
  { 9031, 15, 61, 22, 2, -50 },
  { 9146, 31, 28, 33, 1, -50 },
  { 9255, 30, 4, 30, 0, 6 },
  { 9270, 14, 12, 20, 3, -54 },
  { 9291, 24, 40, 30, 2, -39 },
  { 9411, 26, 54, 33, 4, -53 },
  { 9587, 21, 40, 25, 3, -39 },
  { 9692, 26, 54, 33, 3, -53 },
  { 9868, 24, 39, 30, 3, -38 },
  { 9985, 20, 54, 19, 1, -54 },
  { 10120, 26, 56, 33, 3, -39 },
  { 10302, 25, 53, 33, 4, -53 },
  { 10468, 8, 52, 15, 4, -52 },
  { 10520, 13, 69, 15, -1, -52 },
  { 10633, 26, 53, 30, 4, -53 },
  { 10806, 7, 53, 15, 4, -53 },
  { 10853, 41, 39, 49, 4, -39 },
  { 11053, 25, 39, 33, 4, -39 },
  { 11175, 26, 40, 32, 3, -39 },
  { 11305, 26, 56, 33, 4, -39 },
  { 11487, 26, 56, 33, 3, -39 },
  { 11669, 18, 39, 22, 4, -39 },
  { 11757, 20, 40, 24, 2, -39 },
  { 11857, 17, 47, 20, 1, -46 },
  { 11957, 24, 39, 33, 4, -38 },
  { 12074, 27, 38, 27, 0, -38 },
  { 12203, 42, 38, 44, 1, -38 },
  { 12403, 25, 38, 27, 1, -38 },
  { 12522, 27, 55, 27, 0, -38 },
  { 12708, 19, 38, 22, 2, -38 },
  { 12799, 20, 61, 25, 2, -50 },
  { 12952, 7, 70, 29, 11, -53 },
  { 13014, 20, 61, 25, 3, -50 },
  { 13167, 27, 10, 31, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Medium70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM70PT7B_H_
