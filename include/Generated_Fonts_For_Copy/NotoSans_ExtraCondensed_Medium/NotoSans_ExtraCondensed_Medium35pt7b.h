#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x77, 0x00, 0x2F,
  0xFF, 0xF0, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0x80, 0x06, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x01,
  0xC6, 0x03, 0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x71, 0xC0, 0xE3,
  0x81, 0xC6, 0x03, 0x8C, 0x07, 0x18, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0xE3, 0x81, 0xC6, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x31,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0x81, 0xFF, 0x9F, 0xF9, 0xEC,
  0xCE, 0x60, 0xF3, 0x07, 0x98, 0x1C, 0xC0, 0xF6, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x1B, 0xC0, 0xCE, 0x06, 0x70, 0x33, 0xE1,
  0xBF, 0xFF, 0xDF, 0xFC, 0x3F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x3E, 0x03, 0x81, 0xFC, 0x0C, 0x07, 0x70, 0x70, 0x18, 0xE1, 0xC0,
  0xE3, 0x86, 0x03, 0x8E, 0x38, 0x0E, 0x38, 0xE0, 0x38, 0xE3, 0x00, 0xE3,
  0x9C, 0x03, 0x8E, 0x70, 0x06, 0x39, 0x9F, 0x18, 0xEE, 0x7E, 0x77, 0x33,
  0xB8, 0xFD, 0xCC, 0x73, 0xE7, 0x31, 0xC0, 0x19, 0xC7, 0x00, 0xE7, 0x1C,
  0x03, 0x9C, 0x70, 0x0C, 0x71, 0xC0, 0x71, 0xC7, 0x01, 0xC3, 0x1C, 0x06,
  0x0C, 0x70, 0x38, 0x3B, 0x80, 0xE0, 0x7E, 0x07, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0xE0, 0x0F, 0x78, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x79, 0xEF, 0x39, 0xE3, 0x9C, 0xF1, 0xEE, 0x70, 0x7F,
  0x38, 0x3F, 0x1C, 0x0F, 0x8F, 0x07, 0xC7, 0x87, 0xE1, 0xFF, 0xF8, 0xFF,
  0x9E, 0x1F, 0x8F, 0x80, 0xFF, 0xFE, 0xEE, 0xEE, 0xE0, 0x0F, 0x1E, 0x1C,
  0x3C, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x78, 0x38, 0x38,
  0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x66, 0x7F, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F,
  0x83, 0xDC, 0x79, 0xE3, 0x8C, 0x10, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x39,
  0xDE, 0xF7, 0x39, 0xDC, 0xE0, 0xFF, 0xFF, 0xFF, 0x2F, 0xFF, 0xF0, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0x71, 0xE7, 0x87, 0x38, 0x39, 0xC1,
  0xCE, 0x0F, 0x70, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x1E, 0xE0, 0xE7, 0x87, 0x1C,
  0x78, 0xFF, 0x83, 0xFC, 0x0F, 0xC0, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xBF,
  0x9D, 0x8E, 0x8F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x1F,
  0x83, 0xFF, 0x3F, 0xF8, 0xC1, 0xE4, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC3, 0xFF, 0x3F, 0xFC, 0xC1, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x3F, 0x01,
  0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x40, 0x7B, 0xFF, 0xDF, 0xFC, 0x7F, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x6E, 0x03, 0xB8, 0x0C,
  0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x40, 0xFF, 0x8F, 0xFC, 0x67,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE8, 0x1E, 0xFF, 0xCF, 0xFC, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x87, 0xFC,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9E, 0x1D,
  0xF9, 0xFF, 0xEF, 0x8F, 0x78, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3B, 0x81,
  0xDC, 0x0E, 0xE0, 0xF7, 0x87, 0x9C, 0x38, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xE7,
  0x07, 0xB8, 0x3D, 0xC1, 0xEE, 0x0E, 0x78, 0x71, 0xE7, 0x87, 0xF8, 0x1F,
  0x01, 0xFC, 0x1F, 0xF1, 0xE3, 0xCE, 0x0E, 0xF0, 0x7F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7F, 0x03, 0xB8, 0x3D, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x1F, 0x81,
  0xFE, 0x1F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1E, 0xE0, 0xF7, 0x8F, 0xBF, 0xDC, 0xFF, 0xE3, 0xEF,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF1, 0xFF, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x2F, 0xFF,
  0xF0, 0x3B, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3B,
  0xDE, 0xE7, 0x3B, 0x9C, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x1E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x07,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x00,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x78, 0x03, 0x00, 0x00, 0x3F,
  0x9F, 0xF9, 0xFF, 0x20, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0x07, 0x81, 0xC0, 0x3C, 0x38, 0x01, 0xC3, 0x00,
  0x0E, 0x70, 0x00, 0xE6, 0x0F, 0xC6, 0xE1, 0xFC, 0x7E, 0x39, 0xC7, 0xE3,
  0x1C, 0x7C, 0x71, 0xC7, 0xC7, 0x1C, 0x7C, 0x71, 0xC7, 0xC7, 0x1C, 0x7C,
  0x71, 0xC7, 0xC7, 0x1C, 0x7C, 0x71, 0xC6, 0xE3, 0xBE, 0xEE, 0x3F, 0x7C,
  0xE1, 0xE3, 0x86, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x02,
  0x01, 0xF9, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x3C, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x80,
  0xE1, 0xE0, 0x70, 0x70, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x0E, 0x07,
  0x8F, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x07, 0x80, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B, 0xC0,
  0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x1F, 0x3F, 0xF8, 0xFF,
  0xE3, 0xC7, 0xEF, 0x07, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x07, 0xF0,
  0xFF, 0xCF, 0xFE, 0x78, 0x27, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x04, 0xFF, 0xC3,
  0xFE, 0x07, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x87, 0xCF, 0x07,
  0x9E, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3B, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0x9E, 0x1F, 0x3F, 0xFC, 0x7F, 0xF0,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9,
  0xF0, 0x27, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0xC0, 0x77, 0x80, 0xE7, 0x81, 0xCF,
  0xFF, 0x8F, 0xFF, 0x07, 0xFC, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3C, 0xFF, 0xFF, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E,
  0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x9E, 0xFE, 0xFC, 0xF8, 0xE0, 0x7B,
  0x81, 0xCE, 0x0F, 0x38, 0x38, 0xE1, 0xE3, 0x8F, 0x0E, 0x3C, 0x39, 0xE0,
  0xE7, 0x83, 0xBC, 0x0E, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0x78,
  0x39, 0xE0, 0xE3, 0xC3, 0x8F, 0x0E, 0x1E, 0x38, 0x78, 0xE0, 0xE3, 0x83,
  0xCE, 0x07, 0x38, 0x1E, 0xE0, 0x7C, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0x7F, 0xC0,
  0x77, 0xEE, 0x07, 0x7E, 0xE0, 0x77, 0xEE, 0x0E, 0x7E, 0x70, 0xE7, 0xE7,
  0x0E, 0x7E, 0x70, 0xC7, 0xE7, 0x1C, 0x7E, 0x39, 0xC7, 0xE3, 0x9C, 0x7E,
  0x3B, 0x87, 0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7E, 0x1F, 0x07,
  0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xE0, 0x70, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xF7, 0x07, 0xEE,
  0x0F, 0xDE, 0x1F, 0x9C, 0x3F, 0x3C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xF3,
  0xF0, 0xE7, 0xE1, 0xEF, 0xC1, 0xDF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1E, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78,
  0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0x87, 0xFF,
  0x3F, 0xFD, 0xE1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE1, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0x80, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E,
  0x70, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x7C, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x3C,
  0x7C, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3C, 0xF0, 0xF1, 0xC3, 0xC7, 0x8F,
  0x0E, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0xF0, 0x3C,
  0x1F, 0xE3, 0xFF, 0x7F, 0xF7, 0x82, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFC, 0x1F, 0xFF, 0xEF, 0xFC,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xE0, 0xF7, 0xFF, 0x8F,
  0xFC, 0x0F, 0xE0, 0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x3C, 0x1C,
  0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0xF8, 0x0F, 0x01, 0xFC,
  0x07, 0x81, 0xEE, 0x07, 0xC0, 0xF7, 0x03, 0xE0, 0x7B, 0x81, 0xF0, 0x39,
  0xE0, 0xFC, 0x1C, 0xF0, 0x6E, 0x0E, 0x38, 0x77, 0x0F, 0x1C, 0x3B, 0x87,
  0x8E, 0x1D, 0xC3, 0x87, 0x8E, 0x71, 0xC1, 0xC7, 0x38, 0xE0, 0xE7, 0x1C,
  0xF0, 0x73, 0x8E, 0x78, 0x39, 0xC7, 0x38, 0x1E, 0xE1, 0xDC, 0x07, 0x70,
  0xEE, 0x03, 0xB0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x00,
  0x78, 0x3C, 0xF0, 0x78, 0xE0, 0xE1, 0xE3, 0xC1, 0xC7, 0x83, 0x8E, 0x07,
  0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xE0, 0x71, 0xC1,
  0xE3, 0x83, 0xC7, 0x87, 0x07, 0x1E, 0x0F, 0x38, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xE0, 0x79, 0xC0, 0xF3, 0xC1, 0xC3, 0x87, 0x87, 0x0F, 0x0F, 0x1C,
  0x0E, 0x38, 0x1C, 0xF0, 0x3D, 0xC0, 0x3B, 0x80, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x38, 0x38, 0x70, 0x70, 0x71, 0xC0,
  0xE3, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0xF0, 0xF0, 0xE0, 0xE0, 0xC0, 0x1F, 0xC3, 0xFE, 0x3F, 0xE2, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x0F, 0x1F, 0xF7, 0xFF, 0x78, 0x7F, 0x07, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0x7B, 0xF7, 0xF7, 0x3E, 0x70, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF7,
  0xC7, 0x7F, 0x3B, 0xFD, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFF,
  0x0E, 0xFF, 0xF7, 0x7F, 0x39, 0xF0, 0x0F, 0xC3, 0xFC, 0xFF, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0xE0, 0x1E, 0x03, 0xC1, 0x3F, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x1F, 0x39,
  0xFD, 0xCF, 0xFE, 0xF0, 0xF7, 0x87, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xEF, 0x0F,
  0x3F, 0xF9, 0xFF, 0xC7, 0xE6, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0xF0, 0xE7,
  0x07, 0x38, 0x39, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x02, 0x3F, 0xF0, 0xFF, 0x83, 0xF8,
  0x07, 0x83, 0xF1, 0xFC, 0x79, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0xBF,
  0xEF, 0xF8, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x1F, 0x19,
  0xFD, 0xCF, 0xFE, 0xF0, 0xF7, 0x87, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xEF, 0x0F,
  0x3F, 0xF9, 0xFD, 0xC7, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE8,
  0x0F, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE7, 0xCE, 0xFE, 0xEF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70, 0xEF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x7E, 0xFD, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x77, 0x87, 0xBC, 0x79,
  0xE3, 0x8F, 0x3C, 0x79, 0xC3, 0xDC, 0x1D, 0xE0, 0xEF, 0x07, 0xFC, 0x3E,
  0xE1, 0xE7, 0x0F, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x1C, 0xF0, 0xF7, 0x83,
  0xBC, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xC7, 0xCE, 0xFE, 0xFE, 0xFF, 0xEF, 0xFF,
  0x8F, 0x8F, 0xF0, 0xF8, 0x7F, 0x07, 0x07, 0xF0, 0x70, 0x7F, 0x07, 0x07,
  0xF0, 0x70, 0x7F, 0x07, 0x07, 0xF0, 0x70, 0x7F, 0x07, 0x07, 0xF0, 0x70,
  0x7F, 0x07, 0x07, 0xF0, 0x70, 0x7F, 0x07, 0x07, 0xF0, 0x70, 0x7F, 0x07,
  0x07, 0xF0, 0x70, 0x70, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70, 0x0F, 0xC0, 0x7F,
  0x83, 0xFF, 0x1E, 0x1E, 0x78, 0x79, 0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x70, 0x39, 0xC0, 0xE7, 0x83, 0x9E,
  0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0xE7, 0xC7, 0x7F, 0x3B, 0xFD,
  0xF0, 0xEF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFF, 0x0E, 0xEF, 0xF7, 0x7F,
  0x3D, 0xF1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x1F, 0x19, 0xFD, 0xCF, 0xFE, 0xF0, 0xF7, 0x87, 0xB8,
  0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x03,
  0xB8, 0x1D, 0xC1, 0xEF, 0x0F, 0x3F, 0xF9, 0xFD, 0xC7, 0xCE, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0xE7,
  0xF7, 0xFB, 0xDF, 0x9F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x3F, 0x9F, 0xF7,
  0xFB, 0xC2, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x70, 0x1E, 0x0F, 0xFF, 0xFF, 0xE7, 0xF0, 0x38, 0x38, 0x38,
  0x38, 0x7F, 0xFF, 0xFF, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x3F, 0x3F, 0x1F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0x7F, 0xF7, 0xF7, 0x3E,
  0x70, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x78, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x3C, 0x38, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1D, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x78, 0x3D, 0xC1, 0xE0, 0xE7, 0x07, 0x83, 0x9C, 0x3F, 0x0E, 0x70, 0xFC,
  0x79, 0xE3, 0xF1, 0xC3, 0x8C, 0xC7, 0x0E, 0x33, 0x1C, 0x39, 0xCC, 0x70,
  0xE7, 0x3B, 0xC1, 0xDC, 0xEE, 0x07, 0x73, 0xB8, 0x1D, 0x86, 0xE0, 0x76,
  0x1B, 0x81, 0xF8, 0x6E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3C, 0x1F,
  0x00, 0xF0, 0x3C, 0x00, 0x70, 0x7B, 0xC3, 0x8E, 0x3C, 0x79, 0xE1, 0xCE,
  0x0E, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x81,
  0xFC, 0x0E, 0xF0, 0xF3, 0x87, 0x1E, 0x38, 0x73, 0xC3, 0xFC, 0x1E, 0xF0,
  0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x3C, 0x3C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x78, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xFF,
  0xBF, 0xEF, 0xF8, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xC1, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x0F, 0x0F, 0x83, 0xC0, 0xFC, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0xC1,
  0xF0, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x3F, 0x0F, 0xC0, 0x78, 0x1E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x7C, 0x0F,
  0x07, 0xC3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0xF0, 0xFC, 0x3E, 0x0C, 0x00, 0x38, 0x0F, 0xF8, 0x7F, 0xFF,
  0x8F, 0xF8, 0x1F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 25, 8, 2, -25 },
  { 14, 10, 9, 14, 2, -25 },
  { 26, 15, 25, 17, 1, -25 },
  { 73, 13, 29, 15, 1, -27 },
  { 121, 22, 25, 24, 1, -25 },
  { 190, 17, 25, 18, 1, -25 },
  { 244, 4, 9, 8, 2, -25 },
  { 249, 8, 31, 10, 2, -25 },
  { 280, 8, 31, 10, 1, -25 },
  { 311, 12, 13, 14, 1, -27 },
  { 331, 13, 17, 15, 1, -21 },
  { 359, 5, 9, 8, 1, -4 },
  { 365, 8, 3, 10, 1, -11 },
  { 368, 4, 5, 8, 2, -5 },
  { 371, 12, 25, 13, 1, -25 },
  { 409, 13, 25, 15, 1, -25 },
  { 450, 9, 25, 15, 2, -25 },
  { 479, 13, 25, 15, 1, -25 },
  { 520, 13, 25, 15, 1, -25 },
  { 561, 14, 25, 15, 1, -25 },
  { 605, 12, 25, 15, 2, -25 },
  { 643, 13, 25, 15, 1, -25 },
  { 684, 13, 25, 15, 1, -25 },
  { 725, 13, 25, 15, 1, -25 },
  { 766, 13, 25, 15, 1, -25 },
  { 807, 4, 19, 8, 2, -19 },
  { 817, 5, 24, 8, 1, -19 },
  { 832, 13, 15, 15, 1, -20 },
  { 857, 13, 10, 15, 1, -17 },
  { 874, 13, 15, 15, 1, -20 },
  { 899, 11, 25, 12, 0, -25 },
  { 934, 20, 28, 24, 2, -25 },
  { 1004, 17, 25, 17, 0, -25 },
  { 1058, 14, 25, 17, 2, -25 },
  { 1102, 13, 25, 16, 2, -25 },
  { 1143, 15, 25, 19, 2, -25 },
  { 1190, 10, 25, 14, 3, -25 },
  { 1222, 10, 25, 14, 3, -25 },
  { 1254, 15, 25, 19, 2, -25 },
  { 1301, 14, 25, 19, 3, -25 },
  { 1345, 8, 25, 10, 1, -25 },
  { 1370, 8, 32, 8, -2, -25 },
  { 1402, 14, 25, 16, 3, -25 },
  { 1446, 11, 25, 13, 2, -25 },
  { 1481, 20, 25, 26, 3, -25 },
  { 1544, 15, 25, 21, 3, -25 },
  { 1591, 16, 25, 20, 2, -25 },
  { 1641, 13, 25, 16, 2, -25 },
  { 1682, 16, 31, 20, 2, -25 },
  { 1744, 14, 25, 17, 2, -25 },
  { 1788, 12, 25, 15, 1, -25 },
  { 1826, 13, 25, 14, 0, -25 },
  { 1867, 14, 25, 19, 2, -25 },
  { 1911, 16, 25, 16, 0, -25 },
  { 1961, 25, 25, 25, 0, -25 },
  { 2040, 15, 25, 15, 0, -25 },
  { 2087, 15, 25, 15, 0, -25 },
  { 2134, 12, 25, 13, 1, -25 },
  { 2172, 8, 31, 11, 2, -25 },
  { 2203, 12, 25, 13, 1, -25 },
  { 2241, 8, 31, 11, 1, -25 },
  { 2272, 15, 14, 16, 1, -25 },
  { 2299, 15, 2, 15, 0, 3 },
  { 2303, 7, 6, 10, 1, -27 },
  { 2309, 12, 19, 15, 1, -19 },
  { 2338, 13, 27, 17, 2, -27 },
  { 2382, 11, 19, 13, 1, -19 },
  { 2409, 13, 27, 17, 1, -27 },
  { 2453, 13, 19, 15, 1, -19 },
  { 2484, 10, 27, 9, 0, -27 },
  { 2518, 13, 27, 17, 1, -19 },
  { 2562, 12, 27, 16, 2, -27 },
  { 2603, 4, 26, 8, 2, -26 },
  { 2616, 7, 34, 8, -1, -26 },
  { 2646, 13, 27, 15, 2, -27 },
  { 2690, 4, 27, 8, 2, -27 },
  { 2704, 20, 19, 25, 2, -19 },
  { 2752, 12, 19, 16, 2, -19 },
  { 2781, 14, 19, 16, 1, -19 },
  { 2815, 13, 27, 17, 2, -19 },
  { 2859, 13, 27, 17, 1, -19 },
  { 2903, 9, 19, 11, 2, -19 },
  { 2925, 10, 19, 12, 1, -19 },
  { 2949, 8, 23, 10, 1, -23 },
  { 2972, 12, 19, 16, 2, -19 },
  { 3001, 14, 19, 14, 0, -19 },
  { 3035, 22, 19, 22, 0, -19 },
  { 3088, 13, 19, 14, 0, -19 },
  { 3119, 14, 27, 14, 0, -19 },
  { 3167, 10, 19, 11, 1, -19 },
  { 3191, 10, 31, 13, 1, -25 },
  { 3230, 3, 35, 15, 6, -27 },
  { 3244, 10, 31, 13, 1, -25 },
  { 3283, 13, 5, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Medium35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM35PT7B_H_
