#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x5F, 0x6F, 0x66, 0x47, 0xC6, 0x5D, 0x64, 0x4A, 0xCB,
  0x2F, 0x6C, 0xB2, 0xC0, 0x43, 0x18, 0x8B, 0x49, 0xE0, 0xC0, 0x5A, 0x94,
  0xD5, 0x5C, 0x5D, 0x80, 0x4F, 0x44, 0x60, 0xC0, 0xC0, 0x25, 0x25, 0x00,
  0x46, 0x99, 0x9A, 0x60, 0xF5, 0x50, 0x4A, 0x22, 0x24, 0xF0, 0x4A, 0x26,
  0x21, 0xE0, 0x26, 0x6A, 0xF2, 0x68, 0xE1, 0x1E, 0x24, 0x8E, 0x99, 0x60,
  0xF2, 0x22, 0x44, 0x4A, 0x96, 0xA9, 0x60, 0x4A, 0x9B, 0x52, 0x60, 0x88,
  0x40, 0x60, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x54, 0xA4, 0x10, 0x79, 0xDB,
  0x6D, 0xB9, 0x03, 0x00, 0x66, 0x67, 0x99, 0xF7, 0x5B, 0xC0, 0x25, 0x48,
  0x84, 0x70, 0xF6, 0xDB, 0x80, 0xEE, 0xB0, 0xEE, 0xA0, 0x25, 0x48, 0x95,
  0x70, 0xB7, 0xDB, 0x40, 0xD5, 0x70, 0x55, 0x56, 0xBB, 0x6B, 0x40, 0xAA,
  0xB0, 0x9C, 0xF7, 0xDE, 0xD4, 0x9D, 0xDD, 0xBB, 0x22, 0xA3, 0x18, 0xA9,
  0xC0, 0xF6, 0xE9, 0x00, 0x22, 0xA3, 0x18, 0xA9, 0xC2, 0x10, 0xF7, 0xEB,
  0x40, 0x5E, 0x22, 0x78, 0xE9, 0x24, 0x80, 0xB6, 0xDB, 0xC0, 0x99, 0x66,
  0x66, 0x97, 0x69, 0xD3, 0x66, 0xC9, 0x00, 0xF6, 0x66, 0x69, 0xB6, 0x64,
  0x44, 0xE5, 0x29, 0xC0, 0xEA, 0xAC, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x66,
  0x90, 0xF0, 0xD0, 0x65, 0xDE, 0x93, 0x5B, 0x78, 0x72, 0x46, 0x11, 0x79,
  0x99, 0x70, 0x69, 0xF8, 0x60, 0x6B, 0x24, 0x90, 0x79, 0x99, 0x71, 0x60,
  0x93, 0x5B, 0x68, 0xBE, 0xBF, 0x80, 0x92, 0xED, 0xA8, 0xFE, 0xD5, 0x6B,
  0x5A, 0x80, 0xD6, 0xDA, 0x69, 0x99, 0x60, 0xD6, 0xDD, 0x20, 0x79, 0x99,
  0x71, 0x10, 0xEA, 0x80, 0x71, 0x1E, 0x75, 0x50, 0xB6, 0xDE, 0xB5, 0xB4,
  0xA6, 0xEB, 0x96, 0x58, 0xAD, 0x3A, 0xB5, 0xB4, 0xB0, 0xE9, 0x2E, 0x69,
  0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 3, 2, 4, 0, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 6, 7, 6, 0, -7 },
  { 16, 5, 7, 5, 0, -7 },
  { 21, 1, 2, 2, 0, -6 },
  { 22, 2, 7, 3, 0, -6 },
  { 24, 2, 7, 3, 0, -6 },
  { 26, 3, 3, 4, 0, -7 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 2, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 2, 1, 2, 0, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 4, 7, 4, 0, -7 },
  { 40, 2, 6, 4, 1, -6 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 1, 5, 2, 1, -5 },
  { 72, 2, 6, 2, 0, -5 },
  { 74, 4, 4, 4, 0, -5 },
  { 76, 4, 2, 4, 0, -4 },
  { 77, 4, 4, 4, 0, -5 },
  { 79, 3, 7, 3, 0, -7 },
  { 82, 6, 7, 6, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 3, 6, 4, 1, -6 },
  { 94, 4, 7, 4, 0, -7 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 2, 6, 4, 1, -6 },
  { 103, 2, 6, 4, 1, -6 },
  { 105, 4, 7, 5, 0, -7 },
  { 109, 3, 6, 5, 1, -6 },
  { 112, 2, 6, 3, 0, -6 },
  { 114, 2, 8, 2, 0, -6 },
  { 116, 3, 6, 4, 1, -6 },
  { 119, 2, 6, 3, 1, -6 },
  { 121, 5, 6, 7, 1, -6 },
  { 125, 4, 6, 5, 1, -6 },
  { 128, 5, 7, 5, 0, -7 },
  { 133, 3, 6, 4, 1, -6 },
  { 136, 5, 9, 5, 0, -7 },
  { 142, 3, 6, 4, 1, -6 },
  { 145, 3, 7, 4, 0, -7 },
  { 148, 3, 6, 4, 0, -6 },
  { 151, 3, 6, 5, 1, -6 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 7, 6, 7, 0, -6 },
  { 163, 4, 6, 4, 0, -6 },
  { 166, 4, 6, 4, 0, -6 },
  { 169, 3, 6, 3, 0, -6 },
  { 172, 2, 7, 3, 1, -6 },
  { 174, 3, 6, 3, 0, -6 },
  { 177, 2, 7, 3, 0, -6 },
  { 179, 4, 3, 4, 0, -6 },
  { 181, 4, 1, 4, 0, 1 },
  { 182, 2, 2, 3, 0, -7 },
  { 183, 3, 5, 4, 0, -5 },
  { 185, 3, 7, 4, 1, -7 },
  { 188, 3, 5, 3, 0, -5 },
  { 190, 4, 7, 4, 0, -7 },
  { 194, 4, 5, 4, 0, -5 },
  { 197, 3, 7, 2, 0, -7 },
  { 200, 4, 7, 4, 0, -5 },
  { 204, 3, 7, 4, 1, -7 },
  { 207, 1, 7, 2, 1, -7 },
  { 208, 1, 9, 2, 0, -7 },
  { 210, 3, 7, 4, 1, -7 },
  { 213, 1, 7, 2, 0, -7 },
  { 214, 5, 5, 6, 1, -5 },
  { 218, 3, 5, 4, 1, -5 },
  { 220, 4, 5, 4, 0, -5 },
  { 223, 3, 7, 4, 1, -5 },
  { 226, 4, 7, 4, 0, -5 },
  { 230, 2, 5, 3, 1, -5 },
  { 232, 3, 5, 3, 0, -5 },
  { 234, 2, 6, 3, 0, -6 },
  { 236, 3, 5, 4, 1, -5 },
  { 238, 3, 5, 4, 0, -5 },
  { 240, 6, 5, 6, 0, -5 },
  { 244, 3, 5, 3, 0, -5 },
  { 246, 3, 7, 4, 0, -5 },
  { 249, 3, 5, 3, 0, -5 },
  { 251, 3, 7, 3, 0, -6 },
  { 254, 1, 9, 4, 1, -7 },
  { 256, 3, 7, 3, 0, -6 },
  { 259, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Medium9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM9PT7B_H_
