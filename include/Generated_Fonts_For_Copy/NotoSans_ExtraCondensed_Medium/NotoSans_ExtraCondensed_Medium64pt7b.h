#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xF9, 0xE0, 0x3E,
  0x78, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C,
  0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x3E,
  0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00,
  0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x3E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0xF0, 0x00, 0x7C,
  0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xF9, 0xC3, 0xCF, 0xC3, 0x81, 0x1F, 0x87, 0x00,
  0x3E, 0x0E, 0x00, 0x7C, 0x1C, 0x00, 0xF8, 0x38, 0x01, 0xF0, 0x70, 0x03,
  0xF0, 0xE0, 0x07, 0xE1, 0xC0, 0x0F, 0xE3, 0x80, 0x0F, 0xF7, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0E,
  0x7F, 0x00, 0x1C, 0x7E, 0x00, 0x38, 0xFC, 0x00, 0x70, 0xF8, 0x00, 0xE1,
  0xF8, 0x01, 0xC3, 0xF0, 0x03, 0x87, 0xC0, 0x07, 0x0F, 0xA0, 0x0E, 0x3F,
  0x70, 0x1C, 0xFC, 0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x1E, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x01,
  0xF0, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x07, 0x80,
  0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x0F, 0x80, 0x00, 0x78,
  0x1F, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x1F, 0x0F, 0xF0, 0x7C, 0x1F, 0x1F,
  0x1F, 0xF8, 0x7C, 0x1E, 0x3E, 0x3F, 0xFC, 0x3C, 0x3E, 0x3E, 0x3E, 0x7E,
  0x3E, 0x7E, 0x3C, 0x7E, 0x3E, 0x3F, 0xFC, 0x7C, 0x7C, 0x3E, 0x1F, 0xFC,
  0x7C, 0x7C, 0x1E, 0x0F, 0xF8, 0x78, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x78,
  0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0x07,
  0x80, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x02, 0x1F, 0xFF, 0x03, 0xF0, 0xFE, 0xFC,
  0x0F, 0xC3, 0xF9, 0xF8, 0x3F, 0x1F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC3,
  0xF3, 0xF8, 0x3F, 0x9F, 0x8F, 0xC0, 0x7F, 0x7E, 0x3F, 0x00, 0xFD, 0xF8,
  0xFC, 0x03, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0x0F, 0xC0, 0x0F, 0xFC, 0x3F,
  0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0x87, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0x83,
  0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x78, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x04, 0x07, 0xC0, 0x9E, 0x1E, 0x1E, 0x7F, 0x7B, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x01, 0xF8,
  0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x03, 0xE0, 0x1C, 0x0E, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE,
  0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x10, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xBF, 0x7F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x38, 0x3F, 0x10,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xE1, 0xFF, 0x0F, 0x00, 0xFE, 0x0C,
  0x00, 0xFE, 0x10, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0x0E, 0x00, 0xFF,
  0x08, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x60, 0x01, 0xFE, 0xF8,
  0x07, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x3A, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1E,
  0xFC, 0x00, 0x07, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xF7, 0xF0, 0x00,
  0x7D, 0xFC, 0x00, 0x1E, 0x7F, 0x00, 0x0F, 0x9F, 0xC0, 0x03, 0xC7, 0xF0,
  0x01, 0xF1, 0xFC, 0x00, 0x7C, 0x7F, 0x00, 0x3E, 0x1F, 0xC0, 0x0F, 0x87,
  0xF0, 0x07, 0xC1, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0xF8, 0x1F, 0xC0, 0x3E,
  0x07, 0xF0, 0x1F, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x1F, 0xC0,
  0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0E, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xB0, 0x01, 0xFE, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0x02, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x03, 0xF3, 0xFF, 0x07, 0xEF, 0xFF, 0x0F, 0xDF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xF1, 0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x01, 0xFD,
  0xFC, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0x81, 0xFC, 0x3F, 0x87, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81,
  0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x81,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF8, 0xFF,
  0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x7F, 0x9F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFE, 0xFC, 0x7F, 0xFD,
  0xF8, 0x7F, 0xF3, 0xF0, 0x3F, 0xC7, 0xE0, 0x08, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x20, 0x1F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x80, 0x0E, 0x07, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xF8, 0x7F, 0x9C, 0x03, 0xFA, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x07, 0xC3, 0xF0, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0xFF, 0xF0,
  0xF8, 0xF8, 0x0F, 0xFF, 0x87, 0xCF, 0x80, 0xFF, 0xFC, 0x1E, 0x7C, 0x0F,
  0xC3, 0xE0, 0xFB, 0xE0, 0x7C, 0x1F, 0x07, 0xDF, 0x07, 0xC0, 0xF8, 0x3F,
  0xF0, 0x3E, 0x0F, 0xC1, 0xFF, 0x81, 0xF0, 0x7E, 0x0F, 0xFC, 0x1F, 0x03,
  0xE0, 0x7F, 0xE0, 0xF8, 0x1F, 0x03, 0xFF, 0x07, 0xC0, 0xF8, 0x1F, 0xF8,
  0x3E, 0x07, 0xC0, 0xFF, 0xC1, 0xF0, 0x3E, 0x07, 0xFE, 0x0F, 0x81, 0xF0,
  0x3F, 0xF0, 0x7C, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7C, 0x0F, 0xFC, 0x1F,
  0x03, 0xE0, 0x7F, 0xE0, 0xF8, 0x1F, 0x03, 0xDF, 0x07, 0xC1, 0xF8, 0x3E,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF7, 0xC0, 0xF8, 0x7F, 0x0F, 0x3E, 0x07, 0xFF,
  0x7F, 0xF8, 0xF8, 0x1F, 0xF9, 0xFF, 0x87, 0xC0, 0xFF, 0x8F, 0xFC, 0x3E,
  0x03, 0xFC, 0x3F, 0xC1, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x1F, 0xC1, 0xFF, 0x8F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC,
  0x01, 0xFE, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xF1, 0xF0, 0x3F, 0xC0, 0x18, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x06, 0x0F, 0xFC, 0x0F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0xFF, 0x87,
  0xF0, 0x0F, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0x83, 0xF0, 0x3F, 0xE0, 0x03, 0x81, 0xFE, 0x00, 0x08, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x7F,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x80,
  0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x87,
  0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFE, 0x03, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x1F,
  0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8,
  0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F,
  0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0,
  0x07, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F,
  0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xDF, 0x00, 0x01, 0xF7,
  0xFE, 0xF8, 0x00, 0x0F, 0xBF, 0xF7, 0xE0, 0x00, 0xFD, 0xFF, 0xBF, 0x00,
  0x07, 0xCF, 0xFC, 0xF8, 0x00, 0x3E, 0xFF, 0xE7, 0xC0, 0x01, 0xF7, 0xFF,
  0xBF, 0x00, 0x1F, 0xBF, 0xFD, 0xF8, 0x00, 0xF9, 0xFF, 0xE7, 0xC0, 0x07,
  0xCF, 0xFF, 0x3F, 0x00, 0x7E, 0x7F, 0xF9, 0xF8, 0x03, 0xE3, 0xFF, 0xC7,
  0xC0, 0x1F, 0x1F, 0xFE, 0x3E, 0x00, 0xF8, 0xFF, 0xF1, 0xF8, 0x0F, 0xC7,
  0xFF, 0x8F, 0xC0, 0x7C, 0x3F, 0xFC, 0x3E, 0x03, 0xE1, 0xFF, 0xE1, 0xF0,
  0x3F, 0x0F, 0xFF, 0x0F, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0x83, 0xFF,
  0xC1, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0xC7, 0xE0, 0xFF, 0xF0, 0x7E, 0x3E,
  0x07, 0xFF, 0x81, 0xF1, 0xF0, 0x3F, 0xFC, 0x0F, 0x9F, 0x81, 0xFF, 0xE0,
  0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0x7F, 0xF8, 0x0F, 0xBE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xF0,
  0x03, 0xFF, 0xBF, 0x00, 0x3F, 0xFB, 0xF0, 0x03, 0xFF, 0x9F, 0x80, 0x3F,
  0xF9, 0xF8, 0x03, 0xFF, 0x8F, 0xC0, 0x3F, 0xF8, 0xFC, 0x03, 0xFF, 0xCF,
  0xE0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xC7, 0xE0, 0x3F, 0xFC, 0x3F, 0x03,
  0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0xC3, 0xFF, 0xC0, 0xFC, 0x3F, 0xFC, 0x0F, 0xC3, 0xFF, 0xC0, 0x7E,
  0x3F, 0xFC, 0x07, 0xE3, 0xFF, 0xC0, 0x7F, 0x3F, 0xFC, 0x03, 0xF3, 0xFF,
  0xC0, 0x3F, 0xBF, 0xFC, 0x01, 0xFB, 0xFF, 0xC0, 0x1F, 0xBF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xE3, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xDF, 0xC0, 0x7F, 0xBF, 0x81, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xE3, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFE, 0x7F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xC3, 0xF8,
  0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xE3,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83,
  0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF8,
  0x07, 0x9F, 0xC0, 0x04, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0xFF, 0x1F, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xCF,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF8, 0x00, 0x7E, 0x3F,
  0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE1, 0xF8,
  0x01, 0xF7, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xDF, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xBE, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x7C, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xF9, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xE3, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC7, 0xC0, 0xFE, 0x01, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0x03, 0xF8, 0x3E, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C,
  0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x3E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x7C, 0x3F, 0x80, 0x1F, 0x87, 0xC0, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0x81,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x03,
  0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x07, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x0F,
  0x9F, 0x80, 0x01, 0xF3, 0xE0, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x3E,
  0x7E, 0x00, 0x07, 0xEF, 0x80, 0x3E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x7D,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC,
  0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x7E, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3C, 0x0F, 0xE0, 0x80, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0x0F, 0xDF, 0xE0, 0x3F,
  0x7F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFD, 0xF8, 0x1F, 0xF7, 0xF9, 0xFF, 0xDF, 0xFF, 0xBF, 0x3F, 0xFE, 0x7C,
  0x7F, 0xF1, 0xF0, 0xFF, 0x07, 0xC0, 0x60, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x7F, 0xE0, 0xFC, 0xFF, 0xF0, 0xFD,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xC3, 0xFC, 0xFF, 0x81, 0xFC, 0xFF,
  0x00, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0xFF, 0xF8, 0xFD,
  0xFF, 0xF8, 0xF9, 0xFF, 0xF0, 0xF8, 0xFF, 0xE0, 0xF8, 0x3F, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0x87, 0x0F, 0xE0, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x02, 0x7F,
  0x01, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x1F, 0x83,
  0xFE, 0x3F, 0x0F, 0xFF, 0x7E, 0x3F, 0xFE, 0xFC, 0xFF, 0xFF, 0xF9, 0xFE,
  0x3F, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0xDF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xF7, 0xC7, 0xFF, 0xCF, 0x87, 0xFF, 0x1F, 0x07, 0xFC,
  0x3E, 0x00, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x08,
  0xFE, 0x00, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFE, 0xC0, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x3E, 0x0F, 0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xF9, 0xF3, 0xFF, 0xFB,
  0xE7, 0xF8, 0xFF, 0xDF, 0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0x7E, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xF0, 0x7F,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7E, 0x1F, 0xFC, 0xFC,
  0x1F, 0xF1, 0xF8, 0x07, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF3, 0x00, 0x0F, 0xE7, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xF8, 0xFD, 0xFF, 0xF3, 0xF7, 0xFF, 0xCF,
  0xFF, 0xFF, 0xBF, 0xF9, 0xFE, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFC, 0x39, 0xFB, 0xF7, 0xFF, 0xFF, 0xBF, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x01, 0xC0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE8, 0xFE, 0xFF, 0xCF,
  0xFC, 0xFF, 0x8F, 0xF8, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x1F,
  0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0,
  0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x7E, 0x03, 0xFC, 0xFE, 0x07, 0xF0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xC7, 0xFE, 0x07,
  0xFE, 0x3E, 0x7F, 0xF8, 0x7F, 0xF9, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xBF,
  0xFF, 0x7F, 0xFF, 0x7F, 0xE3, 0xFF, 0xC7, 0xFB, 0xFC, 0x0F, 0xFC, 0x1F,
  0xDF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0xF8, 0x3F,
  0x83, 0xE1, 0xFF, 0x8F, 0x9F, 0xFF, 0x3E, 0x7F, 0xFC, 0xFB, 0xFF, 0xFB,
  0xFF, 0x1F, 0xEF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7F,
  0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x00, 0xF8,
  0x3F, 0x80, 0xF8, 0x7F, 0xE0, 0xF8, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xC3, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x01, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xF8, 0xFD,
  0xFF, 0xF0, 0xFC, 0xFF, 0xE0, 0xFC, 0x3F, 0xC0, 0xFC, 0x0F, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x3E, 0x0F, 0xFC, 0x7C, 0x3F,
  0xFC, 0xF8, 0xFF, 0xF9, 0xF3, 0xFF, 0xFB, 0xE7, 0xF8, 0xFF, 0xDF, 0xC0,
  0x7F, 0xBF, 0x80, 0xFF, 0x7E, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0,
  0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xF0, 0x7F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x1F, 0xFF, 0x7E, 0x1F, 0xFC, 0xFC, 0x1F, 0xF1, 0xF8, 0x07, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFE, 0xF9,
  0xFE, 0xF9, 0xFE, 0xFB, 0xFE, 0xFF, 0xE2, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF,
  0x7F, 0xFF, 0x9F, 0xC1, 0xEF, 0xE0, 0x13, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xFE, 0x3F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC1, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x70, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFD, 0xFC, 0x1F,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xDF, 0x3F, 0xFE, 0x7C, 0x7F, 0xF1, 0xF0,
  0xFF, 0x87, 0xC0, 0x30, 0x00, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF8,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x00,
  0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0xC0, 0x1F,
  0x9F, 0x80, 0xFF, 0xC0, 0x7E, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x7E, 0x03,
  0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xDE, 0x03, 0xF0, 0xFC, 0x0F, 0x3C, 0x07,
  0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0xE0,
  0xF9, 0xF0, 0x7E, 0x07, 0xC1, 0xF3, 0xE0, 0xFC, 0x0F, 0xC3, 0xE3, 0xC1,
  0xF0, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x3F, 0x1F, 0x0F, 0x8F, 0xC0, 0x7E,
  0x3E, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x3E, 0x3E, 0x00, 0xFC, 0xF8, 0x7C,
  0x7C, 0x01, 0xF9, 0xE0, 0x79, 0xF8, 0x03, 0xF7, 0xC0, 0xFB, 0xF0, 0x07,
  0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x0F, 0x7C, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7F,
  0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x9F, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x7F, 0x80, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x80,
  0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 47, 15, 4, -46 },
  { 48, 18, 17, 25, 4, -46 },
  { 87, 28, 46, 30, 1, -46 },
  { 248, 23, 53, 28, 3, -49 },
  { 401, 40, 47, 45, 2, -46 },
  { 636, 30, 47, 32, 2, -46 },
  { 813, 6, 17, 14, 4, -46 },
  { 826, 15, 56, 19, 3, -46 },
  { 931, 14, 56, 19, 2, -46 },
  { 1029, 22, 23, 26, 2, -49 },
  { 1093, 24, 30, 28, 2, -38 },
  { 1183, 10, 15, 15, 2, -7 },
  { 1202, 14, 6, 18, 2, -20 },
  { 1213, 7, 9, 15, 4, -8 },
  { 1221, 23, 46, 24, 1, -46 },
  { 1354, 24, 47, 28, 2, -46 },
  { 1495, 16, 46, 28, 4, -46 },
  { 1587, 23, 46, 28, 2, -46 },
  { 1720, 23, 47, 28, 2, -46 },
  { 1856, 26, 46, 28, 1, -46 },
  { 2006, 22, 47, 28, 3, -46 },
  { 2136, 23, 47, 28, 3, -46 },
  { 2272, 24, 46, 28, 2, -46 },
  { 2410, 24, 47, 28, 2, -46 },
  { 2551, 23, 47, 28, 2, -46 },
  { 2687, 7, 36, 15, 4, -35 },
  { 2719, 10, 43, 15, 2, -35 },
  { 2773, 24, 29, 28, 2, -37 },
  { 2860, 24, 19, 28, 2, -32 },
  { 2917, 24, 29, 28, 2, -37 },
  { 3004, 19, 47, 21, 1, -46 },
  { 3116, 37, 51, 43, 3, -46 },
  { 3352, 30, 46, 30, 0, -46 },
  { 3525, 25, 46, 31, 4, -46 },
  { 3669, 25, 47, 29, 3, -46 },
  { 3816, 27, 46, 34, 4, -46 },
  { 3972, 18, 46, 26, 5, -46 },
  { 4076, 18, 46, 25, 5, -46 },
  { 4180, 29, 47, 35, 3, -46 },
  { 4351, 26, 46, 35, 5, -46 },
  { 4501, 15, 46, 19, 2, -46 },
  { 4588, 14, 59, 15, -3, -46 },
  { 4692, 25, 46, 30, 5, -46 },
  { 4836, 19, 46, 24, 4, -46 },
  { 4946, 37, 46, 47, 5, -46 },
  { 5159, 28, 46, 38, 5, -46 },
  { 5320, 30, 47, 36, 3, -46 },
  { 5497, 23, 46, 29, 4, -46 },
  { 5630, 30, 57, 36, 3, -46 },
  { 5844, 26, 46, 30, 4, -46 },
  { 5994, 22, 47, 27, 2, -46 },
  { 6124, 24, 46, 25, 1, -46 },
  { 6262, 26, 47, 34, 4, -46 },
  { 6415, 29, 46, 29, 0, -46 },
  { 6582, 47, 46, 47, 0, -46 },
  { 6853, 27, 46, 27, 0, -46 },
  { 7009, 27, 46, 27, 0, -46 },
  { 7165, 22, 46, 24, 1, -46 },
  { 7292, 14, 56, 20, 4, -46 },
  { 7390, 23, 46, 24, 1, -46 },
  { 7523, 14, 56, 20, 2, -46 },
  { 7621, 28, 26, 30, 1, -46 },
  { 7712, 28, 5, 27, 0, 5 },
  { 7730, 12, 10, 18, 3, -49 },
  { 7745, 22, 36, 28, 2, -35 },
  { 7844, 24, 50, 30, 4, -49 },
  { 7994, 19, 36, 23, 3, -35 },
  { 8080, 23, 50, 30, 3, -49 },
  { 8224, 22, 36, 28, 3, -35 },
  { 8323, 18, 49, 17, 1, -49 },
  { 8434, 23, 50, 30, 3, -35 },
  { 8578, 22, 49, 30, 4, -49 },
  { 8713, 7, 48, 14, 4, -48 },
  { 8755, 12, 63, 14, -1, -48 },
  { 8850, 23, 49, 27, 4, -49 },
  { 8991, 6, 49, 14, 4, -49 },
  { 9028, 37, 35, 45, 4, -35 },
  { 9190, 22, 35, 30, 4, -35 },
  { 9287, 24, 36, 29, 3, -35 },
  { 9395, 24, 50, 30, 4, -35 },
  { 9545, 23, 50, 30, 3, -35 },
  { 9689, 16, 35, 20, 4, -35 },
  { 9759, 18, 36, 22, 2, -35 },
  { 9840, 16, 43, 18, 1, -42 },
  { 9926, 22, 36, 30, 4, -35 },
  { 10025, 25, 35, 25, 0, -35 },
  { 10135, 39, 35, 40, 1, -35 },
  { 10306, 23, 35, 25, 1, -35 },
  { 10407, 25, 50, 25, 0, -35 },
  { 10564, 18, 35, 20, 1, -35 },
  { 10643, 18, 56, 23, 2, -46 },
  { 10769, 6, 64, 27, 10, -49 },
  { 10817, 18, 56, 23, 3, -46 },
  { 10943, 24, 9, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Medium64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM64PT7B_H_
