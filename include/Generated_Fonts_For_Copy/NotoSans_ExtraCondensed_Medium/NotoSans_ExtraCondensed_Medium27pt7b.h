#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDB, 0x6C, 0x00, 0xFF, 0x80, 0xE7, 0x67, 0x63,
  0x63, 0x63, 0x63, 0x63, 0x18, 0xC3, 0x18, 0x66, 0x0C, 0xC1, 0x99, 0xFF,
  0xFF, 0xF9, 0x8C, 0x31, 0x86, 0x30, 0xCC, 0x7F, 0xFF, 0xFE, 0x66, 0x0C,
  0xC3, 0x18, 0x63, 0x0C, 0x61, 0x98, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0xFF,
  0x7F, 0xBB, 0x2E, 0xC3, 0x30, 0xEC, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x83,
  0x70, 0xDC, 0x37, 0x8D, 0xFF, 0xEF, 0xF0, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x10, 0x00, 0x3C, 0x0C, 0x1B, 0x0C, 0x19, 0x86, 0x0C, 0xE6, 0x06, 0x33,
  0x03, 0x19, 0x81, 0x8D, 0x80, 0xCE, 0xCE, 0x66, 0x6F, 0x9B, 0x66, 0xCF,
  0x36, 0x71, 0x1B, 0x18, 0x19, 0x8C, 0x0C, 0xC6, 0x0E, 0x63, 0x06, 0x31,
  0x83, 0x1D, 0x83, 0x07, 0xC1, 0x81, 0xC0, 0x0C, 0x01, 0xF0, 0x0F, 0xC0,
  0xE6, 0x07, 0x30, 0x39, 0x81, 0xCC, 0x06, 0xE0, 0x3E, 0x00, 0xE0, 0x0F,
  0x00, 0xFC, 0xEE, 0x67, 0x73, 0xB3, 0x0F, 0x98, 0x3C, 0xE1, 0xC7, 0x1F,
  0x1F, 0xDC, 0x7C, 0xF0, 0xED, 0xB6, 0xD8, 0x0C, 0x63, 0x8C, 0x71, 0xC6,
  0x18, 0x63, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x61, 0xC7, 0x0C, 0x38, 0x60,
  0xC0, 0xE1, 0x87, 0x0C, 0x38, 0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC6, 0x18, 0xE3, 0x8C, 0x71, 0x8C, 0x00, 0x1C, 0x0E, 0x07, 0x19, 0xBF,
  0xFB, 0xF8, 0xF8, 0x6C, 0x77, 0x11, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x77, 0x66, 0xEC, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x0C, 0x0F, 0xC7,
  0xF1, 0xCE, 0x61, 0xB8, 0x6E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0x63, 0x9C, 0xE3, 0xF0, 0xF8, 0x1C, 0xF7,
  0xFB, 0xCD, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x08, 0x1F, 0xCF, 0xF1, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0F,
  0xFF, 0xFF, 0x08, 0x1F, 0xCF, 0xF9, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x07, 0x0F, 0x83, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x03, 0xA0,
  0xEF, 0xF3, 0xF8, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0xDC, 0x1B, 0x87,
  0x70, 0xCE, 0x19, 0xC6, 0x38, 0xC7, 0x30, 0xE6, 0x1D, 0xFF, 0xFF, 0xF8,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xF8, 0xFF, 0x11, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0E, 0xC7, 0xBF, 0xCF, 0xE0, 0x02, 0x07, 0xE3, 0xF8, 0xE0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xEF, 0x3F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0x61, 0x9C, 0xE3, 0xF8, 0x7C, 0xFF, 0xFF, 0xF0, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x00, 0x08, 0x0F, 0xC7, 0xF9, 0x86,
  0xE1, 0xF8, 0x76, 0x19, 0xCE, 0x3F, 0x0F, 0x83, 0xE1, 0xDE, 0xE3, 0xB8,
  0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x67, 0xF8, 0xFC, 0x08, 0x0F, 0x87, 0xF3,
  0x8E, 0xE1, 0xB8, 0x6E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x7D, 0xFF, 0x3D,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x01, 0xC7, 0xE1, 0xF0, 0x5F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x27, 0x76, 0x00, 0x00, 0x00, 0x00, 0x77, 0x66, 0xEC,
  0xC0, 0x00, 0x40, 0x30, 0x3C, 0x3C, 0x3C, 0x3C, 0x0E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0x00, 0x40, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x80, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1C,
  0x1E, 0x1E, 0x1F, 0x0F, 0x03, 0x00, 0x80, 0x00, 0x18, 0xFE, 0x7F, 0x47,
  0x03, 0x03, 0x03, 0x07, 0x07, 0x0E, 0x1C, 0x18, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x38, 0x38, 0x07, 0xF0, 0x0E, 0x38, 0x18, 0x0C, 0x30, 0x06,
  0x70, 0x06, 0x63, 0xF7, 0x67, 0x73, 0x66, 0x63, 0xC6, 0x63, 0xC6, 0x63,
  0xCE, 0x63, 0xCE, 0x63, 0xC6, 0x63, 0xC6, 0x66, 0xE7, 0xFE, 0x63, 0x9C,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x10, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x77, 0x03, 0x38, 0x18,
  0xC1, 0xC6, 0x0E, 0x38, 0x7F, 0xC3, 0xFE, 0x38, 0x31, 0xC1, 0xCE, 0x0E,
  0x60, 0x77, 0x01, 0xB8, 0x0E, 0xFF, 0x3F, 0xEE, 0x3F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x8E, 0xFF, 0x3F, 0xEE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE3, 0xFF, 0xEF, 0xE0, 0x02, 0x01, 0xFC, 0xFF, 0x1C, 0x27, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0x88, 0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xF3,
  0x8E, 0x70, 0xEE, 0x1D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0x0E, 0xEF, 0x9F, 0xE3, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xC1, 0x78, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xFE, 0x1F, 0xE0, 0x36, 0x03, 0x70,
  0x37, 0x03, 0x78, 0x33, 0xC3, 0x1F, 0xF0, 0xFF, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x80, 0xFD,
  0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33,
  0xFF, 0xC0, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xEF, 0xBC, 0xE1, 0xFC, 0x3B, 0x8E,
  0x71, 0x8E, 0x71, 0xDC, 0x3B, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x77,
  0x0E, 0x71, 0xCE, 0x38, 0xE7, 0x1C, 0xE1, 0xDC, 0x3B, 0x83, 0x80, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xD8, 0x1F, 0xD8, 0x3F, 0xDC, 0x37, 0xCC, 0x37, 0xCC, 0x37,
  0xCC, 0x77, 0xCE, 0x67, 0xC6, 0x67, 0xC6, 0x67, 0xC7, 0xE7, 0xC7, 0xC7,
  0xC3, 0xC7, 0xC3, 0xC7, 0xC3, 0x87, 0xC1, 0x87, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x87, 0xD8, 0x7D, 0xC7, 0xDC, 0x7C, 0xC7, 0xCE, 0x7C, 0x67, 0xC7,
  0x7C, 0x37, 0xC3, 0xFC, 0x3F, 0xC1, 0xBC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x70, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0x71, 0xE7, 0x07, 0x38, 0x19, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB0, 0x1D,
  0x80, 0xEE, 0x0E, 0x70, 0x71, 0xC7, 0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x3F,
  0xCE, 0x3B, 0x8E, 0xE1, 0xB8, 0x7E, 0x1B, 0x8E, 0xE3, 0xBF, 0xEF, 0xF3,
  0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x02, 0x00,
  0xFE, 0x0F, 0xF8, 0x71, 0xE7, 0x07, 0x38, 0x19, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB0, 0x1D, 0x80, 0xEE, 0x0E,
  0x70, 0x71, 0xC7, 0x0F, 0xF8, 0x1F, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0xFE, 0x1F, 0xE3, 0x8E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8,
  0x67, 0x1C, 0xE7, 0x9F, 0xE3, 0xF8, 0x77, 0x0E, 0x71, 0xCE, 0x38, 0xE7,
  0x1C, 0xE1, 0x9C, 0x3B, 0x87, 0x80, 0x08, 0x1F, 0xDF, 0xFE, 0x2E, 0x07,
  0x03, 0x81, 0xC0, 0x70, 0x3E, 0x07, 0x81, 0xE0, 0x38, 0x1C, 0x06, 0x07,
  0x03, 0xE3, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3F, 0x06, 0xF1, 0xCF, 0xF0, 0xFC, 0x00, 0xE0, 0x3E, 0x07, 0x60,
  0x77, 0x07, 0x70, 0x67, 0x0E, 0x30, 0xE3, 0x0E, 0x38, 0xC3, 0x8C, 0x19,
  0xC1, 0x9C, 0x1D, 0x81, 0xD8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0xE0, 0xE0, 0x7E, 0x0E, 0x06, 0x60, 0xF0, 0xE6, 0x0F, 0x0E, 0x70,
  0xF0, 0xE7, 0x1F, 0x0E, 0x71, 0xB0, 0xC3, 0x1B, 0x9C, 0x31, 0x99, 0xC3,
  0x99, 0x9C, 0x3B, 0x99, 0x83, 0xB9, 0x98, 0x1B, 0x1F, 0x81, 0xB0, 0xF8,
  0x1B, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x07,
  0x00, 0x70, 0xEE, 0x18, 0xC7, 0x1C, 0xE1, 0xB8, 0x37, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xB8, 0x77, 0x0E, 0x61, 0x8E, 0x70,
  0xCE, 0x1F, 0x83, 0x80, 0xE0, 0xEC, 0x1D, 0xC3, 0x38, 0xE3, 0x1C, 0x73,
  0x0E, 0xE0, 0xD8, 0x1F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0xFF,
  0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x1D,
  0x81, 0x9C, 0x38, 0xC3, 0x0E, 0x70, 0x6E, 0x07, 0xFF, 0xFF, 0xFF, 0xE3,
  0x8C, 0x30, 0x80, 0x1E, 0x3F, 0x99, 0xE0, 0x70, 0x38, 0x1C, 0x7E, 0xFF,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xED, 0xE6, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0xE3, 0x7C, 0xF7, 0xB8, 0xEE, 0x1B, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x6E, 0x3B, 0xFC, 0xDF, 0x00, 0x1E,
  0x3F, 0x7B, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x71,
  0x7F, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x31, 0xCC, 0xFB,
  0x7F, 0xD8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8,
  0x77, 0x3D, 0xFB, 0x3E, 0xC0, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0xE1, 0xB8,
  0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x8F, 0xE1, 0xF8,
  0x0E, 0x1F, 0x3E, 0x38, 0x38, 0x38, 0x3E, 0xFE, 0xFE, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0xCF, 0xB7,
  0xFD, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87,
  0x73, 0xDF, 0xB3, 0xCC, 0x03, 0x01, 0xC0, 0x74, 0x1D, 0xFE, 0x7F, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x39, 0xBE, 0xFF, 0xF1, 0xF8,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x38,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x33, 0x30, 0x03, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x37, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x0F, 0x86, 0xC7, 0x63, 0x33, 0x9B, 0x8D, 0xC7, 0xE3, 0xB1, 0xDC,
  0xC6, 0x63, 0xB0, 0xD8, 0x7C, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xCE, 0x39, 0xBE, 0xFB, 0xDF, 0xFF, 0x1C, 0x7E, 0x38, 0x78, 0x70, 0xF0,
  0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0x70, 0xF0, 0xE1, 0x80, 0xCE, 0x6F, 0xBD, 0xFC, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0E, 0x1E, 0x0F,
  0xC7, 0xB9, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1D,
  0x87, 0x73, 0x8F, 0xE1, 0xF0, 0xCE, 0x37, 0xCF, 0x7B, 0x8E, 0xE1, 0xB0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x86, 0xE3, 0xBF, 0xCD, 0xF3,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0xCF, 0xB7, 0xFD,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0x73,
  0xDF, 0xB3, 0xCC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xCF,
  0x7F, 0xF8, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x3C,
  0x7F, 0xF6, 0xC0, 0xC0, 0xE0, 0x78, 0x7C, 0x1E, 0x0E, 0x07, 0x07, 0x8E,
  0xFE, 0xFC, 0x10, 0x60, 0xC1, 0xFF, 0xFF, 0xCC, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x1C, 0x3E, 0x3C, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x7F, 0xED, 0xE6, 0xE0,
  0xF8, 0x36, 0x1D, 0x87, 0x71, 0x9C, 0x63, 0x38, 0xCE, 0x3B, 0x0E, 0xC1,
  0xB0, 0x7C, 0x1E, 0x07, 0x80, 0xE0, 0xE1, 0xC3, 0xF0, 0xE1, 0x98, 0x70,
  0xCC, 0x6C, 0x67, 0x36, 0x73, 0x9B, 0x38, 0xCD, 0x98, 0x66, 0xCC, 0x37,
  0x66, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0x70, 0xF0, 0xE1, 0xDC, 0x77, 0x38, 0xCE, 0x3B, 0x07, 0xC1, 0xE0, 0x38,
  0x1E, 0x07, 0xC3, 0xB0, 0xCE, 0x73, 0x9C, 0x7E, 0x1C, 0xE0, 0xF8, 0x36,
  0x1D, 0xC7, 0x71, 0x9C, 0x63, 0x38, 0xCE, 0x3B, 0x06, 0xC1, 0xB0, 0x7C,
  0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC1, 0xE0, 0x70, 0x00,
  0xFF, 0xFF, 0xF8, 0x61, 0xC3, 0x8E, 0x1C, 0x30, 0xE1, 0x87, 0x0E, 0x1F,
  0xFF, 0x80, 0x0F, 0x1F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0xF0, 0xE0, 0xF0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0xF8, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0x07,
  0x1F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0xF8, 0xF0, 0xF8,
  0x7F, 0xF8, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_Medium27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 8, 7, 11, 1, -19 },
  { 16, 11, 19, 13, 1, -19 },
  { 43, 10, 23, 12, 1, -21 },
  { 72, 17, 20, 19, 1, -20 },
  { 115, 13, 20, 14, 1, -20 },
  { 148, 3, 7, 6, 1, -19 },
  { 151, 6, 23, 8, 1, -19 },
  { 169, 6, 23, 8, 1, -19 },
  { 187, 9, 10, 11, 1, -21 },
  { 199, 10, 13, 12, 1, -16 },
  { 216, 4, 7, 6, 1, -3 },
  { 220, 6, 3, 8, 1, -9 },
  { 223, 3, 3, 6, 2, -3 },
  { 225, 10, 19, 10, 0, -19 },
  { 249, 10, 20, 12, 1, -20 },
  { 274, 6, 19, 12, 2, -19 },
  { 289, 10, 20, 12, 1, -20 },
  { 314, 10, 20, 12, 1, -20 },
  { 339, 11, 19, 12, 0, -19 },
  { 366, 10, 19, 12, 1, -19 },
  { 390, 10, 20, 12, 1, -20 },
  { 415, 10, 19, 12, 1, -19 },
  { 439, 10, 20, 12, 1, -20 },
  { 464, 10, 20, 12, 1, -20 },
  { 489, 3, 15, 6, 2, -15 },
  { 495, 4, 19, 6, 1, -15 },
  { 505, 10, 13, 12, 1, -16 },
  { 522, 10, 7, 12, 1, -13 },
  { 531, 10, 13, 12, 1, -16 },
  { 548, 8, 20, 9, 0, -20 },
  { 568, 16, 21, 18, 1, -19 },
  { 610, 13, 19, 13, 0, -19 },
  { 641, 10, 19, 13, 2, -19 },
  { 665, 11, 20, 12, 1, -20 },
  { 693, 11, 19, 14, 2, -19 },
  { 720, 8, 19, 11, 2, -19 },
  { 739, 8, 19, 11, 2, -19 },
  { 758, 12, 20, 15, 1, -20 },
  { 788, 11, 19, 15, 2, -19 },
  { 815, 6, 19, 8, 1, -19 },
  { 830, 6, 24, 6, -1, -19 },
  { 848, 11, 19, 13, 2, -19 },
  { 875, 8, 19, 10, 2, -19 },
  { 894, 16, 19, 20, 2, -19 },
  { 932, 12, 19, 16, 2, -19 },
  { 961, 13, 20, 15, 1, -20 },
  { 994, 10, 19, 12, 2, -19 },
  { 1018, 13, 25, 15, 1, -20 },
  { 1059, 11, 19, 13, 2, -19 },
  { 1086, 9, 20, 11, 1, -20 },
  { 1109, 10, 19, 11, 0, -19 },
  { 1133, 11, 19, 15, 2, -19 },
  { 1160, 12, 19, 12, 0, -19 },
  { 1189, 20, 19, 20, 0, -19 },
  { 1237, 11, 19, 11, 0, -19 },
  { 1264, 11, 19, 11, 0, -19 },
  { 1291, 9, 19, 10, 1, -19 },
  { 1313, 6, 23, 8, 2, -19 },
  { 1331, 10, 19, 10, 0, -19 },
  { 1355, 6, 23, 8, 1, -19 },
  { 1373, 12, 10, 13, 0, -19 },
  { 1388, 12, 2, 12, 0, 2 },
  { 1391, 5, 5, 8, 1, -21 },
  { 1395, 9, 15, 12, 1, -15 },
  { 1412, 10, 21, 13, 2, -21 },
  { 1439, 8, 15, 10, 1, -15 },
  { 1454, 10, 21, 13, 1, -21 },
  { 1481, 10, 15, 12, 1, -15 },
  { 1500, 8, 21, 7, 0, -21 },
  { 1521, 10, 21, 13, 1, -15 },
  { 1548, 9, 21, 13, 2, -21 },
  { 1572, 2, 20, 6, 2, -20 },
  { 1577, 4, 26, 6, 0, -20 },
  { 1590, 9, 21, 11, 2, -21 },
  { 1614, 2, 21, 6, 2, -21 },
  { 1620, 15, 15, 19, 2, -15 },
  { 1649, 9, 15, 13, 2, -15 },
  { 1666, 10, 15, 12, 1, -15 },
  { 1685, 10, 21, 13, 2, -15 },
  { 1712, 10, 21, 13, 1, -15 },
  { 1739, 6, 15, 9, 2, -15 },
  { 1751, 8, 15, 9, 1, -15 },
  { 1766, 7, 18, 8, 0, -18 },
  { 1782, 9, 15, 13, 2, -15 },
  { 1799, 10, 15, 11, 0, -15 },
  { 1818, 17, 15, 17, 0, -15 },
  { 1850, 10, 15, 10, 0, -15 },
  { 1869, 10, 21, 11, 0, -15 },
  { 1896, 7, 15, 9, 1, -15 },
  { 1910, 8, 23, 10, 1, -19 },
  { 1933, 3, 27, 11, 4, -21 },
  { 1944, 8, 23, 10, 1, -19 },
  { 1967, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Medium27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM27PT7B_H_
