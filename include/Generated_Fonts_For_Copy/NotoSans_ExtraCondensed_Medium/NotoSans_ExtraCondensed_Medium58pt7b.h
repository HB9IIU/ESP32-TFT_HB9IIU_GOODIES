#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium58pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x7E, 0xFF, 0x7F, 0x7E, 0x7E, 0x10, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xF7, 0xC1, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3E,
  0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC0, 0xF3, 0xE0,
  0x79, 0xE0, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78,
  0x1E, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0x9F, 0x9F, 0x9C, 0x18, 0xF8, 0xE0, 0x07, 0xC7, 0x00, 0x7E, 0x38,
  0x03, 0xE1, 0xC0, 0x1F, 0x8E, 0x00, 0x7C, 0x70, 0x03, 0xF3, 0x80, 0x1F,
  0xDC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1D, 0xFC, 0x00,
  0xE7, 0xF0, 0x07, 0x1F, 0x80, 0x38, 0x7C, 0x01, 0xC3, 0xE0, 0x0E, 0x1F,
  0x00, 0x70, 0xF8, 0x03, 0x87, 0xF0, 0x1C, 0x7F, 0xE0, 0xE7, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x10, 0x01, 0xFE, 0x00, 0x1E,
  0x00, 0x3F, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x7C, 0xF8,
  0x03, 0xC0, 0x07, 0xC7, 0xC0, 0x3C, 0x00, 0x78, 0x7C, 0x07, 0xC0, 0x07,
  0x83, 0xC0, 0x78, 0x00, 0xF8, 0x3C, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0xF8,
  0x00, 0xF8, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0xF8, 0x3E,
  0x1E, 0x00, 0x0F, 0x83, 0xE1, 0xE0, 0x00, 0xF8, 0x3E, 0x3E, 0x00, 0x0F,
  0x83, 0xC3, 0xC0, 0x00, 0xF8, 0x3C, 0x3C, 0x00, 0x0F, 0x83, 0xC7, 0xC3,
  0xF0, 0x78, 0x3C, 0x78, 0x7F, 0x87, 0x87, 0xC7, 0x8F, 0xFC, 0x7C, 0x7C,
  0xF9, 0xFF, 0xE7, 0xCF, 0x8F, 0x1E, 0x3E, 0x3F, 0xF9, 0xF1, 0xE1, 0xE1,
  0xFF, 0x1F, 0x3E, 0x1F, 0x1F, 0xE1, 0xE3, 0xE1, 0xF0, 0x7C, 0x3E, 0x3E,
  0x1F, 0x00, 0x03, 0xC3, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x07,
  0xC3, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0xF0,
  0x00, 0xF8, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3E,
  0x1F, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0x3E, 0x1F, 0x00, 0x3E,
  0x01, 0xE1, 0xE0, 0x03, 0xC0, 0x1F, 0x1E, 0x00, 0x3C, 0x01, 0xFF, 0xE0,
  0x07, 0xC0, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xF1,
  0xFB, 0xF0, 0x7C, 0x7E, 0x7E, 0x0F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0x7E,
  0x7E, 0x7E, 0x0F, 0xCF, 0xCF, 0xC0, 0xFD, 0xF1, 0xF0, 0x0F, 0xFE, 0x3E,
  0x01, 0xFF, 0xC7, 0xC0, 0x1F, 0xF0, 0xF8, 0x03, 0xFE, 0x1F, 0x80, 0x3F,
  0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFF, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0x0F,
  0xC1, 0xFF, 0x81, 0xFC, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x80, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x04, 0x0F, 0x02, 0x78, 0xF1, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0x9F, 0x01, 0xF9, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0xFC, 0x1E, 0x07,
  0x00, 0x60, 0x60, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF,
  0xEF, 0xDF, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xC7, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xF3,
  0xF0, 0x1F, 0x9F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0xBE, 0x00,
  0xFD, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x3E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8,
  0x7E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xDF, 0x7F, 0x3F, 0xFC, 0xFD,
  0xF1, 0xF9, 0xC3, 0xF1, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0x07, 0xF0, 0xE0, 0x1F, 0x86, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3E, 0x07, 0xF0, 0xC0, 0x1F, 0xC4, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFD, 0x00, 0x0F, 0xEE,
  0x00, 0xFF, 0x7E, 0x1F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xE0,
  0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xF3, 0xE0,
  0x01, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x03, 0xE0, 0x1F, 0x03, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x9F, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x30, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x80, 0x0F, 0xEC, 0x01, 0xFC, 0xFC, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x50, 0x00, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF8,
  0x10, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x7F, 0x03, 0xE7, 0xFE, 0x1F, 0x7F, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x81, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7E, 0x07, 0xE3, 0xF8, 0x3F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0x7C,
  0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7E,
  0x01, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x8F,
  0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0x8F, 0xE1, 0xFC,
  0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0x7E, 0x03, 0xF9, 0xFE, 0x1F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xC7, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0xBF, 0x87, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFD, 0xF8, 0x7F, 0xCF, 0x80, 0xFC, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x18, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x18, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF,
  0xBE, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xBE, 0x10, 0x0C,
  0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF8, 0xFC, 0x7C, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x8F, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3,
  0xC3, 0xFD, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x0C, 0x03, 0xE3, 0xC0,
  0x3F, 0xF0, 0xF3, 0xE0, 0x7F, 0xF8, 0x7D, 0xE0, 0x7F, 0xFC, 0x3E, 0xF0,
  0x3E, 0x3E, 0x0F, 0xF8, 0x3E, 0x1F, 0x07, 0xFC, 0x1E, 0x0F, 0x83, 0xFE,
  0x1F, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xF0, 0x7F,
  0x83, 0xC0, 0xF8, 0x3F, 0xC1, 0xE0, 0x7C, 0x1F, 0xE0, 0xF0, 0x3E, 0x0F,
  0xF0, 0x78, 0x1F, 0x07, 0xF8, 0x3C, 0x0F, 0x03, 0xFC, 0x1E, 0x07, 0x81,
  0xFE, 0x0F, 0x07, 0xC0, 0xFF, 0x07, 0xC3, 0xE0, 0xFF, 0x83, 0xE1, 0xF8,
  0x7B, 0xC1, 0xF0, 0xDC, 0x3D, 0xF0, 0x7F, 0xEF, 0x7C, 0xF8, 0x3F, 0xF7,
  0xFE, 0x7C, 0x0F, 0xF1, 0xFE, 0x1E, 0x03, 0xF0, 0x7E, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xC0, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFC, 0x3F, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F,
  0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x01, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xC1, 0xE1, 0xFC, 0x01, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x18, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFE, 0x07, 0xC1, 0xFE, 0x00, 0x30, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xE0, 0x0F, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x3F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF,
  0x3F, 0xF1, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8,
  0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E,
  0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xBF,
  0x00, 0xFE, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFB, 0xE0, 0x00, 0xFF, 0xFE, 0xF8, 0x00, 0x3D,
  0xFF, 0xBE, 0x00, 0x1F, 0x7F, 0xE7, 0xC0, 0x07, 0xDF, 0xF9, 0xF0, 0x01,
  0xF7, 0xFF, 0x7C, 0x00, 0xF9, 0xFF, 0xDF, 0x00, 0x3E, 0x7F, 0xF3, 0xE0,
  0x0F, 0x9F, 0xFC, 0xF8, 0x03, 0xC7, 0xFF, 0x3E, 0x01, 0xF1, 0xFF, 0xCF,
  0x80, 0x7C, 0x7F, 0xF1, 0xF0, 0x1F, 0x1F, 0xFC, 0x7C, 0x0F, 0x87, 0xFF,
  0x1F, 0x03, 0xE1, 0xFF, 0xC3, 0xE0, 0xF8, 0x7F, 0xF0, 0xF8, 0x3C, 0x1F,
  0xFC, 0x3E, 0x1F, 0x07, 0xFF, 0x0F, 0x87, 0xC1, 0xFF, 0xC1, 0xF1, 0xF0,
  0x7F, 0xF0, 0x7C, 0x78, 0x1F, 0xFC, 0x1F, 0x3E, 0x07, 0xFF, 0x03, 0xCF,
  0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFE, 0xF8, 0x03, 0xFF, 0xBF, 0x00,
  0xFF, 0xE7, 0xC0, 0x3F, 0xF9, 0xF8, 0x0F, 0xFE, 0x7E, 0x03, 0xFF, 0xCF,
  0x80, 0xFF, 0xF3, 0xF0, 0x3F, 0xFC, 0x7C, 0x0F, 0xFF, 0x1F, 0x83, 0xFF,
  0xC3, 0xE0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x07, 0xC3,
  0xFF, 0xC1, 0xF8, 0xFF, 0xF0, 0x3E, 0x3F, 0xFC, 0x0F, 0xC7, 0xFF, 0x01,
  0xF1, 0xFF, 0xC0, 0x7E, 0x7F, 0xF0, 0x1F, 0x9F, 0xFC, 0x03, 0xE7, 0xFF,
  0x00, 0xFD, 0xFF, 0xC0, 0x1F, 0x7F, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x1F, 0xDF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x1F, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0x81, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFC, 0xFE, 0x7F, 0x00, 0xC7, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xFC, 0x00, 0x7E, 0xF0, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xF0, 0x00, 0xFD, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x1F,
  0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xFE, 0x00,
  0x7E, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xEF, 0x00, 0xFC, 0x1F, 0x00,
  0xFB, 0xC0, 0x3F, 0x07, 0xC0, 0x3C, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xCF, 0x81, 0xF8, 0x1F, 0x81, 0xF3, 0xE0, 0x7E,
  0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x1E, 0x07, 0xC0, 0x3F,
  0x0F, 0x87, 0xC1, 0xF0, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x03, 0xF0, 0xF8,
  0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x83, 0xC3,
  0xE0, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x3E, 0x7E, 0x00,
  0x7E, 0x7C, 0x0F, 0x9F, 0x80, 0x0F, 0x9F, 0x03, 0xE7, 0xE0, 0x03, 0xE7,
  0xC0, 0x79, 0xF0, 0x00, 0xF9, 0xE0, 0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xE3,
  0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xF7,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xF7,
  0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xE3,
  0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xF7,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x38, 0x1F, 0xC4, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xF0,
  0x7D, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xBF, 0x0F,
  0xF7, 0xFF, 0xDE, 0xFF, 0xF3, 0xCF, 0xFC, 0x78, 0xFF, 0x0F, 0x03, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x7C,
  0x7F, 0x83, 0xE7, 0xFF, 0x1F, 0x7F, 0xF8, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F,
  0x3F, 0x80, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xEF,
  0xC0, 0x3F, 0x7F, 0x01, 0xFB, 0xF8, 0x1F, 0xDF, 0xF1, 0xFC, 0xFF, 0xFF,
  0xE7, 0xDF, 0xFE, 0x3C, 0x7F, 0xE1, 0xE1, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xF0, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x08, 0xFF, 0x1E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xF0, 0xFC, 0x1F, 0xF3, 0xF0, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0xFE, 0x1F, 0xF3, 0xF0, 0x3F, 0xDF, 0x80, 0x7F, 0x7E, 0x01,
  0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03,
  0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xF3,
  0xF0, 0x3F, 0xCF, 0xE1, 0xFF, 0x1F, 0xFF, 0x7C, 0x7F, 0xF9, 0xF0, 0xFF,
  0xE7, 0xC1, 0xFE, 0x1F, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0xFC,
  0x0F, 0x87, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x08, 0x3F, 0x81, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x10, 0x00, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xF1, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF,
  0xDF, 0x1F, 0xFF, 0x7C, 0xFE, 0x1F, 0xF3, 0xF0, 0x3F, 0xDF, 0x80, 0x7F,
  0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD,
  0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xF8,
  0x07, 0xF3, 0xF0, 0x3F, 0xCF, 0xF3, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFB,
  0xF0, 0xFF, 0xCF, 0xC1, 0xFE, 0x3F, 0x00, 0x60, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x88, 0x00, 0xFE, 0x3C, 0x07, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x0F, 0x8F, 0xF0, 0xFB, 0xFF, 0x8F, 0xBF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x3E, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x7C,
  0xFB, 0xF7, 0xFF, 0xCF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF0, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x0F,
  0xEF, 0xF9, 0xFF, 0x3F, 0xC7, 0xF0, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x80, 0xFC,
  0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x7E,
  0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xBF,
  0x00, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE,
  0x7C, 0x0F, 0xC7, 0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x78, 0xFF, 0x83, 0xFE, 0x3C, 0xFF,
  0xE3, 0xFF, 0x9E, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xF7, 0xF8,
  0x7F, 0xE1, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xF8, 0x0F, 0xE0, 0x3F, 0xFC,
  0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F,
  0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F,
  0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01,
  0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80,
  0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0,
  0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x0F, 0x0F, 0xF0, 0xF3, 0xFF, 0x8F, 0x3F, 0xFC,
  0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFE, 0x1F, 0xC3, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xF9, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3E, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x07, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x07, 0x87, 0xF8, 0x3C, 0x7F,
  0xF1, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x83, 0xF3, 0xF8, 0x0F, 0xDF,
  0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xF0,
  0x1F, 0xBF, 0x81, 0xFD, 0xFF, 0x1F, 0xCF, 0xBF, 0xFE, 0x7D, 0xFF, 0xE3,
  0xE7, 0xFE, 0x1F, 0x1F, 0xE0, 0xF8, 0x18, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF1, 0xF0,
  0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x1F, 0xFF, 0x7C, 0xFE, 0x1F, 0xF3, 0xF0,
  0x3F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F,
  0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x3F, 0xCF, 0xF1, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFB, 0xF0, 0xFF, 0xCF, 0xC1, 0xFE, 0x3F, 0x00, 0x60,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xF3, 0xFB, 0xFF, 0xEF,
  0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE7, 0xE0, 0x73, 0xF0, 0x09,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x40, 0x0F, 0xB0, 0x0F, 0xDF, 0x1F, 0xEF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x11, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF0, 0x04, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xEF, 0x80, 0x7F, 0x7E, 0x03, 0xFB, 0xF0,
  0x3F, 0xDF, 0xEF, 0xFE, 0x7F, 0xFD, 0xF3, 0xFF, 0xCF, 0x8F, 0xFC, 0x7C,
  0x3F, 0xC3, 0xE0, 0x10, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80,
  0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8,
  0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xC0, 0x3F, 0x7E, 0x01, 0xFC, 0x03,
  0xE7, 0xE0, 0x3F, 0xC0, 0x3E, 0x7E, 0x03, 0xFC, 0x07, 0xE3, 0xE0, 0x3F,
  0xC0, 0x7E, 0x3E, 0x03, 0xFE, 0x07, 0xC3, 0xF0, 0x3D, 0xE0, 0x7C, 0x3F,
  0x07, 0xDE, 0x07, 0xC1, 0xF0, 0x79, 0xE0, 0xFC, 0x1F, 0x07, 0x9E, 0x0F,
  0xC1, 0xF0, 0x79, 0xF0, 0xF8, 0x1F, 0x87, 0x9F, 0x0F, 0x81, 0xF8, 0xF8,
  0xF0, 0xF8, 0x0F, 0x8F, 0x8F, 0x1F, 0x80, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F,
  0x8F, 0x0F, 0x9F, 0x00, 0xF8, 0xF0, 0xF9, 0xF0, 0x07, 0xDF, 0x0F, 0x9F,
  0x00, 0x7D, 0xF0, 0x7B, 0xF0, 0x07, 0xDE, 0x07, 0xBE, 0x00, 0x7D, 0xE0,
  0x7B, 0xE0, 0x07, 0xDE, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x7F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x1F,
  0x9F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7E,
  0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFD, 0xF0, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F,
  0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xF1, 0xF8,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x3F, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0xC0, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x00, 0xFF, 0xE8, 0x00, 0xFF, 0x20, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 42, 14, 3, -41 },
  { 43, 17, 15, 23, 3, -41 },
  { 75, 25, 41, 27, 1, -41 },
  { 204, 21, 47, 26, 2, -44 },
  { 328, 36, 43, 40, 2, -42 },
  { 522, 27, 43, 29, 2, -42 },
  { 668, 6, 15, 13, 3, -41 },
  { 680, 13, 51, 17, 3, -42 },
  { 763, 14, 51, 17, 1, -42 },
  { 853, 20, 20, 24, 2, -44 },
  { 903, 22, 27, 26, 2, -34 },
  { 978, 9, 15, 13, 2, -7 },
  { 995, 13, 5, 16, 2, -18 },
  { 1004, 7, 8, 14, 3, -7 },
  { 1011, 20, 42, 22, 1, -42 },
  { 1116, 21, 43, 25, 2, -42 },
  { 1229, 15, 41, 25, 3, -41 },
  { 1306, 21, 42, 25, 2, -42 },
  { 1417, 21, 43, 25, 2, -42 },
  { 1530, 24, 42, 25, 1, -42 },
  { 1656, 20, 42, 25, 3, -41 },
  { 1761, 21, 43, 25, 2, -42 },
  { 1874, 21, 41, 25, 2, -41 },
  { 1982, 22, 43, 25, 2, -42 },
  { 2101, 21, 43, 25, 2, -42 },
  { 2214, 7, 33, 14, 3, -32 },
  { 2243, 9, 40, 14, 2, -32 },
  { 2288, 22, 27, 26, 2, -34 },
  { 2363, 22, 17, 26, 2, -29 },
  { 2410, 22, 27, 26, 2, -34 },
  { 2485, 17, 43, 19, 1, -42 },
  { 2577, 33, 47, 39, 3, -42 },
  { 2771, 27, 41, 27, 0, -41 },
  { 2910, 22, 41, 29, 4, -41 },
  { 3023, 22, 43, 27, 3, -42 },
  { 3142, 24, 41, 31, 4, -41 },
  { 3265, 17, 41, 24, 4, -41 },
  { 3353, 17, 41, 23, 4, -41 },
  { 3441, 26, 43, 32, 3, -42 },
  { 3581, 24, 41, 32, 4, -41 },
  { 3704, 13, 41, 17, 2, -41 },
  { 3771, 13, 52, 14, -3, -41 },
  { 3856, 23, 41, 27, 4, -41 },
  { 3974, 17, 41, 22, 4, -41 },
  { 4062, 34, 41, 43, 4, -41 },
  { 4237, 26, 41, 34, 4, -41 },
  { 4371, 27, 43, 33, 3, -42 },
  { 4517, 21, 41, 27, 4, -41 },
  { 4625, 27, 52, 33, 3, -42 },
  { 4801, 23, 41, 28, 4, -41 },
  { 4919, 20, 43, 24, 2, -42 },
  { 5027, 21, 41, 23, 1, -41 },
  { 5135, 23, 42, 31, 4, -41 },
  { 5256, 27, 41, 27, 0, -41 },
  { 5395, 42, 41, 42, 0, -41 },
  { 5611, 24, 41, 24, 0, -41 },
  { 5734, 24, 41, 24, 0, -41 },
  { 5857, 20, 41, 22, 1, -41 },
  { 5960, 12, 51, 18, 4, -42 },
  { 6037, 20, 42, 22, 1, -42 },
  { 6142, 12, 51, 18, 2, -42 },
  { 6219, 25, 23, 27, 1, -41 },
  { 6291, 25, 4, 25, 0, 5 },
  { 6304, 12, 9, 16, 2, -44 },
  { 6318, 19, 33, 25, 2, -32 },
  { 6397, 21, 45, 27, 4, -44 },
  { 6516, 18, 33, 21, 2, -32 },
  { 6591, 22, 45, 27, 2, -44 },
  { 6715, 21, 33, 25, 2, -32 },
  { 6802, 16, 44, 15, 1, -44 },
  { 6890, 22, 46, 27, 2, -32 },
  { 7017, 20, 44, 27, 4, -44 },
  { 7127, 7, 43, 13, 3, -43 },
  { 7165, 11, 57, 13, -1, -43 },
  { 7244, 20, 44, 25, 4, -44 },
  { 7354, 5, 44, 13, 4, -44 },
  { 7382, 33, 32, 41, 4, -32 },
  { 7514, 20, 32, 27, 4, -32 },
  { 7594, 22, 33, 27, 2, -32 },
  { 7685, 21, 46, 27, 4, -32 },
  { 7806, 22, 46, 27, 2, -32 },
  { 7933, 14, 32, 18, 4, -32 },
  { 7989, 17, 33, 20, 2, -32 },
  { 8060, 14, 39, 16, 1, -38 },
  { 8129, 21, 32, 27, 3, -31 },
  { 8213, 23, 31, 23, 0, -31 },
  { 8303, 36, 31, 36, 0, -31 },
  { 8443, 21, 31, 23, 1, -31 },
  { 8525, 23, 45, 23, 0, -31 },
  { 8655, 16, 31, 19, 1, -31 },
  { 8717, 16, 51, 21, 2, -42 },
  { 8819, 5, 58, 24, 10, -44 },
  { 8856, 17, 51, 21, 2, -42 },
  { 8965, 22, 8, 26, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Medium58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM58PT7B_H_
