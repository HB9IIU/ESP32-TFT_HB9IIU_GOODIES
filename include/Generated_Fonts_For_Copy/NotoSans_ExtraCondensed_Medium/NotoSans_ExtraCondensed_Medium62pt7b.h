#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xFE, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD,
  0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E,
  0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x01,
  0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x03, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC7, 0xF7, 0x0F, 0x3F, 0x1C, 0x04, 0xFC, 0x70, 0x03, 0xE1, 0xC0,
  0x0F, 0x87, 0x00, 0x3E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xE1, 0xC0, 0x0F,
  0xC7, 0x00, 0x3F, 0x9C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x77, 0xF8, 0x01, 0xC7, 0xE0, 0x07, 0x0F, 0x80,
  0x1C, 0x3F, 0x00, 0x70, 0xFC, 0x01, 0xC3, 0xF0, 0x07, 0x0F, 0xC0, 0x1C,
  0x3F, 0x80, 0x70, 0xFB, 0x01, 0xC7, 0xEF, 0x87, 0x7F, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xC0, 0x03, 0xEF, 0xC0, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x3E,
  0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x0F, 0x00,
  0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0xF0, 0x00, 0x3E, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x3E, 0x00, 0x01, 0xE0,
  0x78, 0x78, 0x3F, 0x03, 0xC1, 0xF1, 0xF0, 0xFF, 0x07, 0xC3, 0xE3, 0xE3,
  0xFF, 0x0F, 0x87, 0xC7, 0x8F, 0xFF, 0x0F, 0x0F, 0x1F, 0x1F, 0x3E, 0x1F,
  0xFE, 0x3E, 0x7C, 0x3E, 0x3F, 0xFC, 0x78, 0xF8, 0x7C, 0x3F, 0xF1, 0xF1,
  0xF0, 0xF8, 0x3F, 0xC3, 0xE3, 0xE0, 0xF0, 0x1E, 0x0F, 0x87, 0x81, 0xF0,
  0x00, 0x1F, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x1E, 0x07, 0xC0, 0x00, 0xF8,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0xF8, 0x00, 0x3C,
  0x07, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x1F, 0x07,
  0x80, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x1F,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0xFE, 0x1F, 0xFE, 0x07, 0xE1, 0xFD,
  0xF8, 0x3F, 0x1F, 0xCF, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xCF, 0xE0, 0xFC,
  0x7E, 0x7E, 0x07, 0xF7, 0xE3, 0xF0, 0x1F, 0xBF, 0x1F, 0x80, 0xFF, 0xF8,
  0xFC, 0x03, 0xFF, 0x87, 0xE0, 0x0F, 0xFC, 0x3F, 0x00, 0x7F, 0xC1, 0xF8,
  0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x07,
  0xFE, 0x0F, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x7F,
  0x0F, 0xFF, 0xF1, 0xF8, 0x3F, 0xFF, 0x0F, 0xE0, 0x7F, 0xE0, 0x3F, 0x80,
  0x38, 0x00, 0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07,
  0x07, 0x83, 0x9F, 0x9E, 0x7E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x87, 0xFF, 0xF1, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0x7E, 0x07,
  0xC1, 0xF0, 0x07, 0x03, 0x80, 0x08, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x8F,
  0x87, 0xC3, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E, 0x08,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0xFC,
  0x1F, 0xC1, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x07,
  0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0x7F, 0xFC, 0xFF,
  0xF1, 0xFB, 0xC3, 0xF3, 0x07, 0xE4, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xC0, 0x7F, 0x8E,
  0x00, 0xFE, 0x10, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFE, 0x7F,
  0xC3, 0xC0, 0x3F, 0x8C, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xBC, 0x01, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x03,
  0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x3E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x00, 0xFC,
  0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x20, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC2, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF2, 0x00, 0x1F, 0xCF, 0x01, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x03, 0xA0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xEF, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x01, 0xF1, 0xFF, 0x83, 0xE7,
  0xFF, 0x87, 0xDF, 0xFF, 0x0F, 0xBF, 0xFF, 0x1F, 0xF0, 0xFE, 0x3F, 0xC0,
  0xFE, 0xFF, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xE0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0xBF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0x9F, 0xE0, 0xFE, 0x1F, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0xCF,
  0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x80, 0xFE, 0x3F, 0xEF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFE, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xF8,
  0x07, 0xF7, 0xF0, 0x3F, 0xCF, 0xF3, 0xFF, 0x3F, 0xFF, 0x7C, 0x7F, 0xFD,
  0xF1, 0xFF, 0xE7, 0xC1, 0xFF, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x39, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x40, 0x0E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8,
  0x7C, 0x7C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0x01, 0xFD, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x03, 0xC3, 0xE0,
  0x1F, 0xFC, 0x3E, 0x3C, 0x07, 0xFF, 0xC3, 0xE7, 0xC0, 0xFF, 0xFC, 0x1E,
  0x7C, 0x0F, 0xC7, 0xC1, 0xE7, 0xC1, 0xF0, 0x7C, 0x1F, 0x78, 0x1F, 0x07,
  0xC1, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0x83,
  0xE0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0x81, 0xFF, 0x83, 0xE0, 0xF8, 0x1F,
  0xF0, 0x3C, 0x0F, 0x81, 0xFF, 0x03, 0xC0, 0xF8, 0x1F, 0xF0, 0x3C, 0x0F,
  0x81, 0xFF, 0x03, 0xC0, 0xF8, 0x1F, 0xF0, 0x3C, 0x0F, 0x81, 0xFF, 0x83,
  0xC0, 0xF8, 0x1E, 0xF8, 0x3E, 0x0F, 0x81, 0xEF, 0x83, 0xE1, 0xF8, 0x3E,
  0xF8, 0x3E, 0x1F, 0xC3, 0xCF, 0x81, 0xF3, 0xDE, 0x7C, 0xF8, 0x1F, 0xF9,
  0xFF, 0x87, 0xC0, 0xFF, 0x9F, 0xF8, 0x7C, 0x07, 0xF0, 0xFF, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x3F,
  0xC0, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFE, 0x1F,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x07, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x0C, 0x1F, 0xE0,
  0x04, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x02, 0x0F, 0xF8,
  0x0E, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0x83, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x0F, 0xE3,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0x03,
  0xC0, 0xFE, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF3, 0xFF, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0x00, 0x7F, 0x9F,
  0xC0, 0x3F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x7C, 0x00, 0x1F, 0xFF, 0xFB, 0xE0,
  0x00, 0xFB, 0xFF, 0xDF, 0x80, 0x07, 0xDF, 0xFE, 0x7C, 0x00, 0x3E, 0xFF,
  0xF3, 0xE0, 0x03, 0xF7, 0xFF, 0x9F, 0x00, 0x1F, 0x3F, 0xFC, 0xFC, 0x00,
  0xF9, 0xFF, 0xE3, 0xE0, 0x0F, 0xCF, 0xFF, 0x1F, 0x00, 0x7C, 0x7F, 0xF8,
  0xFC, 0x03, 0xE3, 0xFF, 0xC3, 0xE0, 0x1F, 0x1F, 0xFE, 0x1F, 0x01, 0xF8,
  0xFF, 0xF0, 0xF8, 0x0F, 0x87, 0xFF, 0x87, 0xE0, 0x7C, 0x3F, 0xFC, 0x1F,
  0x03, 0xE1, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xF0, 0x7F,
  0xF8, 0x3F, 0x0F, 0x83, 0xFF, 0xC0, 0xF8, 0xFC, 0x1F, 0xFE, 0x07, 0xC7,
  0xC0, 0xFF, 0xF0, 0x3F, 0x3E, 0x07, 0xFF, 0x80, 0xF9, 0xF0, 0x3F, 0xFC,
  0x07, 0xDF, 0x01, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x3F,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0xF0, 0x03, 0xFF, 0xDF, 0x80,
  0x3F, 0xFD, 0xF8, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0xFC, 0x03, 0xFF,
  0xC7, 0xE0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xC7, 0xE0, 0x3F, 0xFC, 0x3F,
  0x03, 0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x0F, 0xC3, 0xFF, 0xC0, 0xFC, 0x3F, 0xFC, 0x0F, 0xC3, 0xFF, 0xC0,
  0x7E, 0x3F, 0xFC, 0x07, 0xE3, 0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x03, 0xF3,
  0xFF, 0xC0, 0x1F, 0xBF, 0xFC, 0x01, 0xFB, 0xFF, 0xC0, 0x1F, 0xBF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0xFE,
  0x03, 0xFB, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0xC3, 0xF8,
  0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F,
  0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3,
  0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0x7E, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0x87,
  0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0x1F, 0xC0, 0x0C, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFA, 0x00, 0x0F, 0xEE, 0x00, 0x7F, 0x3F, 0x03, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF8, 0xFF,
  0x03, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xEF, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0x78, 0x01, 0xF8, 0x7E, 0x00, 0xFB, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xDF,
  0x00, 0xFE, 0x0F, 0xC0, 0x3E, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF7, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xC7, 0xC0, 0xFE, 0x03, 0xF0, 0x3E, 0x3E, 0x07, 0xE0,
  0x1F, 0x81, 0xF1, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0x07,
  0xE0, 0xFC, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC1, 0xF0, 0xFE, 0x00, 0xFC,
  0x3E, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x7C, 0x3F, 0x00, 0x3F, 0x0F,
  0x83, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0,
  0x7C, 0x7E, 0x00, 0x3F, 0x3E, 0x03, 0xE7, 0xE0, 0x01, 0xF9, 0xF0, 0x1F,
  0x3F, 0x00, 0x0F, 0xCF, 0x80, 0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x03, 0xCF,
  0xC0, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x1F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x03,
  0xF0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x00,
  0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0x03, 0xF8, 0x20, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xDF, 0xE0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xBF, 0x8F, 0x7D, 0xFF,
  0xFB, 0xE7, 0xFF, 0x9F, 0x1F, 0xF8, 0xF8, 0x7F, 0x87, 0xC0, 0x60, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0xF0, 0x7E, 0x7F, 0xF0, 0xFD, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0x1F, 0xE7, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F,
  0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFF, 0x01, 0xF9, 0xFF, 0x07,
  0xF3, 0xFF, 0xBF, 0xE7, 0xDF, 0xFF, 0x8F, 0x9F, 0xFE, 0x1F, 0x1F, 0xFC,
  0x3E, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xF0, 0xE7, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x3F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF,
  0x3F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x3F, 0xC3, 0xFF, 0x3F, 0x81,
  0xFF, 0x3F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00,
  0xFF, 0x3F, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x1F, 0xE7, 0xFF, 0x1F, 0xFF,
  0xBF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0x3F, 0x03, 0xFC, 0x1F, 0x00, 0x70,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x23, 0xF8, 0x03, 0x1F, 0xF1, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x01, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x0F, 0xFF,
  0xBF, 0x1F, 0xFF, 0xBF, 0x3F, 0xC3, 0xFF, 0x3F, 0x81, 0xFF, 0x3F, 0x00,
  0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x00,
  0xFF, 0x3F, 0x81, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF,
  0x3F, 0x07, 0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0xE0, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x20, 0x00, 0xFC, 0x38, 0x01, 0xFC, 0x3F, 0x1F,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x83, 0xF3, 0xFF, 0x1F, 0xBF, 0xFC, 0xFF, 0xFF,
  0xF7, 0xDF, 0xFF, 0xBF, 0xF1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x7B, 0xFF, 0xFF, 0xFF,
  0xFF, 0x88, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF4, 0xFE,
  0xFF, 0xDF, 0xF3, 0xFE, 0x7F, 0x87, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F,
  0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x0F, 0x8F, 0xFC,
  0x1F, 0xF8, 0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0xBF, 0xFE, 0x7F, 0xFC, 0xFB,
  0xFF, 0xF7, 0xFF, 0xEF, 0xF8, 0xFF, 0xF1, 0xFE, 0xFF, 0x03, 0xFE, 0x07,
  0xEF, 0xE0, 0x3F, 0xC0, 0x7E, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x07, 0xC7, 0xFE, 0x3E, 0x7F, 0xF9, 0xF7, 0xFF,
  0xEF, 0xBF, 0xFF, 0x7F, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xC3, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x01, 0xF1, 0xFF, 0x83, 0xE7,
  0xFF, 0x87, 0xCF, 0xFF, 0x8F, 0xBF, 0xFF, 0x1F, 0xF0, 0x7F, 0x3F, 0xC0,
  0x7E, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF8,
  0x0F, 0xCF, 0xF8, 0x3F, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7E, 0xFF,
  0xF0, 0xFC, 0xFF, 0xE1, 0xF8, 0xFF, 0x03, 0xF0, 0x38, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x0F,
  0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x3F, 0xC3, 0xFF, 0x3F, 0x81, 0xFF, 0x3F,
  0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F,
  0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F,
  0xFF, 0x3F, 0x07, 0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x81, 0xCF, 0xC0,
  0x13, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F,
  0xFE, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x01, 0xC0, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0x7C, 0xFF, 0xF3, 0xE3, 0xFF, 0x1F, 0x0F,
  0xF0, 0xF8, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0xC1, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0xE3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03,
  0xE7, 0xC0, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFD, 0xF8, 0x03, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0x0F, 0xDF, 0x80,
  0x7F, 0xC0, 0x3F, 0x3E, 0x01, 0xFF, 0x00, 0xF8, 0xFC, 0x07, 0xFC, 0x07,
  0xE3, 0xF0, 0x1E, 0xF0, 0x1F, 0x8F, 0xC0, 0x7B, 0xC0, 0x7E, 0x3F, 0x03,
  0xEF, 0x81, 0xF0, 0x7C, 0x0F, 0xBE, 0x07, 0xC1, 0xF8, 0x3E, 0xF8, 0x3F,
  0x07, 0xE0, 0xF3, 0xE0, 0xFC, 0x1F, 0x83, 0xC7, 0x83, 0xF0, 0x7E, 0x1F,
  0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x7C, 0x7E, 0x03, 0xF1, 0xF1, 0xF1, 0xF8,
  0x0F, 0xC7, 0xC7, 0xC7, 0xE0, 0x3F, 0x1E, 0x1F, 0x1F, 0x00, 0x7C, 0xF8,
  0x3C, 0x7C, 0x01, 0xF3, 0xE0, 0xF9, 0xF0, 0x07, 0xCF, 0x83, 0xEF, 0xC0,
  0x1F, 0xBE, 0x0F, 0xBF, 0x00, 0x7E, 0xF0, 0x3E, 0xF8, 0x00, 0xFB, 0xC0,
  0x7B, 0xE0, 0x03, 0xEF, 0x01, 0xEF, 0x80, 0x0F, 0xFC, 0x07, 0xBE, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFD,
  0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3F,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x80,
  0x7F, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE3,
  0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xF7,
  0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x6F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFE, 0xC0, 0x1F, 0xFC, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Medium62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 45, 15, 4, -44 },
  { 41, 18, 16, 25, 3, -44 },
  { 77, 27, 44, 29, 1, -44 },
  { 226, 22, 51, 27, 3, -47 },
  { 367, 39, 46, 43, 2, -45 },
  { 592, 29, 46, 31, 2, -45 },
  { 759, 7, 16, 13, 3, -44 },
  { 773, 14, 55, 18, 3, -45 },
  { 870, 14, 55, 18, 2, -45 },
  { 967, 22, 22, 25, 2, -47 },
  { 1028, 23, 30, 27, 2, -37 },
  { 1115, 9, 15, 14, 2, -7 },
  { 1132, 14, 6, 18, 2, -20 },
  { 1143, 8, 9, 15, 3, -8 },
  { 1152, 22, 45, 24, 1, -45 },
  { 1276, 23, 46, 27, 2, -45 },
  { 1409, 15, 44, 27, 4, -44 },
  { 1492, 22, 45, 27, 2, -45 },
  { 1616, 22, 46, 27, 2, -45 },
  { 1743, 25, 45, 27, 1, -45 },
  { 1884, 22, 45, 27, 3, -44 },
  { 2008, 23, 46, 27, 2, -45 },
  { 2141, 23, 44, 27, 2, -44 },
  { 2268, 23, 46, 27, 2, -45 },
  { 2401, 22, 46, 27, 2, -45 },
  { 2528, 7, 35, 15, 4, -34 },
  { 2559, 9, 42, 15, 2, -34 },
  { 2607, 23, 28, 27, 2, -36 },
  { 2688, 23, 18, 27, 2, -31 },
  { 2740, 24, 28, 27, 2, -36 },
  { 2824, 18, 46, 21, 1, -45 },
  { 2928, 36, 50, 42, 3, -45 },
  { 3153, 29, 44, 29, 0, -44 },
  { 3313, 24, 44, 31, 4, -44 },
  { 3445, 24, 46, 28, 3, -45 },
  { 3583, 26, 44, 33, 4, -44 },
  { 3726, 19, 44, 26, 4, -44 },
  { 3831, 19, 44, 24, 4, -44 },
  { 3936, 28, 46, 34, 3, -45 },
  { 4097, 26, 44, 34, 4, -44 },
  { 4240, 14, 44, 18, 2, -44 },
  { 4317, 13, 56, 15, -3, -44 },
  { 4408, 25, 44, 29, 4, -44 },
  { 4546, 19, 44, 24, 4, -44 },
  { 4651, 37, 44, 46, 4, -44 },
  { 4855, 28, 44, 36, 4, -44 },
  { 5009, 29, 46, 35, 3, -45 },
  { 5176, 22, 44, 28, 4, -44 },
  { 5297, 29, 56, 35, 3, -45 },
  { 5500, 25, 44, 30, 4, -44 },
  { 5638, 22, 46, 26, 2, -45 },
  { 5765, 23, 44, 24, 1, -44 },
  { 5892, 25, 45, 33, 4, -44 },
  { 6033, 29, 44, 29, 0, -44 },
  { 6193, 45, 44, 45, 0, -44 },
  { 6441, 26, 44, 26, 0, -44 },
  { 6584, 26, 44, 26, 0, -44 },
  { 6727, 21, 44, 23, 1, -44 },
  { 6843, 14, 55, 19, 4, -45 },
  { 6940, 22, 45, 24, 1, -45 },
  { 7064, 13, 55, 19, 2, -45 },
  { 7154, 27, 24, 29, 1, -44 },
  { 7235, 27, 4, 27, 0, 5 },
  { 7249, 13, 9, 17, 2, -47 },
  { 7264, 21, 35, 27, 2, -34 },
  { 7356, 23, 48, 29, 4, -47 },
  { 7494, 18, 35, 22, 3, -34 },
  { 7573, 24, 48, 29, 2, -47 },
  { 7717, 21, 35, 27, 3, -34 },
  { 7809, 17, 47, 17, 1, -47 },
  { 7909, 24, 49, 29, 2, -34 },
  { 8056, 21, 47, 29, 4, -47 },
  { 8180, 6, 46, 14, 4, -46 },
  { 8215, 11, 61, 14, -1, -46 },
  { 8299, 22, 47, 26, 4, -47 },
  { 8429, 6, 47, 14, 4, -47 },
  { 8465, 36, 34, 43, 4, -34 },
  { 8618, 21, 34, 29, 4, -34 },
  { 8708, 24, 35, 28, 2, -34 },
  { 8813, 23, 49, 29, 4, -34 },
  { 8954, 24, 49, 29, 2, -34 },
  { 9101, 15, 34, 20, 4, -34 },
  { 9165, 18, 35, 22, 2, -34 },
  { 9244, 15, 42, 17, 1, -41 },
  { 9323, 21, 34, 29, 4, -33 },
  { 9413, 24, 33, 24, 0, -33 },
  { 9512, 38, 33, 39, 0, -33 },
  { 9669, 22, 33, 24, 1, -33 },
  { 9760, 24, 48, 24, 0, -33 },
  { 9904, 18, 33, 20, 1, -33 },
  { 9979, 18, 54, 22, 2, -44 },
  { 10101, 6, 62, 26, 10, -47 },
  { 10148, 18, 54, 22, 2, -44 },
  { 10270, 24, 8, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Medium62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM62PT7B_H_
