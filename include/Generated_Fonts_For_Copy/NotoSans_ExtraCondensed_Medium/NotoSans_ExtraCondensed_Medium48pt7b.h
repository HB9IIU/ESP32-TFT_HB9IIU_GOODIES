#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xEF,
  0xFF, 0xFD, 0xE0, 0xF8, 0xFF, 0xE3, 0xEF, 0x87, 0xBE, 0x1E, 0xF8, 0x7B,
  0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E,
  0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x83,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xC3,
  0x80, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x01,
  0xC3, 0xC0, 0x1E, 0x1E, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xBE, 0xF9,
  0xC1, 0x7C, 0xE0, 0x3C, 0x70, 0x1E, 0x38, 0x0F, 0x1C, 0x07, 0xCE, 0x01,
  0xE7, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0x3E, 0x03, 0x8F, 0x01, 0xC7, 0x80,
  0xE3, 0xC0, 0x71, 0xF0, 0x38, 0xFC, 0x1C, 0xFF, 0xCF, 0xFB, 0xFF, 0xF9,
  0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x02, 0x00, 0xFE, 0x00, 0x70,
  0x03, 0xFC, 0x03, 0xC0, 0x1F, 0xF0, 0x0F, 0x00, 0x71, 0xE0, 0x38, 0x03,
  0xC7, 0x81, 0xE0, 0x0F, 0x0E, 0x07, 0x80, 0x3C, 0x38, 0x1C, 0x00, 0xF0,
  0xF0, 0xF0, 0x03, 0xC3, 0xC3, 0x80, 0x0E, 0x0F, 0x1E, 0x00, 0x38, 0x3C,
  0x78, 0x00, 0xE0, 0xF1, 0xC0, 0x03, 0xC3, 0xCF, 0x00, 0x0F, 0x0E, 0x3C,
  0x7C, 0x3C, 0x38, 0xE3, 0xF8, 0xF1, 0xE7, 0x9F, 0xF1, 0xC7, 0x9E, 0x7B,
  0xC7, 0xFC, 0x73, 0xC7, 0x8F, 0xF3, 0xCF, 0x1E, 0x3F, 0x8F, 0x3C, 0x38,
  0x38, 0x38, 0xF0, 0xE0, 0x01, 0xE3, 0xC3, 0xC0, 0x07, 0x0E, 0x0F, 0x00,
  0x3C, 0x38, 0x3C, 0x00, 0xF0, 0xE0, 0xF0, 0x03, 0x83, 0xC3, 0xC0, 0x1E,
  0x0F, 0x0E, 0x00, 0x78, 0x3C, 0x38, 0x01, 0xC0, 0xF1, 0xE0, 0x0F, 0x03,
  0xC7, 0x80, 0x3C, 0x07, 0x9E, 0x00, 0xE0, 0x1F, 0xF0, 0x07, 0x80, 0x3F,
  0xC0, 0x1C, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0x87,
  0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x78,
  0x00, 0xF8, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xF1,
  0xFF, 0xC3, 0xE3, 0xEF, 0x87, 0xCF, 0x8F, 0x8F, 0x1F, 0x0F, 0xBE, 0x3C,
  0x1F, 0x7C, 0xF8, 0x1F, 0xF9, 0xF0, 0x1F, 0xE3, 0xE0, 0x3F, 0xC7, 0xC0,
  0x3F, 0x0F, 0x80, 0x7E, 0x0F, 0x81, 0xFC, 0x1F, 0x87, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFE, 0xF8, 0x3F, 0xF8, 0xF8, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xE0, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xC3, 0xC2, 0xFB, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E, 0x78, 0x7C, 0x7C,
  0x3C, 0x3E, 0x18, 0x30, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0xF9, 0xF3,
  0xE7, 0xCF, 0x1E, 0x7C, 0xF1, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7B, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0x83, 0xF7, 0xE1, 0xF1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E,
  0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0xF8,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF0,
  0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0xDF, 0xF9, 0xF7,
  0x1F, 0x21, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xEF, 0xE3,
  0x81, 0xF8, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xCF, 0xE3, 0x01, 0xF9, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFB, 0x00, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xDF, 0x00, 0x7B, 0xE0, 0x0E, 0x7C, 0x03, 0xCF, 0x80,
  0x71, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x07,
  0x83, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xF1, 0xE0, 0x3E, 0x3C,
  0x07, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE8, 0x01, 0xF6, 0x03, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC1, 0xFE, 0x20, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC7, 0x83, 0xEF,
  0xF1, 0xEF, 0xFC, 0xF7, 0xFF, 0x7F, 0x1F, 0xBF, 0x07, 0xDF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x78, 0xF8, 0x7C, 0x7F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x3F,
  0x1F, 0x07, 0xC7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xE7,
  0x80, 0xF9, 0xE0, 0x3C, 0x7C, 0x1F, 0x0F, 0x8F, 0x83, 0xF7, 0xE0, 0x7F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x7E, 0x3E,
  0x1F, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBE, 0x03, 0xEF, 0xC1, 0xF9, 0xFD,
  0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x07, 0xF8,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xF7, 0xE3, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x0F, 0x78, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFE, 0xF8, 0xFE, 0x7C, 0x0C, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7B,
  0xEF, 0xFF, 0xFB, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7B, 0xEF, 0xFF, 0xFB, 0xE0, 0x3C, 0xF9, 0xFB, 0xF7, 0xCF,
  0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xCF, 0xBE, 0x7C, 0xF9, 0xE3, 0xC7, 0x9E, 0x3C, 0x78, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xE3, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xC4, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xF8, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E,
  0x3C, 0x0F, 0xF0, 0xE7, 0x81, 0xFF, 0x0E, 0x78, 0x3F, 0xF0, 0xF7, 0x87,
  0x8F, 0x0F, 0x70, 0x78, 0xF0, 0xF7, 0x0F, 0x0F, 0x07, 0xF0, 0xF0, 0xF0,
  0x7F, 0x0F, 0x0F, 0x07, 0xF0, 0xF0, 0xF0, 0x7F, 0x0E, 0x0F, 0x07, 0xF0,
  0xE0, 0xF0, 0xFF, 0x0E, 0x0F, 0x0F, 0xF0, 0xE0, 0xF0, 0xFF, 0x0F, 0x0F,
  0x0F, 0xF0, 0xF1, 0xF0, 0xEF, 0x0F, 0x1B, 0x1E, 0x70, 0x7F, 0xBF, 0xC7,
  0x87, 0xFB, 0xFC, 0x78, 0x3F, 0x1F, 0x87, 0x80, 0x40, 0x40, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x08, 0x00, 0x7E, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9F, 0x00, 0x0F,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF8, 0x01, 0xE1,
  0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xE0, 0x7E, 0x7C, 0x07, 0xEF, 0x80, 0x7D, 0xF0, 0x0F,
  0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x01, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x30, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xF8, 0x3F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80,
  0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07,
  0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x83, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xF9, 0xF8, 0x7F, 0x00, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFD,
  0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xFC, 0x07, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFF, 0xFE, 0xFF, 0xBF, 0xCF,
  0xE0, 0x80, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8,
  0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F,
  0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03,
  0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xDE, 0x00, 0xF7, 0xFE, 0xF0, 0x07, 0xBF, 0xF7,
  0x80, 0x3D, 0xFF, 0x9E, 0x01, 0xEF, 0xFC, 0xF0, 0x1E, 0x7F, 0xE7, 0x80,
  0xF3, 0xFF, 0x3C, 0x07, 0x9F, 0xF8, 0xF0, 0x78, 0xFF, 0xC7, 0x83, 0xC7,
  0xFE, 0x3C, 0x1E, 0x3F, 0xF1, 0xF0, 0xF1, 0xFF, 0x87, 0x8F, 0x0F, 0xFC,
  0x3C, 0x78, 0x7F, 0xE1, 0xE3, 0xC3, 0xFF, 0x07, 0xBC, 0x1F, 0xF8, 0x3D,
  0xE0, 0xFF, 0xC1, 0xEF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0x81,
  0xFF, 0x81, 0xFC, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xE0, 0x7E, 0x03, 0xFF,
  0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xEF, 0x01, 0xFF, 0xBE, 0x07, 0xFE, 0x78, 0x1F, 0xF9, 0xF0, 0x7F, 0xE7,
  0xC1, 0xFF, 0x8F, 0x07, 0xFE, 0x3E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xF1,
  0xFF, 0x83, 0xC7, 0xFE, 0x0F, 0x9F, 0xF8, 0x3E, 0x7F, 0xE0, 0x79, 0xFF,
  0x81, 0xF7, 0xFE, 0x03, 0xDF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFE, 0xFF, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xF8,
  0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07,
  0xE0, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83,
  0xF7, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x0F, 0xFE, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x83, 0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xC1, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x3E,
  0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xE3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xFF, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFE, 0x7C, 0x06, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F,
  0x80, 0x3C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7D, 0xE0,
  0x07, 0xC0, 0x0F, 0x3C, 0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x7C,
  0xF8, 0x07, 0xF0, 0x0F, 0x9F, 0x00, 0xFE, 0x01, 0xF1, 0xE0, 0x1D, 0xC0,
  0x3C, 0x3C, 0x03, 0xB8, 0x0F, 0x87, 0xC0, 0xF7, 0x81, 0xF0, 0xF8, 0x1E,
  0xF0, 0x3E, 0x1F, 0x03, 0xDE, 0x07, 0xC1, 0xE0, 0x7B, 0xC0, 0xF0, 0x3C,
  0x0F, 0x78, 0x3E, 0x07, 0xC3, 0xC7, 0x87, 0xC0, 0xF8, 0x78, 0xF0, 0xF8,
  0x1F, 0x0F, 0x1E, 0x1F, 0x01, 0xE1, 0xE3, 0xC3, 0xC0, 0x3C, 0x3C, 0x78,
  0xF8, 0x07, 0xCF, 0x07, 0x9F, 0x00, 0xF9, 0xE0, 0xF3, 0xE0, 0x1F, 0x3C,
  0x1E, 0x7C, 0x01, 0xE7, 0x83, 0xCF, 0x00, 0x3C, 0xF0, 0x79, 0xE0, 0x07,
  0xBC, 0x07, 0x7C, 0x00, 0xF7, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x03, 0xF3, 0xE0, 0x3E,
  0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x0F,
  0x80, 0xF8, 0xF8, 0x07, 0x9F, 0x00, 0x79, 0xF0, 0x07, 0xDE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x7D, 0xE0, 0x07, 0xDE, 0x00, 0x79, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x8F, 0x00,
  0xF9, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x78,
  0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xE0, 0x3E,
  0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x8F, 0x80, 0x3C,
  0x78, 0x01, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x1E,
  0x07, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7E, 0x10, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7F, 0x9F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0xEF, 0x7F,
  0xEF, 0x7F, 0xCF, 0x3F, 0x8F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x9F, 0xC3, 0xEF, 0xF8, 0xF7, 0xFF, 0x3F, 0xFF,
  0xCF, 0xE1, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03,
  0xEF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0x3D, 0xFF, 0xCF, 0x3F, 0xE3,
  0xC7, 0xF0, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x7E, 0x09, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x13, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0xFE,
  0x7C, 0x7F, 0xDF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE1, 0xFD, 0xF0, 0x3F,
  0x78, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x7F,
  0x3F, 0x7F, 0xCF, 0xFE, 0xF1, 0xFF, 0x3C, 0x3F, 0x8F, 0x07, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x07, 0xEF, 0xC7, 0xC1, 0xF3, 0xE0, 0x79, 0xE0, 0x3D,
  0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x08, 0xFE, 0x7C, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xC8, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xE3,
  0xC7, 0xFC, 0xF3, 0xFF, 0xBC, 0xFF, 0xFF, 0x7E, 0x1F, 0xDF, 0x03, 0xF7,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x3F, 0x7C, 0x0F, 0xDF, 0x07, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xF7, 0xC3, 0xF9, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x60, 0x1F,
  0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x7F, 0x1E,
  0x7F, 0xCF, 0x7F, 0xE7, 0xFF, 0xFB, 0xF8, 0x7D, 0xF8, 0x3E, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xF0, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0x87, 0xDF, 0xEF, 0xF7, 0xF3, 0xF0, 0x40, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x03, 0xFF, 0x03, 0xEF,
  0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8,
  0x3E, 0x78, 0x1F, 0x7C, 0x0F, 0xBC, 0x07, 0xBF, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC7,
  0xC1, 0xE3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x03,
  0xFF, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF1, 0xF8, 0x3F, 0x8F, 0x3F, 0xC7, 0xFC, 0xF7, 0xFE, 0xFF,
  0xEF, 0xFF, 0xEF, 0xFE, 0xFC, 0x3F, 0xC3, 0xEF, 0xC1, 0xF8, 0x1F, 0xF8,
  0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0,
  0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF,
  0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F,
  0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F,
  0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80,
  0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF1, 0xFC, 0x79,
  0xFF, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xE1, 0xF7, 0xE0, 0xFB, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7E, 0x1F, 0x1F, 0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x79,
  0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x87, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0xF1, 0xFC, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xDF,
  0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0,
  0x3E, 0xFC, 0x0F, 0xBF, 0x87, 0xEF, 0xFF, 0xF3, 0xDF, 0xFC, 0xFB, 0xFE,
  0x3E, 0x7F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE3, 0xC7, 0xFC, 0xF3, 0xFF,
  0xBC, 0xFF, 0xFF, 0x7E, 0x1F, 0xDF, 0x03, 0xF7, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7D, 0xE0, 0x3F, 0x7C, 0x0F, 0xDF, 0x07, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xF7, 0xC3, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0xF1, 0xFF, 0x3F, 0xF7,
  0xEF, 0x7E, 0xFF, 0xAF, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x1F,
  0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0x81, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xE1, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xE7, 0x8F,
  0xE3, 0xC0, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x81, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x79, 0xF0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x7D, 0xE0, 0x3F, 0x01, 0xE7,
  0x80, 0xFC, 0x07, 0x9F, 0x03, 0xF0, 0x1E, 0x7C, 0x0F, 0xC0, 0xF8, 0xF0,
  0x7F, 0x83, 0xE3, 0xC1, 0xFE, 0x0F, 0x0F, 0x07, 0xB8, 0x3C, 0x3E, 0x1C,
  0xE1, 0xF0, 0xF8, 0x73, 0x87, 0xC1, 0xE3, 0xCF, 0x1E, 0x07, 0x8F, 0x3C,
  0x78, 0x1E, 0x3C, 0xF1, 0xE0, 0x7C, 0xF1, 0xCF, 0x81, 0xF3, 0x87, 0x3E,
  0x03, 0xDE, 0x1E, 0xF0, 0x0F, 0x78, 0x7B, 0xC0, 0x3D, 0xE1, 0xEF, 0x00,
  0xF7, 0x87, 0xBC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xE0,
  0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0xBC, 0x0F, 0x9F, 0x07,
  0xCF, 0x83, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3E, 0xF8, 0x0F,
  0x78, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0x9F, 0x07, 0xC7,
  0x83, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x0F, 0x7C,
  0x07, 0xC0, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x7C, 0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x7D, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7C,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0xC1, 0xFC,
  0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x0F, 0xF0, 0x3F, 0x80, 0xFC,
  0x03, 0x80, 0x00, 0x3F, 0x80, 0x2F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFD, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 34, 12, 3, -34 },
  { 27, 14, 12, 19, 3, -34 },
  { 48, 21, 34, 23, 1, -34 },
  { 138, 17, 39, 21, 2, -36 },
  { 221, 30, 35, 33, 2, -35 },
  { 353, 23, 35, 24, 1, -35 },
  { 454, 5, 12, 10, 3, -34 },
  { 462, 11, 43, 14, 2, -35 },
  { 522, 11, 43, 14, 1, -35 },
  { 582, 16, 17, 20, 2, -37 },
  { 616, 19, 22, 21, 1, -28 },
  { 669, 7, 11, 11, 2, -5 },
  { 679, 11, 4, 14, 1, -15 },
  { 685, 6, 6, 11, 3, -6 },
  { 690, 17, 34, 18, 1, -34 },
  { 763, 17, 35, 21, 2, -35 },
  { 838, 12, 34, 21, 3, -34 },
  { 889, 17, 35, 21, 2, -35 },
  { 964, 17, 35, 21, 2, -35 },
  { 1039, 19, 34, 21, 1, -34 },
  { 1120, 17, 34, 21, 2, -34 },
  { 1193, 17, 35, 21, 2, -35 },
  { 1268, 18, 34, 21, 1, -34 },
  { 1345, 18, 35, 21, 2, -35 },
  { 1424, 17, 35, 21, 2, -35 },
  { 1499, 6, 26, 11, 3, -26 },
  { 1519, 7, 32, 11, 2, -26 },
  { 1547, 19, 22, 21, 1, -28 },
  { 1600, 19, 14, 21, 1, -24 },
  { 1634, 19, 22, 21, 1, -28 },
  { 1687, 15, 35, 16, 0, -35 },
  { 1753, 28, 39, 32, 2, -35 },
  { 1890, 23, 34, 23, 0, -34 },
  { 1988, 19, 34, 24, 3, -34 },
  { 2069, 19, 35, 22, 2, -35 },
  { 2153, 20, 34, 25, 3, -34 },
  { 2238, 15, 34, 20, 3, -34 },
  { 2302, 15, 34, 19, 3, -34 },
  { 2366, 22, 35, 26, 2, -35 },
  { 2463, 20, 34, 26, 3, -34 },
  { 2548, 12, 34, 14, 1, -34 },
  { 2599, 10, 44, 11, -2, -34 },
  { 2654, 20, 34, 22, 3, -34 },
  { 2739, 15, 34, 18, 3, -34 },
  { 2803, 29, 34, 35, 3, -34 },
  { 2927, 22, 34, 28, 3, -34 },
  { 3021, 23, 35, 27, 2, -35 },
  { 3122, 17, 34, 22, 3, -34 },
  { 3195, 23, 43, 27, 2, -35 },
  { 3319, 19, 34, 23, 3, -34 },
  { 3400, 16, 35, 20, 2, -35 },
  { 3470, 17, 34, 19, 1, -34 },
  { 3543, 20, 34, 26, 3, -34 },
  { 3628, 22, 34, 22, 0, -34 },
  { 3722, 35, 34, 35, 0, -34 },
  { 3871, 20, 34, 20, 0, -34 },
  { 3956, 20, 34, 20, 0, -34 },
  { 4041, 16, 34, 18, 1, -34 },
  { 4109, 11, 43, 15, 3, -35 },
  { 4169, 17, 34, 18, 1, -34 },
  { 4242, 11, 43, 15, 1, -35 },
  { 4302, 21, 19, 22, 1, -34 },
  { 4352, 21, 3, 21, 0, 4 },
  { 4360, 9, 8, 13, 2, -37 },
  { 4369, 16, 26, 21, 2, -26 },
  { 4421, 18, 36, 23, 3, -36 },
  { 4502, 14, 26, 17, 2, -26 },
  { 4548, 18, 36, 23, 2, -36 },
  { 4629, 17, 26, 21, 2, -26 },
  { 4685, 14, 37, 13, 0, -37 },
  { 4750, 18, 38, 23, 2, -26 },
  { 4836, 17, 36, 23, 3, -36 },
  { 4913, 5, 36, 11, 3, -36 },
  { 4936, 9, 48, 11, -1, -36 },
  { 4990, 17, 36, 20, 3, -36 },
  { 5067, 5, 36, 11, 3, -36 },
  { 5090, 28, 26, 34, 3, -26 },
  { 5181, 17, 26, 23, 3, -26 },
  { 5237, 18, 26, 22, 2, -26 },
  { 5296, 18, 38, 23, 3, -26 },
  { 5382, 18, 38, 23, 2, -26 },
  { 5468, 12, 26, 15, 3, -26 },
  { 5507, 13, 26, 17, 2, -26 },
  { 5550, 12, 32, 13, 1, -32 },
  { 5598, 17, 26, 23, 3, -26 },
  { 5654, 19, 26, 19, 0, -26 },
  { 5716, 30, 26, 30, 0, -26 },
  { 5814, 17, 26, 19, 1, -26 },
  { 5870, 19, 38, 19, 0, -26 },
  { 5961, 13, 26, 15, 1, -26 },
  { 6004, 13, 42, 17, 2, -34 },
  { 6073, 4, 48, 20, 8, -37 },
  { 6097, 14, 42, 17, 2, -34 },
  { 6171, 19, 6, 21, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Medium48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM48PT7B_H_
