#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC3, 0xC0, 0xDE, 0xF7, 0xBC, 0x80, 0x12, 0x12, 0x12,
  0x16, 0x7F, 0x34, 0x24, 0x24, 0xFF, 0x24, 0x24, 0x2C, 0x6C, 0x20, 0x87,
  0xF9, 0xA2, 0x8E, 0x1E, 0x2C, 0x92, 0x6B, 0xF8, 0x82, 0x00, 0x61, 0x16,
  0x62, 0x48, 0x49, 0x09, 0x61, 0x2B, 0xAD, 0x53, 0x6B, 0x0B, 0x61, 0x6C,
  0x6D, 0x88, 0xB3, 0x1C, 0x38, 0x1E, 0x19, 0x0C, 0x82, 0xC1, 0xC0, 0xE0,
  0xD3, 0x4D, 0x63, 0x91, 0x8D, 0xE3, 0xD8, 0xFF, 0xC0, 0x32, 0x64, 0xCC,
  0xCC, 0xCC, 0xCC, 0x46, 0x23, 0xC3, 0x08, 0x63, 0x08, 0x42, 0x18, 0x84,
  0x63, 0x11, 0x98, 0x30, 0x8A, 0xFF, 0x73, 0x65, 0x00, 0x30, 0xC3, 0x0C,
  0xFC, 0xC3, 0x0C, 0x30, 0xFE, 0xFF, 0xC0, 0xF0, 0x06, 0x08, 0x30, 0x41,
  0x83, 0x04, 0x18, 0x30, 0x41, 0x82, 0x0C, 0x00, 0x79, 0xEC, 0xF3, 0xCF,
  0x38, 0xE3, 0xCF, 0x3C, 0xFE, 0x78, 0x19, 0xDF, 0xB1, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x80, 0x7B, 0xE8, 0xC3, 0x0C, 0x21, 0x8C, 0x31, 0x8C, 0x3F,
  0xFC, 0xFB, 0xF0, 0xC3, 0x0C, 0x67, 0x07, 0x0C, 0x30, 0xE7, 0xF8, 0x0C,
  0x0C, 0x1C, 0x14, 0x34, 0x24, 0x64, 0x44, 0xC4, 0xFF, 0x04, 0x04, 0x04,
  0xFB, 0xEC, 0x30, 0xC3, 0xEF, 0xC3, 0x0C, 0x30, 0xE6, 0xF8, 0x3D, 0xFC,
  0x30, 0xC2, 0xEC, 0xF3, 0xCF, 0x3C, 0xFB, 0x78, 0xFF, 0xFC, 0x18, 0x30,
  0x41, 0x83, 0x04, 0x18, 0x30, 0xC1, 0x83, 0x00, 0x7B, 0x7C, 0xF3, 0xCD,
  0xE7, 0x37, 0xCE, 0x18, 0xF3, 0x78, 0x73, 0xEC, 0xE3, 0x8E, 0x3C, 0xFF,
  0x0C, 0x30, 0xAE, 0xF0, 0xFC, 0x00, 0xF0, 0xFC, 0x00, 0xFE, 0x02, 0x0C,
  0x39, 0xCE, 0x0E, 0x07, 0x03, 0x02, 0xFF, 0xF0, 0x00, 0xFC, 0x82, 0x0E,
  0x0E, 0x0C, 0x77, 0x30, 0x80, 0x7B, 0xE0, 0xC3, 0x08, 0x63, 0x08, 0x20,
  0x00, 0x1C, 0x30, 0x1E, 0x0C, 0x66, 0x09, 0x13, 0xDE, 0x64, 0x99, 0x26,
  0x49, 0x92, 0x65, 0xBC, 0xDB, 0x00, 0x60, 0x0F, 0xC0, 0x18, 0x0E, 0x07,
  0x06, 0x83, 0x41, 0xB0, 0x98, 0xCC, 0x7E, 0x31, 0x90, 0xD8, 0x6C, 0x38,
  0xF9, 0xFB, 0x1E, 0x3C, 0x79, 0xBF, 0x63, 0xC7, 0x8F, 0x1F, 0xFF, 0xC0,
  0x3E, 0xF9, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x83, 0xA3, 0xC0,
  0xF8, 0xFC, 0xC6, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC,
  0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xB0, 0xC3, 0x0C, 0x3F, 0xFC, 0xFF,
  0xFC, 0x30, 0xC3, 0x0F, 0xBE, 0xC3, 0x0C, 0x30, 0xC0, 0x1E, 0x7F, 0x60,
  0xC0, 0xC0, 0xC0, 0xCF, 0xCF, 0xC3, 0xC3, 0x63, 0x73, 0x3F, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF6,
  0x66, 0x66, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x3E, 0x40, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xF0, 0xF0, 0xF8, 0xC8,
  0xCC, 0xCC, 0xC6, 0xC7, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x3F, 0xFC, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xFF, 0x1F, 0xA2, 0xF6, 0x5E,
  0xDB, 0xCB, 0x79, 0x4F, 0x39, 0xE7, 0x3C, 0x46, 0xE1, 0xE1, 0xE1, 0xF1,
  0xD1, 0xD9, 0xD9, 0xCD, 0xCD, 0xC5, 0xC7, 0xC3, 0xC3, 0x3C, 0x7E, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x76, 0x3C, 0xF9, 0xFB,
  0x16, 0x3C, 0x78, 0xF7, 0x7C, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x3C, 0x7E,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x76, 0x3C, 0x0C,
  0x06, 0x03, 0xF9, 0xFB, 0x1E, 0x3C, 0x79, 0xBF, 0x7C, 0xC9, 0x9B, 0x36,
  0x3C, 0x60, 0x7F, 0xEC, 0x30, 0xC3, 0x87, 0x06, 0x0C, 0x30, 0xFE, 0xF0,
  0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1B, 0x73, 0xC0,
  0xC3, 0xC3, 0x43, 0x62, 0x62, 0x66, 0x26, 0x24, 0x34, 0x3C, 0x1C, 0x18,
  0x18, 0xC2, 0x1E, 0x38, 0xF1, 0xC6, 0x8A, 0x26, 0x53, 0x32, 0x99, 0xB6,
  0xCD, 0xB6, 0x2C, 0xA1, 0xC5, 0x0E, 0x38, 0x71, 0xC1, 0x8E, 0x00, 0xC6,
  0x66, 0x64, 0x2C, 0x3C, 0x18, 0x18, 0x38, 0x3C, 0x2C, 0x66, 0x66, 0xC7,
  0xC7, 0x8D, 0x9B, 0x22, 0xC7, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80,
  0xFF, 0xF0, 0xC3, 0x18, 0x63, 0x0C, 0x21, 0x86, 0x3F, 0xFC, 0xFC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC0, 0x81, 0x81, 0x02, 0x06, 0x04,
  0x0C, 0x18, 0x10, 0x30, 0x60, 0x60, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x7F,
  0x08, 0x18, 0x1C, 0x34, 0x26, 0x62, 0xC3, 0xFF, 0xC8, 0x80, 0x7B, 0xE0,
  0xC3, 0x7F, 0x38, 0xE3, 0xDF, 0xB0, 0xC1, 0x83, 0x06, 0x0D, 0x9F, 0xB1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0xDF, 0x80, 0x3B, 0xF1, 0x8C, 0x63, 0x18,
  0xEB, 0xC0, 0x04, 0x10, 0x41, 0x77, 0xFC, 0xF1, 0x86, 0x1C, 0x73, 0xCD,
  0xD0, 0x71, 0xEC, 0xF3, 0xFF, 0xFC, 0x30, 0xE5, 0xF0, 0x39, 0xD8, 0xC7,
  0xFD, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x77, 0xFC, 0xF1, 0xC6, 0x1C, 0x73,
  0xCD, 0xD0, 0x41, 0x8F, 0xE0, 0xC3, 0x0C, 0x30, 0xDB, 0xFC, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x10, 0xF3, 0xFF, 0xFF, 0xC0, 0x6C, 0x36, 0xDB, 0x6D,
  0xB6, 0xDB, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0xD9, 0xB6, 0x68, 0xF1, 0xF3,
  0x66, 0x4C, 0xD8, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xD9, 0xDF, 0xFB, 0x31,
  0x66, 0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x8C, 0xDB, 0xFC,
  0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x10, 0x79, 0xFB, 0x36, 0x28, 0x50, 0xF1,
  0x66, 0xCC, 0xF0, 0xD9, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xED, 0xFB,
  0x06, 0x0C, 0x18, 0x00, 0x77, 0xFC, 0xF1, 0xC6, 0x1C, 0x73, 0xCD, 0xD0,
  0x41, 0x04, 0x10, 0x9F, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0x7F, 0xA1,
  0x8E, 0x38, 0x63, 0xBF, 0x80, 0x23, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x1A,
  0x70, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCD, 0xD0, 0xC7, 0x8D, 0x13,
  0x66, 0xCD, 0x8A, 0x14, 0x38, 0x70, 0xC6, 0x79, 0xCD, 0x39, 0xB5, 0x26,
  0xA4, 0xD7, 0x9A, 0xF1, 0xCE, 0x31, 0x86, 0x30, 0xC6, 0xD9, 0xB1, 0x43,
  0x87, 0x0E, 0x36, 0x6D, 0x8C, 0xC7, 0x8D, 0x13, 0x66, 0xCD, 0x8A, 0x14,
  0x38, 0x30, 0x41, 0x83, 0x1C, 0x00, 0x7B, 0xC6, 0x23, 0x19, 0x8C, 0x47,
  0xC0, 0x19, 0xD8, 0xC6, 0x31, 0x98, 0xC3, 0x18, 0xC6, 0x30, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0xC6, 0x31, 0x87, 0x3B, 0x18, 0xC6,
  0x33, 0x98, 0x23, 0xFE, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_Medium18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 5, 5, 7, 1, -13 },
  { 9, 8, 13, 9, 0, -13 },
  { 22, 6, 15, 8, 1, -14 },
  { 34, 11, 13, 13, 1, -13 },
  { 52, 9, 13, 9, 0, -13 },
  { 67, 2, 5, 4, 1, -13 },
  { 69, 4, 16, 5, 1, -13 },
  { 77, 5, 16, 5, 0, -13 },
  { 87, 6, 7, 7, 1, -14 },
  { 93, 6, 9, 8, 1, -11 },
  { 100, 2, 4, 4, 1, -2 },
  { 101, 5, 2, 5, 0, -6 },
  { 103, 2, 2, 4, 1, -2 },
  { 104, 7, 13, 7, 0, -13 },
  { 116, 6, 13, 8, 1, -13 },
  { 126, 5, 13, 8, 1, -13 },
  { 135, 6, 13, 8, 1, -13 },
  { 145, 6, 13, 8, 1, -13 },
  { 155, 8, 13, 8, 0, -13 },
  { 168, 6, 13, 8, 1, -13 },
  { 178, 6, 13, 8, 1, -13 },
  { 188, 7, 13, 8, 0, -13 },
  { 200, 6, 13, 8, 1, -13 },
  { 210, 6, 13, 8, 1, -13 },
  { 220, 2, 10, 4, 1, -10 },
  { 223, 2, 12, 4, 1, -10 },
  { 226, 7, 9, 8, 0, -11 },
  { 234, 6, 5, 8, 1, -9 },
  { 238, 6, 9, 8, 1, -11 },
  { 245, 6, 13, 6, 0, -13 },
  { 255, 10, 14, 12, 1, -13 },
  { 273, 9, 13, 9, 0, -13 },
  { 288, 7, 13, 9, 1, -13 },
  { 300, 7, 13, 8, 1, -13 },
  { 312, 8, 13, 10, 1, -13 },
  { 325, 6, 13, 7, 1, -13 },
  { 335, 6, 13, 7, 1, -13 },
  { 345, 8, 13, 10, 1, -13 },
  { 358, 8, 13, 10, 1, -13 },
  { 371, 4, 13, 5, 1, -13 },
  { 378, 4, 17, 4, -1, -13 },
  { 387, 8, 13, 8, 1, -13 },
  { 400, 6, 13, 7, 1, -13 },
  { 410, 11, 13, 13, 1, -13 },
  { 428, 8, 13, 11, 1, -13 },
  { 441, 8, 13, 10, 1, -13 },
  { 454, 7, 13, 8, 1, -13 },
  { 466, 8, 16, 10, 1, -13 },
  { 482, 7, 13, 9, 1, -13 },
  { 494, 6, 13, 7, 1, -13 },
  { 504, 7, 13, 7, 0, -13 },
  { 516, 7, 13, 10, 1, -13 },
  { 528, 8, 13, 8, 0, -13 },
  { 541, 13, 13, 13, 0, -13 },
  { 563, 8, 13, 8, 0, -13 },
  { 576, 7, 13, 7, 0, -13 },
  { 588, 6, 13, 7, 0, -13 },
  { 598, 4, 16, 6, 1, -13 },
  { 606, 7, 13, 7, 0, -13 },
  { 618, 3, 16, 6, 1, -13 },
  { 624, 8, 7, 8, 0, -13 },
  { 631, 8, 1, 8, 0, 2 },
  { 632, 3, 3, 5, 1, -14 },
  { 634, 6, 10, 8, 1, -10 },
  { 642, 7, 14, 9, 1, -14 },
  { 655, 5, 10, 7, 1, -10 },
  { 662, 6, 14, 9, 1, -14 },
  { 673, 6, 10, 8, 1, -10 },
  { 681, 5, 14, 5, 0, -14 },
  { 690, 6, 14, 9, 1, -10 },
  { 701, 6, 14, 8, 1, -14 },
  { 712, 2, 13, 4, 1, -13 },
  { 716, 3, 17, 4, 0, -13 },
  { 723, 7, 14, 8, 1, -14 },
  { 736, 2, 14, 4, 1, -14 },
  { 740, 11, 10, 13, 1, -10 },
  { 754, 6, 10, 8, 1, -10 },
  { 762, 7, 10, 8, 1, -10 },
  { 771, 7, 14, 9, 1, -10 },
  { 784, 6, 14, 9, 1, -10 },
  { 795, 5, 10, 6, 1, -10 },
  { 802, 5, 10, 6, 1, -10 },
  { 809, 5, 12, 5, 0, -12 },
  { 817, 6, 10, 8, 1, -10 },
  { 825, 7, 10, 7, 0, -10 },
  { 834, 11, 10, 11, 0, -10 },
  { 848, 7, 10, 7, 0, -10 },
  { 857, 7, 14, 7, 0, -10 },
  { 870, 5, 10, 6, 0, -10 },
  { 877, 5, 16, 6, 1, -13 },
  { 887, 2, 18, 7, 3, -14 },
  { 892, 5, 16, 6, 1, -13 },
  { 902, 7, 3, 8, 0, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Medium18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM18PT7B_H_
