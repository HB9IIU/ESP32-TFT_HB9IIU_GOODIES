#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF0, 0x00, 0x00, 0x7B, 0xFE, 0xF7, 0x80, 0xF8, 0xFF, 0x8F, 0xF8,
  0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0E, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0xC0, 0x1C, 0x70, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1C, 0x38, 0x07, 0x0E,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xF8,
  0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xBC, 0xC2, 0xF3, 0x03, 0x8C, 0x0E, 0x30,
  0x3C, 0xC0, 0xF3, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0xCF, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0xC0, 0xC7, 0x83,
  0x3F, 0xCF, 0xEF, 0xFF, 0xBF, 0xF8, 0x1F, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x1F, 0xC0, 0x70,
  0x1E, 0xF0, 0x38, 0x0E, 0x38, 0x1C, 0x07, 0x1C, 0x1C, 0x03, 0x8E, 0x0E,
  0x01, 0xC7, 0x8F, 0x00, 0xE3, 0xC7, 0x00, 0x71, 0xE3, 0x80, 0x38, 0xF3,
  0xC0, 0x1C, 0x79, 0xC0, 0x0E, 0x38, 0xE3, 0xC7, 0x1C, 0xE3, 0xF3, 0x8E,
  0x73, 0xFD, 0xEF, 0x39, 0xCE, 0x7F, 0x39, 0xC7, 0x1F, 0x1C, 0xE1, 0xC7,
  0x0E, 0x70, 0xE0, 0x0E, 0x38, 0x70, 0x07, 0x1C, 0x38, 0x07, 0x8E, 0x1C,
  0x03, 0x87, 0x0E, 0x01, 0xC3, 0x87, 0x01, 0xC1, 0xC3, 0x80, 0xE0, 0xE3,
  0xC0, 0x70, 0x39, 0xC0, 0x70, 0x1F, 0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x03,
  0xE0, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3C,
  0x78, 0x03, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x01,
  0xC7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x02, 0x3F, 0xE3, 0xC7, 0xDE, 0x3C, 0x78, 0xF3,
  0xCF, 0x8F, 0x3C, 0xF0, 0x7B, 0xCF, 0x03, 0xF8, 0xF0, 0x3F, 0x8F, 0x01,
  0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF8, 0x7C, 0x7F, 0x87, 0xFF, 0xFC, 0x3F,
  0xF3, 0xE1, 0xFE, 0x1F, 0xFF, 0xFE, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x07,
  0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0,
  0xF0, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x07, 0x39, 0xCF, 0xFF, 0xBF, 0xFF, 0x1F, 0xF9, 0x07, 0xC0,
  0x1D, 0xC0, 0x7B, 0xC1, 0xE3, 0xC3, 0xC7, 0x81, 0x04, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x71, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x7F,
  0x83, 0xFF, 0x0F, 0xFC, 0x7C, 0xF9, 0xE1, 0xEF, 0x07, 0xBC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0x78, 0x79, 0xE1, 0xE7, 0xCF, 0x8F, 0xFC, 0x3F, 0xE0,
  0x3F, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7B, 0xFE, 0x7B,
  0x8F, 0x21, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0x3F, 0xE1, 0xFF, 0xE7,
  0xFF, 0xC7, 0x87, 0xC4, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7, 0x07,
  0xC4, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x81, 0xFE, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3F, 0x00, 0x7F, 0x83, 0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xB8,
  0x03, 0xB8, 0x07, 0x38, 0x07, 0x38, 0x07, 0x78, 0x0E, 0x78, 0x0E, 0x78,
  0x1C, 0x78, 0x1C, 0x78, 0x38, 0x78, 0x38, 0x78, 0x70, 0x78, 0x70, 0x78,
  0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE6, 0x1F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x7B, 0x87, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F,
  0xC0, 0x00, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x70, 0xF7, 0xF3,
  0xFF, 0xEE, 0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xE1, 0xF7, 0xCF,
  0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x3C, 0x3C, 0x3E, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3E, 0x7C, 0x7C, 0x3E, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF0, 0x01, 0x80, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC7,
  0xC7, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0xBE, 0x3F, 0x3F, 0xFE,
  0x7F, 0xBC, 0x7E, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xF1, 0x07, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xBC, 0x3C, 0xF9, 0xF3, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF1, 0xE3, 0xC7, 0x9E, 0x3C,
  0x78, 0xE3, 0xC0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x06, 0x01, 0xFE, 0x3F, 0xF8, 0xFF, 0xE6,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x38,
  0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x0E, 0x0E, 0x70, 0x7F, 0x8E,
  0x70, 0xFF, 0x8E, 0x70, 0xE3, 0x8E, 0xF1, 0xC3, 0x87, 0xE1, 0xC3, 0x87,
  0xE1, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0xC7, 0x87, 0xE3, 0x87, 0x87,
  0xE3, 0x87, 0x87, 0xE3, 0xC7, 0x8E, 0xE3, 0xC7, 0x8E, 0xE1, 0xC7, 0x8E,
  0xE1, 0xED, 0xDC, 0xF0, 0xFD, 0xFC, 0x70, 0xF8, 0xF8, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x40,
  0x0F, 0xC7, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x78, 0x01,
  0xEF, 0x00, 0x3D, 0xE0, 0x07, 0x9C, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x7D, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8,
  0xF0, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF1, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE,
  0x1F, 0x06, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x8E, 0x1F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFC, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1E, 0x3F,
  0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0xFB, 0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x7C, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x81, 0x8F, 0x80, 0x23,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x3D, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x80, 0xF1, 0xF8, 0x7C, 0x3F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x78, 0xFF, 0xFF, 0xF3, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x87, 0xFB, 0xFF, 0xFF, 0xC0, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0xFF, 0xBF,
  0xDF, 0xCF, 0xC0, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0,
  0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF3,
  0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xF7, 0x00, 0xEF,
  0xF7, 0x00, 0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF3, 0x81, 0xCF,
  0xF3, 0x81, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0x8F, 0xF1, 0xC3, 0x8F,
  0xF1, 0xE7, 0x8F, 0xF1, 0xE7, 0x8F, 0xF0, 0xE7, 0x0F, 0xF0, 0xE7, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF7, 0x83, 0xFD, 0xE0, 0xFF, 0x38,
  0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC3, 0xCF,
  0xF0, 0xF3, 0xFC, 0x3C, 0xFF, 0x07, 0xBF, 0xC1, 0xEF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00,
  0xF3, 0xC0, 0x1E, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC,
  0x7E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3,
  0xFE, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x1F,
  0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3E, 0xF0,
  0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0xFC,
  0x7E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF1, 0xFC, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xF1,
  0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0,
  0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0x03,
  0xC0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xE1, 0xCF, 0x80, 0x9E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3D, 0x80, 0xFB,
  0xF7, 0xF7, 0xFF, 0xCF, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7E, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x01, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x3C,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x03, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x1C,
  0x70, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x01, 0xF7, 0x80, 0x78, 0x07,
  0x9E, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x79, 0xE0, 0x3F, 0x01, 0xE7,
  0x80, 0xFC, 0x0F, 0x0F, 0x03, 0xF0, 0x3C, 0x3C, 0x1F, 0xE0, 0xF0, 0xF0,
  0x77, 0x83, 0xC3, 0xC1, 0xCE, 0x0F, 0x0F, 0x07, 0x38, 0x78, 0x1C, 0x1C,
  0xE1, 0xE0, 0x78, 0xF3, 0x87, 0x81, 0xE3, 0xCF, 0x1E, 0x07, 0x8E, 0x1C,
  0x78, 0x1E, 0x38, 0x73, 0xC0, 0x39, 0xE1, 0xCF, 0x00, 0xF7, 0x87, 0x3C,
  0x03, 0xDE, 0x1E, 0xF0, 0x0F, 0x70, 0x3B, 0xC0, 0x3D, 0xC0, 0xEE, 0x00,
  0x77, 0x03, 0xF8, 0x01, 0xDC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0x80, 0xFE, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC1, 0xE1,
  0xE0, 0xF1, 0xE0, 0x38, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF8, 0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x9E, 0x03, 0xCF,
  0x01, 0xEF, 0x80, 0x78, 0xF8, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x81,
  0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x07,
  0x1E, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x3D,
  0xE0, 0x1C, 0x70, 0x1E, 0x3C, 0x0E, 0x0E, 0x0F, 0x07, 0x87, 0x81, 0xC7,
  0x80, 0xF3, 0xC0, 0x3B, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x00, 0x80, 0x7F,
  0xC3, 0xFF, 0x87, 0xFE, 0x10, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0xFF, 0xCF, 0xFF, 0x7F, 0x3D, 0xE0, 0xF7, 0x83, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xDE, 0x1F, 0x7F, 0xDC, 0xFE, 0x71,
  0xF1, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x81, 0xCF, 0xC3, 0xBF, 0xE7, 0x7F,
  0xCF, 0x87, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x3D, 0xE0, 0x7B, 0xE0, 0xF7, 0xE3, 0xEE, 0xFF, 0x9D, 0xFE, 0x39, 0xF8,
  0x00, 0x01, 0x00, 0xFF, 0x3F, 0xF3, 0xFE, 0x7C, 0x27, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC3, 0x3F, 0xF3, 0xFF, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x04, 0x1E, 0x3F, 0x3C, 0xFF, 0x7B, 0xFF, 0xF7, 0x87,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xE0, 0xFB, 0xE3, 0xF7, 0xFF, 0xE7, 0xFB, 0xC7, 0xE3, 0x80, 0x01,
  0x00, 0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x78, 0x79, 0xC0, 0xEF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x06, 0x3F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xE1, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0x06, 0x00, 0x3F, 0x3C, 0xFF, 0x7B, 0xFF, 0xF7, 0xC7,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xE0, 0xFB, 0xE3, 0xF7, 0xFF, 0xE7, 0xFB, 0xC7, 0xE7, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE4, 0x07, 0xCF, 0xFF, 0x1F,
  0xFE, 0x3F, 0xF0, 0x1F, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x83, 0x9F, 0xCE, 0xFF,
  0x3B, 0xFE, 0xF8, 0x7B, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xC0,
  0x23, 0xBF, 0xF7, 0x10, 0x00, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x04, 0x0E, 0x1F, 0x1F,
  0x0E, 0x04, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0xFE, 0xFE, 0xFC,
  0x70, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xFF, 0x07, 0xBC, 0x3C, 0xF0, 0xF3,
  0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xE7, 0x83, 0xBC, 0x0E, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC3, 0xEF, 0x0F, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x1E, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x41, 0xCF,
  0xC3, 0xF3, 0xBF, 0xCF, 0xF7, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xFE, 0x0F,
  0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3E, 0x0F, 0xF0, 0x78, 0x1F, 0xE0, 0xF0,
  0x3F, 0xC1, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xFC, 0x0F, 0x03,
  0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x3F,
  0x81, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xFC, 0x0F, 0x03, 0xF8,
  0x1E, 0x07, 0x80, 0x00, 0x83, 0x9F, 0xCE, 0xFF, 0x3F, 0xFE, 0xF8, 0x7B,
  0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xC0, 0x01, 0x00, 0x3F, 0xC0,
  0xFF, 0xC3, 0xFF, 0xC7, 0xC7, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x79, 0xE0, 0xF3, 0xE3, 0xE3, 0xFF, 0x83,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x81, 0xCF, 0xE3, 0xBF, 0xE7, 0x7F, 0xCF,
  0x87, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3D,
  0xE0, 0x7B, 0xE0, 0xF7, 0xE3, 0xEE, 0xFF, 0x9D, 0xFE, 0x39, 0xF8, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x3F, 0x3C, 0xFF, 0x7B,
  0xFF, 0xF7, 0x87, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFB, 0xE3, 0xF7, 0xFF, 0xE7, 0xFB, 0xC7,
  0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x01, 0xB9, 0xFE, 0xFB,
  0xBE, 0xFF, 0xBE, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x00, 0x02, 0x01, 0xFE, 0x3F, 0xF7, 0xFE, 0x78, 0x2F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xFE, 0x1F, 0xFF, 0xEF, 0xFE, 0x7F, 0x80,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF1, 0x3F, 0xC7, 0xF1, 0xFC, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xF1, 0xFB, 0xFF, 0xF3,
  0xFD, 0xE3, 0xF3, 0xC0, 0xF0, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0xBC, 0x1F, 0x03, 0xDE, 0x0F, 0xC1, 0xEF, 0x07, 0xE0,
  0xF7, 0x83, 0xF0, 0x71, 0xC1, 0xF8, 0x78, 0xF1, 0xDC, 0x3C, 0x78, 0xEF,
  0x1E, 0x3C, 0x73, 0x8E, 0x1E, 0x39, 0xC7, 0x07, 0x1C, 0xE7, 0x83, 0xDE,
  0x73, 0xC1, 0xEE, 0x39, 0xE0, 0xF7, 0x0E, 0xE0, 0x7B, 0x87, 0x70, 0x1D,
  0xC3, 0xF8, 0x0E, 0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x78, 0x1E, 0x7C,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x3C,
  0x3C, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E,
  0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0xFE, 0x0F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0xE0, 0x3C, 0x1F, 0x87, 0xC0, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0xFE, 0x1F,
  0x83, 0xE0, 0x40, 0x00, 0x3F, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF,
  0x80, 0xFE,
};

const GFXglyph NotoSans_ExtraCondensed_Medium41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 29, 10, 2, -29 },
  { 20, 12, 10, 16, 2, -29 },
  { 35, 18, 29, 19, 1, -29 },
  { 101, 14, 33, 18, 2, -31 },
  { 159, 25, 30, 29, 2, -30 },
  { 253, 20, 30, 21, 1, -30 },
  { 328, 5, 10, 9, 2, -29 },
  { 335, 9, 35, 12, 2, -29 },
  { 375, 9, 35, 12, 1, -29 },
  { 415, 15, 14, 17, 1, -31 },
  { 442, 16, 19, 18, 1, -24 },
  { 480, 7, 10, 10, 1, -5 },
  { 489, 10, 4, 12, 1, -13 },
  { 494, 5, 5, 10, 2, -5 },
  { 498, 14, 29, 16, 1, -29 },
  { 549, 14, 30, 18, 2, -30 },
  { 602, 11, 29, 18, 2, -29 },
  { 642, 15, 30, 18, 1, -30 },
  { 699, 15, 30, 18, 1, -30 },
  { 756, 16, 29, 18, 1, -29 },
  { 814, 14, 29, 18, 2, -29 },
  { 865, 14, 30, 18, 2, -30 },
  { 918, 16, 29, 18, 1, -29 },
  { 976, 16, 30, 18, 1, -30 },
  { 1036, 15, 30, 18, 1, -30 },
  { 1093, 5, 22, 10, 2, -22 },
  { 1107, 7, 27, 10, 1, -22 },
  { 1131, 16, 19, 18, 1, -24 },
  { 1169, 16, 11, 18, 1, -20 },
  { 1191, 16, 19, 18, 1, -24 },
  { 1229, 13, 30, 14, 0, -30 },
  { 1278, 24, 33, 28, 2, -30 },
  { 1377, 19, 29, 19, 0, -29 },
  { 1446, 16, 29, 20, 3, -29 },
  { 1504, 16, 30, 19, 2, -30 },
  { 1564, 17, 29, 22, 3, -29 },
  { 1626, 12, 29, 17, 3, -29 },
  { 1670, 12, 29, 16, 3, -29 },
  { 1714, 18, 30, 23, 2, -30 },
  { 1782, 17, 29, 23, 3, -29 },
  { 1844, 10, 29, 12, 1, -29 },
  { 1881, 9, 37, 10, -2, -29 },
  { 1923, 16, 29, 19, 3, -29 },
  { 1981, 12, 29, 16, 3, -29 },
  { 2025, 24, 29, 30, 3, -29 },
  { 2112, 18, 29, 24, 3, -29 },
  { 2178, 19, 30, 23, 2, -30 },
  { 2250, 14, 29, 19, 3, -29 },
  { 2301, 19, 37, 23, 2, -30 },
  { 2389, 16, 29, 20, 3, -29 },
  { 2447, 15, 30, 17, 1, -30 },
  { 2504, 16, 29, 16, 0, -29 },
  { 2562, 16, 29, 22, 3, -29 },
  { 2620, 19, 29, 19, 0, -29 },
  { 2689, 30, 29, 30, 0, -29 },
  { 2798, 17, 29, 17, 0, -29 },
  { 2860, 17, 29, 17, 0, -29 },
  { 2922, 14, 29, 15, 1, -29 },
  { 2973, 9, 36, 13, 3, -29 },
  { 3014, 14, 29, 16, 1, -29 },
  { 3065, 9, 36, 13, 1, -29 },
  { 3106, 17, 16, 19, 1, -29 },
  { 3140, 18, 3, 18, 0, 3 },
  { 3147, 8, 6, 11, 2, -31 },
  { 3153, 14, 23, 18, 1, -23 },
  { 3194, 15, 31, 19, 3, -31 },
  { 3253, 12, 23, 15, 2, -23 },
  { 3288, 15, 31, 19, 2, -31 },
  { 3347, 14, 23, 18, 2, -23 },
  { 3388, 12, 31, 11, 0, -31 },
  { 3435, 15, 33, 19, 2, -23 },
  { 3497, 14, 31, 19, 3, -31 },
  { 3552, 5, 31, 9, 2, -31 },
  { 3572, 8, 41, 9, -1, -31 },
  { 3613, 14, 31, 17, 3, -31 },
  { 3668, 3, 31, 9, 3, -31 },
  { 3680, 23, 23, 29, 3, -23 },
  { 3747, 14, 23, 19, 3, -23 },
  { 3788, 15, 23, 19, 2, -23 },
  { 3832, 15, 33, 19, 3, -23 },
  { 3894, 15, 33, 19, 2, -23 },
  { 3956, 10, 23, 13, 3, -23 },
  { 3985, 12, 23, 14, 1, -23 },
  { 4020, 10, 27, 11, 1, -27 },
  { 4054, 15, 22, 19, 2, -22 },
  { 4096, 16, 22, 16, 0, -22 },
  { 4140, 25, 22, 26, 0, -22 },
  { 4209, 16, 22, 16, 0, -22 },
  { 4253, 16, 32, 16, 0, -22 },
  { 4317, 11, 22, 13, 1, -22 },
  { 4348, 12, 36, 15, 1, -29 },
  { 4402, 3, 41, 17, 7, -31 },
  { 4418, 11, 36, 15, 2, -29 },
  { 4468, 16, 5, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Medium41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM41PT7B_H_
