#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0xD0, 0x29, 0x4A, 0xF5, 0x2B, 0xEA, 0x50, 0x23,
  0xF8, 0xC7, 0x1C, 0xBE, 0x21, 0x00, 0x64, 0x64, 0xA8, 0xA8, 0x6F, 0x75,
  0x15, 0x15, 0x26, 0x21, 0x45, 0x14, 0x61, 0xFD, 0xB6, 0x7C, 0xF0, 0x5A,
  0xAA, 0xB4, 0x89, 0x12, 0x49, 0x6B, 0x00, 0x27, 0xC8, 0xA0, 0x21, 0x3E,
  0x42, 0x10, 0x58, 0xE0, 0xC0, 0x11, 0x12, 0x26, 0x44, 0x80, 0x22, 0x96,
  0x9C, 0xE5, 0x2A, 0x70, 0x2E, 0x92, 0x49, 0x20, 0x66, 0x86, 0x21, 0x10,
  0x88, 0xF8, 0x66, 0x86, 0x26, 0x08, 0x63, 0xF0, 0x11, 0x8C, 0xA5, 0x2B,
  0xE2, 0x10, 0xE8, 0x88, 0xE3, 0x13, 0xE0, 0x33, 0x10, 0x87, 0x65, 0x2B,
  0x70, 0xFF, 0xC4, 0x21, 0x10, 0x84, 0x40, 0x32, 0xD2, 0xA2, 0x2B, 0x39,
  0x70, 0x22, 0xB7, 0x95, 0xB4, 0x42, 0x60, 0xC6, 0x50, 0x05, 0x80, 0x09,
  0xB0, 0xC1, 0x80, 0xF8, 0x01, 0xF0, 0x83, 0x06, 0x6C, 0x00, 0x6B, 0x13,
  0x24, 0x04, 0x40, 0x30, 0x9A, 0x15, 0xEC, 0xBA, 0x6F, 0x56, 0x80, 0xF0,
  0x30, 0xC3, 0x14, 0x59, 0xE7, 0xB2, 0x8C, 0xEB, 0x99, 0xE9, 0x99, 0xF0,
  0x7D, 0x88, 0x88, 0x8C, 0x70, 0xC5, 0xA5, 0x38, 0xCE, 0x72, 0xE0, 0xF2,
  0x4F, 0x24, 0xE0, 0xF2, 0x4F, 0x24, 0x80, 0x36, 0x61, 0x09, 0xC6, 0x39,
  0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xE9, 0x24, 0x92, 0xE0, 0x24,
  0x92, 0x49, 0x27, 0x80, 0x9C, 0xA9, 0x4E, 0x52, 0xD2, 0x98, 0x92, 0x49,
  0x24, 0xE0, 0xC7, 0x8F, 0x1E, 0x5A, 0xB5, 0x6A, 0xD9, 0x92, 0x8E, 0x73,
  0xDA, 0xD6, 0x73, 0x88, 0x66, 0xA3, 0x18, 0xC6, 0x33, 0x70, 0xCB, 0x99,
  0xBE, 0x88, 0x80, 0x66, 0xE3, 0x18, 0xC6, 0x33, 0x70, 0x86, 0xC5, 0xA5,
  0x2F, 0x52, 0x92, 0x98, 0x3A, 0xB0, 0x86, 0x08, 0x72, 0xF0, 0xFF, 0xC8,
  0x42, 0x10, 0x84, 0x20, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xF0, 0x8E, 0x24,
  0x92, 0x59, 0x47, 0x0C, 0x30, 0x88, 0xC4, 0xF6, 0x4A, 0xA5, 0x52, 0xA9,
  0x5C, 0xCC, 0x22, 0x00, 0xCA, 0x94, 0xE2, 0x19, 0x4A, 0xC8, 0x8E, 0xD4,
  0xA7, 0x10, 0x84, 0x20, 0xF1, 0x12, 0x26, 0x44, 0xF0, 0xEA, 0xAA, 0xAC,
  0x84, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x21, 0x9C,
  0x9C, 0x80, 0xF8, 0xC4, 0x25, 0x17, 0xDD, 0x70, 0x88, 0xAF, 0x99, 0x99,
  0xF0, 0x35, 0x4C, 0x44, 0x70, 0x08, 0x4A, 0xB4, 0xE5, 0x29, 0x78, 0x22,
  0x93, 0xF4, 0x21, 0xC0, 0x74, 0x6C, 0x44, 0x44, 0x40, 0x22, 0xD3, 0x94,
  0xA5, 0xE1, 0x9B, 0x80, 0x88, 0xAF, 0x99, 0x99, 0x90, 0xDF, 0x80, 0x51,
  0x55, 0x56, 0x88, 0x9A, 0xAC, 0xAA, 0x90, 0xFF, 0x80, 0x2D, 0xEE, 0x4C,
  0x99, 0x32, 0x64, 0x80, 0x2F, 0x99, 0x99, 0x90, 0x22, 0xD3, 0x94, 0xA5,
  0xC0, 0x2F, 0x99, 0x99, 0xF8, 0x88, 0x22, 0xD3, 0x94, 0xA5, 0xE1, 0x08,
  0x40, 0x3E, 0x49, 0x20, 0x2D, 0xC6, 0x31, 0xE0, 0x4F, 0x24, 0x93, 0x99,
  0x99, 0x9F, 0x9A, 0x94, 0xA6, 0x10, 0x9A, 0xB5, 0xAB, 0x76, 0xCC, 0x80,
  0xD3, 0x88, 0xC5, 0x6C, 0x9A, 0x94, 0xA6, 0x10, 0x8C, 0xC0, 0xF2, 0x64,
  0x4F, 0x12, 0x22, 0x2C, 0x62, 0x22, 0x30, 0xFF, 0xF0, 0x86, 0x22, 0x23,
  0x22, 0x26, 0xC0, 0xEC, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Medium12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 5, 1, -9 },
  { 5, 5, 9, 6, 0, -9 },
  { 11, 5, 10, 5, 0, -9 },
  { 18, 8, 9, 8, 0, -9 },
  { 27, 6, 9, 6, 0, -9 },
  { 34, 1, 4, 3, 1, -9 },
  { 35, 2, 11, 4, 1, -9 },
  { 38, 3, 11, 4, 0, -9 },
  { 43, 5, 4, 5, 0, -9 },
  { 46, 5, 6, 5, 0, -7 },
  { 50, 2, 3, 3, 0, -1 },
  { 51, 3, 1, 3, 0, -4 },
  { 52, 1, 2, 3, 1, -2 },
  { 53, 4, 9, 5, 0, -9 },
  { 58, 5, 9, 5, 0, -9 },
  { 64, 3, 9, 5, 1, -9 },
  { 68, 5, 9, 5, 0, -9 },
  { 74, 5, 9, 5, 0, -9 },
  { 80, 5, 9, 5, 0, -9 },
  { 86, 4, 9, 5, 1, -9 },
  { 91, 5, 9, 5, 0, -9 },
  { 97, 5, 9, 5, 0, -9 },
  { 103, 5, 9, 5, 0, -9 },
  { 109, 5, 9, 5, 0, -9 },
  { 115, 1, 7, 3, 1, -7 },
  { 116, 2, 9, 3, 0, -7 },
  { 119, 5, 5, 5, 0, -7 },
  { 123, 5, 4, 5, 0, -6 },
  { 126, 5, 5, 5, 0, -7 },
  { 130, 4, 9, 4, 0, -9 },
  { 135, 7, 10, 8, 1, -9 },
  { 144, 6, 9, 6, 0, -9 },
  { 151, 4, 9, 6, 1, -9 },
  { 156, 4, 9, 5, 1, -9 },
  { 161, 5, 9, 6, 1, -9 },
  { 167, 3, 9, 5, 1, -9 },
  { 171, 3, 9, 5, 1, -9 },
  { 175, 5, 9, 7, 1, -9 },
  { 181, 5, 9, 7, 1, -9 },
  { 187, 3, 9, 4, 0, -9 },
  { 191, 3, 11, 3, -1, -9 },
  { 196, 5, 9, 6, 1, -9 },
  { 202, 3, 9, 5, 1, -9 },
  { 206, 7, 9, 9, 1, -9 },
  { 214, 5, 9, 7, 1, -9 },
  { 220, 5, 9, 7, 1, -9 },
  { 226, 4, 9, 5, 1, -9 },
  { 231, 5, 11, 7, 1, -9 },
  { 238, 5, 9, 6, 1, -9 },
  { 244, 5, 9, 5, 0, -9 },
  { 250, 5, 9, 5, 0, -9 },
  { 256, 5, 9, 6, 1, -9 },
  { 262, 6, 9, 6, 0, -9 },
  { 269, 9, 9, 9, 0, -9 },
  { 280, 5, 9, 5, 0, -9 },
  { 286, 5, 9, 5, 0, -9 },
  { 292, 4, 9, 5, 0, -9 },
  { 297, 2, 11, 4, 1, -9 },
  { 300, 4, 9, 5, 0, -9 },
  { 305, 3, 11, 4, 0, -9 },
  { 310, 5, 5, 6, 0, -9 },
  { 314, 5, 1, 5, 0, 1 },
  { 315, 3, 2, 3, 0, -9 },
  { 316, 4, 7, 5, 0, -7 },
  { 320, 4, 9, 6, 1, -9 },
  { 325, 4, 7, 4, 0, -7 },
  { 329, 5, 9, 6, 0, -9 },
  { 335, 5, 7, 5, 0, -7 },
  { 340, 4, 9, 3, 0, -9 },
  { 345, 5, 10, 6, 0, -7 },
  { 352, 4, 9, 6, 1, -9 },
  { 357, 1, 9, 3, 1, -9 },
  { 359, 2, 12, 3, 0, -9 },
  { 362, 4, 9, 5, 1, -9 },
  { 367, 1, 9, 3, 1, -9 },
  { 369, 7, 7, 8, 1, -7 },
  { 376, 4, 7, 6, 1, -7 },
  { 380, 5, 7, 6, 0, -7 },
  { 385, 4, 10, 6, 1, -7 },
  { 390, 5, 10, 6, 0, -7 },
  { 397, 3, 7, 4, 1, -7 },
  { 400, 4, 7, 4, 0, -7 },
  { 404, 3, 8, 3, 0, -8 },
  { 407, 4, 6, 6, 1, -6 },
  { 410, 5, 6, 5, 0, -6 },
  { 414, 7, 6, 8, 0, -6 },
  { 420, 5, 6, 5, 0, -6 },
  { 424, 5, 9, 5, 0, -6 },
  { 430, 4, 6, 4, 0, -6 },
  { 433, 4, 11, 4, 0, -9 },
  { 439, 1, 12, 5, 2, -9 },
  { 441, 4, 11, 4, 0, -9 },
  { 447, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Medium12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM12PT7B_H_
