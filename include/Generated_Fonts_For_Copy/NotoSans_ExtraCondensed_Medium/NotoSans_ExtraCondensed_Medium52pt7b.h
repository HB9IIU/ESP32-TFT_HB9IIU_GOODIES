#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0x03,
  0x9F, 0xFF, 0xFF, 0xFF, 0x7C, 0x40, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x7C, 0x1E, 0xF8, 0x3C, 0xF0,
  0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x03, 0xC1,
  0xE0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0x81,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0,
  0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E,
  0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x3C, 0x1C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0,
  0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xDC, 0x71, 0xF3, 0x82, 0x7C, 0x70, 0x0F, 0x8E,
  0x01, 0xF1, 0xC0, 0x3E, 0x38, 0x07, 0xC7, 0x00, 0x7C, 0xE0, 0x0F, 0xDC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xEF, 0xC0, 0x1C, 0xF8, 0x03, 0x8F, 0x80, 0x71,
  0xF0, 0x0E, 0x3E, 0x01, 0xC7, 0xC0, 0x38, 0xFC, 0x07, 0x3E, 0xF0, 0xEF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x3F, 0xE0, 0x0F,
  0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x79, 0xF0, 0x1E, 0x00, 0x78, 0xF0, 0x1E,
  0x00, 0xF0, 0xF0, 0x1E, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x78,
  0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x78, 0xF0,
  0x00, 0xF0, 0x79, 0xE0, 0xF0, 0xF0, 0xF1, 0xE3, 0xF8, 0xF0, 0xF1, 0xE7,
  0xFC, 0x78, 0xF3, 0xC7, 0xFE, 0x79, 0xF3, 0xCF, 0x9E, 0x3F, 0xE3, 0xCF,
  0x1E, 0x3F, 0xE7, 0x8F, 0x0F, 0x1F, 0xC7, 0x8F, 0x0F, 0x06, 0x07, 0x9F,
  0x0F, 0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x0E, 0x1E,
  0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x0F, 0x00, 0x3C, 0x0F, 0x0F, 0x00, 0x3C, 0x0F, 0x0F, 0x00, 0x78, 0x0F,
  0x0F, 0x00, 0x78, 0x0F, 0x1E, 0x00, 0x78, 0x07, 0x9E, 0x00, 0xF0, 0x07,
  0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x70, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x81, 0xF1, 0xFB, 0xE1, 0xF8, 0xF9, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C,
  0x7C, 0x1F, 0x3E, 0x3E, 0x0F, 0xDF, 0x3F, 0x03, 0xFF, 0x1F, 0x80, 0xFF,
  0x8F, 0xC0, 0x7F, 0xC7, 0xE0, 0x1F, 0xC1, 0xF0, 0x0F, 0xE0, 0xF8, 0x07,
  0xF0, 0x7E, 0x07, 0xF8, 0x3F, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xE7, 0xC1, 0xFF, 0xE3, 0xF0, 0x3F, 0xC0, 0xFC, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0x80, 0x03, 0xE0, 0x78, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x20, 0x78, 0x2F, 0x1C, 0x7B, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03,
  0xDF, 0x01, 0xF3, 0xE0, 0xF8, 0xF8, 0x7E, 0x1F, 0x07, 0x07, 0x00, 0x40,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0xFF, 0xFF, 0xFF,
  0xF7, 0x84, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x7E, 0x3F, 0x0F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE3, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xDF,
  0xFC, 0xFB, 0xC7, 0xCC, 0x3E, 0x41, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x01, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x1E,
  0x07, 0xE3, 0x00, 0xF8, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9E, 0x07, 0xE2, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x07,
  0x9F, 0x00, 0x3C, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x01, 0xE1, 0xF0,
  0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF0, 0xE1, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF6, 0x00, 0xFC,
  0xF0, 0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0x80,
  0x02, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x1C, 0x07, 0xCF, 0xF0, 0xFB, 0xFF, 0x1F, 0x7F, 0xF3, 0xFF, 0xFE,
  0x7F, 0x07, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x0F, 0xC7, 0xE3, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x0F, 0x87, 0xE0, 0xFD, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7E,
  0x7E, 0x1F, 0x87, 0xE3, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xEF, 0xC1, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFC, 0x3F, 0x1F, 0x03, 0xE7, 0xE0,
  0x7C, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xFD, 0xF0, 0x3F, 0xBF, 0x0F, 0xE7, 0xFF, 0xBC, 0x7F, 0xF7, 0x87, 0xFC,
  0xF0, 0x7F, 0x3E, 0x01, 0x87, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x08, 0x1F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF,
  0x10, 0x3C, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xCE, 0x0F, 0xD0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x1F,
  0xF0, 0xF1, 0xE0, 0x7F, 0xE1, 0xE3, 0xC1, 0xFF, 0xC3, 0xCF, 0x07, 0xC7,
  0x87, 0x9E, 0x0F, 0x0F, 0x07, 0x3C, 0x3C, 0x1E, 0x0F, 0x78, 0x78, 0x3C,
  0x1E, 0xF0, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0x7F, 0x83, 0xC1, 0xE0,
  0xFF, 0x0F, 0x83, 0xC1, 0xFE, 0x1F, 0x0F, 0x83, 0xFC, 0x1E, 0x1F, 0x07,
  0x78, 0x3C, 0x3E, 0x1E, 0xF0, 0x78, 0x7C, 0x3D, 0xE0, 0xF0, 0xF8, 0x79,
  0xE1, 0xE1, 0xF1, 0xE3, 0xC3, 0xFF, 0xF7, 0xC7, 0x83, 0xFC, 0xFF, 0x0F,
  0x03, 0xF9, 0xFE, 0x1F, 0x03, 0xE1, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0x07, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xDF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xF8, 0x3F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xEF,
  0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7E,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x87, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x0F, 0xCF, 0x80,
  0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF,
  0x80, 0xFE, 0xF8, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF0, 0x30, 0x7F, 0x00, 0x83, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x10, 0x7F, 0x87, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x8F, 0xFC, 0x7C,
  0x0F, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xEF,
  0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x9F, 0x03, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xEF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC,
  0x07, 0x07, 0xE0, 0x02, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x80, 0x3E, 0x3F, 0xC0, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x02, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0xCF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xF8, 0x03,
  0xF7, 0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C,
  0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xF0,
  0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xEF,
  0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F,
  0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x80,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFD, 0xE0, 0x01, 0xEF, 0xF7, 0x80, 0x07, 0xBF, 0xDF, 0x00, 0x1E, 0xFF,
  0x7C, 0x00, 0xFB, 0xFE, 0xF0, 0x03, 0xCF, 0xFB, 0xC0, 0x0F, 0x3F, 0xEF,
  0x80, 0x7D, 0xFF, 0x9E, 0x01, 0xE7, 0xFE, 0x78, 0x07, 0x9F, 0xF9, 0xF0,
  0x1E, 0x7F, 0xE7, 0xC0, 0xF9, 0xFF, 0x8F, 0x03, 0xC7, 0xFE, 0x3C, 0x0F,
  0x1F, 0xF8, 0xF8, 0x7C, 0x7F, 0xE3, 0xE1, 0xF1, 0xFF, 0x87, 0x87, 0x87,
  0xFE, 0x1E, 0x1E, 0x1F, 0xF8, 0x7C, 0xF8, 0x7F, 0xE0, 0xF3, 0xC1, 0xFF,
  0x83, 0xCF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x0F,
  0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0,
  0x1F, 0xF8, 0x07, 0x80, 0x7C, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xF7, 0xC0, 0x3F, 0xEF, 0x80, 0x7F, 0xCF, 0x00,
  0xFF, 0x9F, 0x01, 0xFF, 0xBE, 0x03, 0xFF, 0x3E, 0x07, 0xFE, 0x7C, 0x0F,
  0xFC, 0x7C, 0x1F, 0xF8, 0xF8, 0x3F, 0xF1, 0xF0, 0x7F, 0xE1, 0xF0, 0xFF,
  0xC3, 0xE1, 0xFF, 0x83, 0xE3, 0xFF, 0x07, 0xC7, 0xFE, 0x07, 0xCF, 0xFC,
  0x0F, 0x9F, 0xF8, 0x1F, 0x3F, 0xF0, 0x1F, 0x7F, 0xE0, 0x3E, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x07,
  0xF1, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xF8, 0xFF, 0xBE, 0x07, 0xEF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x0F, 0xEF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB,
  0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF9, 0xFF, 0x8F, 0x81, 0xF8,
  0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80,
  0xF8, 0xF8, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x07,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x01, 0xFF, 0xC1, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xC3, 0xC7, 0xE0, 0x13, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFA, 0x00, 0x3E, 0xC0, 0x1F, 0xBF, 0x1F, 0xCF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x3F, 0x87, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0x9F,
  0x00, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0x00, 0xF9, 0xF0, 0x07, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0xE0, 0x1F, 0x8F, 0x80, 0x7F, 0x80, 0x7C, 0x3E,
  0x01, 0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0xE0,
  0x1F, 0x0F, 0x80, 0xF7, 0xC0, 0xFC, 0x1F, 0x03, 0xCF, 0x03, 0xE0, 0x7C,
  0x0F, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0xF0, 0x3E, 0x07, 0xC1, 0xF3, 0xC0,
  0xF8, 0x1F, 0x07, 0xCF, 0x87, 0xE0, 0x3C, 0x1E, 0x3E, 0x1F, 0x00, 0xF8,
  0x78, 0x78, 0x7C, 0x03, 0xE1, 0xE1, 0xE1, 0xF0, 0x0F, 0x8F, 0x87, 0x87,
  0xC0, 0x3E, 0x3E, 0x1F, 0x3F, 0x00, 0x78, 0xF0, 0x7C, 0xF8, 0x01, 0xF3,
  0xC0, 0xF3, 0xE0, 0x07, 0xCF, 0x03, 0xCF, 0x80, 0x1F, 0x3C, 0x0F, 0x3E,
  0x00, 0x7D, 0xF0, 0x3C, 0xF8, 0x00, 0xF7, 0x80, 0xFF, 0xC0, 0x03, 0xDE,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0,
  0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x7E,
  0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0,
  0x7E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x80, 0x1F, 0x1E,
  0x00, 0x78, 0x7C, 0x03, 0xE0, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xE1, 0xF7, 0xF0, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFF, 0x9F, 0x7E, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFB, 0xDF,
  0xFD, 0xE7, 0xFC, 0xF1, 0xFC, 0x78, 0x10, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x81, 0x00, 0xF8, 0xFE, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0x0F, 0xCF, 0xE0, 0x7C, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0xFE, 0x07, 0xCF,
  0xF0, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF, 0xF8, 0xF9, 0xFF, 0x0F, 0x0F, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x70, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x04, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x02, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFC, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xC1, 0xF0, 0x7F, 0x3E, 0x3F, 0xF7,
  0xC7, 0xFF, 0x79, 0xFF, 0xEF, 0x3F, 0x0F, 0xEF, 0xC0, 0xFD, 0xF0, 0x1F,
  0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD,
  0xF8, 0x1F, 0x9F, 0x07, 0xF3, 0xFF, 0xFE, 0x3F, 0xFB, 0xC7, 0xFE, 0x78,
  0x3F, 0x8F, 0x00, 0x80, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0xBF, 0x0F, 0x83, 0xE7, 0xC0, 0x79, 0xF0, 0x1F, 0x7C,
  0x07, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0x3F,
  0x01, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x03,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xFE, 0x3C, 0x7F, 0xE7, 0x8F,
  0xFE, 0xF3, 0xFF, 0xDE, 0x7E, 0x1F, 0xDF, 0x81, 0xFB, 0xE0, 0x3F, 0x7C,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xF0,
  0x3F, 0x3F, 0x0F, 0xE7, 0xFF, 0xBC, 0x7F, 0xF7, 0x8F, 0xFD, 0xF0, 0x7F,
  0x3E, 0x03, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xA0, 0x03, 0xE7, 0x81, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0xE0, 0xF8, 0xFE, 0x3E,
  0xFF, 0xCF, 0xBF, 0xFB, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0x73, 0xEF, 0xBF, 0xFB, 0xE3, 0x00, 0x00, 0x00, 0x3E, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x07, 0x03, 0xE0, 0xF8, 0x3F, 0x0F,
  0x83, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE1, 0xFB, 0xFE, 0xFF, 0x3F, 0xCF, 0xC0, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0xF8,
  0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x81,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0x7C, 0x0F, 0xE7, 0xC1, 0xF8, 0xF8, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x01, 0x83, 0xC7, 0xF8, 0x3F, 0x8F, 0x3F, 0xF1, 0xFF, 0x3E, 0xFF, 0xCF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x7F, 0xC3, 0xFF, 0xE0, 0xFE, 0x07,
  0xFF, 0x03, 0xF8, 0x1F, 0xFC, 0x07, 0xC0, 0x7F, 0xF0, 0x1F, 0x01, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0,
  0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07,
  0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0,
  0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07,
  0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7C, 0x00,
  0x38, 0x3C, 0x3F, 0x8F, 0x3F, 0xF3, 0xEF, 0xFE, 0xFF, 0xFF, 0xBF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xF0, 0xFC, 0x7E, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x18, 0x0F, 0x0F,
  0xE0, 0xF9, 0xFF, 0x0F, 0xBF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF0, 0xFC, 0xFE,
  0x07, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x03,
  0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xE0, 0x7C, 0xFF, 0x0F, 0xCF, 0xFF,
  0xFC, 0xFB, 0xFF, 0x8F, 0x9F, 0xF0, 0xF8, 0xFE, 0x0F, 0x81, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x3C, 0x7F, 0xE7, 0x8F, 0xFE,
  0xF3, 0xFF, 0xDE, 0x7E, 0x1F, 0xDF, 0x81, 0xFB, 0xE0, 0x3F, 0x7C, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xF0, 0x3F,
  0x3F, 0x0F, 0xE7, 0xFF, 0xBC, 0x7F, 0xF7, 0x8F, 0xFD, 0xF0, 0x7F, 0x3E,
  0x03, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x37, 0x87, 0xFC, 0x7F, 0xE7, 0xFF,
  0xBF, 0xFF, 0xFB, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xEF, 0xFF, 0xDF, 0x03, 0x3E, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x3E, 0xE0, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x00,
  0x40, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x8F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x20, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xF7, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F, 0xFB, 0xCF, 0xFE, 0xF3, 0xFF, 0x3C,
  0x7F, 0x8F, 0x03, 0x00, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03,
  0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC1, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x9F, 0x00,
  0x79, 0xF0, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0x1F, 0x7C,
  0x07, 0xF0, 0x1F, 0x7C, 0x07, 0xF0, 0x1E, 0x7C, 0x07, 0xF0, 0x3E, 0x3C,
  0x0F, 0xF0, 0x3E, 0x3E, 0x0F, 0x70, 0x3E, 0x3E, 0x0F, 0x78, 0x3E, 0x3E,
  0x0F, 0x78, 0x3C, 0x3E, 0x0F, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x7C, 0x1F,
  0x1E, 0x78, 0x7C, 0x1F, 0x1E, 0x3C, 0x78, 0x1F, 0x1E, 0x3C, 0x78, 0x0F,
  0x1E, 0x3C, 0xF8, 0x0F, 0x3C, 0x3C, 0xF8, 0x0F, 0xBC, 0x3C, 0xF8, 0x0F,
  0xBC, 0x3C, 0xF0, 0x0F, 0xBC, 0x1E, 0xF0, 0x07, 0xBC, 0x1F, 0xF0, 0x07,
  0xBC, 0x1F, 0xF0, 0x07, 0xB8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xCF, 0x81, 0xF9,
  0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xFC, 0x7C, 0x0F, 0x8F, 0x81, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xF0, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x00, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xF0, 0x07,
  0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0xFF, 0x83,
  0xF8, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x0F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x13,
  0xFE, 0x01, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 38, 13, 3, -37 },
  { 30, 15, 13, 21, 3, -37 },
  { 55, 23, 37, 25, 1, -37 },
  { 162, 19, 43, 23, 2, -40 },
  { 265, 32, 38, 36, 2, -38 },
  { 417, 25, 39, 26, 1, -38 },
  { 539, 5, 13, 11, 3, -37 },
  { 548, 11, 45, 16, 3, -37 },
  { 610, 12, 45, 16, 1, -37 },
  { 678, 18, 19, 21, 2, -40 },
  { 721, 19, 25, 23, 2, -31 },
  { 781, 8, 13, 12, 2, -6 },
  { 794, 12, 4, 15, 1, -16 },
  { 800, 6, 8, 12, 3, -7 },
  { 806, 18, 37, 20, 1, -37 },
  { 890, 19, 39, 23, 2, -38 },
  { 983, 13, 37, 23, 3, -37 },
  { 1044, 18, 38, 23, 2, -38 },
  { 1130, 18, 39, 23, 2, -38 },
  { 1218, 21, 37, 23, 1, -37 },
  { 1316, 19, 38, 23, 2, -37 },
  { 1407, 19, 39, 23, 2, -38 },
  { 1500, 20, 37, 23, 1, -37 },
  { 1593, 19, 39, 23, 2, -38 },
  { 1686, 19, 39, 23, 2, -38 },
  { 1779, 6, 29, 12, 3, -28 },
  { 1801, 8, 35, 12, 2, -28 },
  { 1836, 20, 23, 23, 1, -30 },
  { 1894, 19, 15, 23, 2, -26 },
  { 1930, 19, 23, 23, 2, -30 },
  { 1985, 15, 39, 17, 1, -38 },
  { 2059, 31, 41, 35, 2, -37 },
  { 2218, 25, 37, 25, 0, -37 },
  { 2334, 20, 37, 26, 4, -37 },
  { 2427, 21, 39, 24, 2, -38 },
  { 2530, 21, 37, 28, 4, -37 },
  { 2628, 15, 37, 21, 4, -37 },
  { 2698, 15, 37, 21, 4, -37 },
  { 2768, 23, 39, 29, 3, -38 },
  { 2881, 21, 37, 29, 4, -37 },
  { 2979, 12, 37, 15, 2, -37 },
  { 3035, 12, 47, 12, -3, -37 },
  { 3106, 21, 37, 24, 4, -37 },
  { 3204, 15, 37, 20, 4, -37 },
  { 3274, 30, 37, 38, 4, -37 },
  { 3413, 23, 37, 31, 4, -37 },
  { 3520, 25, 39, 29, 2, -38 },
  { 3642, 18, 37, 24, 4, -37 },
  { 3726, 25, 47, 29, 2, -38 },
  { 3873, 20, 37, 25, 4, -37 },
  { 3966, 18, 39, 22, 2, -38 },
  { 4054, 19, 37, 21, 1, -37 },
  { 4142, 21, 38, 28, 3, -37 },
  { 4242, 24, 37, 24, 0, -37 },
  { 4353, 38, 37, 38, 0, -37 },
  { 4529, 22, 37, 22, 0, -37 },
  { 4631, 22, 37, 22, 0, -37 },
  { 4733, 18, 37, 20, 1, -37 },
  { 4817, 11, 45, 16, 4, -37 },
  { 4879, 18, 37, 20, 1, -37 },
  { 4963, 11, 45, 16, 2, -37 },
  { 5025, 22, 21, 24, 1, -37 },
  { 5083, 22, 4, 22, 0, 4 },
  { 5094, 10, 8, 15, 2, -40 },
  { 5104, 17, 30, 22, 2, -29 },
  { 5168, 20, 41, 25, 3, -40 },
  { 5271, 16, 30, 19, 2, -29 },
  { 5331, 19, 41, 25, 2, -40 },
  { 5429, 18, 30, 22, 2, -29 },
  { 5497, 15, 40, 14, 0, -40 },
  { 5572, 19, 41, 25, 2, -29 },
  { 5670, 18, 40, 24, 3, -40 },
  { 5760, 6, 39, 11, 3, -39 },
  { 5790, 10, 51, 11, -1, -39 },
  { 5854, 19, 40, 22, 3, -40 },
  { 5949, 5, 40, 11, 3, -40 },
  { 5974, 30, 29, 36, 3, -29 },
  { 6083, 18, 29, 24, 3, -29 },
  { 6149, 20, 30, 24, 2, -29 },
  { 6224, 20, 41, 25, 3, -29 },
  { 6327, 19, 41, 25, 2, -29 },
  { 6425, 13, 29, 16, 3, -29 },
  { 6473, 15, 30, 18, 2, -29 },
  { 6530, 13, 35, 15, 1, -34 },
  { 6587, 18, 29, 24, 3, -28 },
  { 6653, 20, 28, 20, 0, -28 },
  { 6723, 32, 28, 33, 0, -28 },
  { 6835, 19, 28, 20, 1, -28 },
  { 6902, 20, 40, 20, 0, -28 },
  { 7002, 15, 28, 17, 1, -28 },
  { 7055, 14, 45, 19, 2, -37 },
  { 7134, 4, 52, 22, 9, -40 },
  { 7160, 15, 45, 19, 2, -37 },
  { 7245, 20, 7, 23, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Medium52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM52PT7B_H_
