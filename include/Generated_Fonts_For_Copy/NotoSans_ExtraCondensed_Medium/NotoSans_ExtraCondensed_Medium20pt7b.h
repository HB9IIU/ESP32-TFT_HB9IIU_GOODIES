#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0x92, 0x48, 0x2F, 0xC0, 0xCF, 0x3C, 0xF3, 0xCC, 0x1B,
  0x0D, 0x84, 0xC2, 0x47, 0xF8, 0x90, 0xC8, 0x64, 0xFF, 0xFF, 0xC9, 0x84,
  0x82, 0x41, 0x20, 0x10, 0x31, 0xFE, 0x9D, 0x1A, 0x3C, 0x3C, 0x1C, 0x2C,
  0x5C, 0xBF, 0xDF, 0x04, 0x08, 0xF1, 0x8D, 0x18, 0x99, 0x09, 0xB0, 0x9B,
  0x09, 0xA6, 0xD6, 0xF7, 0x5B, 0x05, 0x90, 0xD9, 0x09, 0x91, 0x9B, 0x18,
  0xB1, 0x0E, 0x78, 0x36, 0x13, 0x0D, 0x86, 0xC3, 0xC1, 0xC1, 0xF3, 0xDB,
  0x67, 0xB1, 0xD8, 0xCF, 0xF3, 0xDC, 0xFF, 0xC0, 0x32, 0x66, 0xCC, 0xCC,
  0xCC, 0xCC, 0xC6, 0x63, 0x30, 0xE1, 0x0C, 0x61, 0x0C, 0x63, 0x18, 0xC6,
  0x31, 0x18, 0xCC, 0x60, 0x30, 0x63, 0xF7, 0xF7, 0x9D, 0x92, 0x00, 0x10,
  0x20, 0x40, 0x8F, 0xFF, 0xC4, 0x08, 0x10, 0x20, 0xFB, 0x68, 0xFF, 0x5F,
  0x00, 0x06, 0x0C, 0x10, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x06,
  0x18, 0x00, 0x7C, 0xDB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x67, 0xCF, 0x00, 0x19, 0xDF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0xFD, 0x98, 0x18, 0x30, 0x41, 0x83, 0x0C, 0x38, 0x61, 0x86, 0x0F, 0xFF,
  0xC0, 0xFD, 0x98, 0x18, 0x30, 0xC3, 0x9C, 0x1E, 0x0E, 0x0C, 0x18, 0x7F,
  0xDF, 0x00, 0x06, 0x07, 0x03, 0x83, 0xC1, 0x61, 0xB0, 0x98, 0xCC, 0x46,
  0x7F, 0xFF, 0xE0, 0xC0, 0x60, 0x30, 0xFD, 0x83, 0x06, 0x0C, 0x1F, 0x3F,
  0x07, 0x06, 0x0C, 0x18, 0x7F, 0xDF, 0x00, 0x3C, 0xE1, 0x86, 0x0C, 0x1F,
  0xBF, 0x63, 0xC7, 0x8F, 0x1E, 0x37, 0xC7, 0x80, 0xFF, 0xFC, 0x18, 0x60,
  0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x86, 0x0C, 0x00, 0x7D, 0x9F, 0x1E,
  0x3C, 0xEF, 0x8E, 0x3E, 0xCF, 0x8F, 0x1E, 0x3E, 0xEF, 0x80, 0x79, 0x9B,
  0x1E, 0x3C, 0x78, 0xF3, 0xFF, 0x76, 0x0C, 0x30, 0x6F, 0x9E, 0x00, 0xDF,
  0x00, 0x00, 0x5F, 0x00, 0xDF, 0x00, 0x00, 0x0F, 0x6D, 0x00, 0x02, 0x0C,
  0x73, 0x8C, 0x1C, 0x0E, 0x07, 0x06, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x81, 0x83, 0xC1, 0xE0, 0xE1, 0xCE, 0x70, 0x80, 0xFD, 0x30, 0xC3, 0x0C,
  0x71, 0x8C, 0x30, 0xC0, 0x08, 0x30, 0xC0, 0x1F, 0x83, 0x0C, 0x60, 0x64,
  0x22, 0xCF, 0x2D, 0x93, 0xD9, 0x39, 0x93, 0x9B, 0x29, 0xB2, 0xDF, 0xEC,
  0xCC, 0x40, 0x06, 0x00, 0x3F, 0x80, 0xE0, 0x1C, 0x0E, 0x07, 0x82, 0xC3,
  0x61, 0xB0, 0xCC, 0x66, 0x7F, 0x3F, 0x98, 0x6C, 0x3C, 0x1E, 0x0C, 0xFE,
  0xCE, 0xC3, 0xC3, 0xC3, 0xC6, 0xFC, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE,
  0xFC, 0x08, 0x3F, 0x72, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x7E, 0x3E, 0xFC, 0x67, 0x30, 0xD8, 0x6C, 0x36, 0x0F, 0x07,
  0x83, 0xC3, 0xE1, 0xB0, 0xD8, 0xEF, 0xE7, 0xE0, 0xFF, 0x0C, 0x30, 0xC3,
  0x0F, 0xF0, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0x0F,
  0xFF, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x3F, 0xB8, 0x98, 0x1C, 0x0C, 0x06,
  0x03, 0x1F, 0x8F, 0xC1, 0xE0, 0xF8, 0x6C, 0x37, 0xF8, 0xFC, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0C, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x6F, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3, 0xC6, 0xC6, 0xCC, 0xDC, 0xD8,
  0xF8, 0xF8, 0xEC, 0xCC, 0xC6, 0xC6, 0xC3, 0xC3, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xE0, 0x7F, 0x07, 0xF0, 0x7D,
  0x0F, 0xD8, 0xFD, 0x8F, 0xD8, 0xBC, 0x9B, 0xCD, 0xBC, 0xD3, 0xCF, 0x3C,
  0x73, 0xC7, 0x3C, 0x63, 0xE1, 0xF8, 0xFC, 0x7A, 0x3D, 0x9E, 0xCF, 0x37,
  0x9B, 0xC7, 0xE3, 0x71, 0xB8, 0x7C, 0x3E, 0x0C, 0x3E, 0x39, 0x98, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x6C, 0x77, 0xF1, 0xF0,
  0xFC, 0xCE, 0xC6, 0xC7, 0xC7, 0xC6, 0xC6, 0xFC, 0xF0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x3E, 0x39, 0x98, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x6C, 0x77, 0xF1, 0xF0, 0x18, 0x06, 0x03, 0x80, 0xFC, 0xCE,
  0xC6, 0xC3, 0xC7, 0xC6, 0xFE, 0xFC, 0xCC, 0xCC, 0xC6, 0xC6, 0xC7, 0xC3,
  0x00, 0xFF, 0x96, 0x0C, 0x18, 0x38, 0x3C, 0x1C, 0x18, 0x18, 0x38, 0xDF,
  0xBE, 0x00, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x63, 0x7F, 0x3E, 0xC1, 0xE0, 0xD8, 0x6C, 0x66, 0x33,
  0x18, 0xCC, 0x6C, 0x36, 0x1B, 0x05, 0x83, 0x81, 0xC0, 0xE0, 0xC3, 0x0F,
  0x87, 0x19, 0x0E, 0x33, 0x1C, 0x66, 0x68, 0xCC, 0xD3, 0x19, 0xB6, 0x12,
  0x6C, 0x34, 0xD8, 0x79, 0xB0, 0xF1, 0x41, 0xE3, 0x81, 0x87, 0x03, 0x0E,
  0x00, 0xE3, 0x66, 0x26, 0x36, 0x3C, 0x1C, 0x18, 0x1C, 0x3C, 0x36, 0x36,
  0x66, 0x63, 0xC3, 0xC3, 0x63, 0x66, 0x66, 0x36, 0x3C, 0x3C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x18,
  0x30, 0x61, 0x83, 0x0F, 0xFF, 0xC0, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xF8, 0xC0, 0xC1, 0x81, 0x03, 0x06, 0x06, 0x0C,
  0x08, 0x18, 0x30, 0x20, 0x60, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xF0, 0x0C, 0x0E, 0x07, 0x86, 0xC3, 0x23, 0x19, 0x85, 0x83,
  0xFF, 0x80, 0xC6, 0x30, 0xF9, 0xF0, 0xC3, 0x1F, 0xFC, 0xF3, 0xCF, 0x7F,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE6, 0xFE, 0xDC, 0x3D, 0xEC, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xB7,
  0xC0, 0x06, 0x0C, 0x18, 0x37, 0x6F, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x7D, 0xDE, 0x80, 0x38, 0xFB, 0x1E, 0x3C, 0x7F, 0xF0, 0x60, 0xC0, 0xC8,
  0xF0, 0x3C, 0xD6, 0x18, 0x7B, 0xE6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x00, 0x72, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xDD, 0xF8, 0x30,
  0x70, 0xFF, 0x3C, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xF9, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0x80, 0xF4, 0xFF, 0xFF, 0xFC, 0x6C, 0x86, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6F, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x79, 0xB3, 0x6C,
  0xD9, 0xF3, 0xA6, 0x6C, 0xD8, 0xF1, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xDC,
  0xEF, 0xFE, 0xE6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x30, 0xDD, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x18, 0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xDD, 0xF0,
  0xDC, 0xFE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE6, 0xFE, 0xDC, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x72, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xDD, 0xF8, 0x30, 0x60, 0xC1, 0x83, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0xC6,
  0x30, 0x7F, 0xF1, 0x8E, 0x38, 0xE3, 0x1F, 0xFC, 0x21, 0x1F, 0xF6, 0x31,
  0x8C, 0x63, 0x18, 0xF3, 0x80, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC6, 0xFD, 0xE8, 0xC3, 0xC2, 0x66, 0x66, 0x66, 0x64, 0x2C, 0x3C, 0x3C,
  0x38, 0x18, 0xC6, 0x3C, 0x73, 0x67, 0x36, 0x53, 0x6D, 0x26, 0xD6, 0x29,
  0xE2, 0x9E, 0x39, 0xE3, 0x8C, 0x38, 0xC0, 0xE6, 0x66, 0x6C, 0x3C, 0x3C,
  0x18, 0x3C, 0x3C, 0x6C, 0x66, 0xC7, 0xC3, 0xC6, 0x66, 0x66, 0x66, 0x24,
  0x3C, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x30, 0xF0, 0xE0, 0x7D, 0xF1,
  0x86, 0x18, 0xC3, 0x18, 0x61, 0xFF, 0xC0, 0x39, 0x8C, 0x63, 0x18, 0x8C,
  0xC3, 0x08, 0x63, 0x18, 0xC6, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0x82, 0x08, 0x20, 0x83, 0x0C, 0x1C, 0xC2, 0x08, 0x20, 0x82, 0x18, 0xE0,
  0xF3, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_Medium20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 9, 14, 9, 0, -14 },
  { 27, 7, 16, 9, 1, -15 },
  { 41, 12, 14, 14, 1, -14 },
  { 62, 9, 14, 10, 1, -14 },
  { 78, 2, 5, 4, 1, -14 },
  { 80, 4, 17, 6, 1, -14 },
  { 89, 5, 17, 6, 0, -14 },
  { 100, 7, 7, 8, 1, -15 },
  { 107, 7, 10, 9, 1, -12 },
  { 116, 3, 5, 5, 1, -2 },
  { 118, 4, 2, 6, 1, -6 },
  { 119, 3, 3, 5, 1, -3 },
  { 121, 7, 14, 8, 0, -14 },
  { 134, 7, 14, 9, 1, -14 },
  { 147, 5, 14, 9, 1, -14 },
  { 156, 7, 14, 9, 1, -14 },
  { 169, 7, 14, 9, 1, -14 },
  { 182, 9, 14, 9, 0, -14 },
  { 198, 7, 14, 9, 1, -14 },
  { 211, 7, 14, 9, 1, -14 },
  { 224, 7, 14, 9, 1, -14 },
  { 237, 7, 14, 9, 1, -14 },
  { 250, 7, 14, 9, 1, -14 },
  { 263, 3, 11, 5, 1, -11 },
  { 268, 3, 14, 5, 1, -11 },
  { 274, 7, 9, 9, 1, -12 },
  { 282, 7, 6, 9, 1, -10 },
  { 288, 7, 9, 9, 1, -12 },
  { 296, 6, 14, 7, 0, -14 },
  { 307, 12, 16, 13, 1, -14 },
  { 331, 9, 14, 9, 0, -14 },
  { 347, 8, 14, 10, 1, -14 },
  { 361, 8, 15, 9, 1, -15 },
  { 376, 9, 14, 11, 1, -14 },
  { 392, 6, 14, 8, 1, -14 },
  { 403, 6, 14, 8, 1, -14 },
  { 414, 9, 14, 11, 1, -14 },
  { 430, 9, 14, 11, 1, -14 },
  { 446, 4, 14, 6, 1, -14 },
  { 453, 4, 18, 5, -1, -14 },
  { 462, 8, 14, 9, 1, -14 },
  { 476, 6, 14, 8, 1, -14 },
  { 487, 12, 14, 15, 1, -14 },
  { 508, 9, 14, 12, 1, -14 },
  { 524, 9, 14, 11, 1, -14 },
  { 540, 8, 14, 9, 1, -14 },
  { 554, 9, 17, 11, 1, -14 },
  { 574, 8, 14, 10, 1, -14 },
  { 588, 7, 15, 8, 1, -15 },
  { 602, 8, 14, 8, 0, -14 },
  { 616, 8, 14, 11, 1, -14 },
  { 630, 9, 14, 9, 0, -14 },
  { 646, 15, 14, 15, 0, -14 },
  { 673, 8, 14, 8, 0, -14 },
  { 687, 8, 14, 8, 0, -14 },
  { 701, 7, 14, 8, 0, -14 },
  { 714, 5, 17, 6, 1, -14 },
  { 725, 7, 14, 8, 0, -14 },
  { 738, 4, 17, 6, 1, -14 },
  { 747, 9, 8, 9, 0, -14 },
  { 756, 9, 1, 9, 0, 2 },
  { 758, 4, 3, 6, 1, -15 },
  { 760, 6, 11, 9, 1, -11 },
  { 769, 8, 15, 9, 1, -15 },
  { 784, 6, 11, 7, 1, -11 },
  { 793, 7, 15, 9, 1, -15 },
  { 807, 7, 11, 9, 1, -11 },
  { 817, 6, 15, 5, 0, -15 },
  { 829, 7, 16, 9, 1, -11 },
  { 843, 7, 15, 9, 1, -15 },
  { 857, 2, 15, 4, 1, -15 },
  { 861, 3, 20, 4, 0, -15 },
  { 869, 7, 15, 8, 1, -15 },
  { 883, 2, 15, 4, 1, -15 },
  { 887, 12, 11, 14, 1, -11 },
  { 904, 7, 11, 9, 1, -11 },
  { 914, 7, 11, 9, 1, -11 },
  { 924, 8, 16, 9, 1, -11 },
  { 940, 7, 16, 9, 1, -11 },
  { 954, 5, 11, 6, 1, -11 },
  { 961, 5, 11, 7, 1, -11 },
  { 968, 5, 13, 6, 0, -13 },
  { 977, 7, 11, 9, 1, -11 },
  { 987, 8, 11, 8, 0, -11 },
  { 998, 12, 11, 13, 0, -11 },
  { 1015, 8, 11, 8, 0, -11 },
  { 1026, 8, 16, 8, 0, -11 },
  { 1042, 6, 11, 6, 0, -11 },
  { 1051, 5, 17, 7, 1, -14 },
  { 1062, 2, 20, 8, 3, -15 },
  { 1067, 6, 17, 7, 1, -14 },
  { 1080, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Medium20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM20PT7B_H_
