#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDE, 0xF7, 0xBD, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0x00, 0x01, 0xDF, 0xFF, 0xDC, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xDC, 0x7B, 0x8F, 0x70, 0xEE, 0x18, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x06, 0x1C, 0x06, 0x18, 0x0E, 0x18, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x30,
  0x1C, 0x30, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0x70,
  0x18, 0x70, 0x18, 0x60, 0x38, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1F, 0x83, 0xFF, 0xBF, 0xFB,
  0xF9, 0xDC, 0xC0, 0xE6, 0x07, 0x30, 0x39, 0x81, 0xCC, 0x0F, 0xE0, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x37, 0x81, 0x9E, 0x0C, 0x70, 0x63,
  0x83, 0x1E, 0x19, 0xF8, 0xDE, 0xFF, 0xF7, 0xFF, 0x0F, 0xE0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x04, 0x00, 0x20, 0x3F, 0x01, 0xC0, 0x3F,
  0x01, 0xC0, 0x73, 0x81, 0xC0, 0x73, 0x83, 0x80, 0x71, 0xC3, 0x80, 0x61,
  0xC3, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xC6, 0x00, 0xE1,
  0xCE, 0x00, 0x61, 0xCE, 0x38, 0x71, 0xDC, 0x7C, 0x73, 0x9C, 0xFE, 0x73,
  0x9D, 0xCE, 0x3F, 0x39, 0xC7, 0x1F, 0x39, 0xC7, 0x04, 0x39, 0xC7, 0x00,
  0x71, 0xC7, 0x00, 0x71, 0xC7, 0x00, 0x61, 0xC7, 0x00, 0xE1, 0xC7, 0x00,
  0xE1, 0xC7, 0x01, 0xC1, 0xC7, 0x01, 0xC1, 0xC6, 0x01, 0xC0, 0xEE, 0x03,
  0x80, 0xFE, 0x03, 0x80, 0x7C, 0x01, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x3C,
  0x70, 0x0F, 0x3C, 0x01, 0xCE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0x1E, 0x7B, 0xC7, 0x9E, 0x79, 0xEF, 0x0F, 0x73,
  0xC3, 0xFC, 0xF0, 0x7F, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0xF8, 0x78,
  0x7F, 0x1F, 0xFF, 0xC3, 0xFE, 0x78, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0x77,
  0x77, 0x07, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0,
  0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x70, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xF0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x83, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C,
  0x1E, 0x0E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0x00,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x07, 0x73, 0xBF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x0F, 0xC0, 0xEE, 0x0F, 0x38, 0x71, 0xE1, 0x86, 0x04, 0x20, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0xF3, 0x9E,
  0x79, 0xC7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0x01, 0x00, 0x3F,
  0x81, 0xFF, 0x0F, 0xFC, 0x3C, 0x78, 0xE1, 0xE7, 0x83, 0x9E, 0x0F, 0x78,
  0x3D, 0xC0, 0xF7, 0x03, 0xDC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x03, 0xDC, 0x0F, 0x78, 0x3D, 0xE0, 0xF7,
  0x83, 0x9E, 0x1E, 0x3C, 0x78, 0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0x03, 0xC1,
  0xF0, 0xFC, 0x7F, 0x3F, 0xDE, 0xFF, 0x3D, 0x8F, 0x23, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x02, 0x00, 0x7F, 0x87,
  0xFF, 0x3F, 0xFC, 0x70, 0x78, 0x81, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0xFF,
  0x87, 0xFF, 0x3F, 0xFE, 0x70, 0x78, 0x81, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0xC0, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x6E, 0x01, 0xDC, 0x03,
  0xB8, 0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0x87, 0x07, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x31, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xD8, 0x3E, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0, 0x07, 0xF0, 0xFF,
  0x8F, 0xFC, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x39, 0xF1, 0xDF, 0xCF, 0xFF, 0x7C, 0x7B, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3D, 0xC1, 0xEF, 0x1E,
  0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0x01, 0x00, 0x3F, 0x83, 0xFF, 0x0F, 0xFE,
  0x78, 0x79, 0xE0, 0xF7, 0x03, 0xDC, 0x0F, 0x78, 0x3D, 0xE0, 0xE3, 0xC7,
  0x8F, 0xBC, 0x1F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xFC, 0x3C, 0xF9, 0xE1,
  0xF7, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0x78,
  0x3D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0xFF, 0x83, 0xFF, 0x1E,
  0x1E, 0x78, 0x79, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xDC, 0x0F, 0x78, 0x7D, 0xF1, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x77, 0xFF, 0xFF, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x19, 0xF7, 0xDF, 0x38,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCE, 0x79,
  0xE7, 0x9C, 0x73, 0x80, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0x70, 0x00, 0x80, 0x00, 0x06, 0x03, 0xFC, 0xFF, 0xE7, 0xFE, 0x61,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x3C, 0x07, 0x80, 0x38, 0x1C, 0x00,
  0x70, 0xE0, 0x01, 0xC7, 0x80, 0x03, 0x9C, 0x1F, 0x8E, 0x70, 0xFF, 0x3B,
  0x87, 0x9C, 0x7E, 0x1C, 0x71, 0xF8, 0xE3, 0xC7, 0xE3, 0x8E, 0x1F, 0x8E,
  0x38, 0x7E, 0x38, 0xE1, 0xF8, 0xE3, 0x87, 0xE3, 0x8E, 0x1F, 0x8E, 0x38,
  0x7E, 0x38, 0xE3, 0xB8, 0xE6, 0xCE, 0xE1, 0xFB, 0xF3, 0x87, 0xCF, 0xC7,
  0x06, 0x0C, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x08, 0x07, 0xE3, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x77, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x78, 0x1F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3C, 0xFF,
  0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x3E, 0xE0, 0x7B, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0xBF, 0xFC, 0xFF, 0xC3, 0xFF, 0xCE,
  0x1F, 0xB8, 0x1E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF8, 0x3E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x00,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x3E, 0x08, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x0C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE,
  0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x0F, 0xCE, 0x07, 0xDC, 0x07, 0xB8,
  0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xDC, 0x07, 0xB8, 0x1E, 0x70, 0xFC, 0xFF, 0xF1, 0xFF,
  0xC3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFD, 0xFF,
  0xBF, 0xF7, 0xFE, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x01, 0xFF, 0x03,
  0xFF, 0xE3, 0xFF, 0xE3, 0xF0, 0x31, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x0F, 0x3E, 0x07,
  0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x78, 0xFF, 0xFF,
  0xCF, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x7F, 0x7F, 0xFF, 0xE0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F,
  0xFF, 0xFE, 0xFC, 0x20, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xCF,
  0x0F, 0x1E, 0x3E, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7D, 0xE0, 0xF3, 0xC1,
  0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E, 0x3C, 0x1E, 0x78,
  0x3C, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0x78, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFE, 0xE0, 0x1D, 0xFB, 0x80, 0x77, 0xEE, 0x03, 0xDF, 0xBC, 0x0E,
  0x7E, 0x70, 0x39, 0xF9, 0xC0, 0xE7, 0xE7, 0x87, 0x9F, 0x8E, 0x1C, 0x7E,
  0x38, 0x71, 0xF8, 0xE3, 0xC7, 0xE3, 0xCE, 0x1F, 0x87, 0x38, 0x7E, 0x1C,
  0xE1, 0xF8, 0x77, 0x87, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x81, 0xC0,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xDC, 0x0F, 0xEF, 0x07, 0xF3, 0x83, 0xF9, 0xE1, 0xFC,
  0x70, 0xFE, 0x3C, 0x7F, 0x1E, 0x3F, 0x87, 0x9F, 0xC3, 0xCF, 0xE0, 0xE7,
  0xF0, 0x7B, 0xF8, 0x1D, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xE0, 0x00, 0x80,
  0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x1F, 0x1F, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0xF1, 0xF0, 0x3C, 0x3E, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xE0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC3, 0xEE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0x7F, 0xFB,
  0xFF, 0x9F, 0xF8, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x80, 0x01,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x1F, 0x1F, 0x03, 0xC7, 0x80,
  0xF9, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0xF1, 0xF0, 0x3C, 0x3E, 0x3E, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x1F, 0x8E, 0x0F, 0x9C,
  0x0F, 0x38, 0x1E, 0x70, 0x3C, 0xE0, 0x79, 0xC0, 0xF3, 0x81, 0xE7, 0x07,
  0xCE, 0x1F, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xE3, 0xC1, 0xC3, 0x83,
  0x87, 0x87, 0x0F, 0x0E, 0x0F, 0x1C, 0x1E, 0x38, 0x1E, 0x70, 0x3C, 0xE0,
  0x7D, 0xC0, 0x7B, 0x80, 0xF8, 0x01, 0x00, 0x7F, 0x8F, 0xFE, 0x7F, 0xF7,
  0xC3, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xBF,
  0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x0F, 0x7C, 0x3E, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0xF0, 0x03, 0xF8,
  0x03, 0xDC, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x78, 0xE0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xE1,
  0xC0, 0xF0, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x01,
  0xDE, 0x00, 0xEF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x0E, 0xF0, 0x0F, 0x01, 0xE7, 0x01, 0xF0, 0x1E, 0x78, 0x1F, 0x01,
  0xE7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xC3, 0x81, 0xF8, 0x3C, 0x38,
  0x3B, 0x83, 0xC3, 0xC3, 0xB8, 0x3C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x9C,
  0x38, 0x1C, 0x39, 0xC7, 0x81, 0xC7, 0x9C, 0x78, 0x1E, 0x71, 0xC7, 0x81,
  0xE7, 0x0E, 0x78, 0x1E, 0x70, 0xE7, 0x00, 0xE7, 0x0E, 0xF0, 0x0E, 0xF0,
  0xEF, 0x00, 0xEE, 0x0E, 0xF0, 0x0F, 0xE0, 0xEF, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C,
  0x07, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1C,
  0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x38,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0xFF, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C,
  0x38, 0x1C, 0x78, 0x1C, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF1, 0xE1, 0xE1, 0xC1, 0xC0, 0x0F, 0xC1,
  0xFF, 0x0F, 0xFC, 0x71, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0xFF, 0xCF, 0xFE, 0xF8, 0xF7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xDF, 0xFE, 0xFF, 0x73, 0xF3, 0x80, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF1,
  0xC3, 0xDF, 0xCF, 0xFF, 0xBF, 0x3E, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF1, 0xEF, 0xFF, 0xBD, 0xFC, 0xE3, 0xE0,
  0x0F, 0x83, 0xFC, 0xFF, 0x3E, 0x67, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F,
  0x05, 0xFF, 0x9F, 0xF1, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x1E, 0x3C, 0xFE, 0xF7, 0xFF,
  0xDF, 0x7F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0xE1, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x1C, 0x0F, 0x81, 0xFE, 0x0F,
  0xF8, 0xF1, 0xEF, 0x07, 0x78, 0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x9F, 0xFC, 0x7F, 0xE1, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x7F, 0x8F,
  0x11, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xDF, 0xFB, 0xFF, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x0F,
  0x1C, 0xFE, 0xF7, 0xFF, 0xDF, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE3, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE6, 0x0F, 0x9F, 0xFC,
  0x7F, 0xE0, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF,
  0xBE, 0xF8, 0x7B, 0xE0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x3C, 0x78,
  0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3F, 0xF7, 0xEF, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xC1, 0xEF,
  0x07, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xF9, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC1, 0xCF, 0x07, 0xBC, 0x0E, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE3, 0xC1, 0xF3, 0x9F, 0xCF, 0xEF, 0xFF, 0x7F, 0xBF, 0x3F, 0xDF, 0xF8,
  0x7C, 0x3F, 0xE1, 0xF0, 0xFF, 0x07, 0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x38,
  0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x38, 0x1F,
  0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x38, 0x1F, 0xC0,
  0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x38, 0x1C, 0xE3, 0xE3,
  0x9F, 0xCF, 0xFF, 0xBF, 0xBE, 0xF8, 0x7B, 0xE0, 0xEF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x0F,
  0x80, 0xFF, 0x83, 0xFF, 0x1F, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF, 0x03, 0xB8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x0E, 0xF0, 0x79, 0xE1, 0xE7, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0,
  0xE1, 0xE3, 0x9F, 0xCF, 0xFF, 0xBF, 0x3E, 0xF8, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF1, 0xEF, 0xFF, 0xBD, 0xFC, 0xF3,
  0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x1C, 0xFE, 0xF7, 0xFF, 0xDF, 0x7F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE3,
  0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xE3, 0xF9,
  0xFE, 0x7B, 0xFE, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x87, 0xFD, 0xFF, 0xBC, 0x6F, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xF8, 0x3F, 0xFF, 0x7F, 0xE7, 0xF8, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0xFF,
  0xFF, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0xFE, 0x7F, 0x1F, 0x80, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7B, 0xC7, 0xDF, 0xFE, 0x7F, 0x71, 0xF3, 0x80, 0xF0, 0x1F,
  0xE0, 0x3D, 0xC0, 0x73, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x0E, 0x0E, 0x1C,
  0x3C, 0x3C, 0x78, 0x78, 0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xEF, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x3C, 0x0F, 0x70, 0x3C, 0x0E, 0x70, 0x7C, 0x0E, 0x78,
  0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1C, 0x38, 0x6E, 0x1C, 0x38,
  0xEE, 0x1C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x38, 0x1C,
  0xE7, 0x38, 0x1C, 0xC7, 0x78, 0x1D, 0xC3, 0x78, 0x1F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F,
  0x81, 0xE0, 0x07, 0x81, 0xE0, 0x78, 0x3D, 0xE0, 0xF3, 0x87, 0x8F, 0x1E,
  0x1C, 0x70, 0x7B, 0xC1, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xEE, 0x07, 0xBC, 0x3C, 0x70, 0xF1,
  0xE3, 0x87, 0x9E, 0x0F, 0xF0, 0x3C, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x73,
  0xC1, 0xE7, 0x83, 0xC7, 0x07, 0x0E, 0x0E, 0x1E, 0x3C, 0x3C, 0x78, 0x38,
  0xE0, 0x71, 0xC0, 0xF7, 0x81, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0xFC, 0x1F, 0x87, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x87, 0xE0, 0xF0, 0x1F, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x01,
  0xF8, 0x3F, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x3F, 0x03, 0xC3, 0xF1, 0xF0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x0F, 0xC3, 0xE0, 0xE0, 0x00, 0x3C, 0x03, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xE8, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Medium38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 27, 9, 2, -27 },
  { 18, 11, 10, 15, 2, -27 },
  { 32, 16, 27, 18, 1, -27 },
  { 86, 13, 31, 17, 2, -29 },
  { 137, 24, 28, 26, 1, -28 },
  { 221, 18, 28, 19, 1, -28 },
  { 284, 4, 10, 8, 2, -27 },
  { 289, 8, 33, 11, 2, -27 },
  { 322, 9, 33, 11, 1, -27 },
  { 360, 13, 14, 16, 1, -29 },
  { 383, 15, 18, 17, 1, -22 },
  { 417, 6, 9, 9, 1, -4 },
  { 424, 9, 4, 11, 1, -12 },
  { 429, 5, 5, 9, 2, -5 },
  { 433, 13, 27, 14, 1, -27 },
  { 477, 14, 28, 17, 1, -28 },
  { 526, 10, 27, 17, 2, -27 },
  { 560, 14, 28, 17, 1, -28 },
  { 609, 14, 28, 17, 1, -28 },
  { 658, 15, 27, 17, 1, -27 },
  { 709, 13, 27, 17, 2, -27 },
  { 753, 13, 27, 17, 2, -27 },
  { 797, 14, 27, 17, 1, -27 },
  { 845, 14, 28, 17, 1, -28 },
  { 894, 14, 27, 17, 1, -27 },
  { 942, 5, 21, 9, 2, -21 },
  { 956, 6, 26, 9, 1, -21 },
  { 976, 15, 17, 17, 1, -22 },
  { 1008, 15, 11, 17, 1, -19 },
  { 1029, 15, 17, 17, 1, -22 },
  { 1061, 12, 28, 13, 0, -28 },
  { 1103, 22, 30, 26, 2, -27 },
  { 1186, 18, 27, 18, 0, -27 },
  { 1247, 14, 27, 19, 3, -27 },
  { 1295, 14, 28, 17, 2, -28 },
  { 1344, 15, 27, 20, 3, -27 },
  { 1395, 11, 27, 16, 3, -27 },
  { 1433, 11, 27, 15, 3, -27 },
  { 1471, 17, 28, 21, 2, -28 },
  { 1531, 15, 27, 21, 3, -27 },
  { 1582, 9, 27, 11, 1, -27 },
  { 1613, 8, 35, 9, -2, -27 },
  { 1648, 15, 27, 18, 3, -27 },
  { 1699, 11, 27, 14, 3, -27 },
  { 1737, 22, 27, 28, 3, -27 },
  { 1812, 17, 27, 22, 3, -27 },
  { 1870, 18, 28, 21, 2, -28 },
  { 1933, 13, 27, 17, 3, -27 },
  { 1977, 18, 34, 21, 2, -28 },
  { 2054, 15, 27, 18, 3, -27 },
  { 2105, 13, 28, 16, 1, -28 },
  { 2151, 15, 27, 15, 0, -27 },
  { 2202, 15, 27, 20, 3, -27 },
  { 2253, 17, 27, 17, 0, -27 },
  { 2311, 28, 27, 28, 0, -27 },
  { 2406, 16, 27, 16, 0, -27 },
  { 2460, 16, 27, 16, 0, -27 },
  { 2514, 13, 27, 14, 1, -27 },
  { 2558, 8, 33, 12, 3, -27 },
  { 2591, 13, 27, 14, 1, -27 },
  { 2635, 8, 33, 12, 1, -27 },
  { 2668, 16, 15, 18, 1, -27 },
  { 2698, 16, 3, 16, 0, 3 },
  { 2704, 7, 6, 11, 2, -29 },
  { 2710, 13, 21, 16, 1, -21 },
  { 2745, 14, 29, 18, 2, -29 },
  { 2796, 11, 21, 14, 2, -21 },
  { 2825, 14, 29, 18, 2, -29 },
  { 2876, 13, 21, 16, 2, -21 },
  { 2911, 11, 29, 10, 0, -29 },
  { 2951, 14, 30, 18, 2, -21 },
  { 3004, 14, 29, 18, 2, -29 },
  { 3055, 4, 28, 8, 2, -28 },
  { 3069, 7, 37, 8, -1, -28 },
  { 3102, 14, 29, 16, 2, -29 },
  { 3153, 4, 29, 8, 2, -29 },
  { 3168, 22, 21, 27, 2, -21 },
  { 3226, 14, 21, 18, 2, -21 },
  { 3263, 14, 21, 17, 2, -21 },
  { 3300, 14, 30, 18, 2, -21 },
  { 3353, 14, 30, 18, 2, -21 },
  { 3406, 10, 21, 12, 2, -21 },
  { 3433, 11, 21, 13, 1, -21 },
  { 3462, 9, 25, 11, 1, -25 },
  { 3491, 13, 21, 18, 2, -21 },
  { 3526, 15, 21, 15, 0, -21 },
  { 3566, 24, 21, 24, 0, -21 },
  { 3629, 14, 21, 15, 0, -21 },
  { 3666, 15, 30, 15, 0, -21 },
  { 3723, 10, 21, 12, 1, -21 },
  { 3750, 11, 33, 14, 1, -27 },
  { 3796, 4, 38, 16, 6, -29 },
  { 3815, 10, 33, 14, 2, -27 },
  { 3857, 15, 5, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Medium38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM38PT7B_H_
