#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x5F, 0xF0, 0xE7, 0xC7, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC6, 0x0C, 0xC1, 0x8C, 0x18, 0xC1, 0x8C, 0x18, 0xC1,
  0x98, 0xFF, 0xFF, 0xFF, 0x19, 0x83, 0x18, 0x31, 0x83, 0x18, 0xFF, 0xEF,
  0xFE, 0x33, 0x03, 0x30, 0x33, 0x06, 0x30, 0x63, 0x06, 0x30, 0x04, 0x01,
  0x01, 0xF9, 0xFF, 0x75, 0xB9, 0x0E, 0x43, 0x90, 0xE4, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xC1, 0x70, 0x4C, 0x13, 0x85, 0xFF, 0xEF, 0xF0, 0x30, 0x04,
  0x01, 0x00, 0x40, 0x38, 0x18, 0x3E, 0x0C, 0x3B, 0x8C, 0x18, 0xC6, 0x0C,
  0x63, 0x06, 0x33, 0x03, 0x19, 0x81, 0x8C, 0xC0, 0xC6, 0xCF, 0x77, 0x6F,
  0xDF, 0x76, 0x67, 0x33, 0x30, 0x19, 0x98, 0x1C, 0xCC, 0x0C, 0x66, 0x06,
  0x33, 0x06, 0x19, 0x83, 0x0C, 0xC1, 0x87, 0xE1, 0x81, 0xE0, 0x1E, 0x01,
  0xF8, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC0, 0xCC, 0x07, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x8C, 0xEC, 0xEE, 0x77, 0x71, 0xFB, 0x8F, 0x9C, 0x3C,
  0xE1, 0xE7, 0x9F, 0x1F, 0xDC, 0x7C, 0x70, 0xFB, 0x6D, 0xB0, 0x0E, 0x38,
  0x61, 0xC3, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x30,
  0x60, 0xE1, 0xC1, 0x83, 0x87, 0x07, 0x07, 0xC1, 0x87, 0x0C, 0x38, 0xE1,
  0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x31, 0xC6,
  0x38, 0x1C, 0x03, 0x08, 0xCB, 0xFE, 0xFF, 0xC7, 0x83, 0xE1, 0xDC, 0x73,
  0x88, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x77, 0x76, 0xEE, 0xC0,
  0xFF, 0xFF, 0xC0, 0x5F, 0xF0, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x03, 0x80, 0x1F, 0x0F, 0xC7, 0x39, 0xC6, 0x61,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1D, 0x87, 0x71, 0x9C, 0xE3, 0xF0, 0x7C, 0x0E, 0x3C, 0xFB, 0xFE, 0xF9,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0x3F, 0x3F, 0xEE, 0x39, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0F,
  0xFF, 0xFF, 0x7F, 0x3F, 0xE6, 0x39, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x1F, 0x0F, 0x03, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xF0,
  0xEF, 0xFB, 0xF8, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xDC,
  0x0D, 0xC1, 0x9C, 0x19, 0xC3, 0x9C, 0x31, 0xC7, 0x1C, 0x61, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0x9F, 0xE6,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7F, 0x1F, 0xE0, 0x3C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xF1, 0xEF, 0xFB, 0xF8, 0x0F, 0x87,
  0xE3, 0xC1, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x98, 0xFF, 0xBF, 0xEF, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x87, 0x71, 0xDC, 0xE3, 0xF8, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x3F, 0x1F, 0xE7, 0x3F, 0x87, 0xE1, 0xF8, 0x76, 0x1D, 0xCE, 0x3F, 0x07,
  0x83, 0xF1, 0xCE, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE1, 0xFC, 0x77, 0xF8,
  0xFC, 0x3E, 0x1F, 0xC7, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x77, 0xFD, 0xFF, 0x1D, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xC7,
  0xE1, 0xF0, 0xFF, 0xA0, 0x00, 0x00, 0x2F, 0xF8, 0x77, 0x72, 0x00, 0x00,
  0x00, 0x00, 0x77, 0x76, 0xEE, 0xC0, 0x00, 0x60, 0x3C, 0x1F, 0x0F, 0x87,
  0xC1, 0xE0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x30, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x80,
  0x60, 0x00, 0x7E, 0x7F, 0x99, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x10, 0x1C, 0x0F, 0x07,
  0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0x03, 0x07, 0x00, 0xC3, 0x00, 0x73,
  0x87, 0x19, 0x8F, 0xCC, 0xCE, 0x66, 0xE6, 0x33, 0xF3, 0x19, 0xF1, 0x8C,
  0xF8, 0xCE, 0x7C, 0x67, 0x36, 0x33, 0x9B, 0x99, 0xCC, 0xC7, 0xBC, 0x63,
  0x8C, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x01, 0x01, 0xFF, 0x80, 0x3F, 0x80,
  0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x06, 0xE0, 0x77, 0x03,
  0x98, 0x18, 0xC0, 0xC7, 0x0E, 0x38, 0x71, 0xC3, 0xFE, 0x1F, 0xF9, 0xC1,
  0xCE, 0x0E, 0x70, 0x73, 0x81, 0xF8, 0x0F, 0xC0, 0x70, 0xFF, 0x1F, 0xF3,
  0x8F, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xFF, 0x9F, 0xC3, 0xFE,
  0x70, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xDC, 0x7B, 0xFE, 0x7F,
  0x80, 0x0F, 0xE3, 0xFC, 0xF1, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x8C, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xF8, 0xE7, 0xCE, 0x1C, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x07, 0xF0, 0xFF, 0xCF, 0x0C, 0x70, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xF8, 0x7F, 0xC3, 0xF6, 0x03,
  0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x38, 0x39, 0xE1, 0xC7, 0xFE, 0x1F, 0xE0,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x30, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73,
  0xBE, 0xF1, 0x00, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xCE, 0x79, 0xCE, 0x3B,
  0x87, 0x70, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0E, 0x71, 0xCE, 0x38, 0xE7,
  0x1C, 0xE1, 0xDC, 0x3B, 0x87, 0xF0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFD,
  0x81, 0xFF, 0xC0, 0xDF, 0xF0, 0x6F, 0xD8, 0x37, 0xEC, 0x3B, 0xF7, 0x19,
  0xFB, 0x8C, 0xFC, 0xCE, 0x7E, 0x67, 0x3F, 0x3B, 0x1F, 0x9D, 0x8F, 0xC7,
  0xC7, 0xE3, 0xC3, 0xF1, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x70, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x83, 0xD8, 0x3F, 0xC3, 0xFC, 0x3E, 0xE3, 0xEE, 0x3E,
  0x63, 0xE7, 0x3E, 0x33, 0xE3, 0xBE, 0x3B, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0x0F, 0xC0, 0xFF, 0x0F, 0x3C, 0xF0, 0xE7, 0x03,
  0xB8, 0x1D, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xB0, 0x1D, 0xC0, 0xEE, 0x07, 0x78, 0x71, 0xE7, 0x87, 0xF8, 0x1F,
  0x80, 0xFE, 0x3F, 0xCE, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xEF, 0xFB, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x0F, 0xC0, 0xFF, 0x0F, 0x3C, 0xF0, 0xE7, 0x03, 0xB8, 0x1D,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB0,
  0x1D, 0xC0, 0xEE, 0x07, 0x78, 0x71, 0xE7, 0x87, 0xF8, 0x1F, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0xFE, 0x1F, 0xF3, 0xBE, 0x71,
  0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0x9F, 0xF3, 0xFC, 0x7F, 0x0E,
  0x71, 0xCE, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0x3B, 0x87, 0x70, 0x70, 0x3F,
  0xDF, 0xE7, 0xBB, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x81,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x83, 0xB9, 0xEF, 0xF3, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xEE, 0x39, 0xFF, 0x1F, 0xC0, 0xE0, 0x3F, 0x01, 0xD8,
  0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x38, 0xC1, 0x86, 0x1C, 0x38, 0xE1, 0xC7,
  0x06, 0x30, 0x33, 0x81, 0xDC, 0x0E, 0xE0, 0x36, 0x01, 0xB0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0xF0,
  0x76, 0x0F, 0x07, 0x70, 0xF0, 0x77, 0x0F, 0x8E, 0x70, 0xD8, 0xE7, 0x1D,
  0x8E, 0x31, 0xD8, 0xE3, 0x99, 0x8C, 0x39, 0x9C, 0xC3, 0x99, 0xDC, 0x1B,
  0x8D, 0xC1, 0xB8, 0xDC, 0x1B, 0x0D, 0x81, 0xF0, 0xD8, 0x1F, 0x0D, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x70, 0xE7, 0x0E, 0x30, 0xC3,
  0x9C, 0x39, 0xC1, 0x98, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x81, 0xF8, 0x39, 0x83, 0x9C, 0x31, 0xC7, 0x0E, 0x70, 0xEE,
  0x07, 0xE0, 0x76, 0x0E, 0x70, 0xE7, 0x0C, 0x31, 0xC3, 0x9C, 0x39, 0x81,
  0xB8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x83, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x1F, 0x00, 0xD8, 0x0E, 0xE0, 0x63, 0x07, 0x1C, 0x30, 0x63, 0x83, 0xB8,
  0x0E, 0xFF, 0xFF, 0xFF, 0xF1, 0xC3, 0x87, 0x7F, 0x3F, 0xC8, 0xE0, 0x30,
  0x18, 0x0C, 0xFE, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0xFD, 0xF6,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xF3, 0x7E, 0xF3, 0xB8,
  0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7F, 0x3B,
  0x7E, 0xCF, 0x00, 0x1F, 0x9F, 0x9C, 0x4E, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x0E, 0x07, 0x09, 0xF8, 0x7C, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xCF, 0xBB, 0xFF, 0x71, 0xEC, 0x3F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEC, 0x3D, 0xC7, 0xBF, 0xF3,
  0xEE, 0x3F, 0x0F, 0xE7, 0x19, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0,
  0x38, 0x0E, 0x01, 0x80, 0x70, 0x8F, 0xE1, 0xF8, 0x1F, 0x1F, 0x38, 0x38,
  0x38, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3E, 0xEF, 0xFD, 0xC7, 0xB0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB0, 0xF7, 0x1E, 0xFF,
  0xCF, 0xB8, 0x07, 0x00, 0xC0, 0x19, 0x07, 0x3F, 0xC7, 0xF8, 0x3C, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x7D, 0xBF, 0xF3, 0xF0, 0xF8,
  0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18,
  0xDF, 0xA0, 0x36, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x31, 0xCE, 0x20, 0x00,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x77,
  0xBD, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x3B, 0x0E,
  0xC7, 0x33, 0x8C, 0xE3, 0x70, 0xDC, 0x3F, 0x0E, 0xE3, 0x98, 0xC7, 0x31,
  0xCC, 0x3B, 0x0E, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xDF,
  0x3E, 0xFF, 0xFE, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xC1, 0x87, 0xC1,
  0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1,
  0x87, 0xC1, 0x87, 0xC1, 0x87, 0xDF, 0x6F, 0xFC, 0xFC, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x3F, 0x0F,
  0xF1, 0xC7, 0x30, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0x30, 0xE7, 0x1C, 0x7F, 0x07, 0xC0, 0xDF, 0x37, 0xEE, 0x3B, 0x87,
  0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xB7,
  0xEC, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x3E,
  0xEF, 0xFD, 0xC7, 0xB0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xB0, 0xF7, 0x1E, 0xFF, 0xCF, 0xB8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0xDF, 0xBB, 0xEF, 0x0E, 0x1C, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x00, 0x7F, 0xFF, 0xE2, 0xC0,
  0xE0, 0xF0, 0x78, 0x3E, 0x1E, 0x07, 0x07, 0x07, 0x87, 0xFE, 0xFC, 0x18,
  0x70, 0xE3, 0xFF, 0xE7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x3E, 0x3C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xFC, 0x7E, 0x7F, 0xFD, 0xF6, 0xE0, 0xEC, 0x19, 0x83,
  0x38, 0xE7, 0x1C, 0x63, 0x0C, 0x61, 0xDC, 0x3B, 0x83, 0x60, 0x6C, 0x0D,
  0x81, 0xF0, 0x1C, 0x03, 0x80, 0xE1, 0xC1, 0xB0, 0xF1, 0xD8, 0x78, 0xEE,
  0x3C, 0x77, 0x36, 0x33, 0x9B, 0x18, 0xCD, 0xDC, 0x66, 0x6E, 0x3B, 0x36,
  0x1F, 0x9B, 0x0F, 0x8D, 0x83, 0xC7, 0xC1, 0xE3, 0xE0, 0xF0, 0xE0, 0x78,
  0x70, 0xF1, 0xCE, 0x38, 0xC6, 0x1D, 0xC1, 0xB0, 0x3E, 0x03, 0x80, 0x70,
  0x1F, 0x03, 0xE0, 0xEE, 0x1D, 0xC7, 0x18, 0xE3, 0xB8, 0x38, 0xE0, 0xEC,
  0x19, 0xC3, 0x38, 0xE7, 0x1C, 0x63, 0x0C, 0x61, 0xDC, 0x3B, 0x83, 0x60,
  0x6C, 0x0F, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x3C, 0x07, 0x80, 0xC0, 0x00, 0xFF, 0xFC, 0x38, 0x61, 0xC3, 0x8E, 0x1C,
  0x30, 0xE1, 0xC7, 0x0E, 0x1F, 0xFF, 0x80, 0x07, 0x1F, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF0, 0xE0, 0x78, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x1C, 0x0F, 0x0F, 0x1E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0xF8, 0xF0, 0x70, 0x3F, 0x8F, 0x7F, 0xC3, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 8, 7, 11, 2, -20 },
  { 16, 12, 20, 13, 1, -20 },
  { 46, 10, 23, 12, 1, -21 },
  { 75, 17, 20, 19, 1, -20 },
  { 118, 13, 20, 14, 1, -20 },
  { 151, 3, 7, 6, 2, -20 },
  { 154, 7, 24, 8, 1, -20 },
  { 175, 6, 24, 8, 1, -20 },
  { 193, 10, 10, 12, 1, -21 },
  { 206, 10, 14, 12, 1, -17 },
  { 224, 4, 7, 7, 1, -3 },
  { 228, 6, 3, 8, 1, -9 },
  { 231, 3, 4, 7, 2, -4 },
  { 233, 10, 20, 11, 0, -20 },
  { 258, 10, 20, 12, 1, -20 },
  { 283, 7, 20, 12, 2, -20 },
  { 301, 10, 20, 12, 1, -20 },
  { 326, 10, 20, 12, 1, -20 },
  { 351, 12, 20, 12, 0, -20 },
  { 381, 10, 20, 12, 1, -20 },
  { 406, 10, 20, 12, 1, -20 },
  { 431, 10, 20, 12, 1, -20 },
  { 456, 10, 20, 12, 1, -20 },
  { 481, 10, 20, 12, 1, -20 },
  { 506, 3, 15, 7, 2, -15 },
  { 512, 4, 19, 7, 1, -15 },
  { 522, 11, 12, 12, 1, -16 },
  { 539, 10, 8, 12, 1, -14 },
  { 549, 11, 12, 12, 1, -16 },
  { 566, 9, 20, 9, 0, -20 },
  { 589, 17, 22, 19, 1, -20 },
  { 636, 13, 20, 13, 0, -20 },
  { 669, 11, 20, 14, 2, -20 },
  { 697, 11, 20, 13, 1, -20 },
  { 725, 12, 20, 15, 2, -20 },
  { 755, 8, 20, 12, 2, -20 },
  { 775, 8, 20, 11, 2, -20 },
  { 795, 13, 20, 15, 1, -20 },
  { 828, 11, 20, 15, 2, -20 },
  { 856, 6, 20, 8, 1, -20 },
  { 871, 6, 26, 7, -1, -20 },
  { 891, 11, 20, 13, 2, -20 },
  { 919, 8, 20, 11, 2, -20 },
  { 939, 17, 20, 21, 2, -20 },
  { 982, 12, 20, 16, 2, -20 },
  { 1012, 13, 20, 16, 1, -20 },
  { 1045, 10, 20, 13, 2, -20 },
  { 1070, 13, 25, 16, 1, -20 },
  { 1111, 11, 20, 13, 2, -20 },
  { 1139, 10, 20, 12, 1, -20 },
  { 1164, 11, 20, 11, 0, -20 },
  { 1192, 11, 20, 15, 2, -20 },
  { 1220, 13, 20, 13, 0, -20 },
  { 1253, 20, 20, 20, 0, -20 },
  { 1303, 12, 20, 12, 0, -20 },
  { 1333, 12, 20, 12, 0, -20 },
  { 1363, 9, 20, 11, 1, -20 },
  { 1386, 6, 24, 9, 2, -20 },
  { 1404, 10, 20, 11, 0, -20 },
  { 1429, 6, 24, 9, 1, -20 },
  { 1447, 13, 11, 13, 0, -20 },
  { 1465, 12, 2, 12, 0, 2 },
  { 1468, 6, 4, 8, 1, -21 },
  { 1471, 9, 15, 12, 1, -15 },
  { 1488, 10, 21, 13, 2, -21 },
  { 1515, 9, 15, 10, 1, -15 },
  { 1532, 11, 21, 13, 1, -21 },
  { 1561, 10, 15, 12, 1, -15 },
  { 1580, 8, 21, 7, 0, -21 },
  { 1601, 11, 22, 13, 1, -15 },
  { 1632, 9, 21, 13, 2, -21 },
  { 1656, 3, 21, 6, 2, -21 },
  { 1664, 5, 28, 6, 0, -21 },
  { 1682, 10, 21, 12, 2, -21 },
  { 1709, 2, 21, 6, 2, -21 },
  { 1715, 16, 15, 20, 2, -15 },
  { 1745, 9, 15, 13, 2, -15 },
  { 1762, 11, 15, 13, 1, -15 },
  { 1783, 10, 22, 13, 2, -15 },
  { 1811, 11, 22, 13, 1, -15 },
  { 1842, 7, 15, 9, 2, -15 },
  { 1856, 8, 15, 10, 1, -15 },
  { 1871, 7, 18, 8, 0, -18 },
  { 1887, 9, 15, 13, 2, -15 },
  { 1904, 11, 15, 11, 0, -15 },
  { 1925, 17, 15, 18, 0, -15 },
  { 1957, 11, 15, 11, 0, -15 },
  { 1978, 11, 22, 11, 0, -15 },
  { 2009, 7, 15, 9, 1, -15 },
  { 2023, 8, 24, 10, 1, -20 },
  { 2047, 2, 28, 12, 5, -21 },
  { 2054, 8, 24, 10, 1, -20 },
  { 2078, 11, 4, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Medium28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM28PT7B_H_
