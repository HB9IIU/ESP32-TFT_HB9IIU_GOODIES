#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0xDB, 0x6D, 0x80, 0xFF, 0xEF, 0xDB, 0x36, 0x6C, 0xC8,
  0x80, 0x09, 0x82, 0x61, 0x90, 0x64, 0x19, 0x1F, 0xF1, 0x30, 0x4C, 0x13,
  0x0C, 0xCF, 0xFC, 0xC8, 0x32, 0x0C, 0x82, 0x60, 0x98, 0x10, 0x10, 0x3F,
  0x7E, 0xD2, 0xD0, 0xD0, 0xF0, 0x78, 0x1E, 0x16, 0x13, 0x13, 0x97, 0xFE,
  0x78, 0x10, 0x10, 0x70, 0x43, 0xE3, 0x0D, 0x88, 0x36, 0x60, 0xC9, 0x83,
  0x24, 0x0D, 0xB3, 0x36, 0xDE, 0xFA, 0xD9, 0xDB, 0x20, 0x6C, 0x81, 0x33,
  0x0C, 0xC8, 0x33, 0x21, 0x85, 0x86, 0x1C, 0x38, 0x1F, 0x06, 0x61, 0x98,
  0x66, 0x1B, 0x07, 0xC0, 0xE0, 0x79, 0xF7, 0x6C, 0xDB, 0x1E, 0xC7, 0x31,
  0xCF, 0xF9, 0xF7, 0xFF, 0x6C, 0x80, 0x19, 0x8C, 0xC6, 0x33, 0x18, 0xC6,
  0x31, 0x8C, 0x71, 0x8C, 0x61, 0x8E, 0xC6, 0x18, 0xC3, 0x18, 0xC6, 0x31,
  0xCC, 0x63, 0x18, 0xCE, 0x63, 0x30, 0x38, 0x22, 0x4F, 0xF3, 0x85, 0x3B,
  0xA2, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x6F,
  0xED, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x38, 0x7C,
  0x66, 0xC6, 0xC7, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xE6,
  0x7E, 0x3C, 0x0C, 0x73, 0xDB, 0xCC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x78, 0xFE, 0xC6, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x18,
  0x38, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0x78, 0xFE, 0x86, 0x06, 0x06, 0x06,
  0x0E, 0x78, 0x7C, 0x06, 0x07, 0x07, 0x07, 0x86, 0xFE, 0xFC, 0x07, 0x03,
  0x83, 0xC1, 0x61, 0xB0, 0xD8, 0x4C, 0x66, 0x23, 0x31, 0x90, 0xDF, 0xFF,
  0xF8, 0x18, 0x0C, 0x06, 0x7E, 0x7E, 0x40, 0xC0, 0xC0, 0xC0, 0xF8, 0xFE,
  0x06, 0x07, 0x07, 0x07, 0x07, 0x86, 0xFE, 0xFC, 0x1E, 0x3E, 0x70, 0x60,
  0xC0, 0xC0, 0xDC, 0xFE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xE6, 0x7E, 0x3C,
  0xFF, 0xFF, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x70, 0x60, 0x3C, 0x7E, 0xE6, 0xC7, 0xC7, 0xE6, 0x6E, 0x3C,
  0x7C, 0xE6, 0xC7, 0xC3, 0xC3, 0xC3, 0xFE, 0x7C, 0x38, 0x7C, 0xE6, 0xC6,
  0xC7, 0xC3, 0xC7, 0xC7, 0xFF, 0x7B, 0x06, 0x06, 0x06, 0x0E, 0xFC, 0xF8,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0D, 0xFD, 0xB0, 0x01,
  0x07, 0x0E, 0x38, 0xE0, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x1E, 0x78, 0xE0,
  0x80, 0x79, 0xF9, 0x38, 0x30, 0x61, 0xC3, 0x0E, 0x18, 0x60, 0xC0, 0x00,
  0x06, 0x0C, 0x18, 0x07, 0x80, 0xFE, 0x0C, 0x18, 0xC0, 0x66, 0x31, 0x23,
  0xCF, 0x36, 0x79, 0x33, 0xD9, 0x9E, 0xCC, 0xF6, 0x67, 0x93, 0x2C, 0xFF,
  0x22, 0x21, 0x80, 0x0E, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x33, 0x8F, 0xE7, 0xF9, 0x86,
  0x61, 0xD8, 0x7E, 0x0F, 0x03, 0xF8, 0xFE, 0xC6, 0xC7, 0xC7, 0xC6, 0xC6,
  0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0x1F, 0x9F, 0x9C,
  0x4C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03,
  0x80, 0xFC, 0x3E, 0xF8, 0x7E, 0x33, 0x98, 0xEC, 0x36, 0x1B, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xD8, 0x6C, 0x36, 0x33, 0xF9, 0xF0, 0xFF, 0xFC, 0x30,
  0xC3, 0x0C, 0x3F, 0xFF, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xFF, 0xFC, 0x30,
  0xC3, 0x0C, 0x3F, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x0F, 0x8F, 0xF7,
  0x09, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC3, 0xF0, 0x3E, 0x0F, 0x83,
  0x60, 0xDC, 0x33, 0xFC, 0x7F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF,
  0xD8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xDF, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xFD, 0xE0, 0xC3, 0xC7,
  0xC6, 0xCC, 0xCC, 0xD8, 0xF8, 0xF0, 0xF8, 0xD8, 0xCC, 0xCC, 0xCE, 0xC6,
  0xC7, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xBF, 0x0D, 0xF8, 0x6F,
  0xC3, 0xFB, 0x17, 0xD9, 0xBE, 0xCD, 0xF2, 0x4F, 0x9E, 0x7C, 0xF3, 0xE7,
  0x9F, 0x18, 0xF8, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0x67,
  0xB3, 0xCD, 0xE6, 0xF3, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x83, 0x1E, 0x0F,
  0xE7, 0x19, 0x87, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x83, 0x61, 0xDC, 0x63, 0xF8, 0x7C, 0xF9, 0xFB, 0x3E, 0x3C, 0x78, 0xF1,
  0xE7, 0xFD, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x1E, 0x0F, 0xE7, 0x19,
  0x87, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0x61,
  0xDC, 0x63, 0xF8, 0x7C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0xF0, 0xFC, 0xCE,
  0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0xF8, 0xCC, 0xCC, 0xCE, 0xC6, 0xC7,
  0xC3, 0x3C, 0xFF, 0x8E, 0x0C, 0x18, 0x38, 0x3C, 0x3C, 0x1C, 0x18, 0x30,
  0x70, 0xFF, 0xFE, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x36, 0x1B, 0x0D, 0xFE,
  0x7E, 0xC0, 0xF0, 0x36, 0x1D, 0x86, 0x61, 0x98, 0x63, 0x18, 0xCC, 0x33,
  0x0C, 0xC3, 0xB0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0xC1, 0x83, 0xC1,
  0x83, 0xE1, 0x87, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x72,
  0x4E, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x34, 0x2C, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0xE1, 0xB1, 0x9C, 0xC6, 0x63, 0x60, 0xF0,
  0x78, 0x38, 0x1C, 0x0F, 0x0D, 0x86, 0xC3, 0x33, 0x19, 0x8F, 0xC3, 0xC1,
  0xF1, 0xD8, 0xCC, 0x63, 0x31, 0xB0, 0xD8, 0x3C, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x7F, 0x7F, 0x07, 0x06, 0x0E, 0x0C, 0x0C,
  0x18, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xF0, 0xC0, 0x60,
  0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06,
  0x03, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF,
  0x0C, 0x03, 0x00, 0xE0, 0x78, 0x13, 0x0C, 0xC3, 0x19, 0x86, 0xE0, 0xC0,
  0xFF, 0x80, 0xE6, 0x31, 0x7C, 0xFC, 0x18, 0x30, 0x6F, 0xF9, 0xE3, 0xC7,
  0x8F, 0xFB, 0xB0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0x7D, 0xC6,
  0xE3, 0x71, 0xB0, 0xF8, 0x7E, 0x37, 0x1B, 0x8D, 0xFE, 0xDE, 0x00, 0x3E,
  0xFB, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0xF1, 0xE0, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE7, 0x7F, 0x7B, 0x3C, 0x7E, 0xC6, 0xC2, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0,
  0xE0, 0x7E, 0x3E, 0x1C, 0xF3, 0x0C, 0x31, 0xFF, 0xCC, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE7, 0x7F, 0x7B, 0x03, 0x03, 0x03, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xDE, 0xDF, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFC, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0x77, 0x00, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x6E, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE3, 0xE6, 0xEE, 0xCC, 0xD8, 0xD8, 0xFC, 0xEC, 0xE6, 0xE6, 0xE7, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xDE, 0xF7, 0xF7, 0xF9, 0xC7, 0xC6, 0x3E,
  0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18, 0xF0, 0xC7, 0x86,
  0x30, 0xDE, 0xDF, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E,
  0x3C, 0xDE, 0x6F, 0xB8, 0xDC, 0x6E, 0x36, 0x1F, 0x0F, 0xC6, 0xE3, 0x71,
  0xB7, 0xDB, 0xCC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x3B, 0x7F, 0xE7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x7B, 0x03, 0x03, 0x03,
  0x03, 0x03, 0xDF, 0x7F, 0x38, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x7F,
  0xFC, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x3F, 0xFE, 0x30, 0xC3, 0x1F, 0xFD,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xF3, 0xC0, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x7B, 0xC3, 0xF1, 0x98, 0xCC,
  0x66, 0x63, 0x30, 0xD8, 0x6C, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0xC3, 0x1F,
  0x9C, 0x66, 0x79, 0x99, 0xE6, 0x67, 0x99, 0x96, 0xC3, 0xCB, 0x0F, 0x2C,
  0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x06, 0x38, 0xE3, 0x67, 0x76, 0x36, 0x3C,
  0x1C, 0x1C, 0x3C, 0x36, 0x66, 0x67, 0xE3, 0xC3, 0xF1, 0x98, 0xCC, 0x66,
  0x61, 0xB0, 0xD8, 0x6C, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x61,
  0xE0, 0xF0, 0x00, 0x7C, 0xF8, 0x30, 0xE1, 0x83, 0x0C, 0x18, 0x70, 0xC1,
  0xFF, 0xF0, 0x0C, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0x8E, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xE1, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3,
  0x87, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x71, 0xCC, 0x30, 0xC3, 0x0C, 0x31,
  0xCE, 0x20, 0xF1, 0xBF, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_Medium22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 16, 5, 1, -16 },
  { 7, 7, 6, 9, 1, -16 },
  { 13, 10, 16, 10, 0, -16 },
  { 33, 8, 18, 10, 1, -17 },
  { 51, 14, 16, 15, 1, -16 },
  { 79, 10, 16, 11, 1, -16 },
  { 99, 3, 6, 5, 1, -16 },
  { 102, 5, 19, 7, 1, -16 },
  { 114, 5, 19, 7, 1, -16 },
  { 126, 7, 8, 9, 1, -17 },
  { 133, 8, 10, 10, 1, -13 },
  { 143, 3, 6, 5, 1, -3 },
  { 146, 5, 2, 6, 1, -7 },
  { 148, 3, 3, 5, 1, -3 },
  { 150, 8, 16, 8, 0, -16 },
  { 166, 8, 16, 10, 1, -16 },
  { 182, 6, 16, 10, 1, -16 },
  { 194, 8, 16, 10, 1, -16 },
  { 210, 8, 16, 10, 1, -16 },
  { 226, 9, 16, 10, 0, -16 },
  { 244, 8, 16, 10, 1, -16 },
  { 260, 8, 16, 10, 1, -16 },
  { 276, 8, 16, 10, 1, -16 },
  { 292, 8, 16, 10, 1, -16 },
  { 308, 8, 16, 10, 1, -16 },
  { 324, 3, 12, 5, 1, -12 },
  { 329, 3, 15, 5, 1, -12 },
  { 335, 8, 10, 10, 1, -13 },
  { 345, 8, 6, 10, 1, -11 },
  { 351, 8, 10, 10, 1, -13 },
  { 361, 7, 16, 7, 0, -16 },
  { 375, 13, 18, 15, 1, -16 },
  { 405, 10, 16, 10, 0, -16 },
  { 425, 8, 16, 11, 2, -16 },
  { 441, 9, 16, 10, 1, -16 },
  { 459, 9, 16, 12, 2, -16 },
  { 477, 6, 16, 9, 2, -16 },
  { 489, 6, 16, 9, 2, -16 },
  { 501, 10, 16, 12, 1, -16 },
  { 521, 9, 16, 12, 2, -16 },
  { 539, 5, 16, 6, 1, -16 },
  { 549, 5, 20, 5, -1, -16 },
  { 562, 8, 16, 10, 2, -16 },
  { 578, 6, 16, 8, 2, -16 },
  { 590, 13, 16, 16, 2, -16 },
  { 616, 9, 16, 13, 2, -16 },
  { 634, 10, 16, 12, 1, -16 },
  { 654, 7, 16, 10, 2, -16 },
  { 668, 10, 20, 12, 1, -16 },
  { 693, 8, 16, 10, 2, -16 },
  { 709, 7, 16, 9, 1, -16 },
  { 723, 8, 16, 9, 0, -16 },
  { 739, 9, 16, 12, 1, -16 },
  { 757, 10, 16, 10, 0, -16 },
  { 777, 16, 16, 16, 0, -16 },
  { 809, 9, 16, 9, 0, -16 },
  { 827, 9, 16, 9, 0, -16 },
  { 845, 8, 16, 8, 0, -16 },
  { 861, 5, 20, 7, 1, -16 },
  { 874, 8, 16, 8, 0, -16 },
  { 890, 4, 20, 7, 1, -16 },
  { 900, 10, 9, 10, 0, -16 },
  { 912, 9, 1, 9, 0, 2 },
  { 914, 4, 4, 6, 1, -17 },
  { 916, 7, 12, 9, 1, -12 },
  { 927, 9, 17, 10, 1, -17 },
  { 947, 7, 12, 8, 1, -12 },
  { 958, 8, 17, 10, 1, -17 },
  { 975, 8, 12, 9, 1, -12 },
  { 987, 6, 17, 6, 0, -17 },
  { 1000, 8, 17, 10, 1, -12 },
  { 1017, 8, 17, 10, 1, -17 },
  { 1034, 3, 16, 5, 1, -16 },
  { 1040, 4, 21, 5, 0, -16 },
  { 1051, 8, 17, 9, 1, -17 },
  { 1068, 2, 17, 5, 1, -17 },
  { 1073, 13, 12, 15, 1, -12 },
  { 1093, 8, 12, 10, 1, -12 },
  { 1105, 8, 12, 10, 1, -12 },
  { 1117, 9, 17, 10, 1, -12 },
  { 1137, 8, 17, 10, 1, -12 },
  { 1154, 6, 12, 7, 1, -12 },
  { 1163, 6, 12, 8, 1, -12 },
  { 1172, 6, 15, 6, 0, -15 },
  { 1184, 8, 12, 10, 1, -12 },
  { 1196, 9, 12, 9, 0, -12 },
  { 1210, 14, 12, 14, 0, -12 },
  { 1231, 8, 12, 9, 0, -12 },
  { 1243, 9, 17, 9, 0, -12 },
  { 1263, 7, 12, 7, 0, -12 },
  { 1274, 6, 20, 8, 1, -16 },
  { 1289, 2, 22, 9, 4, -17 },
  { 1295, 6, 20, 8, 1, -16 },
  { 1310, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Medium22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM22PT7B_H_
