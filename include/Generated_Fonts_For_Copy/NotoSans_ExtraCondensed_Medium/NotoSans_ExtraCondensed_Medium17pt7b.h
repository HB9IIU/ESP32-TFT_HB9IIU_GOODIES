#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0xDE, 0xF7, 0xB0, 0x16, 0x16, 0x34, 0x7F, 0x7F,
  0x24, 0x24, 0xFE, 0x2C, 0x2C, 0x68, 0x68, 0x20, 0xCF, 0xE8, 0xA3, 0x87,
  0x0E, 0x2C, 0xBA, 0xBE, 0x20, 0x80, 0xE3, 0x2C, 0x8B, 0x62, 0x50, 0xB4,
  0x2F, 0x7E, 0xA4, 0x29, 0x1A, 0x44, 0x91, 0x34, 0xC6, 0x38, 0x36, 0x1B,
  0x0D, 0x82, 0x81, 0x81, 0xEC, 0x96, 0xCF, 0x63, 0x1B, 0xCF, 0x70, 0xFF,
  0x36, 0x4C, 0xCC, 0x88, 0x8C, 0xC4, 0x46, 0x30, 0xC6, 0x23, 0x31, 0x11,
  0x13, 0x33, 0x26, 0xC0, 0x21, 0x3E, 0xC5, 0x6C, 0x20, 0x82, 0x3F, 0xFC,
  0x82, 0x08, 0xFE, 0xF0, 0xF0, 0x04, 0x30, 0x86, 0x18, 0x43, 0x08, 0x21,
  0x84, 0x30, 0x7B, 0x6C, 0xA3, 0x8E, 0x38, 0xE3, 0x8F, 0x2D, 0x9C, 0x37,
  0xD9, 0x11, 0x11, 0x11, 0x11, 0xFA, 0x60, 0x82, 0x08, 0x61, 0x0C, 0x63,
  0x0C, 0x3F, 0xFA, 0x60, 0x82, 0x19, 0xC3, 0x83, 0x0C, 0x39, 0xBC, 0x0C,
  0x38, 0x71, 0xE2, 0xC5, 0x93, 0x26, 0xFE, 0x18, 0x30, 0x60, 0xFB, 0x0C,
  0x30, 0xA3, 0xE0, 0xC3, 0x0C, 0x39, 0xBC, 0x79, 0x8C, 0x30, 0xB3, 0xEC,
  0xE3, 0x8F, 0x3D, 0x9E, 0xFE, 0x0C, 0x10, 0x60, 0xC1, 0x06, 0x0C, 0x10,
  0x60, 0xC1, 0x00, 0x7B, 0x28, 0xF3, 0xD9, 0xCF, 0xB3, 0x8E, 0x3C, 0xDE,
  0x73, 0x68, 0xA3, 0x8F, 0x3F, 0xDB, 0x08, 0x63, 0xBC, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xF8, 0x02, 0x1C, 0xE7, 0x06, 0x03, 0x03, 0x81, 0xFE, 0x00,
  0x07, 0xF0, 0x83, 0x07, 0x07, 0x1D, 0xCC, 0x20, 0xFC, 0xC2, 0x11, 0x98,
  0x84, 0x00, 0x18, 0xC0, 0x3E, 0x18, 0x44, 0x0B, 0x3A, 0x92, 0xE5, 0xBB,
  0x6E, 0xDB, 0x96, 0xA6, 0xEC, 0x01, 0x80, 0x3E, 0x00, 0x18, 0x18, 0x3C,
  0x3C, 0x24, 0x24, 0x66, 0x7E, 0x66, 0x42, 0xC3, 0xC3, 0xF9, 0x9B, 0x16,
  0x2C, 0xDF, 0x33, 0x63, 0xC7, 0x8F, 0x37, 0xC0, 0x3D, 0x9C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x06, 0x4F, 0xF9, 0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0xF7, 0xC0, 0xFE, 0x31, 0x8C, 0x7F, 0x18, 0xC6, 0x3F, 0xF0,
  0xFE, 0x31, 0x8C, 0x7F, 0xF8, 0xC6, 0x31, 0x80, 0x3E, 0xC7, 0x06, 0x0C,
  0x19, 0xF3, 0xE1, 0xC3, 0x85, 0x89, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0xE9, 0x24, 0x92, 0x49, 0x70, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xE0, 0xC7, 0x9B, 0x26, 0xCD, 0x1E,
  0x3C, 0x6C, 0xC9, 0x9B, 0x36, 0x30, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x3F, 0xF0, 0xE0, 0xF8, 0x7E, 0x1F, 0xC5, 0xF1, 0x74, 0xDD, 0x27, 0x69,
  0xCE, 0x73, 0x9C, 0xC7, 0x31, 0xE3, 0xE3, 0xE3, 0xF3, 0xD3, 0xDB, 0xDB,
  0xCF, 0xCF, 0xC7, 0xC7, 0xC3, 0x7C, 0x66, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC6, 0x6E, 0x3C, 0xFB, 0x3C, 0xF1, 0xCF, 0x3F, 0xB0, 0xC3,
  0x0C, 0x30, 0x7C, 0x66, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6,
  0x6E, 0x3C, 0x0C, 0x06, 0x06, 0xF9, 0xBB, 0x36, 0x2C, 0xDB, 0xBE, 0x6C,
  0xC9, 0x9B, 0x36, 0x30, 0x7E, 0x61, 0x0C, 0x38, 0xE3, 0x08, 0x67, 0xE0,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8D, 0xBB, 0xE0, 0xC3, 0xC2,
  0x42, 0x66, 0x66, 0x64, 0x24, 0x2C, 0x3C, 0x38, 0x18, 0x18, 0xC6, 0x1C,
  0x63, 0x46, 0x34, 0x73, 0x6F, 0x26, 0xD2, 0x69, 0x62, 0x96, 0x29, 0xE2,
  0x9C, 0x38, 0xC3, 0x8C, 0xC6, 0xC9, 0xB1, 0x63, 0x83, 0x0E, 0x1C, 0x2C,
  0xD9, 0x16, 0x30, 0xC6, 0x89, 0xB3, 0x62, 0x87, 0x0E, 0x08, 0x10, 0x20,
  0x40, 0x80, 0xFC, 0x30, 0x86, 0x18, 0x43, 0x08, 0x61, 0x8F, 0xFF, 0xFC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC1, 0x06, 0x08, 0x20, 0xC1,
  0x06, 0x18, 0x20, 0xC1, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0xF0,
  0x18, 0x18, 0x3C, 0x24, 0x66, 0x42, 0xC3, 0xFF, 0xFC, 0xC8, 0x80, 0xFC,
  0xC2, 0x7F, 0xC6, 0x33, 0xE8, 0xC3, 0x0C, 0x30, 0xFB, 0x3C, 0x71, 0xC7,
  0x1C, 0x73, 0xB8, 0x7E, 0x31, 0x08, 0x43, 0x19, 0x78, 0x0C, 0x30, 0xC3,
  0x7F, 0x3C, 0xE3, 0x8E, 0x3C, 0xF3, 0x74, 0x7B, 0x28, 0xE3, 0xFE, 0x0C,
  0x32, 0x78, 0x3B, 0x58, 0xCF, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0x77,
  0x3C, 0xE3, 0x8E, 0x3C, 0xF3, 0x7C, 0x30, 0xE6, 0xF8, 0xC3, 0x0C, 0x30,
  0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCC, 0xB0, 0xFF, 0xFF, 0xC0, 0x4C,
  0x06, 0xDB, 0x6D, 0xB6, 0xDF, 0xC0, 0xC3, 0x0C, 0x30, 0xCF, 0x6D, 0x3C,
  0xF3, 0x6D, 0xB3, 0xCC, 0xFF, 0xFF, 0xFF, 0xC0, 0xBB, 0xB3, 0x3C, 0xCF,
  0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xC0, 0xBB, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCC, 0x7B, 0x3C, 0xE3, 0x8E, 0x3C, 0xF3, 0x78, 0xBB, 0x3C,
  0x71, 0xC7, 0x1C, 0x73, 0xFB, 0x0C, 0x30, 0xC0, 0x77, 0x3C, 0xE3, 0x8E,
  0x3C, 0xF3, 0x7C, 0x30, 0xC3, 0x0C, 0xBE, 0xCC, 0xCC, 0xCC, 0xC0, 0xF9,
  0x8C, 0x73, 0x1B, 0xF0, 0x26, 0xF6, 0x66, 0x66, 0x66, 0x30, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF7, 0x74, 0xC7, 0x89, 0x33, 0x66, 0x85, 0x0E, 0x1C,
  0x30, 0xCC, 0x69, 0xC9, 0x2B, 0x35, 0x67, 0xA8, 0xF5, 0x0C, 0xA1, 0x9C,
  0x31, 0x80, 0xCD, 0xB2, 0x8E, 0x30, 0xE6, 0x9B, 0xCC, 0xC6, 0x89, 0x33,
  0x66, 0x85, 0x0E, 0x1C, 0x30, 0x60, 0xC5, 0x0E, 0x00, 0x78, 0xC4, 0x63,
  0x31, 0x88, 0xF8, 0x36, 0x66, 0x66, 0x6C, 0x66, 0x66, 0x63, 0x10, 0xFF,
  0xFF, 0x80, 0xC3, 0x18, 0xC6, 0x30, 0xC7, 0x63, 0x18, 0xC6, 0x72, 0x00,
  0x73, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_Medium17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 5, 4, 7, 1, -12 },
  { 7, 8, 12, 8, 0, -12 },
  { 19, 6, 14, 7, 1, -13 },
  { 30, 10, 12, 12, 1, -12 },
  { 45, 9, 12, 9, 0, -12 },
  { 59, 2, 4, 4, 1, -12 },
  { 60, 4, 15, 5, 1, -12 },
  { 68, 4, 15, 5, 0, -12 },
  { 76, 5, 6, 7, 1, -13 },
  { 80, 6, 8, 7, 1, -10 },
  { 86, 2, 4, 4, 1, -2 },
  { 87, 4, 1, 5, 0, -5 },
  { 88, 2, 2, 4, 1, -2 },
  { 89, 6, 12, 6, 0, -12 },
  { 98, 6, 12, 7, 1, -12 },
  { 107, 4, 12, 7, 1, -12 },
  { 113, 6, 12, 7, 1, -12 },
  { 122, 6, 12, 7, 1, -12 },
  { 131, 7, 12, 7, 0, -12 },
  { 142, 6, 12, 7, 1, -12 },
  { 151, 6, 12, 7, 1, -12 },
  { 160, 7, 12, 7, 0, -12 },
  { 171, 6, 12, 7, 1, -12 },
  { 180, 6, 12, 7, 1, -12 },
  { 189, 2, 9, 4, 1, -9 },
  { 192, 2, 11, 4, 1, -9 },
  { 195, 7, 8, 7, 0, -10 },
  { 202, 7, 4, 7, 0, -8 },
  { 206, 6, 8, 7, 1, -10 },
  { 212, 5, 12, 6, 0, -12 },
  { 220, 10, 13, 11, 1, -12 },
  { 237, 8, 12, 8, 0, -12 },
  { 249, 7, 12, 8, 1, -12 },
  { 260, 6, 12, 8, 1, -12 },
  { 269, 7, 12, 9, 1, -12 },
  { 280, 5, 12, 7, 1, -12 },
  { 288, 5, 12, 7, 1, -12 },
  { 296, 7, 12, 9, 1, -12 },
  { 307, 7, 12, 9, 1, -12 },
  { 318, 3, 12, 5, 1, -12 },
  { 323, 4, 15, 4, -1, -12 },
  { 331, 7, 12, 8, 1, -12 },
  { 342, 5, 12, 6, 1, -12 },
  { 350, 10, 12, 12, 1, -12 },
  { 365, 8, 12, 10, 1, -12 },
  { 377, 8, 12, 10, 1, -12 },
  { 389, 6, 12, 8, 1, -12 },
  { 398, 8, 15, 10, 1, -12 },
  { 413, 7, 12, 8, 1, -12 },
  { 424, 5, 12, 7, 1, -12 },
  { 432, 7, 12, 7, 0, -12 },
  { 443, 7, 12, 9, 1, -12 },
  { 454, 8, 12, 8, 0, -12 },
  { 466, 12, 12, 12, 0, -12 },
  { 484, 7, 12, 7, 0, -12 },
  { 495, 7, 12, 7, 0, -12 },
  { 506, 6, 12, 6, 0, -12 },
  { 515, 4, 15, 5, 1, -12 },
  { 523, 6, 12, 6, 0, -12 },
  { 532, 4, 15, 5, 0, -12 },
  { 540, 8, 7, 8, 0, -12 },
  { 547, 7, 2, 7, 0, 1 },
  { 549, 3, 3, 5, 1, -13 },
  { 551, 5, 9, 7, 1, -9 },
  { 557, 6, 13, 8, 1, -13 },
  { 567, 5, 9, 6, 1, -9 },
  { 573, 6, 13, 8, 1, -13 },
  { 583, 6, 9, 7, 1, -9 },
  { 590, 5, 13, 5, 0, -13 },
  { 599, 6, 13, 8, 1, -9 },
  { 609, 6, 13, 8, 1, -13 },
  { 619, 2, 13, 4, 1, -13 },
  { 623, 3, 17, 4, 0, -13 },
  { 630, 6, 13, 7, 1, -13 },
  { 640, 2, 13, 4, 1, -13 },
  { 644, 10, 9, 12, 1, -9 },
  { 656, 6, 9, 8, 1, -9 },
  { 663, 6, 9, 8, 1, -9 },
  { 670, 6, 13, 8, 1, -9 },
  { 680, 6, 13, 8, 1, -9 },
  { 690, 4, 9, 5, 1, -9 },
  { 695, 4, 9, 6, 1, -9 },
  { 700, 4, 11, 5, 0, -11 },
  { 706, 6, 9, 8, 1, -9 },
  { 713, 7, 9, 7, 0, -9 },
  { 721, 11, 9, 11, 0, -9 },
  { 734, 6, 9, 7, 0, -9 },
  { 741, 7, 13, 7, 0, -9 },
  { 753, 5, 9, 5, 0, -9 },
  { 759, 4, 15, 6, 1, -12 },
  { 767, 1, 17, 7, 3, -13 },
  { 770, 5, 15, 6, 1, -12 },
  { 780, 7, 2, 7, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Medium17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM17PT7B_H_
