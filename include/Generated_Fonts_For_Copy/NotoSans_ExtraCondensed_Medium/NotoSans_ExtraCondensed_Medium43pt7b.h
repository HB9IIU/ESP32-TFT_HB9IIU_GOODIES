#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xE7, 0x38, 0x00, 0x01, 0x3D, 0xFF, 0xFF, 0xC0, 0xF8, 0xFF, 0xC7,
  0xDE, 0x3E, 0xF1, 0xF7, 0x8F, 0xBC, 0x79, 0xE1, 0xCF, 0x0E, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E,
  0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x70, 0xE0, 0x1E, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80,
  0x78, 0xE0, 0x0E, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0xFF, 0x87, 0xFF, 0xDF, 0xFF, 0x3F, 0xDE, 0xF3, 0x85, 0xE7, 0x03,
  0xCE, 0x07, 0x9C, 0x0F, 0x38, 0x1E, 0x70, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3B, 0xE0, 0x73, 0xC0, 0xE7,
  0x81, 0xCF, 0x03, 0x9F, 0x07, 0x3F, 0x0E, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F,
  0xFE, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x70, 0x1F, 0xC0, 0x3C, 0x07, 0xF8, 0x0E, 0x03, 0xCE,
  0x03, 0x80, 0xE3, 0xC1, 0xE0, 0x38, 0x70, 0x70, 0x0E, 0x1C, 0x1C, 0x03,
  0x87, 0x0E, 0x00, 0xE1, 0xC3, 0x80, 0x38, 0x71, 0xE0, 0x0E, 0x1C, 0x70,
  0x03, 0x87, 0x1C, 0x00, 0xE1, 0xCF, 0x1E, 0x38, 0x73, 0x8F, 0xCE, 0x3C,
  0xE7, 0xFB, 0xCE, 0x79, 0xCE, 0x7F, 0x9C, 0xF3, 0xCF, 0xC7, 0x38, 0x71,
  0xE3, 0xCE, 0x1C, 0x00, 0xE3, 0x87, 0x00, 0x38, 0xE1, 0xC0, 0x1C, 0x38,
  0x70, 0x07, 0x0E, 0x1C, 0x03, 0xC3, 0x87, 0x00, 0xE0, 0xE1, 0xC0, 0x38,
  0x38, 0x70, 0x1E, 0x0E, 0x1C, 0x07, 0x03, 0xCF, 0x01, 0xC0, 0x7F, 0x80,
  0xF0, 0x1F, 0xE0, 0x38, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0x3C, 0xF8, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x3E,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x02,
  0x3F, 0xE1, 0xE1, 0xEF, 0x8F, 0x1F, 0x3C, 0x78, 0xF1, 0xF3, 0xCF, 0x87,
  0xBE, 0x7C, 0x1F, 0xE3, 0xC0, 0xFF, 0x1E, 0x03, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0xFC, 0x1F, 0x07, 0xF0, 0xFC, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFC,
  0xF8, 0x3F, 0x87, 0xE0, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0x03,
  0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x04, 0x38, 0x2F, 0x73, 0xDF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0xF3, 0x81, 0xE7, 0x87,
  0x8F, 0x83, 0x0C, 0x02, 0x10, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x9E, 0x3C, 0x78, 0xE3, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x31, 0xEF, 0xFF, 0x7D, 0xE0, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC7, 0xC7, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x1E, 0xF0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xF7, 0xC3,
  0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF0,
  0xFE, 0x3F, 0xCF, 0x7F, 0xCF, 0x71, 0xE4, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x30, 0x3E, 0x20,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x30,
  0x3E, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x78, 0xFE, 0x7F,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0x78, 0x03, 0xBC,
  0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x70,
  0xF0, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8E,
  0x03, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7A,
  0x01, 0xF7, 0x8F, 0xCF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x84, 0x0F, 0x3F, 0x1E, 0xFF,
  0x3F, 0xFF, 0x7E, 0x3E, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1E, 0xF0, 0x7D, 0xF0,
  0xF1, 0xF7, 0xE3, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xEF, 0xC7, 0xC1, 0xE3, 0xC0, 0xF9,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x0F, 0x07, 0x87, 0xC7,
  0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F,
  0x3E, 0x0F, 0x0F, 0x8F, 0x83, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D,
  0xE0, 0x1F, 0xF8, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x87, 0xE3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x7C,
  0x3F, 0x3F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x07, 0x8F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x21,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x79, 0xFF, 0xDF, 0x78, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC7, 0x9F, 0xFD, 0xF7,
  0x80, 0x3C, 0x7C, 0xF9, 0xF3, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1,
  0xE3, 0x8F, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0xC3, 0xFF, 0x3F, 0xFC, 0xFF, 0xF2, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x70, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x38, 0x0F, 0x07, 0x3C, 0x1F,
  0xE3, 0x9C, 0x1F, 0xF1, 0xEE, 0x1E, 0x38, 0xFF, 0x0E, 0x3C, 0x3F, 0x8F,
  0x1E, 0x1F, 0x87, 0x0F, 0x0F, 0xC3, 0x87, 0x87, 0xE1, 0xC3, 0xC3, 0xF0,
  0xE1, 0xE1, 0xF8, 0x70, 0xF0, 0xFC, 0x38, 0x78, 0x7E, 0x1C, 0x3C, 0x7F,
  0x0E, 0x1E, 0x3B, 0x87, 0x9B, 0x1D, 0xE1, 0xFD, 0xFC, 0x70, 0xFC, 0xFE,
  0x38, 0x3E, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x1F, 0xC3, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3D, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xE7, 0xC0,
  0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xF0, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFE,
  0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF0, 0x21, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x43, 0xF9, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xF0, 0x7E, 0x3C, 0x0F, 0xCF,
  0x01, 0xF3, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x07, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF7, 0xFF, 0xBC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xF8, 0x0C, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x0F, 0x3C,
  0x01, 0xE7, 0xC0, 0x3C, 0xFC, 0x07, 0x8F, 0xF3, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xF3, 0xFF, 0xF7, 0xFB,
  0xF8, 0x40, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03,
  0xE7, 0x83, 0xE3, 0xC1, 0xF1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C,
  0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x7E, 0xF0, 0x3E, 0x7C, 0x1E, 0x3E, 0x0F, 0x0F, 0x07, 0x87,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x1F, 0x3C, 0x07, 0x9E,
  0x03, 0xEF, 0x01, 0xF7, 0x80, 0x7F, 0xC0, 0x3E, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xBF, 0xFC, 0x01,
  0xEF, 0xF7, 0x00, 0x7B, 0xFD, 0xE0, 0x1F, 0xFF, 0x78, 0x07, 0x7F, 0xDE,
  0x03, 0xDF, 0xF3, 0x80, 0xF7, 0xFC, 0xF0, 0x39, 0xFF, 0x3C, 0x0E, 0x7F,
  0xC7, 0x07, 0x9F, 0xF1, 0xE1, 0xE7, 0xFC, 0x78, 0x71, 0xFF, 0x1E, 0x3C,
  0x7F, 0xC3, 0x8F, 0x1F, 0xF0, 0xF3, 0x87, 0xFC, 0x3C, 0xE1, 0xFF, 0x07,
  0x78, 0x7F, 0xC1, 0xDE, 0x1F, 0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0xC1, 0xFF,
  0x03, 0xF0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81,
  0xFF, 0x01, 0xE0, 0x7C, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xF7,
  0x81, 0xFE, 0xF0, 0x3F, 0xDF, 0x07, 0xF9, 0xE0, 0xFF, 0x3C, 0x1F, 0xE3,
  0xC3, 0xFC, 0x78, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xFE, 0x1F, 0x3F, 0xC1,
  0xE7, 0xF8, 0x3C, 0xFF, 0x03, 0xDF, 0xE0, 0x7B, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xE7,
  0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3E,
  0x07, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x1F, 0x78, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x87,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x07, 0xC3,
  0xE0, 0x3C, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1E, 0x7C,
  0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x0F, 0xE7, 0x81, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x03, 0xE7, 0x81, 0xF3, 0xC3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3C, 0x78, 0x1E, 0x3E, 0x0F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF8, 0xF0, 0x3C, 0x78, 0x1F, 0x3C, 0x0F, 0x9E, 0x03, 0xCF, 0x01, 0xF7,
  0x80, 0x7B, 0xC0, 0x3E, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFC,
  0x1B, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0xC7, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xDF, 0x03, 0xCF, 0xEF,
  0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x07, 0xBC, 0x00, 0x3B, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xE0, 0x1F, 0x00,
  0x7B, 0xC0, 0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x03, 0xCF, 0x00, 0xFC, 0x07,
  0x9E, 0x03, 0xF8, 0x0F, 0x3E, 0x07, 0xF0, 0x1E, 0x3C, 0x0E, 0xE0, 0x7C,
  0x78, 0x1D, 0xC0, 0xF0, 0xF0, 0x3B, 0xC1, 0xE1, 0xE0, 0xF7, 0x83, 0xC3,
  0xE1, 0xEF, 0x07, 0x83, 0xC3, 0xCE, 0x1F, 0x07, 0x87, 0x1C, 0x3C, 0x0F,
  0x0E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0xF0, 0x3E, 0x78, 0xF1, 0xE0, 0x3C,
  0xF0, 0xE7, 0xC0, 0x79, 0xC1, 0xCF, 0x00, 0xF3, 0x83, 0xDE, 0x01, 0xE7,
  0x07, 0xBC, 0x03, 0xDE, 0x0F, 0x78, 0x03, 0xFC, 0x0E, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x78, 0x07, 0xDF, 0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0x81, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x01, 0xEF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x0F, 0x87,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7C,
  0xF8, 0x07, 0xFE, 0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0xC1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFC,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x3C, 0x3C, 0x0F, 0x0E,
  0x01, 0xE7, 0x80, 0x79, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x01, 0xC0, 0x3F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0x83, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0x83, 0xDE,
  0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFB, 0xC1, 0xF7, 0xC7,
  0xEF, 0xFF, 0xCF, 0xF3, 0x8F, 0xC7, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0xC0, 0xF3, 0xF0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFC, 0x7C, 0xF8, 0x3E,
  0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF8, 0x1E, 0xF8, 0x3E, 0xFC, 0x7C, 0xFF, 0xFC, 0xE7, 0xF8, 0xE3, 0xF0,
  0x01, 0x80, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xC1, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xE3, 0x1F, 0xF8,
  0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x06, 0x0F, 0x1F,
  0xCF, 0x3F, 0xEF, 0x7F, 0xEF, 0x7C, 0x7F, 0x78, 0x3F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0x78,
  0x3F, 0x7C, 0x7F, 0x3F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x01, 0x00, 0x1F,
  0xC0, 0x7F, 0xC1, 0xFF, 0xC7, 0xC7, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x27, 0xE0,
  0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x03, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x3F, 0xEF, 0x7C, 0x7F, 0x78, 0x3F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0x78, 0x3F, 0x7C, 0x7F, 0x3F, 0xEF, 0x3F, 0xEF, 0x1F, 0x8F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x40, 0x3E,
  0x78, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE3, 0x83, 0xDF, 0xC7, 0xFF, 0xCF, 0xFF, 0xDF, 0x8F, 0xBE, 0x0F,
  0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3E, 0x73, 0xFE,
  0xF7, 0x80, 0x00, 0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x0E, 0x0F, 0x1F, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x9E, 0xFE, 0xFE, 0xFC,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0x83, 0xEF, 0x07,
  0x9E, 0x1E, 0x3C, 0x7C, 0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7C, 0xF0, 0xF1, 0xE1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x87, 0xCF, 0x07, 0x9E, 0x0F, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x30, 0x73, 0xF8,
  0xFE, 0x3B, 0xFE, 0x7F, 0x9D, 0xFF, 0x7F, 0xEF, 0xC7, 0xF1, 0xF7, 0xC3,
  0xF0, 0x7B, 0xC0, 0xF8, 0x3D, 0xE0, 0x78, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8,
  0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xFE, 0x07, 0x81, 0xFF, 0x03, 0xC0, 0xFF,
  0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xE0, 0x78, 0x1F, 0xF0, 0x3C, 0x0F,
  0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xFE, 0x07, 0x81, 0xFF, 0x03, 0xC0,
  0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xE0, 0x78, 0x1F, 0x00, 0xC1,
  0xCF, 0xE3, 0xBF, 0xE7, 0x7F, 0xEF, 0xC7, 0xDF, 0x07, 0xBC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0x01, 0x80, 0x0F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C,
  0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xC0, 0xE3, 0xF0, 0xE7,
  0xF8, 0xEF, 0xFC, 0xFC, 0x3C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xFC,
  0x7C, 0xFF, 0xFC, 0xF7, 0xF8, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xEF, 0x7C,
  0x7F, 0x78, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0x78, 0x3F, 0x7C, 0x7F, 0x3F, 0xEF, 0x3F,
  0xEF, 0x1F, 0x8F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x01,
  0xF8, 0xFE, 0x7F, 0xBF, 0xEF, 0xFF, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0x00, 0xFF, 0x8F, 0xFE, 0xFF, 0xE7,
  0x83, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x01, 0xFF, 0x1F, 0x7F, 0xFB, 0xFF, 0x8F, 0xF8, 0x1C, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3E, 0x4F, 0xF1, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xE7, 0xF7, 0xFD, 0xEF, 0xFB,
  0xCF, 0xC7, 0x80, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7,
  0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0x73, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x79, 0xE0,
  0x7C, 0x0F, 0x3C, 0x1F, 0xC1, 0xE7, 0x83, 0xB8, 0x3C, 0x78, 0x77, 0x0F,
  0x0F, 0x0E, 0xE1, 0xE1, 0xE1, 0xDC, 0x3C, 0x3C, 0x7B, 0x87, 0x87, 0x8F,
  0x78, 0xE0, 0x79, 0xC7, 0x3C, 0x0F, 0x38, 0xE7, 0x81, 0xE7, 0x1C, 0xF0,
  0x3D, 0xE3, 0x9E, 0x03, 0xBC, 0x7B, 0x80, 0x77, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x1F,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0F, 0x78,
  0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C,
  0x3C, 0x3E, 0x3C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xBC, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE7, 0x80,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x02, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x07, 0xF8, 0x3F,
  0x01, 0xF8, 0x0F, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0x80, 0xFC, 0x0F, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x3F,
  0x07, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0E, 0x00, 0x3E, 0x00, 0xBF, 0xE0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC,
  0x0F, 0xF4, 0x00, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 31, 10, 3, -31 },
  { 21, 13, 11, 17, 2, -31 },
  { 39, 19, 31, 20, 1, -31 },
  { 113, 15, 36, 19, 2, -33 },
  { 181, 26, 31, 30, 2, -31 },
  { 282, 21, 31, 22, 1, -31 },
  { 364, 5, 11, 9, 2, -31 },
  { 371, 10, 38, 13, 2, -31 },
  { 419, 10, 38, 13, 1, -31 },
  { 467, 15, 16, 18, 1, -33 },
  { 497, 17, 20, 19, 1, -25 },
  { 540, 7, 11, 10, 1, -5 },
  { 550, 10, 4, 12, 1, -14 },
  { 555, 6, 6, 10, 2, -6 },
  { 560, 15, 31, 16, 1, -31 },
  { 619, 15, 31, 19, 2, -31 },
  { 678, 11, 31, 19, 2, -31 },
  { 721, 16, 31, 19, 1, -31 },
  { 783, 16, 31, 19, 1, -31 },
  { 845, 17, 31, 19, 1, -31 },
  { 911, 15, 31, 19, 2, -31 },
  { 970, 15, 31, 19, 2, -31 },
  { 1029, 16, 31, 19, 1, -31 },
  { 1091, 17, 31, 19, 1, -31 },
  { 1157, 16, 31, 19, 1, -31 },
  { 1219, 6, 23, 10, 2, -23 },
  { 1237, 7, 29, 10, 1, -23 },
  { 1263, 17, 19, 19, 1, -25 },
  { 1304, 17, 12, 19, 1, -21 },
  { 1330, 17, 19, 19, 1, -25 },
  { 1371, 13, 31, 14, 0, -31 },
  { 1422, 25, 35, 29, 2, -31 },
  { 1532, 20, 31, 20, 0, -31 },
  { 1610, 16, 31, 21, 3, -31 },
  { 1672, 17, 31, 20, 2, -31 },
  { 1738, 18, 31, 23, 3, -31 },
  { 1808, 13, 31, 18, 3, -31 },
  { 1859, 13, 31, 17, 3, -31 },
  { 1910, 19, 31, 24, 2, -31 },
  { 1984, 18, 31, 24, 3, -31 },
  { 2054, 10, 31, 13, 1, -31 },
  { 2093, 9, 40, 10, -2, -31 },
  { 2138, 17, 31, 20, 3, -31 },
  { 2204, 13, 31, 16, 3, -31 },
  { 2255, 26, 31, 32, 3, -31 },
  { 2356, 19, 31, 25, 3, -31 },
  { 2430, 20, 31, 24, 2, -31 },
  { 2508, 15, 31, 20, 3, -31 },
  { 2567, 20, 38, 24, 2, -31 },
  { 2662, 17, 31, 20, 3, -31 },
  { 2728, 14, 31, 18, 2, -31 },
  { 2783, 16, 31, 17, 0, -31 },
  { 2845, 17, 31, 23, 3, -31 },
  { 2911, 20, 31, 20, 0, -31 },
  { 2989, 31, 31, 31, 0, -31 },
  { 3110, 18, 31, 18, 0, -31 },
  { 3180, 18, 31, 18, 0, -31 },
  { 3250, 14, 31, 16, 1, -31 },
  { 3305, 9, 38, 13, 3, -31 },
  { 3348, 15, 31, 16, 1, -31 },
  { 3407, 9, 38, 13, 1, -31 },
  { 3450, 18, 17, 20, 1, -31 },
  { 3489, 19, 2, 18, 0, 4 },
  { 3494, 8, 7, 12, 2, -33 },
  { 3501, 15, 24, 18, 1, -24 },
  { 3546, 16, 33, 20, 3, -33 },
  { 3612, 13, 24, 16, 2, -24 },
  { 3651, 16, 33, 20, 2, -33 },
  { 3717, 15, 24, 18, 2, -24 },
  { 3762, 13, 33, 11, 0, -33 },
  { 3816, 16, 34, 20, 2, -24 },
  { 3884, 15, 33, 20, 3, -33 },
  { 3946, 5, 32, 10, 2, -32 },
  { 3966, 8, 42, 10, -1, -32 },
  { 4008, 15, 33, 18, 3, -33 },
  { 4070, 4, 33, 9, 3, -33 },
  { 4087, 25, 24, 30, 3, -24 },
  { 4162, 15, 24, 20, 3, -24 },
  { 4207, 16, 24, 20, 2, -24 },
  { 4255, 16, 34, 20, 3, -24 },
  { 4323, 16, 34, 20, 2, -24 },
  { 4391, 10, 24, 14, 3, -24 },
  { 4421, 13, 24, 15, 1, -24 },
  { 4460, 10, 28, 12, 1, -28 },
  { 4495, 15, 23, 20, 3, -23 },
  { 4539, 17, 23, 17, 0, -23 },
  { 4588, 27, 23, 27, 0, -23 },
  { 4666, 16, 23, 17, 0, -23 },
  { 4712, 17, 33, 17, 0, -23 },
  { 4783, 12, 23, 14, 1, -23 },
  { 4818, 13, 38, 15, 1, -31 },
  { 4880, 4, 43, 18, 7, -33 },
  { 4902, 12, 38, 15, 2, -31 },
  { 4959, 17, 6, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Medium43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM43PT7B_H_
