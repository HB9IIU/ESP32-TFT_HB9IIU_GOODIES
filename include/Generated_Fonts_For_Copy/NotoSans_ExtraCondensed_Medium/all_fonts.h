#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraCondensed_Medium
// Headers: 67

#include "NotoSans_ExtraCondensed_Medium6pt7b.h"
#include "NotoSans_ExtraCondensed_Medium7pt7b.h"
#include "NotoSans_ExtraCondensed_Medium8pt7b.h"
#include "NotoSans_ExtraCondensed_Medium9pt7b.h"
#include "NotoSans_ExtraCondensed_Medium10pt7b.h"
#include "NotoSans_ExtraCondensed_Medium11pt7b.h"
#include "NotoSans_ExtraCondensed_Medium12pt7b.h"
#include "NotoSans_ExtraCondensed_Medium13pt7b.h"
#include "NotoSans_ExtraCondensed_Medium14pt7b.h"
#include "NotoSans_ExtraCondensed_Medium15pt7b.h"
#include "NotoSans_ExtraCondensed_Medium16pt7b.h"
#include "NotoSans_ExtraCondensed_Medium17pt7b.h"
#include "NotoSans_ExtraCondensed_Medium18pt7b.h"
#include "NotoSans_ExtraCondensed_Medium19pt7b.h"
#include "NotoSans_ExtraCondensed_Medium20pt7b.h"
#include "NotoSans_ExtraCondensed_Medium21pt7b.h"
#include "NotoSans_ExtraCondensed_Medium22pt7b.h"
#include "NotoSans_ExtraCondensed_Medium23pt7b.h"
#include "NotoSans_ExtraCondensed_Medium24pt7b.h"
#include "NotoSans_ExtraCondensed_Medium25pt7b.h"
#include "NotoSans_ExtraCondensed_Medium26pt7b.h"
#include "NotoSans_ExtraCondensed_Medium27pt7b.h"
#include "NotoSans_ExtraCondensed_Medium28pt7b.h"
#include "NotoSans_ExtraCondensed_Medium29pt7b.h"
#include "NotoSans_ExtraCondensed_Medium30pt7b.h"
#include "NotoSans_ExtraCondensed_Medium31pt7b.h"
#include "NotoSans_ExtraCondensed_Medium32pt7b.h"
#include "NotoSans_ExtraCondensed_Medium33pt7b.h"
#include "NotoSans_ExtraCondensed_Medium34pt7b.h"
#include "NotoSans_ExtraCondensed_Medium35pt7b.h"
#include "NotoSans_ExtraCondensed_Medium36pt7b.h"
#include "NotoSans_ExtraCondensed_Medium37pt7b.h"
#include "NotoSans_ExtraCondensed_Medium38pt7b.h"
#include "NotoSans_ExtraCondensed_Medium39pt7b.h"
#include "NotoSans_ExtraCondensed_Medium40pt7b.h"
#include "NotoSans_ExtraCondensed_Medium41pt7b.h"
#include "NotoSans_ExtraCondensed_Medium42pt7b.h"
#include "NotoSans_ExtraCondensed_Medium43pt7b.h"
#include "NotoSans_ExtraCondensed_Medium44pt7b.h"
#include "NotoSans_ExtraCondensed_Medium45pt7b.h"
#include "NotoSans_ExtraCondensed_Medium46pt7b.h"
#include "NotoSans_ExtraCondensed_Medium47pt7b.h"
#include "NotoSans_ExtraCondensed_Medium48pt7b.h"
#include "NotoSans_ExtraCondensed_Medium49pt7b.h"
#include "NotoSans_ExtraCondensed_Medium50pt7b.h"
#include "NotoSans_ExtraCondensed_Medium51pt7b.h"
#include "NotoSans_ExtraCondensed_Medium52pt7b.h"
#include "NotoSans_ExtraCondensed_Medium53pt7b.h"
#include "NotoSans_ExtraCondensed_Medium54pt7b.h"
#include "NotoSans_ExtraCondensed_Medium55pt7b.h"
#include "NotoSans_ExtraCondensed_Medium56pt7b.h"
#include "NotoSans_ExtraCondensed_Medium57pt7b.h"
#include "NotoSans_ExtraCondensed_Medium58pt7b.h"
#include "NotoSans_ExtraCondensed_Medium59pt7b.h"
#include "NotoSans_ExtraCondensed_Medium60pt7b.h"
#include "NotoSans_ExtraCondensed_Medium61pt7b.h"
#include "NotoSans_ExtraCondensed_Medium62pt7b.h"
#include "NotoSans_ExtraCondensed_Medium63pt7b.h"
#include "NotoSans_ExtraCondensed_Medium64pt7b.h"
#include "NotoSans_ExtraCondensed_Medium65pt7b.h"
#include "NotoSans_ExtraCondensed_Medium66pt7b.h"
#include "NotoSans_ExtraCondensed_Medium67pt7b.h"
#include "NotoSans_ExtraCondensed_Medium68pt7b.h"
#include "NotoSans_ExtraCondensed_Medium69pt7b.h"
#include "NotoSans_ExtraCondensed_Medium70pt7b.h"
#include "NotoSans_ExtraCondensed_Medium71pt7b.h"
#include "NotoSans_ExtraCondensed_Medium72pt7b.h"
