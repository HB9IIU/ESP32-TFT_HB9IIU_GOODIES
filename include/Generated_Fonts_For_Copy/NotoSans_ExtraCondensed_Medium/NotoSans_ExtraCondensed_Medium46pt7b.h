#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B,
  0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0xEF, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0,
  0xF7, 0x87, 0xBC, 0x1D, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03,
  0xC3, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x80,
  0x38, 0x70, 0x03, 0x87, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x1E,
  0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0F, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0xF9, 0x82, 0xF1,
  0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF9, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xBF, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8F, 0x81,
  0x8F, 0xF1, 0xBE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x3C,
  0x03, 0xF8, 0x03, 0x80, 0x7F, 0xC0, 0x78, 0x07, 0x3C, 0x07, 0x00, 0xF1,
  0xC0, 0x70, 0x0F, 0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0xE0, 0x0E, 0x1E, 0x1E,
  0x00, 0xE1, 0xE1, 0xE0, 0x0E, 0x1E, 0x1C, 0x00, 0xE1, 0xE3, 0xC0, 0x0E,
  0x1E, 0x3C, 0x00, 0xE1, 0xE3, 0x80, 0x0E, 0x1E, 0x78, 0xF8, 0xF1, 0xE7,
  0x1F, 0xCF, 0x1C, 0x73, 0xFE, 0x73, 0xCF, 0x3C, 0xE7, 0xFC, 0xE3, 0x8F,
  0x3F, 0x8E, 0x78, 0xF1, 0xF1, 0xE7, 0x8F, 0x00, 0x1C, 0x78, 0x70, 0x03,
  0xC7, 0x87, 0x00, 0x3C, 0x78, 0x70, 0x03, 0x87, 0x87, 0x00, 0x78, 0x78,
  0x70, 0x07, 0x07, 0x87, 0x00, 0x70, 0x78, 0xF0, 0x0F, 0x07, 0x8F, 0x00,
  0xE0, 0x38, 0xF0, 0x0E, 0x03, 0x8E, 0x01, 0xE0, 0x3F, 0xE0, 0x1C, 0x01,
  0xFC, 0x03, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xDF, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07,
  0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC3, 0xE3, 0xEF, 0x0F, 0x9F, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF1, 0xE0, 0xF3, 0xCF, 0x83, 0xFF, 0x3E, 0x07, 0xF8, 0xF8,
  0x1F, 0xE3, 0xE0, 0x3F, 0x8F, 0x80, 0x7C, 0x1E, 0x03, 0xF0, 0x7C, 0x1F,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFE, 0x3E, 0x0F, 0xF0, 0x7C,
  0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0, 0x03, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC1, 0x79, 0xCF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1F, 0x7C,
  0x3E, 0x3E, 0x1C, 0x3C, 0x0C, 0x18, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x7D, 0xF7, 0xDF, 0x79,
  0xE7, 0xBC, 0xF3, 0xCE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x77, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E,
  0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F,
  0xDF, 0x7F, 0xCF, 0xF1, 0xEC, 0x3C, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x1F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0x70, 0x3E,
  0x60, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0x70, 0x3E, 0x40, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0E, 0xF0, 0x03, 0xDE, 0x00,
  0x73, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03,
  0x87, 0x80, 0xF0, 0xF0, 0x1C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F,
  0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7D, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0xC0, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C,
  0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x0F, 0x1F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x1E, 0x7C, 0x07, 0x9F, 0x03, 0xE3, 0xC0,
  0xF0, 0xF8, 0x7C, 0x1F, 0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0,
  0x07, 0xF8, 0x03, 0xFF, 0x01, 0xF3, 0xE0, 0xF8, 0x7C, 0x7C, 0x0F, 0x9F,
  0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80,
  0x7D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C,
  0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xCF, 0x0F, 0x8F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x77, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x77, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xFF,
  0xF8, 0x39, 0xF7, 0xDF, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3D, 0xF7, 0xDF, 0x79, 0xE7, 0xBC, 0xF3, 0xCE,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x30, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC7,
  0x03, 0xFC, 0x79, 0xE0, 0xFF, 0x87, 0x3C, 0x3F, 0xF0, 0xE7, 0x07, 0x0E,
  0x1E, 0xE1, 0xE1, 0xC3, 0xFC, 0x38, 0x38, 0x7F, 0x87, 0x0F, 0x0F, 0xF1,
  0xE1, 0xE1, 0xFE, 0x3C, 0x3C, 0x3F, 0xC7, 0x87, 0x87, 0xF8, 0xF0, 0xF0,
  0xFF, 0x1E, 0x1E, 0x1F, 0xE3, 0xC3, 0xC3, 0xBC, 0x38, 0x78, 0x77, 0x87,
  0x1F, 0x1E, 0xF0, 0xF3, 0x73, 0x8E, 0x0F, 0xEF, 0xF1, 0xC1, 0xF8, 0xFC,
  0x3C, 0x0E, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x10, 0x01, 0xFC, 0x1E, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x80, 0x1E, 0x1E,
  0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x01,
  0xF0, 0x3C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F,
  0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBE,
  0x00, 0x1E, 0xF8, 0x00, 0x7C, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xF8, 0x3F, 0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x0F,
  0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0x81, 0xFB,
  0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x1F, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x81, 0x8F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x87, 0xF1, 0xF0,
  0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x83, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFC, 0x06, 0x0F, 0x80, 0x10, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xEF, 0xFB, 0xFC,
  0xFE, 0x3F, 0x00, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0,
  0x3E, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7E, 0x78, 0x0F, 0x8F, 0x81, 0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x80, 0xF9,
  0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xE0, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0x78, 0x01, 0xFF,
  0xF7, 0x80, 0x1F, 0xFF, 0x78, 0x03, 0xDF, 0xFB, 0xC0, 0x3D, 0xFF, 0xBC,
  0x03, 0xDF, 0xFB, 0xC0, 0x39, 0xFF, 0xBC, 0x07, 0x9F, 0xF9, 0xE0, 0x79,
  0xFF, 0x9E, 0x07, 0x9F, 0xF9, 0xE0, 0xF1, 0xFF, 0x8E, 0x0F, 0x1F, 0xF8,
  0xF0, 0xF1, 0xFF, 0x8F, 0x0E, 0x1F, 0xF8, 0xF1, 0xE1, 0xFF, 0x87, 0x9E,
  0x1F, 0xF8, 0x79, 0xE1, 0xFF, 0x87, 0x9C, 0x1F, 0xF8, 0x7B, 0xC1, 0xFF,
  0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x83, 0xF8, 0x1F, 0xF8, 0x1F,
  0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F,
  0xF8, 0x0F, 0x01, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0xF0,
  0x1F, 0xF7, 0x80, 0xFF, 0xBE, 0x07, 0xFC, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF,
  0x9E, 0x0F, 0xFC, 0xF0, 0x7F, 0xE3, 0xC3, 0xFF, 0x1E, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC3, 0xC7, 0xFE, 0x1F, 0x3F, 0xF0, 0x79, 0xFF, 0x83, 0xCF, 0xFC,
  0x1F, 0x7F, 0xE0, 0x79, 0xFF, 0x03, 0xEF, 0xF8, 0x0F, 0x7F, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0x80,
  0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00,
  0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x7E,
  0xF9, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0x87, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xF8, 0x7F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3E,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E,
  0x07, 0xCF, 0x83, 0xF3, 0xE3, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xF8, 0xF8, 0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x0F, 0xF8, 0x3F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC1, 0xDF, 0x00, 0xBE, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFC,
  0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x0F, 0x3E, 0x03, 0xE7, 0xE0, 0xFC, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x3E, 0x00,
  0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x07,
  0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F,
  0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xE3, 0xE0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x7B, 0xC0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xB8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xFC, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0xF8, 0x03,
  0xEF, 0x00, 0x7C, 0x01, 0xF7, 0x80, 0x3F, 0x00, 0xFB, 0xE0, 0x1F, 0x80,
  0x79, 0xF0, 0x1F, 0xC0, 0x3C, 0xF8, 0x0F, 0xE0, 0x3E, 0x3C, 0x07, 0xF0,
  0x1F, 0x1E, 0x03, 0xBC, 0x0F, 0x8F, 0x01, 0xDE, 0x07, 0x87, 0xC1, 0xEF,
  0x03, 0xC3, 0xE0, 0xF7, 0x83, 0xE0, 0xF0, 0x79, 0xC1, 0xF0, 0x78, 0x3C,
  0xF0, 0xF8, 0x3C, 0x1C, 0x78, 0x78, 0x1F, 0x1E, 0x3C, 0x3C, 0x0F, 0x8F,
  0x1E, 0x3E, 0x03, 0xC7, 0x87, 0x1F, 0x01, 0xE3, 0xC3, 0xCF, 0x80, 0xF1,
  0xC1, 0xE7, 0x80, 0x7D, 0xE0, 0xF3, 0xC0, 0x1E, 0xF0, 0x79, 0xE0, 0x0F,
  0x78, 0x1D, 0xF0, 0x07, 0xBC, 0x0E, 0xF8, 0x03, 0xDC, 0x07, 0xF8, 0x01,
  0xEE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE7, 0x80, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xC1, 0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0xF8,
  0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x7C, 0x01, 0xE7, 0x80,
  0x7C, 0xF0, 0x0F, 0x1F, 0x03, 0xE1, 0xE0, 0x78, 0x3E, 0x0F, 0x07, 0xC3,
  0xE0, 0x78, 0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x7C,
  0x7C, 0x0F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xE3, 0xE0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBC,
  0x00, 0x7B, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x01, 0xEF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x1E, 0x7E, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x03, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x0F,
  0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F,
  0x78, 0x3F, 0x7C, 0x7F, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xC7, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x7E, 0x1E, 0x7F, 0x8F,
  0x7F, 0xE7, 0xFF, 0xF3, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x0F, 0x7C, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF7,
  0xC0, 0xFB, 0xF0, 0x7D, 0xFC, 0x7C, 0xF7, 0xFE, 0x7B, 0xFE, 0x3C, 0x7E,
  0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0x8F, 0xFE, 0x7E, 0x09, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x05, 0xFC, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC3, 0xF1, 0xE3, 0xFC, 0xF3, 0xFF,
  0x7B, 0xFF, 0xFD, 0xF0, 0x7E, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFB, 0xC0,
  0x7D, 0xF0, 0x7E, 0xFC, 0x7F, 0x3F, 0xF7, 0x8F, 0xF3, 0xC3, 0xF1, 0xE0,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x7C, 0x1E, 0x78, 0x1E,
  0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x02, 0x3F, 0x1E, 0x3F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0xC7, 0x8F, 0xF3, 0xCF, 0xFD, 0xE7, 0xFF, 0xF7, 0xC1, 0xFB, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xEF, 0x01, 0xF7, 0xC1, 0xFB, 0xF3, 0xFC, 0xFF, 0xDE,
  0x3F, 0xCF, 0x0F, 0xC7, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x79, 0x00, 0x7C, 0xC0, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFE, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF1, 0xF8, 0xF7, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF7, 0xBF, 0xFF, 0x00, 0x00, 0x07, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80,
  0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x7F, 0xBF,
  0x9F, 0xCF, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF1,
  0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFD, 0xF0, 0xF8, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xF8, 0x7F, 0x3D, 0xFF,
  0x3F, 0xEF, 0x7F, 0xCF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xFE,
  0x0F, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F, 0xF0, 0x1F, 0x03,
  0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0,
  0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0xE1, 0xF8, 0xF7, 0xFC, 0xF7, 0xFE, 0xFF,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xCF,
  0x01, 0xE7, 0xC1, 0xF1, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0xF1, 0xF8, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xEF, 0xCF, 0xC1, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xDF, 0x03, 0xEF, 0xC1, 0xF7, 0xFB, 0xF3,
  0xDF, 0xF9, 0xEF, 0xF8, 0xF1, 0xF8, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD,
  0xEF, 0xFF, 0xF7, 0xC1, 0xFB, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x01,
  0xF7, 0xC1, 0xFB, 0xF3, 0xFC, 0xFF, 0xDE, 0x3F, 0xCF, 0x0F, 0xC7, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0xE1,
  0xFC, 0x7F, 0xDF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0xF3, 0xFF, 0x9F, 0xBE, 0x78, 0x13, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xFD, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F, 0xEF, 0x3F, 0xCF,
  0x1F, 0x8F, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x7C,
  0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3E, 0x1F, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xDE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x0F, 0x78, 0x1F, 0x80, 0xF7, 0x81, 0xFC,
  0x1F, 0x7C, 0x1F, 0xC1, 0xF3, 0xC1, 0xDC, 0x1E, 0x3C, 0x1D, 0xC1, 0xE3,
  0xC3, 0xDC, 0x1E, 0x3C, 0x3D, 0xE3, 0xE3, 0xE3, 0xDE, 0x3C, 0x1E, 0x39,
  0xE3, 0xC1, 0xE3, 0x8E, 0x3C, 0x1E, 0x38, 0xE3, 0xC1, 0xE7, 0x8E, 0x7C,
  0x1F, 0x78, 0xF7, 0x80, 0xF7, 0x8F, 0x78, 0x0F, 0x70, 0xF7, 0x80, 0xF7,
  0x07, 0x78, 0x0F, 0x70, 0x77, 0x00, 0x7F, 0x07, 0x70, 0x07, 0xF0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xBE, 0x07, 0xCF, 0x07, 0xC7, 0xC3, 0xE1,
  0xE1, 0xE0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0xC1, 0xE1, 0xE1,
  0xF0, 0xF8, 0xF0, 0x3C, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xDE,
  0x01, 0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x7C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3C, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03,
  0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x3F,
  0x81, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0x00, 0x3F, 0x80, 0x5F, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F,
  0xA0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 33, 11, 3, -33 },
  { 22, 13, 12, 18, 3, -33 },
  { 42, 20, 33, 22, 1, -33 },
  { 125, 16, 38, 20, 2, -35 },
  { 201, 28, 33, 32, 2, -33 },
  { 317, 22, 33, 23, 1, -33 },
  { 408, 5, 12, 10, 3, -33 },
  { 416, 11, 40, 14, 2, -33 },
  { 471, 11, 40, 14, 1, -33 },
  { 526, 16, 16, 19, 1, -35 },
  { 558, 18, 22, 20, 1, -27 },
  { 608, 6, 11, 11, 2, -5 },
  { 617, 11, 5, 13, 1, -15 },
  { 624, 5, 6, 11, 3, -6 },
  { 628, 16, 33, 18, 1, -33 },
  { 694, 16, 33, 20, 2, -33 },
  { 760, 11, 33, 20, 3, -33 },
  { 806, 16, 33, 20, 2, -33 },
  { 872, 16, 33, 20, 2, -33 },
  { 938, 19, 33, 20, 1, -33 },
  { 1017, 16, 33, 20, 2, -33 },
  { 1083, 16, 33, 20, 2, -33 },
  { 1149, 18, 33, 20, 1, -33 },
  { 1224, 18, 33, 20, 1, -33 },
  { 1299, 16, 33, 20, 2, -33 },
  { 1365, 5, 25, 11, 3, -25 },
  { 1381, 6, 31, 11, 2, -25 },
  { 1405, 18, 21, 20, 1, -27 },
  { 1453, 18, 13, 20, 1, -23 },
  { 1483, 18, 21, 20, 1, -27 },
  { 1531, 14, 33, 15, 0, -33 },
  { 1589, 27, 37, 31, 2, -33 },
  { 1714, 22, 33, 22, 0, -33 },
  { 1805, 18, 33, 23, 3, -33 },
  { 1880, 18, 33, 21, 2, -33 },
  { 1955, 19, 33, 24, 3, -33 },
  { 2034, 14, 33, 19, 3, -33 },
  { 2092, 14, 33, 18, 3, -33 },
  { 2150, 21, 33, 25, 2, -33 },
  { 2237, 19, 33, 25, 3, -33 },
  { 2316, 11, 33, 13, 1, -33 },
  { 2362, 10, 42, 11, -2, -33 },
  { 2415, 19, 33, 21, 3, -33 },
  { 2494, 14, 33, 18, 3, -33 },
  { 2552, 28, 33, 34, 3, -33 },
  { 2668, 21, 33, 27, 3, -33 },
  { 2755, 22, 33, 26, 2, -33 },
  { 2846, 17, 33, 21, 3, -33 },
  { 2917, 22, 41, 26, 2, -33 },
  { 3030, 18, 33, 22, 3, -33 },
  { 3105, 15, 33, 19, 2, -33 },
  { 3167, 18, 33, 18, 0, -33 },
  { 3242, 19, 33, 25, 3, -33 },
  { 3321, 21, 33, 21, 0, -33 },
  { 3408, 33, 33, 33, 0, -33 },
  { 3545, 19, 33, 19, 0, -33 },
  { 3624, 19, 33, 19, 0, -33 },
  { 3703, 15, 33, 17, 1, -33 },
  { 3765, 10, 40, 14, 3, -33 },
  { 3815, 16, 33, 18, 1, -33 },
  { 3881, 10, 40, 14, 1, -33 },
  { 3931, 20, 18, 22, 1, -33 },
  { 3976, 20, 3, 20, 0, 4 },
  { 3984, 9, 7, 13, 2, -35 },
  { 3992, 16, 25, 20, 1, -25 },
  { 4042, 17, 35, 22, 3, -35 },
  { 4117, 14, 25, 17, 2, -25 },
  { 4161, 17, 35, 22, 2, -35 },
  { 4236, 16, 25, 20, 2, -25 },
  { 4286, 13, 35, 12, 0, -35 },
  { 4343, 17, 36, 22, 2, -25 },
  { 4420, 16, 35, 22, 3, -35 },
  { 4490, 5, 34, 10, 3, -34 },
  { 4512, 9, 45, 10, -1, -34 },
  { 4563, 16, 35, 20, 3, -35 },
  { 4633, 4, 35, 10, 3, -35 },
  { 4651, 26, 25, 32, 3, -25 },
  { 4733, 16, 25, 22, 3, -25 },
  { 4783, 17, 25, 21, 2, -25 },
  { 4837, 17, 36, 22, 3, -25 },
  { 4914, 17, 36, 22, 2, -25 },
  { 4991, 11, 25, 15, 3, -25 },
  { 5026, 14, 25, 16, 1, -25 },
  { 5070, 11, 30, 13, 1, -30 },
  { 5112, 16, 25, 22, 3, -25 },
  { 5162, 18, 25, 18, 0, -25 },
  { 5219, 28, 25, 29, 0, -25 },
  { 5307, 17, 25, 18, 0, -25 },
  { 5361, 18, 36, 18, 0, -25 },
  { 5442, 13, 25, 15, 1, -25 },
  { 5483, 14, 40, 16, 1, -33 },
  { 5553, 4, 46, 19, 8, -35 },
  { 5576, 13, 40, 16, 2, -33 },
  { 5641, 18, 6, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Medium46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM46PT7B_H_
