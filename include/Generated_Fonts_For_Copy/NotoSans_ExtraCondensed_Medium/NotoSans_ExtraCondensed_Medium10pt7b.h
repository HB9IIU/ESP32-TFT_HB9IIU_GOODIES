#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x52, 0xBE, 0xAF, 0x31, 0x80, 0x27, 0xA4, 0x23, 0xB6,
  0x20, 0x69, 0x52, 0xD3, 0xD1, 0xA5, 0x4B, 0x00, 0x62, 0x98, 0xDA, 0xC9,
  0xA0, 0xC0, 0x69, 0x48, 0x92, 0x20, 0xC9, 0x22, 0x92, 0x80, 0x2B, 0x66,
  0x22, 0xF2, 0x20, 0x60, 0xE0, 0x80, 0x32, 0x24, 0x44, 0x80, 0x65, 0x99,
  0x95, 0x60, 0x75, 0x54, 0xF1, 0x12, 0x24, 0xF0, 0xF1, 0x16, 0x11, 0xE0,
  0x33, 0x55, 0x97, 0x10, 0x74, 0x4B, 0x11, 0xE0, 0x74, 0xAD, 0x95, 0x60,
  0xF1, 0x22, 0x24, 0x40, 0x79, 0x56, 0x99, 0x70, 0x69, 0x97, 0x11, 0x60,
  0x88, 0x40, 0x60, 0x12, 0xC2, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE4,
  0xA4, 0x10, 0x39, 0x17, 0xEB, 0xAE, 0xF4, 0x0E, 0x23, 0x14, 0xA7, 0x4A,
  0x20, 0xEA, 0xAE, 0xBA, 0xE0, 0x74, 0x4C, 0x44, 0x70, 0xEB, 0x99, 0x9A,
  0xE0, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x7A, 0x11, 0xB4, 0xA5, 0xE0,
  0x99, 0x9F, 0x99, 0x90, 0xE9, 0x24, 0xB8, 0x24, 0x92, 0x49, 0xC0, 0xBA,
  0xCC, 0xAA, 0xB0, 0x92, 0x49, 0x38, 0x8F, 0x3D, 0x75, 0xD6, 0x9A, 0x40,
  0x9D, 0xDD, 0xBB, 0x90, 0x72, 0x53, 0x94, 0xA5, 0xC0, 0xF6, 0xF9, 0x20,
  0x72, 0x53, 0x94, 0xA5, 0xC2, 0x08, 0xEA, 0xAE, 0xEA, 0xB0, 0x78, 0x46,
  0x11, 0xE0, 0xF4, 0x44, 0x44, 0x40, 0x99, 0x99, 0x99, 0xE0, 0x9C, 0x94,
  0xA6, 0x30, 0x80, 0x93, 0x25, 0x6B, 0x56, 0xCD, 0x99, 0x00, 0x96, 0x62,
  0x65, 0x90, 0x95, 0x66, 0x22, 0x20, 0xF2, 0x24, 0x44, 0xF0, 0xEA, 0xAA,
  0xC0, 0x84, 0x44, 0x22, 0x10, 0xD5, 0x55, 0xC0, 0x23, 0x15, 0x30, 0xF0,
  0xD0, 0x25, 0x17, 0x97, 0x93, 0x5B, 0x6F, 0x2E, 0x44, 0xC0, 0x11, 0x57,
  0x99, 0x97, 0x79, 0xF4, 0x70, 0x69, 0xE4, 0x92, 0x47, 0x99, 0x97, 0x17,
  0x93, 0x5B, 0x6D, 0xBE, 0x45, 0x55, 0x80, 0x92, 0x5D, 0xAD, 0xFF, 0x4D,
  0xEB, 0x5A, 0xD4, 0x56, 0xDB, 0x40, 0x25, 0x99, 0x57, 0x56, 0xDB, 0xE4,
  0x47, 0x99, 0x97, 0x11, 0x7A, 0xA0, 0x57, 0x33, 0xC0, 0x4F, 0x24, 0x98,
  0xB6, 0xDE, 0x9A, 0x66, 0x60, 0xB6, 0xD7, 0x5A, 0x48, 0xF6, 0x66, 0x90,
  0x96, 0x66, 0x64, 0xC0, 0xE9, 0x2E, 0x29, 0x2C, 0x92, 0x20, 0xFF, 0xC0,
  0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 4, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 4, 0, -8 },
  { 13, 7, 7, 7, 0, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 1, 2, 2, 1, -7 },
  { 26, 3, 9, 3, 0, -7 },
  { 30, 3, 9, 3, 0, -7 },
  { 34, 4, 4, 4, 0, -8 },
  { 36, 4, 5, 4, 0, -6 },
  { 39, 2, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 1, -1 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 2, 7, 4, 1, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 4, 7, 4, 0, -7 },
  { 76, 4, 7, 4, 0, -7 },
  { 80, 4, 7, 4, 0, -7 },
  { 84, 1, 5, 2, 1, -5 },
  { 85, 2, 6, 2, 0, -5 },
  { 87, 4, 5, 4, 0, -6 },
  { 90, 4, 3, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -6 },
  { 95, 3, 7, 3, 0, -7 },
  { 98, 6, 8, 7, 0, -7 },
  { 104, 5, 7, 5, 0, -7 },
  { 109, 4, 7, 5, 1, -7 },
  { 113, 4, 7, 5, 0, -7 },
  { 117, 4, 7, 5, 1, -7 },
  { 121, 3, 7, 4, 1, -7 },
  { 124, 3, 7, 4, 1, -7 },
  { 127, 5, 7, 6, 0, -7 },
  { 132, 4, 7, 5, 1, -7 },
  { 136, 3, 7, 3, 0, -7 },
  { 139, 3, 9, 2, -1, -7 },
  { 143, 4, 7, 5, 1, -7 },
  { 147, 3, 7, 4, 1, -7 },
  { 150, 6, 7, 7, 1, -7 },
  { 156, 4, 7, 6, 1, -7 },
  { 160, 5, 7, 6, 0, -7 },
  { 165, 3, 7, 5, 1, -7 },
  { 168, 5, 9, 6, 0, -7 },
  { 174, 4, 7, 5, 1, -7 },
  { 178, 4, 7, 4, 0, -7 },
  { 182, 4, 7, 4, 0, -7 },
  { 186, 4, 7, 5, 1, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 7, 7, 7, 0, -7 },
  { 202, 4, 7, 4, 0, -7 },
  { 206, 4, 7, 4, 0, -7 },
  { 210, 4, 7, 4, 0, -7 },
  { 214, 2, 9, 3, 1, -7 },
  { 217, 4, 7, 4, 0, -7 },
  { 221, 2, 9, 3, 0, -7 },
  { 224, 5, 4, 5, 0, -7 },
  { 227, 4, 1, 4, 0, 1 },
  { 228, 2, 2, 3, 0, -8 },
  { 229, 4, 6, 4, 0, -6 },
  { 232, 3, 8, 5, 1, -8 },
  { 235, 3, 6, 4, 0, -6 },
  { 238, 4, 8, 5, 0, -8 },
  { 242, 4, 5, 4, 0, -5 },
  { 245, 3, 8, 3, 0, -8 },
  { 248, 4, 8, 5, 0, -6 },
  { 252, 3, 8, 5, 1, -8 },
  { 255, 1, 7, 2, 1, -7 },
  { 256, 2, 9, 2, 0, -7 },
  { 259, 3, 8, 4, 1, -8 },
  { 262, 1, 8, 2, 1, -8 },
  { 263, 5, 6, 7, 1, -6 },
  { 267, 3, 6, 5, 1, -6 },
  { 270, 4, 6, 5, 0, -6 },
  { 273, 3, 8, 5, 1, -6 },
  { 276, 4, 8, 5, 0, -6 },
  { 280, 2, 6, 3, 1, -6 },
  { 282, 3, 6, 3, 0, -6 },
  { 285, 3, 7, 3, 0, -7 },
  { 288, 3, 5, 5, 1, -5 },
  { 290, 4, 5, 4, 0, -5 },
  { 293, 6, 5, 6, 0, -5 },
  { 297, 4, 5, 4, 0, -5 },
  { 300, 4, 7, 4, 0, -5 },
  { 304, 3, 5, 3, 0, -5 },
  { 306, 3, 9, 4, 0, -7 },
  { 310, 1, 10, 4, 2, -8 },
  { 312, 3, 9, 4, 0, -7 },
  { 316, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Medium10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM10PT7B_H_
